# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-string_cache"
PV = "0.8.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-string_cache+default-devel \
 rust-string_cache+serde-devel \
 rust-string_cache+serde_support-devel \
 rust-string_cache-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-string_cache-0.8.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83edaeeb5aa3c6ee9c64e32f6cdecc27fd76619a2af04d7e53db7371af04e5ab"

URI_x86_64_v2_rust-string_cache+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache+default-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache+default-devel}"
SRC_URI[x86_64_v2_rust-string_cache+default-devel.sha256sum] = "bde9906ab9afa01289402674885131d3ffa43d73c19053bcf8dbc23f50eb2954"

URI_x86_64_v2_rust-string_cache+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache+serde-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache+serde-devel}"
SRC_URI[x86_64_v2_rust-string_cache+serde-devel.sha256sum] = "eededafb44493c2690eee2804dce0779df790e8a49108cb46fe921ffc50783ea"

URI_x86_64_v2_rust-string_cache+serde_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache+serde_support-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache+serde_support-devel}"
SRC_URI[x86_64_v2_rust-string_cache+serde_support-devel.sha256sum] = "cb7b7daea0ac4175c46b06e44ef1f21517a597931eb85b7851d9dc2dee1896d4"

URI_x86_64_v2_rust-string_cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache-devel}"
SRC_URI[x86_64_v2_rust-string_cache-devel.sha256sum] = "92a2e45a84a45c8fd4e0232b75e2f01ee1257b18e9f53b6638135e878151319c"

URI_aarch64_rust-string_cache+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache+default-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-string_cache+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache+default-devel}"
SRC_URI[aarch64_rust-string_cache+default-devel.sha256sum] = "40b95bbd4509937669abed6d7a27d68ab9ad0b7f82f849ea37ad5d4e0faac1db"

URI_aarch64_rust-string_cache+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache+serde-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-string_cache+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache+serde-devel}"
SRC_URI[aarch64_rust-string_cache+serde-devel.sha256sum] = "8a731a33d166a30879aee2fd54c5554569eda5d902b420fb89261400eeac922b"

URI_aarch64_rust-string_cache+serde_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache+serde_support-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-string_cache+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache+serde_support-devel}"
SRC_URI[aarch64_rust-string_cache+serde_support-devel.sha256sum] = "213472c2fcd39182b425a844fcb14c659f5c36aa381f3491e52d22b21ac666c2"

URI_aarch64_rust-string_cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-string_cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache-devel}"
SRC_URI[aarch64_rust-string_cache-devel.sha256sum] = "4f06b4aab607961486f23f7e04851eb252e32d02d6e678ad45ab928a6eed6da2"

RDEPENDS:rust-string_cache+default-devel = " \
 cargo \
 rust-string_cache+serde_support-devel \
 rust-string_cache-devel \
 "
RDEPENDS:rust-string_cache+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-string_cache-devel \
 "
RDEPENDS:rust-string_cache+serde_support-devel = " \
 cargo \
 rust-string_cache+serde-devel \
 rust-string_cache-devel \
 "
RDEPENDS:rust-string_cache-devel = " \
 cargo \
 rust \
 rust-new_debug_unreachable+default-devel \
 rust-parking_lot+default-devel \
 rust-phf_shared+default-devel \
 rust-precomputed-hash+default-devel \
 "
