# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-latest-openjdk"
PE = "1"
PV = "25.0.1.0.8"
PR = "0.1.el10_0"
PACKAGES = " \
 java-latest-openjdk \
 java-latest-openjdk-demo \
 java-latest-openjdk-demo-fastdebug \
 java-latest-openjdk-demo-slowdebug \
 java-latest-openjdk-devel \
 java-latest-openjdk-devel-fastdebug \
 java-latest-openjdk-devel-slowdebug \
 java-latest-openjdk-fastdebug \
 java-latest-openjdk-headless \
 java-latest-openjdk-headless-fastdebug \
 java-latest-openjdk-headless-slowdebug \
 java-latest-openjdk-javadoc \
 java-latest-openjdk-javadoc-zip \
 java-latest-openjdk-jmods \
 java-latest-openjdk-jmods-fastdebug \
 java-latest-openjdk-jmods-slowdebug \
 java-latest-openjdk-slowdebug \
 java-latest-openjdk-src \
 java-latest-openjdk-src-fastdebug \
 java-latest-openjdk-src-slowdebug \
 java-latest-openjdk-static-libs \
 java-latest-openjdk-static-libs-fastdebug \
 java-latest-openjdk-static-libs-slowdebug \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/java-latest-openjdk-25.0.1.0.8-0.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "301ea9b652db2422c35f64bcb88adeb765265c0126e82acc74816fa496c68937"

URI_x86_64_v2_java-latest-openjdk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk}"
SRC_URI[x86_64_v2_java-latest-openjdk.sha256sum] = "21d096aa7564f4bf0a67e93b36fef1bcad2ee150c935074f9afe9908b0788e16"

URI_x86_64_v2_java-latest-openjdk-demo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-demo}"
SRC_URI[x86_64_v2_java-latest-openjdk-demo.sha256sum] = "13c2c83455deb7a2cde0984add99e5f77a5fdfe4924ed4fb78b21bd9fbd7ce4b"

URI_x86_64_v2_java-latest-openjdk-demo-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-fastdebug-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-demo-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-demo-fastdebug.sha256sum] = "1f955ea853db0f9516f4af801fb65cf89eb521591eb4933313d02ecabca537a3"

URI_x86_64_v2_java-latest-openjdk-demo-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-slowdebug-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-demo-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-demo-slowdebug.sha256sum] = "a49a019324d80956bfd0fcfdcc6775b1bb752d2160d657d40cb26828696815cb"

URI_x86_64_v2_java-latest-openjdk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-devel}"
SRC_URI[x86_64_v2_java-latest-openjdk-devel.sha256sum] = "f380c37657ae33fa7eaac12577bca4749ee333123d46cc4b8609a291f012649c"

URI_x86_64_v2_java-latest-openjdk-devel-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-fastdebug-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-devel-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-devel-fastdebug.sha256sum] = "6a23eed83804a87c11cbbef373274b8af1bf7e8e47b3b1499eac173d73998f27"

URI_x86_64_v2_java-latest-openjdk-devel-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-slowdebug-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-devel-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-devel-slowdebug.sha256sum] = "605742c2a78a98e807d2fb59ba99b6ff3ed6ca8c8c88fec02ee4b01fb258484a"

URI_x86_64_v2_java-latest-openjdk-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-fastdebug-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-fastdebug.sha256sum] = "6f4729442d765b0171c6b505ea384668b4605b3237ae1b433f91baa6a8a2cc0d"

URI_x86_64_v2_java-latest-openjdk-headless = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-headless}"
SRC_URI[x86_64_v2_java-latest-openjdk-headless.sha256sum] = "d76c6d4cd889965654870d2f4239ff4a8aff50e4f6bf80cc806010fd52783837"
RPROVIDES:java-latest-openjdk-headless:x86_64_v2 = "virtual/java-headless_or_java-21-headless_or_java-25-headless"

URI_x86_64_v2_java-latest-openjdk-headless-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-fastdebug-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-headless-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-headless-fastdebug.sha256sum] = "012911e3814f806d793f29c86c601f05fac07d0d0005402fa867a9ba53d34dce"

URI_x86_64_v2_java-latest-openjdk-headless-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-slowdebug-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-headless-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-headless-slowdebug.sha256sum] = "fbcdcd9098c02a9c561d7bf95f772964548da68e7c8b12a4c69cb03eae0bd7bc"

URI_x86_64_v2_java-latest-openjdk-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-javadoc-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-javadoc}"
SRC_URI[x86_64_v2_java-latest-openjdk-javadoc.sha256sum] = "ee1ad735b474e0bcad08752f98e798c162a64361ad10e417a2d8f401fb6eb013"

URI_x86_64_v2_java-latest-openjdk-javadoc-zip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-javadoc-zip-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-javadoc-zip}"
SRC_URI[x86_64_v2_java-latest-openjdk-javadoc-zip.sha256sum] = "26da9356afe6e4c25b3bd59ba539c030642389ed0b0397be15ee803e54a1a759"

URI_x86_64_v2_java-latest-openjdk-jmods = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-jmods}"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods.sha256sum] = "1db848e0a01e3e33e15ec94024a2a5bbf18b2f78fd21f410752fedb6b1ef25cc"

URI_x86_64_v2_java-latest-openjdk-jmods-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-fastdebug-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-jmods-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods-fastdebug.sha256sum] = "f983056f318eacdca08ee369776662a454faf582940ef7c420cf8086b806f841"

URI_x86_64_v2_java-latest-openjdk-jmods-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-slowdebug-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-jmods-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods-slowdebug.sha256sum] = "43963e2f0f798756a67f99c1e6fa275a5b108034c65451d94cf0cbc846f12a47"

URI_x86_64_v2_java-latest-openjdk-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-slowdebug-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-slowdebug.sha256sum] = "1c894e01218b5ed53a92661ed8277a4f7674648c624ccc8c454e140ed341a4e3"

URI_x86_64_v2_java-latest-openjdk-src = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-src}"
SRC_URI[x86_64_v2_java-latest-openjdk-src.sha256sum] = "5411cf7bb072f5bf8a7ae8e9573dfa34d14052511c59a518bc67c4359489cb0d"

URI_x86_64_v2_java-latest-openjdk-src-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-fastdebug-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-src-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-src-fastdebug.sha256sum] = "86567cbeed4d9def63db52eab8526001b3591355e69c191d9794c5113c3b8ad0"

URI_x86_64_v2_java-latest-openjdk-src-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-slowdebug-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-src-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-src-slowdebug.sha256sum] = "48ca11a61f52037d03f1f69d18a30cb309714a89523df600885d7e896c085d5f"

URI_x86_64_v2_java-latest-openjdk-static-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-static-libs}"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs.sha256sum] = "d8fde9deb6a2b2d8f8891e58ef267fa2f4e08d0869a5840415a5230666e564e6"

URI_x86_64_v2_java-latest-openjdk-static-libs-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-fastdebug-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-static-libs-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs-fastdebug.sha256sum] = "6b44242d4d1532fcf711d9652181e9db965f2a9ea32499b138288fd50e53115d"

URI_x86_64_v2_java-latest-openjdk-static-libs-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-slowdebug-25.0.1.0.8-0.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-static-libs-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs-slowdebug.sha256sum] = "d8f552ae6812f4881247384d63d3e3ee575893be98f0ee16d54dde3dcb7d76d8"

URI_aarch64_java-latest-openjdk = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk}"
SRC_URI[aarch64_java-latest-openjdk.sha256sum] = "f72cca4c2a75b2af858478150c8a1d9447fea4fb2419dcea32d95490e0b33c1d"

URI_aarch64_java-latest-openjdk-demo = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-demo}"
SRC_URI[aarch64_java-latest-openjdk-demo.sha256sum] = "d981dcc4c2233b5b6143e5efa9b2861cd889a475bd3ea2a086487b6852859220"

URI_aarch64_java-latest-openjdk-demo-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-fastdebug-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-demo-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-demo-fastdebug.sha256sum] = "fc9db312663ae0fbe4d00f9397e5cc253bce993be5eddcf25857615159b5472c"

URI_aarch64_java-latest-openjdk-demo-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-slowdebug-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-demo-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-demo-slowdebug.sha256sum] = "172f8c537481004737e0c79d3e727087f3e10511458912125b5e848f80b15fdd"

URI_aarch64_java-latest-openjdk-devel = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-devel}"
SRC_URI[aarch64_java-latest-openjdk-devel.sha256sum] = "8d960a1facace1ca7c56e40456830f5fee002120f3bfc7facd8669669ae53041"

URI_aarch64_java-latest-openjdk-devel-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-fastdebug-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-devel-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-devel-fastdebug.sha256sum] = "1659ff6830d6f19faf74ab98ec95c1e041af0d27ad00b48f33ca2f52e87f95c3"

URI_aarch64_java-latest-openjdk-devel-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-slowdebug-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-devel-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-devel-slowdebug.sha256sum] = "feb9852cdc07ea34d5f09646dffa172a16156213358dbafed135868207197e56"

URI_aarch64_java-latest-openjdk-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-fastdebug-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-fastdebug.sha256sum] = "524968cf0be7598f21635ac485c3f40394f0d3567a188433cb82b4d126280fce"

URI_aarch64_java-latest-openjdk-headless = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-headless}"
SRC_URI[aarch64_java-latest-openjdk-headless.sha256sum] = "e5381d20be6a2303219a9c2878733535b762ee7c372729a7de4026a3498e8454"
RPROVIDES:java-latest-openjdk-headless:aarch64 = "virtual/java-headless_or_java-21-headless_or_java-25-headless"

URI_aarch64_java-latest-openjdk-headless-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-fastdebug-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-headless-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-headless-fastdebug.sha256sum] = "f77eabd2cf1f31a17334aaf9de6fa7793db81721edfc10e388124fca6e79b9d8"

URI_aarch64_java-latest-openjdk-headless-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-slowdebug-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-headless-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-headless-slowdebug.sha256sum] = "bd2777bb815b0a6e53e94565c329627f85180657afcdbf9739c833ee942334e0"

URI_aarch64_java-latest-openjdk-javadoc = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-javadoc-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-javadoc}"
SRC_URI[aarch64_java-latest-openjdk-javadoc.sha256sum] = "ae57c7df7efb4765f17601e928876704b7fbf42215e1f7e63f1244d0ed6ca229"

URI_aarch64_java-latest-openjdk-javadoc-zip = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-javadoc-zip-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-javadoc-zip}"
SRC_URI[aarch64_java-latest-openjdk-javadoc-zip.sha256sum] = "de394803c38314bec34bcc1f036dba82ff6ddc459854c1a38f42cc3345fcfc08"

URI_aarch64_java-latest-openjdk-jmods = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-jmods}"
SRC_URI[aarch64_java-latest-openjdk-jmods.sha256sum] = "f2fd5058760d3ab56e3d4d17518e1bcf2de1a4ce7cee9b674cbc4f15a3aa2f73"

URI_aarch64_java-latest-openjdk-jmods-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-fastdebug-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-jmods-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-jmods-fastdebug.sha256sum] = "ae9bea6d0bde78bd89b2898cbdccb2ebbfce2d8bdedda31c59b5fd4cbc6b1f9c"

URI_aarch64_java-latest-openjdk-jmods-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-slowdebug-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-jmods-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-jmods-slowdebug.sha256sum] = "dfd23c4913a91a2dfdddba81503e99cd18324b62c289d793495f9c1a4123a162"

URI_aarch64_java-latest-openjdk-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-slowdebug-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-slowdebug.sha256sum] = "19dab2c44ef14a340f8d1fc46c333afc953b6f7360853e19bd48f0b808a379e2"

URI_aarch64_java-latest-openjdk-src = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-src}"
SRC_URI[aarch64_java-latest-openjdk-src.sha256sum] = "1afc9ce974c83e7ecfcf0621eb84dcceec142cad97bbdbf05c7a13a5881514a4"

URI_aarch64_java-latest-openjdk-src-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-fastdebug-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-src-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-src-fastdebug.sha256sum] = "5994b51e2d8a26fceb6fad1bfb451ceba7569f7d40e265936ed2bae8aab5de7d"

URI_aarch64_java-latest-openjdk-src-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-slowdebug-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-src-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-src-slowdebug.sha256sum] = "df7cc0ef9006ebb382503bf0a57d3f537f3aa1b400beecbd3df3e5743cc36774"

URI_aarch64_java-latest-openjdk-static-libs = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-static-libs}"
SRC_URI[aarch64_java-latest-openjdk-static-libs.sha256sum] = "8446456bcdb8c0133b9582e89ef0b10c1d45cab5d6269d00f6294e6c76060991"

URI_aarch64_java-latest-openjdk-static-libs-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-fastdebug-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-static-libs-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-static-libs-fastdebug.sha256sum] = "bfc45db973d5000782982378049a4e48592d6f12cc29199e056e9c2fa7be1ae4"

URI_aarch64_java-latest-openjdk-static-libs-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-slowdebug-25.0.1.0.8-0.1.el10_0.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-static-libs-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-static-libs-slowdebug.sha256sum] = "96844573aa4c91adf3eb619b3cd6282a0f77f1ae762934d797c6998d8e9643e4"

RDEPENDS:java-latest-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-demo = " \
 java-latest-openjdk \
 "
RDEPENDS:java-latest-openjdk-demo-fastdebug = " \
 java-latest-openjdk-fastdebug \
 "
RDEPENDS:java-latest-openjdk-demo-slowdebug = " \
 java-latest-openjdk-slowdebug \
 "
RDEPENDS:java-latest-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk \
 "
RDEPENDS:java-latest-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk-fastdebug \
 "
RDEPENDS:java-latest-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk-slowdebug \
 "
RDEPENDS:java-latest-openjdk-fastdebug = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless-fastdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-headless-fastdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-headless-slowdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-javadoc = " \
 alternatives \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:java-latest-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:java-latest-openjdk-jmods = " \
 java-latest-openjdk-devel \
 "
RDEPENDS:java-latest-openjdk-jmods-fastdebug = " \
 java-latest-openjdk-devel-fastdebug \
 "
RDEPENDS:java-latest-openjdk-jmods-slowdebug = " \
 java-latest-openjdk-devel-slowdebug \
 "
RDEPENDS:java-latest-openjdk-slowdebug = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless-slowdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-src = " \
 java-latest-openjdk-headless \
 "
RDEPENDS:java-latest-openjdk-src-fastdebug = " \
 java-latest-openjdk-headless-fastdebug \
 "
RDEPENDS:java-latest-openjdk-src-slowdebug = " \
 java-latest-openjdk-headless-slowdebug \
 "
RDEPENDS:java-latest-openjdk-static-libs = " \
 java-latest-openjdk-devel \
 "
RDEPENDS:java-latest-openjdk-static-libs-fastdebug = " \
 java-latest-openjdk-devel-fastdebug \
 "
RDEPENDS:java-latest-openjdk-static-libs-slowdebug = " \
 java-latest-openjdk-devel-slowdebug \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/java-headless_or_java-21-headless_or_java-25-headless"

PROVIDES:append:aarch64 = " rpm/virtual/java-headless_or_java-21-headless_or_java-25-headless"
