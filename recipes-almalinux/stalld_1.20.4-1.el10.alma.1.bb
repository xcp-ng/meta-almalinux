# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stalld"
PV = "1.20.4"
PR = "1.el10.alma.1"
PACKAGES = " \
 stalld \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/stalld-1.20.4-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d189cf21217117f31c6b16018f6353ebc71ae8bf3b0f8c18b3e692d1b3d0ec12"

URI_x86_64_v2_stalld = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stalld-1.20.4-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_stalld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stalld}"
SRC_URI[x86_64_v2_stalld.sha256sum] = "ac98e163cac9a82bf9630be1228fa8b5be99ff8392fdd48f03b798840b819f3b"

URI_aarch64_stalld = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stalld-1.20.4-1.el10.alma.1.aarch64.rpm;name=aarch64_stalld;unpack=0"
SRC_URI:append = " ${URI_aarch64_stalld}"
SRC_URI[aarch64_stalld.sha256sum] = "bd8c6ff08629a9252a81b6b25d1f7eec8bd1a46e153eb50a5c778bcb942703d6"

RDEPENDS:stalld = " \
 bash \
 glibc \
 libbpf \
 systemd \
 "
