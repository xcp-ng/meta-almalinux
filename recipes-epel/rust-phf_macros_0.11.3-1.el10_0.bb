# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf_macros"
PV = "0.11.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-phf_macros+default-devel \
 rust-phf_macros+unicase-devel \
 rust-phf_macros+unicase_-devel \
 rust-phf_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf_macros-0.11.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10279c7f68f33940b8726f900cac79be475f54e2d45b12f7eb070a02a1d9afe8"

URI_x86_64_v2_rust-phf_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros+default-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros+default-devel}"
SRC_URI[x86_64_v2_rust-phf_macros+default-devel.sha256sum] = "e7989cdc358b9264903a3924481d792102c6b8d6a34e33f9cf58927db23b0c03"

URI_x86_64_v2_rust-phf_macros+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros+unicase-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros+unicase-devel}"
SRC_URI[x86_64_v2_rust-phf_macros+unicase-devel.sha256sum] = "6884ff4b70d84b891337603b216aa5448f541c6c9513165247cffe49daaa0a5a"

URI_x86_64_v2_rust-phf_macros+unicase_-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros+unicase_-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros+unicase_-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros+unicase_-devel}"
SRC_URI[x86_64_v2_rust-phf_macros+unicase_-devel.sha256sum] = "e36374accc29f9c840bde9f617bdfc8b2390f1c0829d9ea772e5b9d2b878c7d0"

URI_x86_64_v2_rust-phf_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros-devel}"
SRC_URI[x86_64_v2_rust-phf_macros-devel.sha256sum] = "f29eb9d7fe7742059fd39996165d8fe429d32066d577444e9e806555b5ad233c"

URI_aarch64_rust-phf_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros+default-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros+default-devel}"
SRC_URI[aarch64_rust-phf_macros+default-devel.sha256sum] = "0a9449bd910f439ecadd275dad5fb26e2c6eaf65bf1f4639ec74bdc43790aa77"

URI_aarch64_rust-phf_macros+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros+unicase-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf_macros+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros+unicase-devel}"
SRC_URI[aarch64_rust-phf_macros+unicase-devel.sha256sum] = "0dc11d9b1a0d113b7964b42e7e4ed26d9b1150dc0d2300225866a133fec85865"

URI_aarch64_rust-phf_macros+unicase_-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros+unicase_-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf_macros+unicase_-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros+unicase_-devel}"
SRC_URI[aarch64_rust-phf_macros+unicase_-devel.sha256sum] = "9292a313754d1480c2593b876dadbdaa5d9bf56d37707ffc35b77ee10f834f36"

URI_aarch64_rust-phf_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros-devel}"
SRC_URI[aarch64_rust-phf_macros-devel.sha256sum] = "ed22de396f40a596832851b1278a6732d8e8004a1619b240683f5f96db17888a"

RDEPENDS:rust-phf_macros+default-devel = " \
 cargo \
 rust-phf_macros-devel \
 "
RDEPENDS:rust-phf_macros+unicase-devel = " \
 cargo \
 rust-phf_macros+unicase_-devel \
 rust-phf_macros-devel \
 rust-phf_shared+unicase-devel \
 "
RDEPENDS:rust-phf_macros+unicase_-devel = " \
 cargo \
 rust-phf_macros-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-phf_macros-devel = " \
 cargo \
 rust \
 rust-phf_generator+default-devel \
 rust-phf_shared-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
