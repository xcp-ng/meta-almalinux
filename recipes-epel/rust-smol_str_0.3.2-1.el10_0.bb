# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-smol_str"
PV = "0.3.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-smol_str+arbitrary-devel \
 rust-smol_str+default-devel \
 rust-smol_str+serde-devel \
 rust-smol_str+std-devel \
 rust-smol_str-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-smol_str-0.3.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6ec86fc52eeb07ea7f5ad4f911d82cc632660629a9d1f8af22e538ab63d8a70"

URI_x86_64_v2_rust-smol_str+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str+arbitrary-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-smol_str+arbitrary-devel.sha256sum] = "08043ca61b1da267e9eb1979cb1df5a2638613a3df57be0ef1dbc85505bef2fa"

URI_x86_64_v2_rust-smol_str+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str+default-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str+default-devel}"
SRC_URI[x86_64_v2_rust-smol_str+default-devel.sha256sum] = "de6f151134c6631dab831fd5d7ec3886c7783c0b2c797f34ec4b1ee9ec3804fb"

URI_x86_64_v2_rust-smol_str+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str+serde-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str+serde-devel}"
SRC_URI[x86_64_v2_rust-smol_str+serde-devel.sha256sum] = "463857f75f084181b65961ffa90dac4a790b1c6f324342ca28e3683b04917c13"

URI_x86_64_v2_rust-smol_str+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str+std-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str+std-devel}"
SRC_URI[x86_64_v2_rust-smol_str+std-devel.sha256sum] = "4a110f5143ebdb9e434476ad9c6de0faad96e0686d2c4218aba8af68fac93cdd"

URI_x86_64_v2_rust-smol_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str-devel}"
SRC_URI[x86_64_v2_rust-smol_str-devel.sha256sum] = "bd57683cfd251304562eb8388f9c4da3f5786f6c4a654f8fbc6e4abaa2b4b072"

URI_aarch64_rust-smol_str+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str+arbitrary-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-smol_str+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str+arbitrary-devel}"
SRC_URI[aarch64_rust-smol_str+arbitrary-devel.sha256sum] = "cdab36fadbd7e64fad6c1d45009ad1cd211817bce12cdcdd7acad99a59179f2d"

URI_aarch64_rust-smol_str+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str+default-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-smol_str+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str+default-devel}"
SRC_URI[aarch64_rust-smol_str+default-devel.sha256sum] = "be88e1f6a828e61de8004089de5ec5e4d9b93efd3b979cea5ff5d33b4d41a256"

URI_aarch64_rust-smol_str+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str+serde-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-smol_str+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str+serde-devel}"
SRC_URI[aarch64_rust-smol_str+serde-devel.sha256sum] = "81a3f604e1defa4d8db59f26a6f06f81b558cab5105c18d4599f3870803f9ce7"

URI_aarch64_rust-smol_str+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str+std-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-smol_str+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str+std-devel}"
SRC_URI[aarch64_rust-smol_str+std-devel.sha256sum] = "91600593390b5195b80cd8fb8494c9deaf465f1f369277be591836b6a9dae378"

URI_aarch64_rust-smol_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-smol_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str-devel}"
SRC_URI[aarch64_rust-smol_str-devel.sha256sum] = "73f8d09d2546056d00d921eeb687875fbbfb2e8a6ff0c44c76ccf75bd4f920b0"

RDEPENDS:rust-smol_str+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-smol_str+default-devel = " \
 cargo \
 rust-smol_str+std-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-smol_str+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-smol_str+std-devel = " \
 cargo \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-smol_str-devel = " \
 cargo \
 "
