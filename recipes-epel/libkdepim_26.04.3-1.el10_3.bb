# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdepim"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 libkdepim \
 libkdepim-devel \
 libkdepim-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkdepim-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bdee41ade99b96cc232f9279e5c6116efd1d5f9f3089c40418ae5a7e430c21a"

URI_x86_64_v2_libkdepim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdepim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdepim}"
SRC_URI[x86_64_v2_libkdepim.sha256sum] = "ed107b3f46c6baae3bb29ff455bbb4bdc853b6e56fc1761aba298daa57cc2582"

URI_x86_64_v2_libkdepim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdepim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdepim-devel}"
SRC_URI[x86_64_v2_libkdepim-devel.sha256sum] = "ad6ae4036cde4f04272e91828f7bf6d43d475c853e0e84f7c88fd92ecf7ed7a4"

URI_x86_64_v2_libkdepim-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libkdepim-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdepim-doc}"
SRC_URI[x86_64_v2_libkdepim-doc.sha256sum] = "061dd4dd90f375aaaeaa8bee8c3efd437f36ae9830a3aaef32384ba240da9508"

URI_aarch64_libkdepim = "${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkdepim;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdepim}"
SRC_URI[aarch64_libkdepim.sha256sum] = "b373a20e599307f02f5c8bd26d89eb2e6da00e76f153df21124d8db151407417"

URI_aarch64_libkdepim-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkdepim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdepim-devel}"
SRC_URI[aarch64_libkdepim-devel.sha256sum] = "f699910f0d9b7bbfab9879aaf7cfc538ba115139d150a0595be0d60453493151"

URI_aarch64_libkdepim-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_libkdepim-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdepim-doc}"
SRC_URI[aarch64_libkdepim-doc.sha256sum] = "b5287149ed042d93b8634bcdd52ddf95d9c8d1954d92b4440b97c9ce6ed13ae1"

RDEPENDS:libkdepim = " \
 glibc \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdepim-devel = " \
 cmake-filesystem \
 glibc \
 libkdepim \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdepim-doc = " \
 "
