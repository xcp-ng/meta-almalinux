# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-remote-desktop"
PV = "47.3"
PR = "3.el10_1"
PACKAGES = " \
 gnome-remote-desktop \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-remote-desktop-47.3-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68b2df31ae4b6505273ed26fbe4ae0c99e19f1192c56506d5bc10132907d3e35"

URI_x86_64_v2_gnome-remote-desktop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-remote-desktop-47.3-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_gnome-remote-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-remote-desktop}"
SRC_URI[x86_64_v2_gnome-remote-desktop.sha256sum] = "ed967a9052d11491208b524ac81a6e23986084d3c0acc5657596754805abcdd0"

URI_aarch64_gnome-remote-desktop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-remote-desktop-47.3-3.el10_1.aarch64.rpm;name=aarch64_gnome-remote-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-remote-desktop}"
SRC_URI[aarch64_gnome-remote-desktop.sha256sum] = "9b892190158b7766370df4ed46e1539b4e21e14da191184403d7091c64c3fba4"

RDEPENDS:gnome-remote-desktop = " \
 bash \
 cairo \
 fdk-aac-free \
 freerdp-libs \
 fuse3-libs \
 glib2 \
 glibc \
 libei \
 libepoxy \
 libgcc \
 libnotify \
 libsecret \
 libwinpr \
 libxkbcommon \
 opus \
 pipewire \
 pipewire-libs \
 polkit-libs \
 systemd-libs \
 tpm2-tss \
 "
