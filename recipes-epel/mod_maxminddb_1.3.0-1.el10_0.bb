# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_maxminddb"
PV = "1.3.0"
PR = "1.el10_0"
PACKAGES = " \
 mod_maxminddb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mod_maxminddb-1.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f188d831a535974e94294fcb5ff27d8a43815c66d76cec425c7510160c7d287b"

URI_x86_64_v2_mod_maxminddb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mod_maxminddb-1.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mod_maxminddb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_maxminddb}"
SRC_URI[x86_64_v2_mod_maxminddb.sha256sum] = "a46063edbd83499fcb52aac83e72e35c9168f93263d1e7aa6e7858f64e7e9d4a"

URI_aarch64_mod_maxminddb = "${EPEL_MIRROR}/aarch64/Packages/m/mod_maxminddb-1.3.0-1.el10_0.aarch64.rpm;name=aarch64_mod_maxminddb;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_maxminddb}"
SRC_URI[aarch64_mod_maxminddb.sha256sum] = "4dcb1454b8916175966b2ccd40883994811052fcfc559a97f96f49c3b23a5811"

RDEPENDS:mod_maxminddb = " \
 glibc \
 httpd-core \
 libmaxminddb \
 "
