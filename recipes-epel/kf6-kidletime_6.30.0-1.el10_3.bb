# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kidletime"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kidletime \
 kf6-kidletime-devel \
 kf6-kidletime-doc \
 kf6-kidletime-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kidletime-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "debe5f6d43f80d5283ac3bea6b36aebb61a8b71a499e0cf4d0435c25aca13586"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kidletime;unpack=0"
SRC_URI[x86_64_v2_kf6-kidletime.sha256sum] = "596548d7729a9a8798b3763bdd8e14354fff7c7b3d4e267502e479f4b2cc2518"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kidletime-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kidletime-devel.sha256sum] = "640932536f446049d8fc318ca309ec2de3fa2ec2cc8b3763bb3bd0427d43c693"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kidletime-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kidletime-doc.sha256sum] = "357cedc75cc3b40840c2660db5de29c1222068f4f1d1095c6434eeae89d54d91"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kidletime-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kidletime-html.sha256sum] = "4fdd568d9838092c261d09e5fe3f2f880db7496bd6f77fa277b802d356faf671"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kidletime;unpack=0"
SRC_URI[aarch64_kf6-kidletime.sha256sum] = "7922bc92c4a49ee990eb06d553f5135079faa88ccbe2de9738d67ad31d479d6f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kidletime-devel;unpack=0"
SRC_URI[aarch64_kf6-kidletime-devel.sha256sum] = "5277bd4f5e061f91f69e45aedf89fbad261e6a802885ec371923e029dee7ab69"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kidletime-doc;unpack=0"
SRC_URI[aarch64_kf6-kidletime-doc.sha256sum] = "4b3887c695b43485a78fc7cf93683250df67aebda148d61b93931c75efc129c6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kidletime-html;unpack=0"
SRC_URI[aarch64_kf6-kidletime-html.sha256sum] = "f514f84513a20969edc1af920cda432578522fd051dfb4d448ac1304ec49ba1d"

RDEPENDS:kf6-kidletime = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kidletime-devel = " \
 cmake-filesystem \
 kf6-kidletime \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kidletime-doc = " \
 "
RDEPENDS:kf6-kidletime-html = " \
 "
