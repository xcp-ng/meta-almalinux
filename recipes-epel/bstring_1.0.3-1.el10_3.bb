# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bstring"
PV = "1.0.3"
PR = "1.el10_3"
PACKAGES = " \
 bstring \
 bstring-devel \
 bstring-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bstring-1.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3c36c0db3752174f0aba844e03c5ea757723a9bc589b18b186f0e389b4fb9a0e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bstring-1.0.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bstring;unpack=0"
SRC_URI[x86_64_v2_bstring.sha256sum] = "d3b52aabe55536025e08c5867683988de1b4cbc9c9021abb61958f4f7043b3a6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bstring-devel-1.0.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bstring-devel;unpack=0"
SRC_URI[x86_64_v2_bstring-devel.sha256sum] = "0583262a19873578d916139e45027772e0bfac368569c290aa0fe91ce788b1f7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bstring-doc-1.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_bstring-doc;unpack=0"
SRC_URI[x86_64_v2_bstring-doc.sha256sum] = "f5376a5e62cfd09267e614bd7ab43c2a1f8c15d48bf72acfc2761650e926322a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bstring-1.0.3-1.el10_3.aarch64.rpm;name=aarch64_bstring;unpack=0"
SRC_URI[aarch64_bstring.sha256sum] = "fd809dfdc6c7759cdd00b05f42e0754d2e1fa62327838d535239c5d9f9254614"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bstring-devel-1.0.3-1.el10_3.aarch64.rpm;name=aarch64_bstring-devel;unpack=0"
SRC_URI[aarch64_bstring-devel.sha256sum] = "bb235aaf57d10069a6b3998a7353e04b04f87fcbb240ee5351ed613b0ff31d8a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bstring-doc-1.0.3-1.el10_3.noarch.rpm;name=aarch64_bstring-doc;unpack=0"
SRC_URI[aarch64_bstring-doc.sha256sum] = "108f9e7c1c92879256e35f457b86b57c10ad0b09d85791d0251c51b5cc570de5"

RDEPENDS:bstring = " \
 glibc \
 "
RDEPENDS:bstring-devel = " \
 bstring \
 pkgconf-pkg-config \
 "
RDEPENDS:bstring-doc = " \
 "
