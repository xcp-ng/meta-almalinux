# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-RecordParser"
PV = "1.6.5"
PR = "34.el10_3"
PACKAGES = " \
 perl-Text-RecordParser \
 perl-Text-RecordParser-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-RecordParser-1.6.5-34.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4c00dabf02d9c7b045c393efb5f89fe2f2ad6fc7ea599567dca20e2ae9bc612"

URI_x86_64_v2_perl-Text-RecordParser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-RecordParser-1.6.5-34.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-RecordParser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-RecordParser}"
SRC_URI[x86_64_v2_perl-Text-RecordParser.sha256sum] = "9cb05f0578e2d544d08740f81f5850cbd6513383b43e875f9a8e816323e8122b"

URI_x86_64_v2_perl-Text-RecordParser-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-RecordParser-tools-1.6.5-34.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-RecordParser-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-RecordParser-tools}"
SRC_URI[x86_64_v2_perl-Text-RecordParser-tools.sha256sum] = "9519540a6ddca8b64ca416028022bc3ea10d0b287e805a8f6b2417b33353e52f"

URI_aarch64_perl-Text-RecordParser = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-RecordParser-1.6.5-34.el10_3.noarch.rpm;name=aarch64_perl-Text-RecordParser;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-RecordParser}"
SRC_URI[aarch64_perl-Text-RecordParser.sha256sum] = "1a476bac630d7b113e319e1950ec896ed361a1565800a363234056501ab175ae"

URI_aarch64_perl-Text-RecordParser-tools = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-RecordParser-tools-1.6.5-34.el10_3.noarch.rpm;name=aarch64_perl-Text-RecordParser-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-RecordParser-tools}"
SRC_URI[aarch64_perl-Text-RecordParser-tools.sha256sum] = "a66f8a847e1e822b5d3bfb71b593fd3937745ba9856bde6ea313bb045762a322"

RDEPENDS:perl-Text-RecordParser = " \
 perl-Carp \
 perl-Class-Accessor \
 perl-IO-stringy \
 perl-List-MoreUtils \
 perl-Readonly \
 perl-Text-ParseWords \
 perl-Text-RecordParser \
 perl-base \
 perl-libs \
 perl-version \
 "
RDEPENDS:perl-Text-RecordParser-tools = " \
 perl-English \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-GraphViz \
 perl-Pod-Usage \
 perl-Readonly \
 perl-Scalar-List-Utils \
 perl-Text-Autoformat \
 perl-Text-RecordParser \
 perl-Text-TabularDisplay \
 perl-interpreter \
 perl-libs \
 perl-version \
 "
