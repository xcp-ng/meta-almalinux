# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CPAN-DistnameInfo"
PV = "0.12"
PR = "32.el10"
PACKAGES = " \
 perl-CPAN-DistnameInfo \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-CPAN-DistnameInfo-0.12-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "230e01fcbb82390c81d53dbb53bbf29bbd080dc2e307497c53e26129a34e06e0"

URI_x86_64_v2_perl-CPAN-DistnameInfo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-CPAN-DistnameInfo-0.12-32.el10.noarch.rpm;name=x86_64_v2_perl-CPAN-DistnameInfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CPAN-DistnameInfo}"
SRC_URI[x86_64_v2_perl-CPAN-DistnameInfo.sha256sum] = "1493c0e5b3fd60ff14881976927cb8f4e6299886f1c6bb748591c357d49fcdf9"

URI_aarch64_perl-CPAN-DistnameInfo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-CPAN-DistnameInfo-0.12-32.el10.noarch.rpm;name=aarch64_perl-CPAN-DistnameInfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CPAN-DistnameInfo}"
SRC_URI[aarch64_perl-CPAN-DistnameInfo.sha256sum] = "1493c0e5b3fd60ff14881976927cb8f4e6299886f1c6bb748591c357d49fcdf9"

RDEPENDS:perl-CPAN-DistnameInfo = " \
 perl-libs \
 "
