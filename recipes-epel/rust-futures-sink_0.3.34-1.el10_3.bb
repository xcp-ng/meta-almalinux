# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-sink"
PV = "0.3.34"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-sink+alloc-devel \
 rust-futures-sink+default-devel \
 rust-futures-sink+std-devel \
 rust-futures-sink-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-futures-sink-0.3.34-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "16e912de57d96d5c706a4ea0cf1b07fb1e094993dfccd47b94325bba119df30c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink+alloc-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-sink+alloc-devel.sha256sum] = "56cb46724d1817caaf3160bb4c7ba669cbf51f99b4258899d95e55ceaadd454c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink+default-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-sink+default-devel.sha256sum] = "ea577c15438c3be8a5a575d25d5c3ef4b13d305c26e793ec1685c624ea38cd21"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink+std-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-sink+std-devel.sha256sum] = "031329692aa7ab0fbabf1afbfbabfc1ee20eccb4cbface64b8cdefe7f9c0b05b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-sink-devel.sha256sum] = "9203a558374519228fa3704aafceb0060b3b4fd4642eaf1649dedc76dcb93bad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink+alloc-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-sink+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-futures-sink+alloc-devel.sha256sum] = "ae4964b7eaa9230b17a651883cdf6b0c48d9441e529e96dc738eefca535f6ab4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink+default-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-sink+default-devel;unpack=0"
SRC_URI[aarch64_rust-futures-sink+default-devel.sha256sum] = "4ed1d17ed6eee676434711e8528a4725e9a2ad46b71cff101daca235598b4fc3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink+std-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-sink+std-devel;unpack=0"
SRC_URI[aarch64_rust-futures-sink+std-devel.sha256sum] = "6100a6aafe9d4b8ed572b80b7c1250ecc532f871ea9fe79f2cde912bb5c219a4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-sink-devel;unpack=0"
SRC_URI[aarch64_rust-futures-sink-devel.sha256sum] = "d35cfe010aa2cb1d6c565ee5c96cd68ece976d195f9f20f02ee8605fdba15558"

RDEPENDS:rust-futures-sink+alloc-devel = " \
 cargo \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-sink+default-devel = " \
 cargo \
 rust-futures-sink+std-devel \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-sink+std-devel = " \
 cargo \
 rust-futures-sink+alloc-devel \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-sink-devel = " \
 cargo \
 rust \
 "
