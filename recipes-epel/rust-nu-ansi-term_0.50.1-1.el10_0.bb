# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nu-ansi-term"
PV = "0.50.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-nu-ansi-term+default-devel \
 rust-nu-ansi-term+derive_serde_style-devel \
 rust-nu-ansi-term+gnu_legacy-devel \
 rust-nu-ansi-term+serde-devel \
 rust-nu-ansi-term-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nu-ansi-term-0.50.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c0fcba16ba73f9af32e90e06409aa8dda49ab1c1c133a1fc684198f5f64e514"

URI_x86_64_v2_rust-nu-ansi-term+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term+default-devel-0.50.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nu-ansi-term+default-devel}"
SRC_URI[x86_64_v2_rust-nu-ansi-term+default-devel.sha256sum] = "d30a0843933b415b1e6c9f23cdce0410da5b0d5eac23abff78a48fb2cb5e49cd"

URI_x86_64_v2_rust-nu-ansi-term+derive_serde_style-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term+derive_serde_style-devel-0.50.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term+derive_serde_style-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nu-ansi-term+derive_serde_style-devel}"
SRC_URI[x86_64_v2_rust-nu-ansi-term+derive_serde_style-devel.sha256sum] = "b687f9f0f71e0b859f3ca3e5847c3f84e81054a7ee4636bbdc07445876f7c0f2"

URI_x86_64_v2_rust-nu-ansi-term+gnu_legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term+gnu_legacy-devel-0.50.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term+gnu_legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nu-ansi-term+gnu_legacy-devel}"
SRC_URI[x86_64_v2_rust-nu-ansi-term+gnu_legacy-devel.sha256sum] = "dea0f18b35fab4eec2e85f958fe64b7a90e4b4f8828fdf954143ff61a39d29f0"

URI_x86_64_v2_rust-nu-ansi-term+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term+serde-devel-0.50.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nu-ansi-term+serde-devel}"
SRC_URI[x86_64_v2_rust-nu-ansi-term+serde-devel.sha256sum] = "66f54212f64bbc1dc9967c1107023af020272c3dd45cdaf4ad2710d0f01ab37e"

URI_x86_64_v2_rust-nu-ansi-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term-devel-0.50.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nu-ansi-term-devel}"
SRC_URI[x86_64_v2_rust-nu-ansi-term-devel.sha256sum] = "738f03978c73516101e442decf480af39c66f8f73f69e6190c475f984adaa140"

URI_aarch64_rust-nu-ansi-term+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term+default-devel-0.50.1-1.el10_0.noarch.rpm;name=aarch64_rust-nu-ansi-term+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nu-ansi-term+default-devel}"
SRC_URI[aarch64_rust-nu-ansi-term+default-devel.sha256sum] = "e56ac1eefba637e71e80a1f405ece256e88816f86a01e9e5d7b72b342e2a0ccb"

URI_aarch64_rust-nu-ansi-term+derive_serde_style-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term+derive_serde_style-devel-0.50.1-1.el10_0.noarch.rpm;name=aarch64_rust-nu-ansi-term+derive_serde_style-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nu-ansi-term+derive_serde_style-devel}"
SRC_URI[aarch64_rust-nu-ansi-term+derive_serde_style-devel.sha256sum] = "088ca468c15f2aeb113b49c9e95c2d32d48a91d0f3e7065e04242662770690a4"

URI_aarch64_rust-nu-ansi-term+gnu_legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term+gnu_legacy-devel-0.50.1-1.el10_0.noarch.rpm;name=aarch64_rust-nu-ansi-term+gnu_legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nu-ansi-term+gnu_legacy-devel}"
SRC_URI[aarch64_rust-nu-ansi-term+gnu_legacy-devel.sha256sum] = "f40959173405ef20ca66a79620fe09a31671f4fc845266075e2658cc7f0c23b0"

URI_aarch64_rust-nu-ansi-term+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term+serde-devel-0.50.1-1.el10_0.noarch.rpm;name=aarch64_rust-nu-ansi-term+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nu-ansi-term+serde-devel}"
SRC_URI[aarch64_rust-nu-ansi-term+serde-devel.sha256sum] = "1cbafeb8bebf314a2605a7df4770dafea83a0f74db7a72bda4d683b49a13a59d"

URI_aarch64_rust-nu-ansi-term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term-devel-0.50.1-1.el10_0.noarch.rpm;name=aarch64_rust-nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nu-ansi-term-devel}"
SRC_URI[aarch64_rust-nu-ansi-term-devel.sha256sum] = "1aabfcd083b01608eaa9cff3176be5319f2358edf157a2be7f3b0cca458d1d47"

RDEPENDS:rust-nu-ansi-term+default-devel = " \
 cargo \
 rust-nu-ansi-term-devel \
 "
RDEPENDS:rust-nu-ansi-term+derive_serde_style-devel = " \
 cargo \
 rust-nu-ansi-term+serde-devel \
 rust-nu-ansi-term-devel \
 "
RDEPENDS:rust-nu-ansi-term+gnu_legacy-devel = " \
 cargo \
 rust-nu-ansi-term-devel \
 "
RDEPENDS:rust-nu-ansi-term+serde-devel = " \
 cargo \
 rust-nu-ansi-term-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-nu-ansi-term-devel = " \
 cargo \
 rust \
 "
