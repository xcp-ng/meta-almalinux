# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtbase"
PV = "6.8.1"
PR = "9.el10_0"
PACKAGES = " \
 qt6-qtbase \
 qt6-qtbase-common \
 qt6-qtbase-devel \
 qt6-qtbase-examples \
 qt6-qtbase-gui \
 qt6-qtbase-mysql \
 qt6-qtbase-odbc \
 qt6-qtbase-postgresql \
 qt6-qtbase-private-devel \
 qt6-qtbase-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtbase-6.8.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb6fd63e1a88acfe5d40a2bc4793af2a5d933f75074e9c7a00a1f7d0b69b09f8"

URI_x86_64_v2_qt6-qtbase = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-6.8.1-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase}"
SRC_URI[x86_64_v2_qt6-qtbase.sha256sum] = "ea42dcd75028dd685060dbe701ef906db4340b18e4a3c975c74580f53d6dfe9c"

URI_x86_64_v2_qt6-qtbase-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-common-6.8.1-9.el10_0.noarch.rpm;name=x86_64_v2_qt6-qtbase-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-common}"
SRC_URI[x86_64_v2_qt6-qtbase-common.sha256sum] = "2baa8d2e46e918b540c61a8d7ff2f4ff040d6624caf3bceac5644eb9a2a19949"

URI_x86_64_v2_qt6-qtbase-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-devel-6.8.1-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-devel}"
SRC_URI[x86_64_v2_qt6-qtbase-devel.sha256sum] = "2952a148a77a6cd27d4bfafb3bcfc2daa87b60b689b8ce6d9097be32ffd10dcf"

URI_x86_64_v2_qt6-qtbase-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtbase-examples-6.8.1-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-examples}"
SRC_URI[x86_64_v2_qt6-qtbase-examples.sha256sum] = "5a8602568559da02077e1e74fcc3a3b12496bde897ab21ebc9ca885952add926"

URI_x86_64_v2_qt6-qtbase-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-gui-6.8.1-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-gui}"
SRC_URI[x86_64_v2_qt6-qtbase-gui.sha256sum] = "e4345c9e339e95cafc12abbe8ea8925a46a095e12478814e64e5a790c757270d"

URI_x86_64_v2_qt6-qtbase-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-mysql-6.8.1-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-mysql}"
SRC_URI[x86_64_v2_qt6-qtbase-mysql.sha256sum] = "479de4110c590402db15b1e70cfe75add2c2c9e6b973fecbc8cc16edb969f197"

URI_x86_64_v2_qt6-qtbase-odbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-odbc-6.8.1-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-odbc}"
SRC_URI[x86_64_v2_qt6-qtbase-odbc.sha256sum] = "bbadb0982e9946eb210b0f8061c5a1920cf7b549c638e60c73067a7b21e32ee8"

URI_x86_64_v2_qt6-qtbase-postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-postgresql-6.8.1-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-postgresql}"
SRC_URI[x86_64_v2_qt6-qtbase-postgresql.sha256sum] = "39059be783823b365a6c248c03cad4c2a111f80774e17e5fbee1a93d73d51354"

URI_x86_64_v2_qt6-qtbase-private-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtbase-private-devel-6.8.1-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-private-devel}"
SRC_URI[x86_64_v2_qt6-qtbase-private-devel.sha256sum] = "9f938d0bd6ca54e61bd39e54abfbbf7a0163454d8bbfdfdf51858a3b5aec5272"

URI_x86_64_v2_qt6-qtbase-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtbase-static-6.8.1-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-static}"
SRC_URI[x86_64_v2_qt6-qtbase-static.sha256sum] = "a3e4d4410035698e01a842f9aad8c907b6b33d7a022049c8285cc3d3dbb84da8"

URI_aarch64_qt6-qtbase = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-6.8.1-9.el10_0.aarch64.rpm;name=aarch64_qt6-qtbase;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase}"
SRC_URI[aarch64_qt6-qtbase.sha256sum] = "49ad553e9906518892d161fda728945ee422c73e388fe4febedbee871e3d4c3a"

URI_aarch64_qt6-qtbase-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-common-6.8.1-9.el10_0.noarch.rpm;name=aarch64_qt6-qtbase-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-common}"
SRC_URI[aarch64_qt6-qtbase-common.sha256sum] = "2baa8d2e46e918b540c61a8d7ff2f4ff040d6624caf3bceac5644eb9a2a19949"

URI_aarch64_qt6-qtbase-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-devel-6.8.1-9.el10_0.aarch64.rpm;name=aarch64_qt6-qtbase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-devel}"
SRC_URI[aarch64_qt6-qtbase-devel.sha256sum] = "05f0991282a1cc3a4e52821ab7a6e813111c1ae28e46c1202a51afe6119554ea"

URI_aarch64_qt6-qtbase-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtbase-examples-6.8.1-9.el10_0.aarch64.rpm;name=aarch64_qt6-qtbase-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-examples}"
SRC_URI[aarch64_qt6-qtbase-examples.sha256sum] = "aa5765e8cd51ad97b293f64788aac6c143aab2bcf68f352c8edc421d1d1d0adb"

URI_aarch64_qt6-qtbase-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-gui-6.8.1-9.el10_0.aarch64.rpm;name=aarch64_qt6-qtbase-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-gui}"
SRC_URI[aarch64_qt6-qtbase-gui.sha256sum] = "ebe3b2d48dede7abb18b6ed1595b0f856c5e1be4841021d13e8b595870e1f0a5"

URI_aarch64_qt6-qtbase-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-mysql-6.8.1-9.el10_0.aarch64.rpm;name=aarch64_qt6-qtbase-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-mysql}"
SRC_URI[aarch64_qt6-qtbase-mysql.sha256sum] = "f537361d1752d30c6f7c987fe0d4eda711a5788c5b81fcac6222e70c83336f73"

URI_aarch64_qt6-qtbase-odbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-odbc-6.8.1-9.el10_0.aarch64.rpm;name=aarch64_qt6-qtbase-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-odbc}"
SRC_URI[aarch64_qt6-qtbase-odbc.sha256sum] = "94f9972973da9cf981e21f4e62c7140b28a21aaebd35424bfe6ba5656a7a59ab"

URI_aarch64_qt6-qtbase-postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-postgresql-6.8.1-9.el10_0.aarch64.rpm;name=aarch64_qt6-qtbase-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-postgresql}"
SRC_URI[aarch64_qt6-qtbase-postgresql.sha256sum] = "931e2e848a2040cf4e8ea92dc428cfdf3a4f211b8bbcaaa070250a08056c717d"

URI_aarch64_qt6-qtbase-private-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtbase-private-devel-6.8.1-9.el10_0.aarch64.rpm;name=aarch64_qt6-qtbase-private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-private-devel}"
SRC_URI[aarch64_qt6-qtbase-private-devel.sha256sum] = "185eef93247e327fa6e2189492ff789cf17d2e4648c5c39bbb97152556f03754"

URI_aarch64_qt6-qtbase-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtbase-static-6.8.1-9.el10_0.aarch64.rpm;name=aarch64_qt6-qtbase-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-static}"
SRC_URI[aarch64_qt6-qtbase-static.sha256sum] = "a3742293e71f354d223cf9a0ab9bda3504ab0cebbec389880ae87d21bf0e32ff"

RDEPENDS:qt6-qtbase = " \
 dbus-libs \
 glib2 \
 glibc \
 krb5-libs \
 libbrotli \
 libgcc \
 libicu \
 libproxy \
 libstdc++ \
 libzstd \
 openssl-libs \
 pcre2-utf16 \
 qt6-filesystem \
 qt6-qtbase-common \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:qt6-qtbase-common = " \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtbase-devel = " \
 bash \
 cmake-filesystem \
 glibc \
 libgcc \
 libglvnd-devel \
 libstdc++ \
 libxkbcommon-devel \
 libzstd \
 pcre2-utf16 \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qtbase-mysql \
 qt6-qtbase-odbc \
 qt6-qtbase-postgresql \
 qt6-rpm-macros \
 vulkan-loader-devel \
 "
RDEPENDS:qt6-qtbase-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:qt6-qtbase-gui:x86_64_v2 = " \
 bash \
 cups-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 glx-utils \
 harfbuzz \
 libICE \
 libSM \
 libX11 \
 libX11-xcb \
 libdrm \
 libgcc \
 libglvnd-egl \
 libglvnd-glx \
 libglvnd-opengl \
 libinput \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libxcb \
 libxkbcommon \
 libxkbcommon-x11 \
 mesa-libgbm \
 mtdev \
 qt6-qtbase \
 systemd-libs \
 xcb-util-cursor \
 xcb-util-image \
 xcb-util-keysyms \
 xcb-util-renderutil \
 xcb-util-wm \
 zlib-ng-compat \
"
RDEPENDS:qt6-qtbase-gui:aarch64 = " \
 bash \
 cups-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 glx-utils \
 harfbuzz \
 libICE \
 libSM \
 libX11 \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libglvnd-glx \
 libglvnd-opengl \
 libinput \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libxcb \
 libxkbcommon \
 libxkbcommon-x11 \
 mesa-libgbm \
 mtdev \
 qt6-qtbase \
 systemd-libs \
 xcb-util-cursor \
 xcb-util-image \
 xcb-util-keysyms \
 xcb-util-renderutil \
 xcb-util-wm \
 zlib-ng-compat \
"
RDEPENDS:qt6-qtbase-mysql = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 mariadb-connector-c \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtbase-odbc = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt6-qtbase \
 unixODBC \
 "
RDEPENDS:qt6-qtbase-postgresql = " \
 cmake-filesystem \
 glibc \
 libpq \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtbase-private-devel = " \
 cmake-filesystem \
 cups-devel \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:qt6-qtbase-static = " \
 cmake-filesystem \
 fontconfig-devel \
 glib2-devel \
 libinput-devel \
 libxkbcommon-devel \
 qt6-qtbase-devel \
 zlib-ng-compat-devel \
 "
