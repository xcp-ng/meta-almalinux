# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knot-resolver"
PV = "5.7.6"
PR = "1.el10_1"
PACKAGES = " \
 knot-resolver \
 knot-resolver-devel \
 knot-resolver-module-dnstap \
 knot-resolver-module-http \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knot-resolver-5.7.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ac129fd7a93104e1bbafad150dcca1aa22f3aee54600828a1515dcf2c4b72db"

URI_x86_64_v2_knot-resolver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-resolver-5.7.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-resolver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-resolver}"
SRC_URI[x86_64_v2_knot-resolver.sha256sum] = "6e38e489cdf803289d92e6878a0903df265279d786d4bd75242887e08c524e2f"

URI_x86_64_v2_knot-resolver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-resolver-devel-5.7.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-resolver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-resolver-devel}"
SRC_URI[x86_64_v2_knot-resolver-devel.sha256sum] = "8d623d8ad043746ad544b41181982bb2f20958fece28d0a5a5cd087f4b6f3be1"

URI_x86_64_v2_knot-resolver-module-dnstap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-resolver-module-dnstap-5.7.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-resolver-module-dnstap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-resolver-module-dnstap}"
SRC_URI[x86_64_v2_knot-resolver-module-dnstap.sha256sum] = "efcc8e7e7a02754c8450b7031957052adffdf6e59a6f93db6385f3c59d25be95"

URI_x86_64_v2_knot-resolver-module-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-resolver-module-http-5.7.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-resolver-module-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-resolver-module-http}"
SRC_URI[x86_64_v2_knot-resolver-module-http.sha256sum] = "9f7d048e77fdf92701e971e9d894d2099dfc351ad30a3f8e819d12ab7e20903d"

URI_aarch64_knot-resolver = "${EPEL_MIRROR}/aarch64/Packages/k/knot-resolver-5.7.6-1.el10_1.aarch64.rpm;name=aarch64_knot-resolver;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-resolver}"
SRC_URI[aarch64_knot-resolver.sha256sum] = "c83c3ecd6e632f07af5511ef9fc91d441b78abf2c78f51c56eb79a70ef4979a1"

URI_aarch64_knot-resolver-devel = "${EPEL_MIRROR}/aarch64/Packages/k/knot-resolver-devel-5.7.6-1.el10_1.aarch64.rpm;name=aarch64_knot-resolver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-resolver-devel}"
SRC_URI[aarch64_knot-resolver-devel.sha256sum] = "299d2bd2ce7b9f3413f67ff9cb0cb48bf75bc749916c9408d10955b8decbce58"

URI_aarch64_knot-resolver-module-dnstap = "${EPEL_MIRROR}/aarch64/Packages/k/knot-resolver-module-dnstap-5.7.6-1.el10_1.aarch64.rpm;name=aarch64_knot-resolver-module-dnstap;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-resolver-module-dnstap}"
SRC_URI[aarch64_knot-resolver-module-dnstap.sha256sum] = "8cc0fdf56b40fee13bc32eb6cd60cbbcd601a8d972eee8e8d5e354a97413968d"

URI_aarch64_knot-resolver-module-http = "${EPEL_MIRROR}/aarch64/Packages/k/knot-resolver-module-http-5.7.6-1.el10_1.aarch64.rpm;name=aarch64_knot-resolver-module-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-resolver-module-http}"
SRC_URI[aarch64_knot-resolver-module-http.sha256sum] = "3826fbd05be0af6eca591b6e654b61bf81186240429a2e1d7ec4ad50561444d7"

RDEPENDS:knot-resolver = " \
 bash \
 glibc \
 gnutls \
 jemalloc \
 knot-libs \
 libcap-ng \
 libedit \
 libgcc \
 libnghttp2 \
 libstdc++ \
 libuv \
 lmdb-libs \
 lua5.1-basexx \
 lua5.1-cqueues \
 lua5.1-http \
 luajit \
 systemd \
 systemd-libs \
 "
RDEPENDS:knot-resolver-devel = " \
 gnutls-devel \
 knot-devel \
 knot-resolver \
 libuv-devel \
 lmdb-devel \
 luajit-devel \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:knot-resolver-module-dnstap = " \
 fstrm \
 glibc \
 knot-resolver \
 libgcc \
 libuv \
 protobuf-c \
 "
RDEPENDS:knot-resolver-module-http = " \
 glibc \
 knot-resolver \
 lua5.1-http \
 lua5.1-mmdb \
 "
