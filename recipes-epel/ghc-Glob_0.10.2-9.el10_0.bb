# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-Glob"
PV = "0.10.2"
PR = "9.el10_0"
PACKAGES = " \
 ghc-Glob \
 ghc-Glob-devel \
 ghc-Glob-doc \
 ghc-Glob-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-Glob-0.10.2-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2158276cd6158978a4cd0047364876df7d9c70e485831d5b9b13db2289e533fe"

URI_x86_64_v2_ghc-Glob = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Glob-0.10.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Glob;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Glob}"
SRC_URI[x86_64_v2_ghc-Glob.sha256sum] = "4f6cc8b45acebb53c7168601e46b448aee2ef9b1df5695fa1fcf36177f23d78d"

URI_x86_64_v2_ghc-Glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Glob-devel-0.10.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Glob-devel}"
SRC_URI[x86_64_v2_ghc-Glob-devel.sha256sum] = "39eb6094c32570395cd06e7ca6494ab676a8409ae2c8d9900cf97485d84ad429"

URI_x86_64_v2_ghc-Glob-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Glob-doc-0.10.2-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-Glob-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Glob-doc}"
SRC_URI[x86_64_v2_ghc-Glob-doc.sha256sum] = "651116874a822a00f04dab8a6e93b8953492a83e2821a7b292f663f18abf726b"

URI_x86_64_v2_ghc-Glob-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Glob-prof-0.10.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Glob-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Glob-prof}"
SRC_URI[x86_64_v2_ghc-Glob-prof.sha256sum] = "54b5dbdb70c84a3f52caad84c22bce71a1a5ae8e31725d0fd0eebd95fe1e59c5"

URI_aarch64_ghc-Glob = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Glob-0.10.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-Glob;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Glob}"
SRC_URI[aarch64_ghc-Glob.sha256sum] = "6374e4c95cf45024a34a9ac03c64a454f715d2ad1d2c60734df215a10f48f819"

URI_aarch64_ghc-Glob-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Glob-devel-0.10.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-Glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Glob-devel}"
SRC_URI[aarch64_ghc-Glob-devel.sha256sum] = "88fd7072f8a1623f9927a26b687450757dc29e43c7e2fd6878726a4d554a19f9"

URI_aarch64_ghc-Glob-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Glob-doc-0.10.2-9.el10_0.noarch.rpm;name=aarch64_ghc-Glob-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Glob-doc}"
SRC_URI[aarch64_ghc-Glob-doc.sha256sum] = "17501e08936342555b661208d541124cf9c752e1ffe9df51701baf920b041019"

URI_aarch64_ghc-Glob-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Glob-prof-0.10.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-Glob-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Glob-prof}"
SRC_URI[aarch64_ghc-Glob-prof.sha256sum] = "b994e798b0564659cda30688cfc98acfc27ccc4ebe770cb02d0b99019036dd31"

RDEPENDS:ghc-Glob = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-Glob-devel = " \
 ghc-Glob \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-directory-devel \
 ghc-dlist-devel \
 ghc-filepath-devel \
 ghc-transformers-compat-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-Glob-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-Glob-prof = " \
 ghc-Glob-devel \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-directory-prof \
 ghc-dlist-prof \
 ghc-filepath-prof \
 ghc-transformers-compat-prof \
 ghc-transformers-prof \
 "
