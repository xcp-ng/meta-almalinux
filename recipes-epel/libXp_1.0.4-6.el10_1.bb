# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXp"
PV = "1.0.4"
PR = "6.el10_1"
PACKAGES = " \
 libXp \
 libXp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libXp-1.0.4-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fe940742cc7e9a5cc64141e1c246cd34e07f50e5d3f49bee12e575a1d718df9"

URI_x86_64_v2_libXp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXp-1.0.4-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXp}"
SRC_URI[x86_64_v2_libXp.sha256sum] = "c8732adbcf57cc457534dccafa94cfa347c96e15c810ba2cc400b1350495c4f6"

URI_x86_64_v2_libXp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXp-devel-1.0.4-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXp-devel}"
SRC_URI[x86_64_v2_libXp-devel.sha256sum] = "26b1b2a5788435709ad97465e4c954137b83e8cab15a34d3da4049348acfc5d8"

URI_aarch64_libXp = "${EPEL_MIRROR}/aarch64/Packages/l/libXp-1.0.4-6.el10_1.aarch64.rpm;name=aarch64_libXp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXp}"
SRC_URI[aarch64_libXp.sha256sum] = "cdfa8a033a23e2039a65a9f7f04b62c165be30c72eb249868423c907e428829f"

URI_aarch64_libXp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libXp-devel-1.0.4-6.el10_1.aarch64.rpm;name=aarch64_libXp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXp-devel}"
SRC_URI[aarch64_libXp-devel.sha256sum] = "98bd0be9a813ba7eef52dfa1746891c32a8f4589396a50b7e79d4348345049f1"

RDEPENDS:libXp = " \
 glibc \
 libX11 \
 libXau \
 libXext \
 "
RDEPENDS:libXp-devel = " \
 libX11-devel \
 libXau-devel \
 libXext-devel \
 libXp \
 libXp-devel \
 pkgconf-pkg-config \
 "
