# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fiat-crypto"
PV = "0.2.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-fiat-crypto+default-devel \
 rust-fiat-crypto+std-devel \
 rust-fiat-crypto-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fiat-crypto-0.2.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c9bbf6830d3a3d5ce573d9c37fd53b963e695e7f57704558820fca3227db307"

URI_x86_64_v2_rust-fiat-crypto+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fiat-crypto+default-devel-0.2.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fiat-crypto+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fiat-crypto+default-devel}"
SRC_URI[x86_64_v2_rust-fiat-crypto+default-devel.sha256sum] = "1a470d58435bb88a5403df511d767d103a8124c09dd160022ac1e2641c177bfc"

URI_x86_64_v2_rust-fiat-crypto+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fiat-crypto+std-devel-0.2.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fiat-crypto+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fiat-crypto+std-devel}"
SRC_URI[x86_64_v2_rust-fiat-crypto+std-devel.sha256sum] = "b3fe71ee8664418b7bc2ba3f3f98542d50f8cc66de187492c90d08b959ef3d96"

URI_x86_64_v2_rust-fiat-crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fiat-crypto-devel-0.2.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fiat-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fiat-crypto-devel}"
SRC_URI[x86_64_v2_rust-fiat-crypto-devel.sha256sum] = "7cd16b38b236e4a0d7c097eab7d34455016ebe90c8ef5d44db86396b6450133b"

URI_aarch64_rust-fiat-crypto+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fiat-crypto+default-devel-0.2.9-1.el10_0.noarch.rpm;name=aarch64_rust-fiat-crypto+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fiat-crypto+default-devel}"
SRC_URI[aarch64_rust-fiat-crypto+default-devel.sha256sum] = "0db1496d2cac9f98103ac283400948fc57201d852f54f89f6570a2138ace8fc5"

URI_aarch64_rust-fiat-crypto+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fiat-crypto+std-devel-0.2.9-1.el10_0.noarch.rpm;name=aarch64_rust-fiat-crypto+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fiat-crypto+std-devel}"
SRC_URI[aarch64_rust-fiat-crypto+std-devel.sha256sum] = "3d78285820dc9f240b6ccd0a763e6e38b0273c65b293d830633a9603c87961c6"

URI_aarch64_rust-fiat-crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fiat-crypto-devel-0.2.9-1.el10_0.noarch.rpm;name=aarch64_rust-fiat-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fiat-crypto-devel}"
SRC_URI[aarch64_rust-fiat-crypto-devel.sha256sum] = "50ce198bef2f01350029377b92e32bde5ffd77ef55febf99aa3870afab491bcd"

RDEPENDS:rust-fiat-crypto+default-devel = " \
 cargo \
 rust-fiat-crypto+std-devel \
 rust-fiat-crypto-devel \
 "
RDEPENDS:rust-fiat-crypto+std-devel = " \
 cargo \
 rust-fiat-crypto-devel \
 "
RDEPENDS:rust-fiat-crypto-devel = " \
 cargo \
 "
