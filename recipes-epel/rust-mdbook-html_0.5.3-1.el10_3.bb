# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mdbook-html"
PV = "0.5.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-mdbook-html+default-devel \
 rust-mdbook-html+search-devel \
 rust-mdbook-html-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mdbook-html-0.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c08e50de2c992a778c67979b65da9a485b2f24096e5a46fe5a9d878562448aa6"

URI_x86_64_v2_rust-mdbook-html+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-html+default-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-html+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-html+default-devel}"
SRC_URI[x86_64_v2_rust-mdbook-html+default-devel.sha256sum] = "3f5b322f0006ee71d67c7e788a4c6af3086b08146c5f421cc26e11531efff9c5"

URI_x86_64_v2_rust-mdbook-html+search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-html+search-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-html+search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-html+search-devel}"
SRC_URI[x86_64_v2_rust-mdbook-html+search-devel.sha256sum] = "83943f13d60263fc22f9b78d33bdd1c746324fcdb283ed33897e218b2e55f481"

URI_x86_64_v2_rust-mdbook-html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-html-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-html-devel}"
SRC_URI[x86_64_v2_rust-mdbook-html-devel.sha256sum] = "6141422ce2b5b34c19d9080b249cd51ffd63cdb03081964a7cf4c0f9e9693fbd"

URI_aarch64_rust-mdbook-html+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-html+default-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-html+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-html+default-devel}"
SRC_URI[aarch64_rust-mdbook-html+default-devel.sha256sum] = "e2e004de413cbe516558c72a3300e09674a720433e58d84c393a97de0f933940"

URI_aarch64_rust-mdbook-html+search-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-html+search-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-html+search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-html+search-devel}"
SRC_URI[aarch64_rust-mdbook-html+search-devel.sha256sum] = "027c9cf8981d62994c4e2bdafa04145419b5d894bd0dddebd17e6a7fc942528d"

URI_aarch64_rust-mdbook-html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-html-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-html-devel}"
SRC_URI[aarch64_rust-mdbook-html-devel.sha256sum] = "17af587e60539c87aba2a936de167b4cb3da06a771cdc135b99ce4b200e3050c"

RDEPENDS:rust-mdbook-html+default-devel = " \
 cargo \
 rust-mdbook-html-devel \
 "
RDEPENDS:rust-mdbook-html+search-devel = " \
 cargo \
 rust-elasticlunr-rs+default-devel \
 rust-mdbook-html-devel \
 "
RDEPENDS:rust-mdbook-html-devel = " \
 adobe-source-code-pro-fonts \
 cargo \
 open-sans-fonts \
 rust \
 rust-anyhow+default-devel \
 rust-ego-tree+default-devel \
 rust-font-awesome-as-a-crate+default-devel \
 rust-handlebars+default-devel \
 rust-hex+default-devel \
 rust-html5ever+default-devel \
 rust-indexmap+default-devel \
 rust-mdbook-core+default-devel \
 rust-mdbook-markdown+default-devel \
 rust-mdbook-renderer+default-devel \
 rust-pulldown-cmark+html-devel \
 rust-pulldown-cmark-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-sha2+default-devel \
 rust-tracing+default-devel \
 "
