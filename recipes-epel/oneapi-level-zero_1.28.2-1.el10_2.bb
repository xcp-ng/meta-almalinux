# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oneapi-level-zero"
PV = "1.28.2"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 oneapi-level-zero \
 oneapi-level-zero-devel \
 oneapi-level-zero-zello_world \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/o/oneapi-level-zero-1.28.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f70e3ab2673422a5887ce45f85db5d312783cb876deefc39f9ed42366cbe02ca"

URI_x86_64_v2_oneapi-level-zero = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oneapi-level-zero-1.28.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oneapi-level-zero;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oneapi-level-zero}"
SRC_URI[x86_64_v2_oneapi-level-zero.sha256sum] = "72dafe275bc459a492d8b4e0fe8b82fa42a11f2239f23ed233f42d20afb6cc88"

URI_x86_64_v2_oneapi-level-zero-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oneapi-level-zero-devel-1.28.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oneapi-level-zero-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oneapi-level-zero-devel}"
SRC_URI[x86_64_v2_oneapi-level-zero-devel.sha256sum] = "b11ac5a2fc65d4bb67643522ff1f421da6e8e8218361447ef55ff8dbd9343bdf"

URI_x86_64_v2_oneapi-level-zero-zello_world = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oneapi-level-zero-zello_world-1.28.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oneapi-level-zero-zello_world;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oneapi-level-zero-zello_world}"
SRC_URI[x86_64_v2_oneapi-level-zero-zello_world.sha256sum] = "e08abae5f59872c9284d1df49f4fe825f5588afffcaba369fd54f24e549aa664"

RDEPENDS:oneapi-level-zero = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:oneapi-level-zero-devel = " \
 oneapi-level-zero \
 oneapi-level-zero-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:oneapi-level-zero-zello_world = " \
 glibc \
 libgcc \
 libstdc++ \
 oneapi-level-zero \
 "
