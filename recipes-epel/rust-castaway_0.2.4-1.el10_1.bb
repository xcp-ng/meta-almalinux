# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-castaway"
PV = "0.2.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-castaway+alloc-devel \
 rust-castaway+default-devel \
 rust-castaway+std-devel \
 rust-castaway-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-castaway-0.2.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f79b81f7a47aa871d9e040ea8da575d731cf1913daab7623aa5aa3a4f2ebd61"

URI_x86_64_v2_rust-castaway+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-castaway+alloc-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-castaway+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-castaway+alloc-devel}"
SRC_URI[x86_64_v2_rust-castaway+alloc-devel.sha256sum] = "d194289afbe0ee1b732ed5c8ff02096be9ae7ff331c99f8c319558ecc0f2dcbf"

URI_x86_64_v2_rust-castaway+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-castaway+default-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-castaway+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-castaway+default-devel}"
SRC_URI[x86_64_v2_rust-castaway+default-devel.sha256sum] = "172a581d37e58167c2e9f0e080922741cdecef2a05c675ecd303c9b763ed94e6"

URI_x86_64_v2_rust-castaway+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-castaway+std-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-castaway+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-castaway+std-devel}"
SRC_URI[x86_64_v2_rust-castaway+std-devel.sha256sum] = "3c3afd614b58cb6800191570ca790ae0cc211a782ba2971383ff1a9d15814c6d"

URI_x86_64_v2_rust-castaway-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-castaway-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-castaway-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-castaway-devel}"
SRC_URI[x86_64_v2_rust-castaway-devel.sha256sum] = "131b498b6de1202786eaac2af96bcbc0cb0255e7bfbb9454b6dcbbb2c3457663"

URI_aarch64_rust-castaway+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-castaway+alloc-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-castaway+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-castaway+alloc-devel}"
SRC_URI[aarch64_rust-castaway+alloc-devel.sha256sum] = "ec0d62e066c721057ec202e40a90a8c076a9a379cada3019bd95494ed54245ad"

URI_aarch64_rust-castaway+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-castaway+default-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-castaway+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-castaway+default-devel}"
SRC_URI[aarch64_rust-castaway+default-devel.sha256sum] = "5e4b3d8f6806c833f315ae1a5f39a44d62bdb210db8f50fac9513df013e96464"

URI_aarch64_rust-castaway+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-castaway+std-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-castaway+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-castaway+std-devel}"
SRC_URI[aarch64_rust-castaway+std-devel.sha256sum] = "cde17dccac256a1baa7d83514528b119fab673b582e0636357c48d90df410d52"

URI_aarch64_rust-castaway-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-castaway-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-castaway-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-castaway-devel}"
SRC_URI[aarch64_rust-castaway-devel.sha256sum] = "6ebbec348eaaa61265dcb4ba77b416ab41e5efe8d414212e4152016aee6bf74b"

RDEPENDS:rust-castaway+alloc-devel = " \
 cargo \
 rust-castaway-devel \
 "
RDEPENDS:rust-castaway+default-devel = " \
 cargo \
 rust-castaway+std-devel \
 rust-castaway-devel \
 "
RDEPENDS:rust-castaway+std-devel = " \
 cargo \
 rust-castaway+alloc-devel \
 rust-castaway-devel \
 "
RDEPENDS:rust-castaway-devel = " \
 cargo \
 rust-rustversion+default-devel \
 "
