# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgedit-gtksourceview"
PV = "299.4.0"
PR = "1.el10_0"
PACKAGES = " \
 libgedit-gtksourceview \
 libgedit-gtksourceview-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgedit-gtksourceview-299.4.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fdfec0ff4efb3ab30662cb614e1df29e731ee1781538320416a0c739029456d"

URI_x86_64_v2_libgedit-gtksourceview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-gtksourceview-299.4.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-gtksourceview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-gtksourceview}"
SRC_URI[x86_64_v2_libgedit-gtksourceview.sha256sum] = "edfa626e7fe1793ab8bcb04a54d72be7c496656eb42407259818c49d211a1a71"

URI_x86_64_v2_libgedit-gtksourceview-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-gtksourceview-devel-299.4.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-gtksourceview-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-gtksourceview-devel}"
SRC_URI[x86_64_v2_libgedit-gtksourceview-devel.sha256sum] = "29201c7e7d31768cc6a5497af20eacede10504f241be504594ec2ba226b77729"

URI_aarch64_libgedit-gtksourceview = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-gtksourceview-299.4.0-1.el10_0.aarch64.rpm;name=aarch64_libgedit-gtksourceview;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-gtksourceview}"
SRC_URI[aarch64_libgedit-gtksourceview.sha256sum] = "1e3bcef1f5e91340599d9b7ec33b27723b9847afe52e7c4a07ac2548f35e1ae7"

URI_aarch64_libgedit-gtksourceview-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-gtksourceview-devel-299.4.0-1.el10_0.aarch64.rpm;name=aarch64_libgedit-gtksourceview-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-gtksourceview-devel}"
SRC_URI[aarch64_libgedit-gtksourceview-devel.sha256sum] = "d2e588e5282733fefa822522fa36df3cd7439ca142bec61b0e808b335b0b8166"

RDEPENDS:libgedit-gtksourceview = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libxml2 \
 pango \
 "
RDEPENDS:libgedit-gtksourceview-devel = " \
 glib2-devel \
 gtk3-devel \
 libgedit-gtksourceview \
 libxml2-devel \
 pkgconf-pkg-config \
 "
