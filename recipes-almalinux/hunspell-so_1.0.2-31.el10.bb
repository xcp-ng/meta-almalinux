# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-so"
PV = "1.0.2"
PR = "31.el10"
PACKAGES = " \
 hunspell-so \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-so-1.0.2-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72fd6421afa31f77a70dd1963d990a41b3fdee21f42513fa0c9c032e7c479f96"

URI_x86_64_v2_hunspell-so = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-so-1.0.2-31.el10.noarch.rpm;name=x86_64_v2_hunspell-so;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-so}"
SRC_URI[x86_64_v2_hunspell-so.sha256sum] = "7d2b5b0cd3f553a2a98fab7924d1b52c5a440106fc2d9d4147b8c15960b56057"

URI_aarch64_hunspell-so = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-so-1.0.2-31.el10.noarch.rpm;name=aarch64_hunspell-so;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-so}"
SRC_URI[aarch64_hunspell-so.sha256sum] = "7d2b5b0cd3f553a2a98fab7924d1b52c5a440106fc2d9d4147b8c15960b56057"

RDEPENDS:hunspell-so = " \
 hunspell \
 "
