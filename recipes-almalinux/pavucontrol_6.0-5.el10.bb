# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pavucontrol"
PV = "6.0"
PR = "5.el10"
PACKAGES = " \
 pavucontrol \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pavucontrol-6.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c98703241557cc2995bcc16c74c16a4221e20015abaa41570675195b77f5d2e6"

URI_x86_64_v2_pavucontrol = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pavucontrol-6.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_pavucontrol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pavucontrol}"
SRC_URI[x86_64_v2_pavucontrol.sha256sum] = "023ec718dddc2f3e7568645275db125231a211bfea1b7066c0e30ceed5cdb4ef"

URI_aarch64_pavucontrol = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pavucontrol-6.0-5.el10.aarch64.rpm;name=aarch64_pavucontrol;unpack=0"
SRC_URI:append = " ${URI_aarch64_pavucontrol}"
SRC_URI[aarch64_pavucontrol.sha256sum] = "1b0a7b7b25ce63b2b0888487288203f35b9709e5204b4f3f9241040b6d4f23e0"

RDEPENDS:pavucontrol = " \
 glib2 \
 glibc \
 glibmm2.68 \
 gtk4 \
 gtkmm4.0 \
 json-glib \
 libgcc \
 libsigc++30 \
 libstdc++ \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 "
