# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qatzip"
PV = "2.0.0"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 qatzip \
 qatzip-devel \
 qatzip-libs \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qatzip-2.0.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0d84f58c9fe76eb9eef05049e9d4fdb39d0a5a888619366a0eb7199330953a70"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatzip-2.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatzip;unpack=0"
SRC_URI[x86_64_v2_qatzip.sha256sum] = "ed69bac81669cef7ab3feaa33c28621aa4671759165ad1448d3cc4832cc85ccc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qatzip-devel-2.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatzip-devel;unpack=0"
SRC_URI[x86_64_v2_qatzip-devel.sha256sum] = "cd71de2643bd2a15dd3a81e1d945fbc541fbf5b654e42425e681af11af94c0a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatzip-libs-2.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatzip-libs;unpack=0"
SRC_URI[x86_64_v2_qatzip-libs.sha256sum] = "85a94316a431115b1f06a9fa7aa30d0cf88020d373c576bb0729e06e321a8efa"

RDEPENDS:qatzip = " \
 glibc \
 libzstd \
 lz4-libs \
 numactl-libs \
 qatlib \
 zlib-ng-compat \
 "
RDEPENDS:qatzip-devel = " \
 lz4-devel \
 pkgconf-pkg-config \
 qatzip-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:qatzip-libs = " \
 glibc \
 libzstd \
 lz4-libs \
 numactl-libs \
 qatlib \
 zlib-ng-compat \
 "
