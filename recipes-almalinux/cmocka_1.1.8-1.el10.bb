# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cmocka"
PV = "1.1.8"
PR = "1.el10"
PACKAGES = " \
 libcmocka \
 libcmocka-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/cmocka-1.1.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b71e29673a3b37c49fb2fe8f2c4ea1f516885209ec1ab274908a6ec2be0e36ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libcmocka-1.1.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_libcmocka;unpack=0"
SRC_URI[x86_64_v2_libcmocka.sha256sum] = "0850d9bb5a5af0b7375e0b1388f3626ad745c2e8e76aeee4effd6a19f7179e76"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libcmocka-devel-1.1.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_libcmocka-devel;unpack=0"
SRC_URI[x86_64_v2_libcmocka-devel.sha256sum] = "39e4fabb4870dd7fa235d5b023f43b36b6061c627cdf78871941e3226b5b880a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libcmocka-1.1.8-1.el10.aarch64.rpm;name=aarch64_libcmocka;unpack=0"
SRC_URI[aarch64_libcmocka.sha256sum] = "4efe0bdcedd3ecf94150dc1b33052b45b78c10dbf4939c165c58e99dd243c286"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libcmocka-devel-1.1.8-1.el10.aarch64.rpm;name=aarch64_libcmocka-devel;unpack=0"
SRC_URI[aarch64_libcmocka-devel.sha256sum] = "594a8332f58999dff0d6410c50899bed3fe972ea7015a243632ce34291df453e"

RDEPENDS:libcmocka = " \
 glibc \
 "
RDEPENDS:libcmocka-devel = " \
 cmake-filesystem \
 libcmocka \
 pkgconf-pkg-config \
 "
