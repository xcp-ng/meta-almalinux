# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-alsa-sys"
PV = "0.3.1"
PR = "10.el10_0"
PACKAGES = " \
 rust-alsa-sys+default-devel \
 rust-alsa-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-alsa-sys-0.3.1-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21f5b9a4c9ff38383a23e8bb969a20606dfaec722f22d9ba712e11c44cc382f5"

URI_x86_64_v2_rust-alsa-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alsa-sys+default-devel-0.3.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alsa-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-alsa-sys+default-devel}"
SRC_URI[x86_64_v2_rust-alsa-sys+default-devel.sha256sum] = "6a6030972771ebf88cf3431a97f873bcc93e5185de5a4384084563546d042019"

URI_x86_64_v2_rust-alsa-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alsa-sys-devel-0.3.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alsa-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-alsa-sys-devel}"
SRC_URI[x86_64_v2_rust-alsa-sys-devel.sha256sum] = "07b7e51bc25e9d7bb397c842f5a940a35285d2a7564a1982d3bf25cd92310d5c"

URI_aarch64_rust-alsa-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-alsa-sys+default-devel-0.3.1-10.el10_0.noarch.rpm;name=aarch64_rust-alsa-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-alsa-sys+default-devel}"
SRC_URI[aarch64_rust-alsa-sys+default-devel.sha256sum] = "83a80137cc06b0cbdc87e108ed544ad9bd1c89bfaa1e9d96333cbce31ab27d59"

URI_aarch64_rust-alsa-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-alsa-sys-devel-0.3.1-10.el10_0.noarch.rpm;name=aarch64_rust-alsa-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-alsa-sys-devel}"
SRC_URI[aarch64_rust-alsa-sys-devel.sha256sum] = "8aea7a3f5ae1bb5fbc1d3a9651f9c4bb4d2899f3a94a3c29478e465c59e2081b"

RDEPENDS:rust-alsa-sys+default-devel = " \
 cargo \
 rust-alsa-sys-devel \
 "
RDEPENDS:rust-alsa-sys-devel = " \
 alsa-lib-devel \
 bash \
 cargo \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
