# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-osrf-pycommon"
PV = "2.1.7"
PR = "1.el10_2"
PACKAGES = " \
 python-osrf-pycommon-doc \
 python3-osrf-pycommon \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-osrf-pycommon-2.1.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3fa2df7f6bd0b0ba3b004ca1f08814a2b8b6ab14ee0a7a43b6a00cd1aa8468de"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-osrf-pycommon-doc-2.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-osrf-pycommon-doc;unpack=0"
SRC_URI[x86_64_v2_python-osrf-pycommon-doc.sha256sum] = "89346ba1c369ea81fdc4af038678179c1bd4eace25d7959cbcca6d568400d02f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-osrf-pycommon-2.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-osrf-pycommon;unpack=0"
SRC_URI[x86_64_v2_python3-osrf-pycommon.sha256sum] = "d19d8fbd5adee60765a0f1b1921ecc4a11adfeff4267f9b2e9b86aff64e23fac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-osrf-pycommon-doc-2.1.7-1.el10_2.noarch.rpm;name=aarch64_python-osrf-pycommon-doc;unpack=0"
SRC_URI[aarch64_python-osrf-pycommon-doc.sha256sum] = "78fae758469aec45a37bd136418f9f2724897e5126f8bf955a6e5475480b0d1b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-osrf-pycommon-2.1.7-1.el10_2.noarch.rpm;name=aarch64_python3-osrf-pycommon;unpack=0"
SRC_URI[aarch64_python3-osrf-pycommon.sha256sum] = "7dd21d2514ea84fd3ef09bd2201062674fb733a3ca9a4977c77a69e2bfe340d3"

RDEPENDS:python-osrf-pycommon-doc = " \
 "
RDEPENDS:python3-osrf-pycommon = " \
 python3 \
 "
