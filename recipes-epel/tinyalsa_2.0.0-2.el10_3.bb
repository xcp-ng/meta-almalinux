# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tinyalsa"
PV = "2.0.0"
PR = "2.el10_3"
PACKAGES = " \
 tinyalsa \
 tinyalsa-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tinyalsa-2.0.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "85cfa2accdb7d2c2db36fedc913537084e5d7b4ce6f6e8be15c971be027c9744"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinyalsa-2.0.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinyalsa;unpack=0"
SRC_URI[x86_64_v2_tinyalsa.sha256sum] = "971700615e8e62fbc3b3e5ee2d85e93fb29acd62af6210dd4a14f62a9e65cd8d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinyalsa-devel-2.0.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinyalsa-devel;unpack=0"
SRC_URI[x86_64_v2_tinyalsa-devel.sha256sum] = "bf5329413fe6979a1360dea2c4e2bb65ef0aa30c03cbff272b7fe13ebda8cb23"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tinyalsa-2.0.0-2.el10_3.aarch64.rpm;name=aarch64_tinyalsa;unpack=0"
SRC_URI[aarch64_tinyalsa.sha256sum] = "39a0bee1805b1d48f9af5cba49fdb162073339a65dca57f3f5bc8c2967cd5376"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tinyalsa-devel-2.0.0-2.el10_3.aarch64.rpm;name=aarch64_tinyalsa-devel;unpack=0"
SRC_URI[aarch64_tinyalsa-devel.sha256sum] = "980085021eb4be175d9358a9c7e2bf2b4f9049c53de4392135ed519b069d7cbf"

RDEPENDS:tinyalsa = " \
 glibc \
 "
RDEPENDS:tinyalsa-devel = " \
 pkgconf-pkg-config \
 tinyalsa \
 "
