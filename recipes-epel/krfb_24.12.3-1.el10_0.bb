# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krfb"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 krfb \
 krfb-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krfb-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36a78028e69dff1fc8d7ec8670c37e60248fa2333f45fd55df8b10b4a63cb561"

URI_x86_64_v2_krfb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krfb-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krfb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krfb}"
SRC_URI[x86_64_v2_krfb.sha256sum] = "4d5babaa6e363a3f0ede55d08c5a66bbf3d8044266377aa14cefba9cd0e28490"

URI_x86_64_v2_krfb-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krfb-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krfb-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krfb-libs}"
SRC_URI[x86_64_v2_krfb-libs.sha256sum] = "87667e27312122797ce978c25a3ce23f0f4e77128584711ea556ad3867b2c424"

URI_aarch64_krfb = "${EPEL_MIRROR}/aarch64/Packages/k/krfb-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_krfb;unpack=0"
SRC_URI:append = " ${URI_aarch64_krfb}"
SRC_URI[aarch64_krfb.sha256sum] = "d9bc4faa3f02938c56fe86920f4c63614054914bbedf0427c4862013570f25b1"

URI_aarch64_krfb-libs = "${EPEL_MIRROR}/aarch64/Packages/k/krfb-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_krfb-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_krfb-libs}"
SRC_URI[aarch64_krfb-libs.sha256sum] = "5fae8b53ef46696a37aafca61feea155c8b4e00c1bd4f59e7c47a04624a1b2d3"

RDEPENDS:krfb = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 krfb-libs \
 libXtst \
 libstdc++ \
 libvncserver \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:krfb-libs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kpipewire \
 krfb \
 kwayland \
 libX11 \
 libXtst \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 xcb-util-image \
 "
