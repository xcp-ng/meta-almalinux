# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clinfo"
PV = "3.0.25.02.14"
PR = "1.el10_1"
PACKAGES = " \
 clinfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clinfo-3.0.25.02.14-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d675b9306127dfad74b30b9cdf050a8586a27a8925760fc9cfd8918e7a057e8"

URI_x86_64_v2_clinfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clinfo-3.0.25.02.14-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clinfo}"
SRC_URI[x86_64_v2_clinfo.sha256sum] = "b7defbb1dcfd0830a438aa8abc6fffc897b13765cf854524449c501103488928"

URI_aarch64_clinfo = "${EPEL_MIRROR}/aarch64/Packages/c/clinfo-3.0.25.02.14-1.el10_1.aarch64.rpm;name=aarch64_clinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_clinfo}"
SRC_URI[aarch64_clinfo.sha256sum] = "482b3fd0467fb74917da2fa93ce28ff17e8a7fe405d8acc07a8a56a729b7aeb7"

RDEPENDS:clinfo = " \
 glibc \
 ocl-icd \
 "
