# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Term-Size-Perl"
PV = "0.031"
PR = "22.el10"
PACKAGES = " \
 perl-Term-Size-Perl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Term-Size-Perl-0.031-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebcc37ccdb6d0ac12b552f35598678f18d3269ca65e7ce6a6a31053cfe7a089f"

URI_x86_64_v2_perl-Term-Size-Perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Term-Size-Perl-0.031-22.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Term-Size-Perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Term-Size-Perl}"
SRC_URI[x86_64_v2_perl-Term-Size-Perl.sha256sum] = "e15afa47a8fd512376176045a60fa880e7f1354a8e8ecf87d1164d24d4a49bb8"

URI_aarch64_perl-Term-Size-Perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Term-Size-Perl-0.031-22.el10.aarch64.rpm;name=aarch64_perl-Term-Size-Perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Term-Size-Perl}"
SRC_URI[aarch64_perl-Term-Size-Perl.sha256sum] = "ab8402c7068d911343962ce2cf4216e888656a6059f8554f3b44c58160c30a61"

RDEPENDS:perl-Term-Size-Perl = " \
 perl-Exporter \
 perl-Term-Size-Perl \
 perl-libs \
 perl-vars \
 "
