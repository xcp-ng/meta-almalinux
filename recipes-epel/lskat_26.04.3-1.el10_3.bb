# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lskat"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 lskat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lskat-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85646cefc3f8a4dc8987090c66a66e149444c688b36b1aa4082f510b0a5f7404"

URI_x86_64_v2_lskat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lskat-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lskat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lskat}"
SRC_URI[x86_64_v2_lskat.sha256sum] = "f17454611d797616935af966ad404eb0b8f312a57b541f18ee08bfeb0c536d5f"

URI_aarch64_lskat = "${EPEL_MIRROR}/aarch64/Packages/l/lskat-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_lskat;unpack=0"
SRC_URI:append = " ${URI_aarch64_lskat}"
SRC_URI[aarch64_lskat.sha256sum] = "b5f6b74a9880c698273a2fbe9c2e54e21136e82ac2fe6fffc0e0322efaa5e68d"

RDEPENDS:lskat = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
