# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmag"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kmag \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmag-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "800c562fe91e270c83387309a8cd7f9b73d4205fe782dd02bccbebacfeba8aec"

URI_x86_64_v2_kmag = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmag-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmag;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmag}"
SRC_URI[x86_64_v2_kmag.sha256sum] = "56a58fc82730e5f0afb8839446fba9a2c4782eab7601f92f535ecc1587214c21"

URI_aarch64_kmag = "${EPEL_MIRROR}/aarch64/Packages/k/kmag-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmag;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmag}"
SRC_URI[aarch64_kmag.sha256sum] = "31cae97d5ab479a70c9e608dc11497e8a4c7ff460d348506324f5e5b026d14fc"

RDEPENDS:kmag = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qaccessibilityclient-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
