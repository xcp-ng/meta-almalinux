# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mailcommon"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 mailcommon \
 mailcommon-devel \
 mailcommon-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/mailcommon-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1a1835462fe418cce12ca0049cc4d427fb615eaa214a5fbcc8f18462628cac2e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailcommon;unpack=0"
SRC_URI[x86_64_v2_mailcommon.sha256sum] = "2da1a9b8ec1c077c5bcd01becb920c66833cd4c8a98083503c3019ad42d8a9ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailcommon-devel;unpack=0"
SRC_URI[x86_64_v2_mailcommon-devel.sha256sum] = "b6c69aedd47379698f90227a819a56ec989feac865f6c79c330e67f426d68831"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mailcommon-doc;unpack=0"
SRC_URI[x86_64_v2_mailcommon-doc.sha256sum] = "9d0faaee6b8ae74bb4a03dd363cfe1254171c8ac323894b34654e8961fa24e1e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_mailcommon;unpack=0"
SRC_URI[aarch64_mailcommon.sha256sum] = "67ad6f6ba2cff9e6fdda0f0683d7fe9975f1ac4edce30332d1d28b4a6470b722"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_mailcommon-devel;unpack=0"
SRC_URI[aarch64_mailcommon-devel.sha256sum] = "1470568be5267ce53488e0dea69664fc171f12fa695effc7fc588de838e2038b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_mailcommon-doc;unpack=0"
SRC_URI[aarch64_mailcommon-doc.sha256sum] = "47fbd3ddb78f739aa7a451e67337fdd99b69a53fec1f5546ee8f9a1bb1bf9f5f"

RDEPENDS:mailcommon = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 glibc \
 gpgme2pp \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kmime \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kmailtransport \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libkleo \
 libstdc++ \
 mailimporter \
 messagelib \
 pimcommon \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
RDEPENDS:mailcommon-devel = " \
 akonadi-mime-devel \
 akonadi-server-devel \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 mailcommon \
 messagelib-devel \
 pimcommon-devel \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:mailcommon-doc = " \
 "
