# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-cli-tools"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kde-cli-tools \
 kdesu \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-cli-tools-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3df437ac1c14de7d2b9618beac8faaa72089b9cec5116440f14c12e428ab8a79"

URI_x86_64_v2_kde-cli-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-cli-tools-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-cli-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-cli-tools}"
SRC_URI[x86_64_v2_kde-cli-tools.sha256sum] = "876c8062a027adbd308e6a3fe95825ae6646a88dfe2136b6d25444b030c51a39"

URI_x86_64_v2_kdesu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdesu-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdesu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdesu}"
SRC_URI[x86_64_v2_kdesu.sha256sum] = "e9533b243dfc27a76aafb65be33c65ca7061deb23fd05e5ed41a321a7c97fdbd"

URI_aarch64_kde-cli-tools = "${EPEL_MIRROR}/aarch64/Packages/k/kde-cli-tools-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kde-cli-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-cli-tools}"
SRC_URI[aarch64_kde-cli-tools.sha256sum] = "39039a4f88017502d11a9cbab3f0792a04e644614fc75fc7e79f2a27c8d437fb"

URI_aarch64_kdesu = "${EPEL_MIRROR}/aarch64/Packages/k/kdesu-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kdesu;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdesu}"
SRC_URI[aarch64_kdesu.sha256sum] = "ab8b88533c6c6a086a87b686a54d93400a1f81a57056deccb30eef04df51bfc5"

RDEPENDS:kde-cli-tools = " \
 bash \
 glibc \
 kdesu \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-kwindowsystem \
 libkworkspace6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:kdesu = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdesu \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
