# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-mime"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 akonadi-mime \
 akonadi-mime-devel \
 akonadi-mime-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-mime-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9596c17ee5953c09a51a0a5c3ed398b5cdb1e9d8fe084bb0faefa11a0846b2e"

URI_x86_64_v2_akonadi-mime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-mime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-mime}"
SRC_URI[x86_64_v2_akonadi-mime.sha256sum] = "88288e90e9280a32c4205c7e4df866ffb05df30e55feef8cffccc34702ef0019"

URI_x86_64_v2_akonadi-mime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-mime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-mime-devel}"
SRC_URI[x86_64_v2_akonadi-mime-devel.sha256sum] = "d3acbf304a800b49467f0943ed393fa7d2544a8709b6d04874030064083ad9a2"

URI_x86_64_v2_akonadi-mime-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-mime-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-mime-doc}"
SRC_URI[x86_64_v2_akonadi-mime-doc.sha256sum] = "e763da412f3d640dbf77ed3755165d8367a662bdfa383f2923f19a07f8453566"

URI_aarch64_akonadi-mime = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-mime;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-mime}"
SRC_URI[aarch64_akonadi-mime.sha256sum] = "c55a201e5f8f67dedb432cc40770a318ecf3ab714b7a3503105ea9b771cf2234"

URI_aarch64_akonadi-mime-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-mime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-mime-devel}"
SRC_URI[aarch64_akonadi-mime-devel.sha256sum] = "8ff421935ffb5d8ba9d11d06d1b039336ca815b06d37ef9647f701080c4a9562"

URI_aarch64_akonadi-mime-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_akonadi-mime-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-mime-doc}"
SRC_URI[aarch64_akonadi-mime-doc.sha256sum] = "f3d662e449c509e9d1fc7143125ed3c8301579693f56f290f3dd58d562437f2b"

RDEPENDS:akonadi-mime = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-mime-devel = " \
 akonadi-mime \
 akonadi-server-devel \
 cmake-filesystem \
 "
RDEPENDS:akonadi-mime-doc = " \
 "
