# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "md4c"
PV = "0.5.1"
PR = "5.el10_2"
PACKAGES = " \
 md4c \
 md4c-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/md4c-0.5.1-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf4ea4a96509d97ecebb913da6417082a442b1721b7b854e5ba719695a9982d8"

URI_x86_64_v2_md4c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/md4c-0.5.1-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_md4c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_md4c}"
SRC_URI[x86_64_v2_md4c.sha256sum] = "c5eb2839ff5016c03069594e76f9cc0c97b22e62813f57710da724cde680851c"

URI_x86_64_v2_md4c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/md4c-devel-0.5.1-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_md4c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_md4c-devel}"
SRC_URI[x86_64_v2_md4c-devel.sha256sum] = "eef6cff286e4ae4d96c31cd33f7ed1c66c570cb93840fe355ec1e26cdfaa961e"

URI_aarch64_md4c = "${EPEL_MIRROR}/aarch64/Packages/m/md4c-0.5.1-5.el10_2.aarch64.rpm;name=aarch64_md4c;unpack=0"
SRC_URI:append = " ${URI_aarch64_md4c}"
SRC_URI[aarch64_md4c.sha256sum] = "19848fc51630093122bf54443b6fc0966b55c9129de6163e9bbf25c09fca6048"

URI_aarch64_md4c-devel = "${EPEL_MIRROR}/aarch64/Packages/m/md4c-devel-0.5.1-5.el10_2.aarch64.rpm;name=aarch64_md4c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_md4c-devel}"
SRC_URI[aarch64_md4c-devel.sha256sum] = "b2bdb5236774c8d58001b5825ac21f036f7ada289aef6ec8ee910d6784695a25"

RDEPENDS:md4c = " \
 glibc \
 "
RDEPENDS:md4c-devel = " \
 cmake-filesystem \
 md4c \
 pkgconf-pkg-config \
 "
