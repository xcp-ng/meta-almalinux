# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign"
PV = "0.20.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign+aliyun-devel \
 rust-reqsign+aws-devel \
 rust-reqsign+azure-devel \
 rust-reqsign+default-context-devel \
 rust-reqsign+default-devel \
 rust-reqsign+full-devel \
 rust-reqsign+google-devel \
 rust-reqsign+huaweicloud-devel \
 rust-reqsign+oracle-devel \
 rust-reqsign+tencent-devel \
 rust-reqsign+volcengine-devel \
 rust-reqsign-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-0.20.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e3032d7230188c3dd3ddeb9dd90d9c3b74f75decc55430a930c9849fbaf6c05"

URI_x86_64_v2_rust-reqsign+aliyun-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+aliyun-devel-0.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+aliyun-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+aliyun-devel}"
SRC_URI[x86_64_v2_rust-reqsign+aliyun-devel.sha256sum] = "cd6962b03ee2d2beb521ef1534d04331377675e318f56488474e961af1015f03"

URI_x86_64_v2_rust-reqsign+aws-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+aws-devel-0.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+aws-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+aws-devel}"
SRC_URI[x86_64_v2_rust-reqsign+aws-devel.sha256sum] = "2d5d2f2842427609b5d374b20d3e12432791a465c8bb8712b564883392633850"

URI_x86_64_v2_rust-reqsign+azure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+azure-devel-0.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+azure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+azure-devel}"
SRC_URI[x86_64_v2_rust-reqsign+azure-devel.sha256sum] = "7384224831165e201b1c7488595e5fbf0247318d1cfdb1bf52032da01e066f83"

URI_x86_64_v2_rust-reqsign+default-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+default-context-devel-0.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+default-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+default-context-devel}"
SRC_URI[x86_64_v2_rust-reqsign+default-context-devel.sha256sum] = "f08308cd488124cce7cc4ad1f983265f28bfdd895ca9376ae02edd967923b994"

URI_x86_64_v2_rust-reqsign+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+default-devel-0.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign+default-devel.sha256sum] = "c364bd407cbe67b7ba41049a91f06d1dff3fccf1eae35e5a69d243d2706a1780"

URI_x86_64_v2_rust-reqsign+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+full-devel-0.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+full-devel}"
SRC_URI[x86_64_v2_rust-reqsign+full-devel.sha256sum] = "e0bf77affd5ad1dc93565955d73b618d77287919885ee58286d3d0e88053b9b3"

URI_x86_64_v2_rust-reqsign+google-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+google-devel-0.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+google-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+google-devel}"
SRC_URI[x86_64_v2_rust-reqsign+google-devel.sha256sum] = "745080c3866a1836cc29f9445226fe69a88ef422dad3d43f429abfd8714a6a14"

URI_x86_64_v2_rust-reqsign+huaweicloud-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+huaweicloud-devel-0.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+huaweicloud-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+huaweicloud-devel}"
SRC_URI[x86_64_v2_rust-reqsign+huaweicloud-devel.sha256sum] = "3109cd0c319ac4004d6fd7f07e8d4ce532d0adb2c4b8f8be61e6d71020beb4f4"

URI_x86_64_v2_rust-reqsign+oracle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+oracle-devel-0.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+oracle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+oracle-devel}"
SRC_URI[x86_64_v2_rust-reqsign+oracle-devel.sha256sum] = "9d40ad6ecc51ba6dc26998dbdabd45e7143b493ba24aec0d4855619c0d3c3903"

URI_x86_64_v2_rust-reqsign+tencent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+tencent-devel-0.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+tencent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+tencent-devel}"
SRC_URI[x86_64_v2_rust-reqsign+tencent-devel.sha256sum] = "ead6e9e1f3e9eb27ddfe57ca59af102717553e3e46cc411f21734e46b85a1d37"

URI_x86_64_v2_rust-reqsign+volcengine-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+volcengine-devel-0.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+volcengine-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+volcengine-devel}"
SRC_URI[x86_64_v2_rust-reqsign+volcengine-devel.sha256sum] = "a7d2de1a4d02301e35b390674bf2c300186be9aace20fd86acc2423fc9728545"

URI_x86_64_v2_rust-reqsign-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-devel-0.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-devel}"
SRC_URI[x86_64_v2_rust-reqsign-devel.sha256sum] = "f86125aa592524394ada3ddace1434defd69b8ec6078ee3499dc0c00a3172583"

URI_aarch64_rust-reqsign+aliyun-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+aliyun-devel-0.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+aliyun-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+aliyun-devel}"
SRC_URI[aarch64_rust-reqsign+aliyun-devel.sha256sum] = "a1e1329b9ed0416376e6eb78ec024038f805f427082bada6f4b1f96f3c1099d3"

URI_aarch64_rust-reqsign+aws-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+aws-devel-0.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+aws-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+aws-devel}"
SRC_URI[aarch64_rust-reqsign+aws-devel.sha256sum] = "9daed9a27ceaaf52345856c3c7390fa7daba7355873a3cf6c649b0fb0afce915"

URI_aarch64_rust-reqsign+azure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+azure-devel-0.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+azure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+azure-devel}"
SRC_URI[aarch64_rust-reqsign+azure-devel.sha256sum] = "ec598cc045633dabd9674173564f54ecd3e44f5f374594a48ed4833e65e65006"

URI_aarch64_rust-reqsign+default-context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+default-context-devel-0.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+default-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+default-context-devel}"
SRC_URI[aarch64_rust-reqsign+default-context-devel.sha256sum] = "8791397d7709f92ca130fdc71558c26313cf056e514f6ff36e5086fa6d15df72"

URI_aarch64_rust-reqsign+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+default-devel-0.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+default-devel}"
SRC_URI[aarch64_rust-reqsign+default-devel.sha256sum] = "4677434eab48ebc708002d89706fd3e09d309b4cbfab753f84eeb39afee6a60f"

URI_aarch64_rust-reqsign+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+full-devel-0.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+full-devel}"
SRC_URI[aarch64_rust-reqsign+full-devel.sha256sum] = "a40b533e1a8fcabef0599e358206eb3b950b5fc1405ff9534a5c864312606fcd"

URI_aarch64_rust-reqsign+google-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+google-devel-0.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+google-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+google-devel}"
SRC_URI[aarch64_rust-reqsign+google-devel.sha256sum] = "078be62f80344b7536362f97f5ae68d12524bc4438c35ea8b53ab640e82fecf2"

URI_aarch64_rust-reqsign+huaweicloud-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+huaweicloud-devel-0.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+huaweicloud-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+huaweicloud-devel}"
SRC_URI[aarch64_rust-reqsign+huaweicloud-devel.sha256sum] = "a6c69ec320ca1b52a613bcc14a9b43add8b8ccbbb6c3081bd15d89932a547435"

URI_aarch64_rust-reqsign+oracle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+oracle-devel-0.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+oracle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+oracle-devel}"
SRC_URI[aarch64_rust-reqsign+oracle-devel.sha256sum] = "d4dcbaa9dc4aa5baf344d074e56bc964ac96dc900ca910a40bbfbd624186b66a"

URI_aarch64_rust-reqsign+tencent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+tencent-devel-0.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+tencent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+tencent-devel}"
SRC_URI[aarch64_rust-reqsign+tencent-devel.sha256sum] = "b27fef6b5ef173ce5d991414bb81825dae84e72f4cb8c55a8bf2d2bfa7a135b9"

URI_aarch64_rust-reqsign+volcengine-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+volcengine-devel-0.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+volcengine-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+volcengine-devel}"
SRC_URI[aarch64_rust-reqsign+volcengine-devel.sha256sum] = "d546bc0048580891523db002125d30493f7c1a655e8162d75cc1af82a5ba8e1f"

URI_aarch64_rust-reqsign-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-devel-0.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-devel}"
SRC_URI[aarch64_rust-reqsign-devel.sha256sum] = "fbcc8203418a97aa091a48a90a7723a752266b81779fec4d5d480668120b79cb"

RDEPENDS:rust-reqsign+aliyun-devel = " \
 cargo \
 rust-reqsign-aliyun-oss+default-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+aws-devel = " \
 cargo \
 rust-reqsign-aws-v4+default-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+azure-devel = " \
 cargo \
 rust-reqsign-azure-storage+default-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+default-context-devel = " \
 cargo \
 rust-reqsign-command-execute-tokio+default-devel \
 rust-reqsign-devel \
 rust-reqsign-file-read-tokio+default-devel \
 rust-reqsign-http-send-reqwest+default-devel \
 "
RDEPENDS:rust-reqsign+default-devel = " \
 cargo \
 rust-reqsign+default-context-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+full-devel = " \
 cargo \
 rust-reqsign+aliyun-devel \
 rust-reqsign+aws-devel \
 rust-reqsign+azure-devel \
 rust-reqsign+google-devel \
 rust-reqsign+huaweicloud-devel \
 rust-reqsign+oracle-devel \
 rust-reqsign+tencent-devel \
 rust-reqsign+volcengine-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+google-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-google+default-devel \
 "
RDEPENDS:rust-reqsign+huaweicloud-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-huaweicloud-obs+default-devel \
 "
RDEPENDS:rust-reqsign+oracle-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-oracle+default-devel \
 "
RDEPENDS:rust-reqsign+tencent-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-tencent-cos+default-devel \
 "
RDEPENDS:rust-reqsign+volcengine-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-volcengine-tos+default-devel \
 "
RDEPENDS:rust-reqsign-devel = " \
 cargo \
 rust \
 rust-reqsign-core+default-devel \
 "
