# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-parking_lot"
PV = "0.12.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-parking_lot+arc_lock-devel \
 rust-parking_lot+deadlock_detection-devel \
 rust-parking_lot+default-devel \
 rust-parking_lot+hardware-lock-elision-devel \
 rust-parking_lot+nightly-devel \
 rust-parking_lot+owning_ref-devel \
 rust-parking_lot+send_guard-devel \
 rust-parking_lot+serde-devel \
 rust-parking_lot-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-parking_lot-0.12.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "155966178e9c3f91a23acbd64178387607c3280bf9eee33ad46b030ae208a6f6"

URI_x86_64_v2_rust-parking_lot+arc_lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+arc_lock-devel-0.12.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+arc_lock-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+arc_lock-devel.sha256sum] = "f867e62469d842c3f21dc78e7ce7aa27c313719a4f3d6c4e05a274f8d076d6f0"

URI_x86_64_v2_rust-parking_lot+deadlock_detection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+deadlock_detection-devel-0.12.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+deadlock_detection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+deadlock_detection-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+deadlock_detection-devel.sha256sum] = "186582d8e6c01a50476856c05b11066eb3b3bd786a9ee6216a630e436f3caf64"

URI_x86_64_v2_rust-parking_lot+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+default-devel-0.12.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+default-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+default-devel.sha256sum] = "42f65eebd109092ad4ec97550949f9d1b1ff23001439096abc193d8417c867a8"

URI_x86_64_v2_rust-parking_lot+hardware-lock-elision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+hardware-lock-elision-devel-0.12.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+hardware-lock-elision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+hardware-lock-elision-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+hardware-lock-elision-devel.sha256sum] = "76d98000ec2e19c41dbf958ca6ea72445c56adebfed1e4af735c77dceb0b7623"

URI_x86_64_v2_rust-parking_lot+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+nightly-devel-0.12.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+nightly-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+nightly-devel.sha256sum] = "d665fb83433a7c99133f543f16e195b92a6afc65c9a297a36c327d2c2c5839ce"

URI_x86_64_v2_rust-parking_lot+owning_ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+owning_ref-devel-0.12.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+owning_ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+owning_ref-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+owning_ref-devel.sha256sum] = "35bdf5605ff3054b85101f42d5e4c275376e2556870d024ea8a8ccfcb2630b53"

URI_x86_64_v2_rust-parking_lot+send_guard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+send_guard-devel-0.12.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+send_guard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+send_guard-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+send_guard-devel.sha256sum] = "e8e7d89ea4b0b7b8c50be07e716771b3d9ad33551b11341fe225475acf76cfc3"

URI_x86_64_v2_rust-parking_lot+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+serde-devel-0.12.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+serde-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+serde-devel.sha256sum] = "fe63dc8b2a2624e200f755929d2e2c9a59ff86bf24d0278d849f7ada02a5e4e7"

URI_x86_64_v2_rust-parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot-devel-0.12.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot-devel}"
SRC_URI[x86_64_v2_rust-parking_lot-devel.sha256sum] = "36c17179ea1d0c1099af32d9dd3ad498aa6758620f265c2028fd17720bda2632"

URI_aarch64_rust-parking_lot+arc_lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+arc_lock-devel-0.12.5-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+arc_lock-devel}"
SRC_URI[aarch64_rust-parking_lot+arc_lock-devel.sha256sum] = "ab0e070db01e13f80deac0f2d3dce89ae453073fcd3521342f1d5073902b9345"

URI_aarch64_rust-parking_lot+deadlock_detection-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+deadlock_detection-devel-0.12.5-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot+deadlock_detection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+deadlock_detection-devel}"
SRC_URI[aarch64_rust-parking_lot+deadlock_detection-devel.sha256sum] = "fad0a57c328ac1e4dfbc832f202a8f9da684f0755e6c9703e2ac979911c55517"

URI_aarch64_rust-parking_lot+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+default-devel-0.12.5-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+default-devel}"
SRC_URI[aarch64_rust-parking_lot+default-devel.sha256sum] = "bbbe4ca662fd260c0bbd1199fa10dedf0df283c7770691d303002f944273faa4"

URI_aarch64_rust-parking_lot+hardware-lock-elision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+hardware-lock-elision-devel-0.12.5-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot+hardware-lock-elision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+hardware-lock-elision-devel}"
SRC_URI[aarch64_rust-parking_lot+hardware-lock-elision-devel.sha256sum] = "ff0a81c0d901e2f0f7bf4dd086eb4630ac814b31a90352542bebf4b6ae672fb2"

URI_aarch64_rust-parking_lot+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+nightly-devel-0.12.5-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+nightly-devel}"
SRC_URI[aarch64_rust-parking_lot+nightly-devel.sha256sum] = "f8bef22af5f6c9bb72ea84ef8296469ec34de480a50f1b25b81429a4a36cf0c1"

URI_aarch64_rust-parking_lot+owning_ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+owning_ref-devel-0.12.5-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot+owning_ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+owning_ref-devel}"
SRC_URI[aarch64_rust-parking_lot+owning_ref-devel.sha256sum] = "e7ae5c64cb9e261072671226a436e66617344e09b87196a4423b43f66feea1f2"

URI_aarch64_rust-parking_lot+send_guard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+send_guard-devel-0.12.5-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot+send_guard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+send_guard-devel}"
SRC_URI[aarch64_rust-parking_lot+send_guard-devel.sha256sum] = "d7f578fd9596d31c89caafe1d8b9bd4139ade0f73aa34436586496656cba096a"

URI_aarch64_rust-parking_lot+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+serde-devel-0.12.5-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+serde-devel}"
SRC_URI[aarch64_rust-parking_lot+serde-devel.sha256sum] = "4ca382cfcef3b441162ef4169ee4821e7b9638b414fed49871f51db3d235da97"

URI_aarch64_rust-parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot-devel-0.12.5-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot-devel}"
SRC_URI[aarch64_rust-parking_lot-devel.sha256sum] = "9c786e33e599b0e433d903054b252da1bd3c0954c0d01281acec7622860e558e"

RDEPENDS:rust-parking_lot+arc_lock-devel = " \
 cargo \
 rust-lock_api+arc_lock-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+deadlock_detection-devel = " \
 cargo \
 rust-parking_lot-devel \
 rust-parking_lot_core+deadlock_detection-devel \
 "
RDEPENDS:rust-parking_lot+default-devel = " \
 cargo \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+hardware-lock-elision-devel = " \
 cargo \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+nightly-devel = " \
 cargo \
 rust-lock_api+nightly-devel \
 rust-parking_lot-devel \
 rust-parking_lot_core+nightly-devel \
 "
RDEPENDS:rust-parking_lot+owning_ref-devel = " \
 cargo \
 rust-lock_api+owning_ref-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+send_guard-devel = " \
 cargo \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+serde-devel = " \
 cargo \
 rust-lock_api+serde-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot-devel = " \
 cargo \
 rust \
 rust-lock_api+default-devel \
 rust-parking_lot_core+default-devel \
 "
