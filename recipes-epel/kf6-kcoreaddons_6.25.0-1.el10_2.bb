# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcoreaddons"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kcoreaddons \
 kf6-kcoreaddons-devel \
 kf6-kcoreaddons-doc \
 kf6-kcoreaddons-html \
 python3-kf6-kcoreaddons \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcoreaddons-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32ea8fc208fc0248895ae87fe59b7ad100432cb1691bdc0958d54970d692c504"

URI_x86_64_v2_kf6-kcoreaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcoreaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons}"
SRC_URI[x86_64_v2_kf6-kcoreaddons.sha256sum] = "340cbc79d7a8532183482d718e855d2f72256c49c52e33ef142b26df07725ffb"

URI_x86_64_v2_kf6-kcoreaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcoreaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons-devel}"
SRC_URI[x86_64_v2_kf6-kcoreaddons-devel.sha256sum] = "589e65f3980ec09672a307d2278b7626e5fd9c82e712b6999fc4832c968455a3"

URI_x86_64_v2_kf6-kcoreaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcoreaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons-doc}"
SRC_URI[x86_64_v2_kf6-kcoreaddons-doc.sha256sum] = "518a36bcce5858405ddfeda98c71d3c59ce644a02efce6064ddc9697b9beff31"

URI_x86_64_v2_kf6-kcoreaddons-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcoreaddons-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons-html}"
SRC_URI[x86_64_v2_kf6-kcoreaddons-html.sha256sum] = "5e67d6523fa5a770f7828752699516506ae1c2f59a8482bcf7291146337c1878"

URI_x86_64_v2_python3-kf6-kcoreaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kcoreaddons-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kcoreaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kcoreaddons}"
SRC_URI[x86_64_v2_python3-kf6-kcoreaddons.sha256sum] = "b6c2f179d5eeb932bd21aae4a5e95d42da1cd121791c096a90bedea74af37bcc"

URI_aarch64_kf6-kcoreaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcoreaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons}"
SRC_URI[aarch64_kf6-kcoreaddons.sha256sum] = "1bb03330df101374cb4c6022c497c9cdbd388e283130ce184f52f158104d56fe"

URI_aarch64_kf6-kcoreaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcoreaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons-devel}"
SRC_URI[aarch64_kf6-kcoreaddons-devel.sha256sum] = "9d25a9c2322e9faf66ae4f863381f278aeb996009a317799c2b7b91fd9c7934b"

URI_aarch64_kf6-kcoreaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcoreaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons-doc}"
SRC_URI[aarch64_kf6-kcoreaddons-doc.sha256sum] = "3a6ac49e0e7a6b946578da3f7031486ba8bbf0d19409422ed427304e157f156e"

URI_aarch64_kf6-kcoreaddons-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcoreaddons-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons-html}"
SRC_URI[aarch64_kf6-kcoreaddons-html.sha256sum] = "726def0a72e3d9608ce8699dad9a71c0b3e2c3650fbb4935b7a4d35f2fcfa36f"

URI_aarch64_python3-kf6-kcoreaddons = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kcoreaddons-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_python3-kf6-kcoreaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kcoreaddons}"
SRC_URI[aarch64_python3-kf6-kcoreaddons.sha256sum] = "b4e56fbae4f5087cd4ade4a91cde70453bcce742556e15144a7fcdb04e588bea"

RDEPENDS:kf6-kcoreaddons = " \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 systemd-libs \
 "
RDEPENDS:kf6-kcoreaddons-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcoreaddons-doc = " \
 "
RDEPENDS:kf6-kcoreaddons-html = " \
 "
RDEPENDS:python3-kf6-kcoreaddons = " \
 glibc \
 kf6-kcoreaddons \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 "
