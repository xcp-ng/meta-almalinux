# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sparsehash"
PV = "2.0.4"
PR = "1.el10_2"
PACKAGES = " \
 sparsehash-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sparsehash-2.0.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "970c6ef7e726b0a8270f1f78a683e00beabc462b1498e1400b7a2cdc155f2533"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sparsehash-devel-2.0.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sparsehash-devel;unpack=0"
SRC_URI[x86_64_v2_sparsehash-devel.sha256sum] = "bb65d2e81efbeb5478cca509df40a5a8fe8dc76b6c828dbefcef34030006ddfd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sparsehash-devel-2.0.4-1.el10_2.aarch64.rpm;name=aarch64_sparsehash-devel;unpack=0"
SRC_URI[aarch64_sparsehash-devel.sha256sum] = "4e92fa9cbcd3a24163ac1625ec765234c1fbd01dec4e5e6e3036efa1402b7dc4"

RDEPENDS:sparsehash-devel = " \
 pkgconf-pkg-config \
 "
