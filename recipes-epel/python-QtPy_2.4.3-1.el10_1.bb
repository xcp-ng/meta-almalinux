# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-QtPy"
PV = "2.4.3"
PR = "1.el10_1"
PACKAGES = " \
 python3-QtPy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-QtPy-2.4.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ff718eab33733072f2481de2a0e2e4f8675afd2323dd8c9498732c04372e811"

URI_x86_64_v2_python3-QtPy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-QtPy-2.4.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-QtPy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-QtPy}"
SRC_URI[x86_64_v2_python3-QtPy.sha256sum] = "3802822c18abb7963f82766032c3608414bf451347ef2aa8f72bb72b6de7d70d"

URI_aarch64_python3-QtPy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-QtPy-2.4.3-1.el10_1.noarch.rpm;name=aarch64_python3-QtPy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-QtPy}"
SRC_URI[aarch64_python3-QtPy.sha256sum] = "5d8ffadbe39787ebc462d2c2edf9b05c673c08727d41b33997f9a2dd2380e966"

RDEPENDS:python3-QtPy = " \
 python3 \
 python3-packaging \
 "
