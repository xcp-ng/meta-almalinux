# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apt"
PV = "3.3.3"
PR = "1.el10_2"
PACKAGES = " \
 apt \
 apt-apidoc \
 apt-devel \
 apt-doc \
 apt-libs \
 apt-utils \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/apt-3.3.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8661d31799b68e2451cd3abf14857003333045712f1eb3692e13551b374a9d0b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-3.3.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt;unpack=0"
SRC_URI[x86_64_v2_apt.sha256sum] = "72605f5894d51889c1290a97eb9ec7ac1a42c6435bca344f39300c030042ee63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-apidoc-3.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_apt-apidoc;unpack=0"
SRC_URI[x86_64_v2_apt-apidoc.sha256sum] = "1638cffdbfc94c331af8f206a5795a1209e51d85b1807a2f23dafea875d6d3c7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-devel-3.3.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-devel;unpack=0"
SRC_URI[x86_64_v2_apt-devel.sha256sum] = "11285047643824a1721fe227580f5af2c65408297727660f75a098886318a1c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-doc-3.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_apt-doc;unpack=0"
SRC_URI[x86_64_v2_apt-doc.sha256sum] = "c80364ffcfb4656d216be417076ad4538ae4bdfdb6a8e8d4ae568173fd131dc3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-libs-3.3.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-libs;unpack=0"
SRC_URI[x86_64_v2_apt-libs.sha256sum] = "77b4a3d20465bd40d2202e563b975ada2bc56cf430c866e7a5def2c30e5b1ee0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-utils-3.3.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-utils;unpack=0"
SRC_URI[x86_64_v2_apt-utils.sha256sum] = "ae89420df56ff20e70ed955af5454b6987e1a752ca92aa5feb45063d999dc890"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apt-3.3.3-1.el10_2.aarch64.rpm;name=aarch64_apt;unpack=0"
SRC_URI[aarch64_apt.sha256sum] = "0605f25f2d02e673d6fc90ccdabc9c971e9e6bd37a62bca35ead3a2bb9f3cfb8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apt-apidoc-3.3.3-1.el10_2.noarch.rpm;name=aarch64_apt-apidoc;unpack=0"
SRC_URI[aarch64_apt-apidoc.sha256sum] = "d827f797300e8d2cb3b376399a8ad3854006b16684f383e7ae2045b9f9812822"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apt-devel-3.3.3-1.el10_2.aarch64.rpm;name=aarch64_apt-devel;unpack=0"
SRC_URI[aarch64_apt-devel.sha256sum] = "488d8fa694647a28eb07a826f3fe0422a75dae1bcfc762194c7ee7b08ab8c6fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apt-doc-3.3.3-1.el10_2.noarch.rpm;name=aarch64_apt-doc;unpack=0"
SRC_URI[aarch64_apt-doc.sha256sum] = "7b16016bc3bd90de8f0741cc93d32b56679eb30ab91f81294f9aacecf4e5cf7f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apt-libs-3.3.3-1.el10_2.aarch64.rpm;name=aarch64_apt-libs;unpack=0"
SRC_URI[aarch64_apt-libs.sha256sum] = "695925cb7ad2f436274565e6fefa8c793ca84eec8e6eb9cc7bc82f64c43b4c8d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apt-utils-3.3.3-1.el10_2.aarch64.rpm;name=aarch64_apt-utils;unpack=0"
SRC_URI[aarch64_apt-utils.sha256sum] = "5c572de778542951b05ecc40d470daea56174be2e0c76623599013868756cf70"

RDEPENDS:apt = " \
 apt-libs \
 bash \
 dpkg \
 glibc \
 libgcc \
 libseccomp \
 libstdc++ \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:apt-apidoc = " \
 "
RDEPENDS:apt-devel = " \
 apt-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:apt-doc = " \
 "
RDEPENDS:apt-libs = " \
 bzip2-libs \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 openssl-libs \
 systemd-libs \
 xxhash-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:apt-utils = " \
 apt \
 apt-libs \
 glibc \
 libdb \
 libgcc \
 libstdc++ \
 "
