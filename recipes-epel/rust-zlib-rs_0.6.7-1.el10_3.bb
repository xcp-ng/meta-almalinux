# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zlib-rs"
PV = "0.6.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-zlib-rs+__internal-api-devel \
 rust-zlib-rs+avx512-devel \
 rust-zlib-rs+c-allocator-devel \
 rust-zlib-rs+default-devel \
 rust-zlib-rs+lsx-devel \
 rust-zlib-rs+rust-allocator-devel \
 rust-zlib-rs+std-devel \
 rust-zlib-rs+vpclmulqdq-devel \
 rust-zlib-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zlib-rs-0.6.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "091defa8179043ea29435fd5999b970af52187972cd20ed9f87b6cbb33b6d7c2"

URI_x86_64_v2_rust-zlib-rs+__internal-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+__internal-api-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+__internal-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+__internal-api-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+__internal-api-devel.sha256sum] = "b7d7bd6ecfcb41dbe84a5daef1faadd52a38d954aa6f65a8d67047720a521ae5"

URI_x86_64_v2_rust-zlib-rs+avx512-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+avx512-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+avx512-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+avx512-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+avx512-devel.sha256sum] = "c850687e5d1df376395d7bd8d066a279658b47568bd550a6434be4ed1b19941b"

URI_x86_64_v2_rust-zlib-rs+c-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+c-allocator-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+c-allocator-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+c-allocator-devel.sha256sum] = "687fa68825a299ea2e087ecbcc2391d9b9b6addd2eb6da78dde469378d8add00"

URI_x86_64_v2_rust-zlib-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+default-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+default-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+default-devel.sha256sum] = "5d665fd7f9f0cf13b34fddaff937fe5775d6df22acb63af858935cc8e8788d02"

URI_x86_64_v2_rust-zlib-rs+lsx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+lsx-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+lsx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+lsx-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+lsx-devel.sha256sum] = "963d943b8040516ff39d5da18d7a4d22b8665d04e7fd92c104783c1d276c5011"

URI_x86_64_v2_rust-zlib-rs+rust-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+rust-allocator-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+rust-allocator-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+rust-allocator-devel.sha256sum] = "4ddfb98b1793d6834b23a0ede284d1ef3204628ec03ef3125670f329bbe1370e"

URI_x86_64_v2_rust-zlib-rs+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+std-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+std-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+std-devel.sha256sum] = "83462a82a7f1088bae458051becab038adce8b716cf43b018f37000c3f152586"

URI_x86_64_v2_rust-zlib-rs+vpclmulqdq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+vpclmulqdq-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+vpclmulqdq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+vpclmulqdq-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+vpclmulqdq-devel.sha256sum] = "daa2969a7f24025c698a3a1254a8e44f8669e9b3dbcf3aeb5ad85dbb393f1a94"

URI_x86_64_v2_rust-zlib-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs-devel.sha256sum] = "e2c53092bd348750300c223b6232b00dc3b1fb4960660cc517ef4179a38b17e6"

URI_aarch64_rust-zlib-rs+__internal-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+__internal-api-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+__internal-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+__internal-api-devel}"
SRC_URI[aarch64_rust-zlib-rs+__internal-api-devel.sha256sum] = "885a3c810ec57af45504f725d574c997ce613435eea0633447a07c104b6627fa"

URI_aarch64_rust-zlib-rs+avx512-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+avx512-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+avx512-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+avx512-devel}"
SRC_URI[aarch64_rust-zlib-rs+avx512-devel.sha256sum] = "eb3d233932fa2e61fc4bf71cf5b80e555d0a508edfd6ca44c7ff6ea450011a87"

URI_aarch64_rust-zlib-rs+c-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+c-allocator-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+c-allocator-devel}"
SRC_URI[aarch64_rust-zlib-rs+c-allocator-devel.sha256sum] = "77c3c330bf84f0f2a888f0f89c6ba1cb5903bdc0a6bab9bfa023dd3974a71f52"

URI_aarch64_rust-zlib-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+default-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+default-devel}"
SRC_URI[aarch64_rust-zlib-rs+default-devel.sha256sum] = "c9b05b013f61f6ac6b9ef0960a6c26bcc352df1735bf8b9648ef988face22f33"

URI_aarch64_rust-zlib-rs+lsx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+lsx-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+lsx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+lsx-devel}"
SRC_URI[aarch64_rust-zlib-rs+lsx-devel.sha256sum] = "34ff2ea2caf99b01423bac6eb0de01806afab5d1be459eefbbb67d7429787a70"

URI_aarch64_rust-zlib-rs+rust-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+rust-allocator-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+rust-allocator-devel}"
SRC_URI[aarch64_rust-zlib-rs+rust-allocator-devel.sha256sum] = "1e6983f7e4c46f8ee637599846b28141a9d4bee131502ab292fd4c14bd91bdaf"

URI_aarch64_rust-zlib-rs+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+std-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+std-devel}"
SRC_URI[aarch64_rust-zlib-rs+std-devel.sha256sum] = "fc084c61504b80dd52aca6198ac317c5445674a33a48b9a6f663297b9f76053e"

URI_aarch64_rust-zlib-rs+vpclmulqdq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+vpclmulqdq-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+vpclmulqdq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+vpclmulqdq-devel}"
SRC_URI[aarch64_rust-zlib-rs+vpclmulqdq-devel.sha256sum] = "3288b1da6fe78c3d5bec6076648f6e5d78ff9f4c68b83682153f5d484831d63b"

URI_aarch64_rust-zlib-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs-devel}"
SRC_URI[aarch64_rust-zlib-rs-devel.sha256sum] = "2caf64c9cfa6a27f6a419d7667c429aec88ea21a6a501dc92ee2b121836edaec"

RDEPENDS:rust-zlib-rs+__internal-api-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+avx512-devel = " \
 cargo \
 rust-zlib-rs+vpclmulqdq-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+c-allocator-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+default-devel = " \
 cargo \
 rust-zlib-rs+c-allocator-devel \
 rust-zlib-rs+std-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+lsx-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+rust-allocator-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+std-devel = " \
 cargo \
 rust-zlib-rs+rust-allocator-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+vpclmulqdq-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs-devel = " \
 cargo \
 rust \
 "
