# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf_codegen"
PV = "0.11.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-phf_codegen+default-devel \
 rust-phf_codegen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf_codegen-0.11.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92bb076702cfc4d87ee5c1f9be63d2f8f891a266317706255d3e00cfb1f1ea3d"

URI_x86_64_v2_rust-phf_codegen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_codegen+default-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_codegen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_codegen+default-devel}"
SRC_URI[x86_64_v2_rust-phf_codegen+default-devel.sha256sum] = "bade078aa068a54f015ddb1702d0cb430f638868ab8f6c783cccf02b3f153dad"

URI_x86_64_v2_rust-phf_codegen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_codegen-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_codegen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_codegen-devel}"
SRC_URI[x86_64_v2_rust-phf_codegen-devel.sha256sum] = "b34a9328c11a739c91329828d399d75a9bb383fae45d164b98e708057cb80952"

URI_aarch64_rust-phf_codegen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_codegen+default-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf_codegen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_codegen+default-devel}"
SRC_URI[aarch64_rust-phf_codegen+default-devel.sha256sum] = "7c950e38b7669dff11051bedba93ac77af19a40b83b79f44669f8aa4578a5e89"

URI_aarch64_rust-phf_codegen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_codegen-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf_codegen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_codegen-devel}"
SRC_URI[aarch64_rust-phf_codegen-devel.sha256sum] = "414322820e271c1ce6c74fa513d66781e555b096cf54236c0180b2bbea6151af"

RDEPENDS:rust-phf_codegen+default-devel = " \
 cargo \
 rust-phf_codegen-devel \
 "
RDEPENDS:rust-phf_codegen-devel = " \
 cargo \
 rust \
 rust-phf_generator+default-devel \
 rust-phf_shared+default-devel \
 "
