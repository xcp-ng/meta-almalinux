# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-php"
PV = "0.23.11"
PR = "2.el10_1"
PACKAGES = " \
 rust-tree-sitter-php+default-devel \
 rust-tree-sitter-php-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-php-0.23.11-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75e33ead044bd92e7d436d985ec55c8ea5ffdc0e16137405c8f2061834203db4"

URI_x86_64_v2_rust-tree-sitter-php+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-php+default-devel-0.23.11-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-php+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-php+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-php+default-devel.sha256sum] = "f3fbf4fb7fb6f5a6cfd16f96ccba079468754418e4694b01c55722e0ffb83fbb"

URI_x86_64_v2_rust-tree-sitter-php-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-php-devel-0.23.11-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-php-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-php-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-php-devel.sha256sum] = "bc14d9204007b9f8ddd702491b656ac878e9039bf9ce7bfc40ff7277e24b11a0"

URI_aarch64_rust-tree-sitter-php+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-php+default-devel-0.23.11-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-php+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-php+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-php+default-devel.sha256sum] = "c92fb1bd5d7d44c48eeda2c6363d369a7b656cdd2f70ff87606f31191f15d383"

URI_aarch64_rust-tree-sitter-php-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-php-devel-0.23.11-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-php-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-php-devel}"
SRC_URI[aarch64_rust-tree-sitter-php-devel.sha256sum] = "2b7c3860702c61c5482dc0257962386c84acd0618552ee2640a65971ce158670"

RDEPENDS:rust-tree-sitter-php+default-devel = " \
 cargo \
 rust-tree-sitter-php-devel \
 "
RDEPENDS:rust-tree-sitter-php-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
