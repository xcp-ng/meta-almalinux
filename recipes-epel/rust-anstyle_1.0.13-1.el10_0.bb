# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle"
PV = "1.0.13"
PR = "1.el10_0"
PACKAGES = " \
 rust-anstyle+default-devel \
 rust-anstyle+std-devel \
 rust-anstyle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-1.0.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a6cd67576a9e46d728121986dbddac727b4303546a37f0139d12be6a5ada51c"

URI_x86_64_v2_rust-anstyle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle+default-devel-1.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle+default-devel.sha256sum] = "c452f256469c935af9861da43b771d855ca6854e04f7c45bd77eb18d9d57fbc7"

URI_x86_64_v2_rust-anstyle+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle+std-devel-1.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle+std-devel}"
SRC_URI[x86_64_v2_rust-anstyle+std-devel.sha256sum] = "bfeb2ec476c7b569291bf65dea776bb6f0730ad53461019dd7f45cef36f6baaa"

URI_x86_64_v2_rust-anstyle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-devel-1.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-devel}"
SRC_URI[x86_64_v2_rust-anstyle-devel.sha256sum] = "1f04af4ad3da874be6cb8765ecc1928c26107317acfabc730888911f3dd8e2b2"

URI_aarch64_rust-anstyle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle+default-devel-1.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-anstyle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle+default-devel}"
SRC_URI[aarch64_rust-anstyle+default-devel.sha256sum] = "f814fe54a55e616475c4431259478af1d6f6a0f834d0f2408ad64e409dfded16"

URI_aarch64_rust-anstyle+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle+std-devel-1.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-anstyle+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle+std-devel}"
SRC_URI[aarch64_rust-anstyle+std-devel.sha256sum] = "828d77c90cc78f48666fc41c5cd65afd52eb34f2b80b73644b9fb61c0692ca7f"

URI_aarch64_rust-anstyle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-devel-1.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-anstyle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-devel}"
SRC_URI[aarch64_rust-anstyle-devel.sha256sum] = "9343eef5e57423abb3559ca305dc560dfc1a053766e0ed481a7d5175b9fbecd1"

RDEPENDS:rust-anstyle+default-devel = " \
 cargo \
 rust-anstyle+std-devel \
 rust-anstyle-devel \
 "
RDEPENDS:rust-anstyle+std-devel = " \
 cargo \
 rust-anstyle-devel \
 "
RDEPENDS:rust-anstyle-devel = " \
 cargo \
 rust \
 "
