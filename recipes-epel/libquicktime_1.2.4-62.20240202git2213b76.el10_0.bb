# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libquicktime"
PV = "1.2.4"
PR = "62.20240202git2213b76.el10_0"
PACKAGES = " \
 libquicktime \
 libquicktime-devel \
 libquicktime-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libquicktime-1.2.4-62.20240202git2213b76.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "363987a3420ccf88c4b931437a2edcc2e6a5564a5af5d1ce11f073f1b3a077c8"

URI_x86_64_v2_libquicktime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libquicktime-1.2.4-62.20240202git2213b76.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libquicktime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquicktime}"
SRC_URI[x86_64_v2_libquicktime.sha256sum] = "45335197d304582c65cf7eeba60f9d2b23ae315842b137aee8411dfd7834b778"

URI_x86_64_v2_libquicktime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libquicktime-devel-1.2.4-62.20240202git2213b76.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libquicktime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquicktime-devel}"
SRC_URI[x86_64_v2_libquicktime-devel.sha256sum] = "a9f8e35b9a5e4dd2c09b4c170a6ebfabc283479ffd7c75e1679fedba191a9c9c"

URI_x86_64_v2_libquicktime-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libquicktime-utils-1.2.4-62.20240202git2213b76.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libquicktime-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquicktime-utils}"
SRC_URI[x86_64_v2_libquicktime-utils.sha256sum] = "964f994da7be4d72a5edb592bfc070fc607b03b69e6e9bf9c6dfa27c311224af"

URI_aarch64_libquicktime = "${EPEL_MIRROR}/aarch64/Packages/l/libquicktime-1.2.4-62.20240202git2213b76.el10_0.aarch64.rpm;name=aarch64_libquicktime;unpack=0"
SRC_URI:append = " ${URI_aarch64_libquicktime}"
SRC_URI[aarch64_libquicktime.sha256sum] = "7f4d103fe22cdd32413c98c7e4d83822786ef6dac5ebaa1476e6802cefb62412"

URI_aarch64_libquicktime-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libquicktime-devel-1.2.4-62.20240202git2213b76.el10_0.aarch64.rpm;name=aarch64_libquicktime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libquicktime-devel}"
SRC_URI[aarch64_libquicktime-devel.sha256sum] = "e2495f5856e219c6803211d712ea3ca3b573b8737d40751f68737da4a1484c75"

URI_aarch64_libquicktime-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libquicktime-utils-1.2.4-62.20240202git2213b76.el10_0.aarch64.rpm;name=aarch64_libquicktime-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libquicktime-utils}"
SRC_URI[aarch64_libquicktime-utils.sha256sum] = "457b89e74d29217fe91430cdefe399d26f806dc96bc51d0aa6871a0a8a3d8995"

RDEPENDS:libquicktime = " \
 glibc \
 lame-libs \
 libjpeg-turbo \
 libpng \
 libvorbis \
 zlib-ng-compat \
 "
RDEPENDS:libquicktime-devel = " \
 libquicktime \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:libquicktime-utils = " \
 alsa-lib \
 glib2 \
 glibc \
 gtk2 \
 libX11 \
 libXaw \
 libXext \
 libXt \
 libXv \
 libglvnd-glx \
 libquicktime \
 "
