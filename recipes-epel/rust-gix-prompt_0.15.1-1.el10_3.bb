# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-prompt"
PV = "0.15.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-prompt+default-devel \
 rust-gix-prompt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-prompt-0.15.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21eadb2b4bdef2fd0cd7a686eecee63ce618bf7f375642647db96a93fbbe0fe9"

URI_x86_64_v2_rust-gix-prompt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-prompt+default-devel-0.15.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-prompt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-prompt+default-devel}"
SRC_URI[x86_64_v2_rust-gix-prompt+default-devel.sha256sum] = "a8d68c7142b0821276e0df7040ce35167e5e917a86517fba32af5c3c607d1e0d"

URI_x86_64_v2_rust-gix-prompt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-prompt-devel-0.15.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-prompt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-prompt-devel}"
SRC_URI[x86_64_v2_rust-gix-prompt-devel.sha256sum] = "44e547b830430d426cf3c80d4a0822ff35f0a8acf7ae49dad4abb5e3cb1e04ce"

URI_aarch64_rust-gix-prompt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-prompt+default-devel-0.15.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-prompt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-prompt+default-devel}"
SRC_URI[aarch64_rust-gix-prompt+default-devel.sha256sum] = "463a74099f41a850cf31782e66acbf6f26ff13c198085aed5de7fb5b66da6d1d"

URI_aarch64_rust-gix-prompt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-prompt-devel-0.15.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-prompt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-prompt-devel}"
SRC_URI[aarch64_rust-gix-prompt-devel.sha256sum] = "22ec171268c3a7e643aeb5e05aa3bcc2e325026b7cf01a89d9b548f443e96d37"

RDEPENDS:rust-gix-prompt+default-devel = " \
 cargo \
 rust-gix-prompt-devel \
 "
RDEPENDS:rust-gix-prompt-devel = " \
 cargo \
 rust \
 rust-gix-command+default-devel \
 rust-gix-config-value+default-devel \
 rust-parking_lot+default-devel \
 rust-rustix+default-devel \
 rust-rustix+termios-devel \
 rust-thiserror+default-devel \
 "
