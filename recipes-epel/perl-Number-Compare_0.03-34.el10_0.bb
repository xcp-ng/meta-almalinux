# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Number-Compare"
PV = "0.03"
PR = "34.el10_0"
PACKAGES = " \
 perl-Number-Compare \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Number-Compare-0.03-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d78ce4af566e90b3d32fca7d8f3c56b65690ef07d157a987947790df8245f69f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Number-Compare-0.03-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Number-Compare;unpack=0"
SRC_URI[x86_64_v2_perl-Number-Compare.sha256sum] = "f43858666f7d105940a697dfa75453c2fd4096107d6e35789c71121c7d3404b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Number-Compare-0.03-34.el10_0.noarch.rpm;name=aarch64_perl-Number-Compare;unpack=0"
SRC_URI[aarch64_perl-Number-Compare.sha256sum] = "c5bbcd75d26987ba94e01aee8795178c2856e6dbc28055536bac1dc5ca1e9b65"

RDEPENDS:perl-Number-Compare = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
