# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indoc"
PV = "2.0.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-indoc+default-devel \
 rust-indoc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indoc-2.0.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe1867896df6a60fd792132148240bc7fabcc87be3d4fc794d210ff944788593"

URI_x86_64_v2_rust-indoc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indoc+default-devel-2.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indoc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indoc+default-devel}"
SRC_URI[x86_64_v2_rust-indoc+default-devel.sha256sum] = "22efeee8046f673b2a045a76d5f9b5671fb8e8637c255214c53b991c6af06efb"

URI_x86_64_v2_rust-indoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indoc-devel-2.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indoc-devel}"
SRC_URI[x86_64_v2_rust-indoc-devel.sha256sum] = "d59fce1bebf84953af07e0006f7adb81848113f195d3d8488fcb067e366ece45"

URI_aarch64_rust-indoc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indoc+default-devel-2.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-indoc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indoc+default-devel}"
SRC_URI[aarch64_rust-indoc+default-devel.sha256sum] = "5d47dd98695ecbb831893bcfdcdc26c7d8e0d3f355ac73d3715c98d1311082b0"

URI_aarch64_rust-indoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indoc-devel-2.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-indoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indoc-devel}"
SRC_URI[aarch64_rust-indoc-devel.sha256sum] = "8d86bc2d6a7b037225abb12c33606396bfcab9398635addc8047e22ba5bbf891"

RDEPENDS:rust-indoc+default-devel = " \
 cargo \
 rust-indoc-devel \
 "
RDEPENDS:rust-indoc-devel = " \
 cargo \
 rust \
 rust-rustversion+default-devel \
 "
