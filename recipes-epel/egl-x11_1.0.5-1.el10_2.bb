# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-x11"
PV = "1.0.5"
PR = "1.el10_2"
PACKAGES = " \
 egl-x11 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/egl-x11-1.0.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4640b75f89144a28d6c287a7ff2f0f9e3eb045e4fe3816f65ab03bd60d3e594a"

URI_x86_64_v2_egl-x11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-x11-1.0.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_egl-x11}"
SRC_URI[x86_64_v2_egl-x11.sha256sum] = "b666a385db32efa325900831a745edc17f7524327c332a14310eeef94d7e1a04"

URI_aarch64_egl-x11 = "${EPEL_MIRROR}/aarch64/Packages/e/egl-x11-1.0.5-1.el10_2.aarch64.rpm;name=aarch64_egl-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-x11}"
SRC_URI[aarch64_egl-x11.sha256sum] = "e5bfdce35e1d01e2df0533a40b064921996c9ab5f8ed91691aaf6bab0a113462"

RDEPENDS:egl-x11 = " \
 glibc \
 libX11 \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libxcb \
 mesa-libgbm \
 "
