# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bindgen0.69"
PV = "0.69.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-bindgen0.69+__cli-devel \
 rust-bindgen0.69+__testing_only_extra_assertions-devel \
 rust-bindgen0.69+__testing_only_libclang_16-devel \
 rust-bindgen0.69+__testing_only_libclang_9-devel \
 rust-bindgen0.69+default-devel \
 rust-bindgen0.69+experimental-devel \
 rust-bindgen0.69+logging-devel \
 rust-bindgen0.69+prettyplease-devel \
 rust-bindgen0.69+runtime-devel \
 rust-bindgen0.69+static-devel \
 rust-bindgen0.69+which-rustfmt-devel \
 rust-bindgen0.69-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bindgen0.69-0.69.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18c7d1efbbd564fa17518cfb92468efb5090d5a20f7314bd1aec88d081be6e6c"

URI_x86_64_v2_rust-bindgen0.69+__cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen0.69+__cli-devel-0.69.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen0.69+__cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen0.69+__cli-devel}"
SRC_URI[x86_64_v2_rust-bindgen0.69+__cli-devel.sha256sum] = "3bb03ad2654892bc025607ed20033fd62a316a373236c2b81b270046f6bc5af0"

URI_x86_64_v2_rust-bindgen0.69+__testing_only_extra_assertions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen0.69+__testing_only_extra_assertions-devel-0.69.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen0.69+__testing_only_extra_assertions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen0.69+__testing_only_extra_assertions-devel}"
SRC_URI[x86_64_v2_rust-bindgen0.69+__testing_only_extra_assertions-devel.sha256sum] = "45d7c8a087bcfca6d348b56ee90b3298233f52baa7e7675cf6b0b52a049ac1e0"

URI_x86_64_v2_rust-bindgen0.69+__testing_only_libclang_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen0.69+__testing_only_libclang_16-devel-0.69.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen0.69+__testing_only_libclang_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen0.69+__testing_only_libclang_16-devel}"
SRC_URI[x86_64_v2_rust-bindgen0.69+__testing_only_libclang_16-devel.sha256sum] = "7105e0c94e677dbe47ec0627ca848e0af6a8ecbeabefe694898cf48b74f8ee9c"

URI_x86_64_v2_rust-bindgen0.69+__testing_only_libclang_9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen0.69+__testing_only_libclang_9-devel-0.69.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen0.69+__testing_only_libclang_9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen0.69+__testing_only_libclang_9-devel}"
SRC_URI[x86_64_v2_rust-bindgen0.69+__testing_only_libclang_9-devel.sha256sum] = "392dbc9d49f77a3ce4f4f01733fd29b5b7818111d903f165bf67af052fa45c26"

URI_x86_64_v2_rust-bindgen0.69+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen0.69+default-devel-0.69.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen0.69+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen0.69+default-devel}"
SRC_URI[x86_64_v2_rust-bindgen0.69+default-devel.sha256sum] = "327b960e6c5f5647760043c75d90bb0b5218d910f2576c0632ccb8060a5a4ebb"

URI_x86_64_v2_rust-bindgen0.69+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen0.69+experimental-devel-0.69.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen0.69+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen0.69+experimental-devel}"
SRC_URI[x86_64_v2_rust-bindgen0.69+experimental-devel.sha256sum] = "4ef0334de4f39bc2826cefe748558e6c343830d0289389aefc9c14f6a400a847"

URI_x86_64_v2_rust-bindgen0.69+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen0.69+logging-devel-0.69.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen0.69+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen0.69+logging-devel}"
SRC_URI[x86_64_v2_rust-bindgen0.69+logging-devel.sha256sum] = "dccaf4baef8f3308b129148faf5c84a621b493183b67b05a63e753d4bf5e9ea8"

URI_x86_64_v2_rust-bindgen0.69+prettyplease-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen0.69+prettyplease-devel-0.69.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen0.69+prettyplease-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen0.69+prettyplease-devel}"
SRC_URI[x86_64_v2_rust-bindgen0.69+prettyplease-devel.sha256sum] = "d236feeac6bcf9d002fbbd95ec93d922f22108e65146b4d3217c932b53f0e6ca"

URI_x86_64_v2_rust-bindgen0.69+runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen0.69+runtime-devel-0.69.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen0.69+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen0.69+runtime-devel}"
SRC_URI[x86_64_v2_rust-bindgen0.69+runtime-devel.sha256sum] = "de140e1a90248694832701d6d4f6bd414d21fb35ef33efd72dd09b655bfa1c72"

URI_x86_64_v2_rust-bindgen0.69+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen0.69+static-devel-0.69.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen0.69+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen0.69+static-devel}"
SRC_URI[x86_64_v2_rust-bindgen0.69+static-devel.sha256sum] = "541b7b4e09d013f0c562b63e99c0aaa3d538d8a16462bbf5ec864aa0f4833dd3"

URI_x86_64_v2_rust-bindgen0.69+which-rustfmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen0.69+which-rustfmt-devel-0.69.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen0.69+which-rustfmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen0.69+which-rustfmt-devel}"
SRC_URI[x86_64_v2_rust-bindgen0.69+which-rustfmt-devel.sha256sum] = "125ca86970e7589e8a3f351fb91c51c79bc572d541f99338edc28a1c2238fc39"

URI_x86_64_v2_rust-bindgen0.69-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen0.69-devel-0.69.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen0.69-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen0.69-devel}"
SRC_URI[x86_64_v2_rust-bindgen0.69-devel.sha256sum] = "deecea1f60ecfaa5a52560ae997a743287ce3a333cf0f4636a9ee9a0e976dce4"

URI_aarch64_rust-bindgen0.69+__cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen0.69+__cli-devel-0.69.5-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen0.69+__cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen0.69+__cli-devel}"
SRC_URI[aarch64_rust-bindgen0.69+__cli-devel.sha256sum] = "f77aa14acb957b211297d01146a80b6b49fa37e1627f7de1254126844fa1cd79"

URI_aarch64_rust-bindgen0.69+__testing_only_extra_assertions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen0.69+__testing_only_extra_assertions-devel-0.69.5-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen0.69+__testing_only_extra_assertions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen0.69+__testing_only_extra_assertions-devel}"
SRC_URI[aarch64_rust-bindgen0.69+__testing_only_extra_assertions-devel.sha256sum] = "84260370937c94959cf0829b33c4a3ba073d6d12ceb3d3cc7aff40c45069d5aa"

URI_aarch64_rust-bindgen0.69+__testing_only_libclang_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen0.69+__testing_only_libclang_16-devel-0.69.5-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen0.69+__testing_only_libclang_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen0.69+__testing_only_libclang_16-devel}"
SRC_URI[aarch64_rust-bindgen0.69+__testing_only_libclang_16-devel.sha256sum] = "a1e40fc55f749267dc926e1eb1d6320bcc755524575ed0f882b98475a4138650"

URI_aarch64_rust-bindgen0.69+__testing_only_libclang_9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen0.69+__testing_only_libclang_9-devel-0.69.5-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen0.69+__testing_only_libclang_9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen0.69+__testing_only_libclang_9-devel}"
SRC_URI[aarch64_rust-bindgen0.69+__testing_only_libclang_9-devel.sha256sum] = "418be41b274efa15ba52884718c950dfce63e905cf642312ed0330f345e949cb"

URI_aarch64_rust-bindgen0.69+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen0.69+default-devel-0.69.5-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen0.69+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen0.69+default-devel}"
SRC_URI[aarch64_rust-bindgen0.69+default-devel.sha256sum] = "497b978bd98b172606e69891d38f3f0ab8b9ea87a123785ca2bdd8b45466893e"

URI_aarch64_rust-bindgen0.69+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen0.69+experimental-devel-0.69.5-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen0.69+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen0.69+experimental-devel}"
SRC_URI[aarch64_rust-bindgen0.69+experimental-devel.sha256sum] = "eec89f4bd9cf3680d9859e6d44e27f757b7534b7a15e9c83452a18a1dd7c66f0"

URI_aarch64_rust-bindgen0.69+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen0.69+logging-devel-0.69.5-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen0.69+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen0.69+logging-devel}"
SRC_URI[aarch64_rust-bindgen0.69+logging-devel.sha256sum] = "bba95cbdc9a1e513f2025cb7d0ba21a78190512e7c2e4031d8d8acdcb0119541"

URI_aarch64_rust-bindgen0.69+prettyplease-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen0.69+prettyplease-devel-0.69.5-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen0.69+prettyplease-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen0.69+prettyplease-devel}"
SRC_URI[aarch64_rust-bindgen0.69+prettyplease-devel.sha256sum] = "60e50a2d55e632c8a5bbd46ce7ead1f231ec022ff3cbc3175040d3a336e81660"

URI_aarch64_rust-bindgen0.69+runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen0.69+runtime-devel-0.69.5-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen0.69+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen0.69+runtime-devel}"
SRC_URI[aarch64_rust-bindgen0.69+runtime-devel.sha256sum] = "5c1f96d3be10017102294a44592d31a140effd9bddef6b544cbcac0b48007212"

URI_aarch64_rust-bindgen0.69+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen0.69+static-devel-0.69.5-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen0.69+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen0.69+static-devel}"
SRC_URI[aarch64_rust-bindgen0.69+static-devel.sha256sum] = "031a5a5366c95aca19ac909675ef3db1dad80f3748618e2ccd7abb21d0e8ead2"

URI_aarch64_rust-bindgen0.69+which-rustfmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen0.69+which-rustfmt-devel-0.69.5-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen0.69+which-rustfmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen0.69+which-rustfmt-devel}"
SRC_URI[aarch64_rust-bindgen0.69+which-rustfmt-devel.sha256sum] = "7fefe1f4d3da2c9c3ede3b83cd6ba74f6736960c3f184bf9c4dde566fb740bb4"

URI_aarch64_rust-bindgen0.69-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen0.69-devel-0.69.5-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen0.69-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen0.69-devel}"
SRC_URI[aarch64_rust-bindgen0.69-devel.sha256sum] = "64a3a92341840e72f5d89361e722c94d452d54593e77d5b9bf186332801c938c"

RDEPENDS:rust-bindgen0.69+__cli-devel = " \
 cargo \
 rust-bindgen0.69-devel \
 "
RDEPENDS:rust-bindgen0.69+__testing_only_extra_assertions-devel = " \
 cargo \
 rust-bindgen0.69-devel \
 "
RDEPENDS:rust-bindgen0.69+__testing_only_libclang_16-devel = " \
 cargo \
 rust-bindgen0.69-devel \
 "
RDEPENDS:rust-bindgen0.69+__testing_only_libclang_9-devel = " \
 cargo \
 rust-bindgen0.69-devel \
 "
RDEPENDS:rust-bindgen0.69+default-devel = " \
 cargo \
 rust-bindgen0.69+logging-devel \
 rust-bindgen0.69+prettyplease-devel \
 rust-bindgen0.69+runtime-devel \
 rust-bindgen0.69+which-rustfmt-devel \
 rust-bindgen0.69-devel \
 "
RDEPENDS:rust-bindgen0.69+experimental-devel = " \
 cargo \
 rust-annotate-snippets0.9+color-devel \
 rust-annotate-snippets0.9+default-devel \
 rust-bindgen0.69-devel \
 "
RDEPENDS:rust-bindgen0.69+logging-devel = " \
 cargo \
 rust-bindgen0.69-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-bindgen0.69+prettyplease-devel = " \
 cargo \
 rust-bindgen0.69-devel \
 rust-prettyplease+default-devel \
 rust-prettyplease+verbatim-devel \
 "
RDEPENDS:rust-bindgen0.69+runtime-devel = " \
 cargo \
 rust-bindgen0.69-devel \
 rust-clang-sys+runtime-devel \
 "
RDEPENDS:rust-bindgen0.69+static-devel = " \
 cargo \
 rust-bindgen0.69-devel \
 rust-clang-sys+static-devel \
 "
RDEPENDS:rust-bindgen0.69+which-rustfmt-devel = " \
 cargo \
 rust-bindgen0.69-devel \
 rust-which4-devel \
 "
RDEPENDS:rust-bindgen0.69-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cexpr+default-devel \
 rust-clang-sys+clang_6_0-devel \
 rust-clang-sys+default-devel \
 rust-lazy_static+default-devel \
 rust-lazycell+default-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-regex+std-devel \
 rust-regex+unicode-perl-devel \
 rust-regex-devel \
 rust-rustc-hash1+default-devel \
 rust-shlex+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+visit-mut-devel \
 virtual/crate_itertools__ge_0.10.0_with_crate_itertools__lt_0.13.0~ \
 "
