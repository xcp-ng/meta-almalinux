# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-svg"
PV = "1.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-anstyle-svg+default-devel \
 rust-anstyle-svg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-svg-1.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdeb907fe31d2036659ad1e918fe0f36dbaaff20e4590988902bbb83c89a9ebb"

URI_x86_64_v2_rust-anstyle-svg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-svg+default-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-svg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-svg+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-svg+default-devel.sha256sum] = "351028774b7af828c6768439071553f011192d8034f7880cf34f2cde9e749b70"

URI_x86_64_v2_rust-anstyle-svg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-svg-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-svg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-svg-devel}"
SRC_URI[x86_64_v2_rust-anstyle-svg-devel.sha256sum] = "721bc9ce377b79ef2b430df4a480cd14775461e3ac613aa981ee416de9a19e8a"

URI_aarch64_rust-anstyle-svg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-svg+default-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-anstyle-svg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-svg+default-devel}"
SRC_URI[aarch64_rust-anstyle-svg+default-devel.sha256sum] = "3da1c95402b856bd37771ae3e07a06b7c4806b267b859958153cd25c426c9033"

URI_aarch64_rust-anstyle-svg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-svg-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-anstyle-svg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-svg-devel}"
SRC_URI[aarch64_rust-anstyle-svg-devel.sha256sum] = "ef8e531910c9fff1926a83470f6740dbcbaf0f4d6e57a48f6baab88fee620a3a"

RDEPENDS:rust-anstyle-svg+default-devel = " \
 cargo \
 rust-anstyle-svg-devel \
 "
RDEPENDS:rust-anstyle-svg-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-anstyle-lossy+default-devel \
 rust-anstyle-parse+default-devel \
 rust-html-escape+default-devel \
 rust-unicode-width+default-devel \
 "
