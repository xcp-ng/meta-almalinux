# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-utils"
PV = "0.8.23"
PR = "1.el10_3"
PACKAGES = " \
 rust-crossbeam-utils+default-devel \
 rust-crossbeam-utils+nightly-devel \
 rust-crossbeam-utils+std-devel \
 rust-crossbeam-utils-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-utils-0.8.23-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ced6313db4ed1a88f41749569456e4ebd9b683d71c376f4075117b3713695987"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+default-devel-0.8.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-utils+default-devel.sha256sum] = "89a7d7363f0973a8eaa96e2efd3d420a511983d0bd854d059e56f1f924662f18"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+nightly-devel-0.8.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-utils+nightly-devel.sha256sum] = "21e656291f69c40abe92e776cda62a7c522c592907f88fc8cd9ffe204e578900"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+std-devel-0.8.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-utils+std-devel.sha256sum] = "600cf5cae376c4c5862134ffe6436f85f7e891581f8d0a58c16f62562bb60044"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils-devel-0.8.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-utils-devel.sha256sum] = "cb1d3447cd2c653cb0af3b3b208a1439c04aee7d633b1e00a92edf169093d807"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+default-devel-0.8.23-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-utils+default-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-utils+default-devel.sha256sum] = "b2f1a23c823e13063ff5859b7da77370c4bf2629acc1f2311f0f6094d0c56c42"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+nightly-devel-0.8.23-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-utils+nightly-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-utils+nightly-devel.sha256sum] = "b139e3f4c79a22456573705f0b511cf23afe3ac5402b5f3a2057c90cb42711c7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+std-devel-0.8.23-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-utils+std-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-utils+std-devel.sha256sum] = "e3d0cc64896abdd050070d37f9992126f70e50983f6d1f06f240dd8b86cb54de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils-devel-0.8.23-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-utils-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-utils-devel.sha256sum] = "8cc2d925fbcde3dd7a8726102373333ba7a9fbacb57fcb06897c542286342f02"

RDEPENDS:rust-crossbeam-utils+default-devel = " \
 cargo \
 rust-crossbeam-utils+std-devel \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils+nightly-devel = " \
 cargo \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils+std-devel = " \
 cargo \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils-devel = " \
 cargo \
 rust \
 "
