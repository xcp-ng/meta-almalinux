# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deadpool-runtime"
PV = "0.1.4"
PR = "2.el10_1"
PACKAGES = " \
 rust-deadpool-runtime+default-devel \
 rust-deadpool-runtime+tokio_1-devel \
 rust-deadpool-runtime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deadpool-runtime-0.1.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c243a527017b1376afa7e117aa474a7397b255a3fef7f3cc14c8df220a8d1beb"

URI_x86_64_v2_rust-deadpool-runtime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-runtime+default-devel-0.1.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-runtime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool-runtime+default-devel}"
SRC_URI[x86_64_v2_rust-deadpool-runtime+default-devel.sha256sum] = "6f417b2ac7dfd1b85ecd3005bf981575306d7caff57a552192719886cd6cefe4"

URI_x86_64_v2_rust-deadpool-runtime+tokio_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-runtime+tokio_1-devel-0.1.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-runtime+tokio_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool-runtime+tokio_1-devel}"
SRC_URI[x86_64_v2_rust-deadpool-runtime+tokio_1-devel.sha256sum] = "07ee3d41466152ccddf3ffb4a042177545b3bbdd443a7d3fc37eac0ef274cdd8"

URI_x86_64_v2_rust-deadpool-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-runtime-devel-0.1.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool-runtime-devel}"
SRC_URI[x86_64_v2_rust-deadpool-runtime-devel.sha256sum] = "fae544c5e45bf24251532671c029c813b811412bd06e9574f9c11b06b067b89e"

URI_aarch64_rust-deadpool-runtime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-runtime+default-devel-0.1.4-2.el10_1.noarch.rpm;name=aarch64_rust-deadpool-runtime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool-runtime+default-devel}"
SRC_URI[aarch64_rust-deadpool-runtime+default-devel.sha256sum] = "cc450dff300897daff7694b7158bd6604e76f51a5e153f0b4c3ed8ecf0dda67c"

URI_aarch64_rust-deadpool-runtime+tokio_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-runtime+tokio_1-devel-0.1.4-2.el10_1.noarch.rpm;name=aarch64_rust-deadpool-runtime+tokio_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool-runtime+tokio_1-devel}"
SRC_URI[aarch64_rust-deadpool-runtime+tokio_1-devel.sha256sum] = "7e8cd96d48336f2f1cb4482ac2c3949092b3b37b0a20ef047ce4b6b3b156bdae"

URI_aarch64_rust-deadpool-runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-runtime-devel-0.1.4-2.el10_1.noarch.rpm;name=aarch64_rust-deadpool-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool-runtime-devel}"
SRC_URI[aarch64_rust-deadpool-runtime-devel.sha256sum] = "34d0f898821b73f383c1fb00f9aa99e7970bc2640b269967cb450ce0f73dd55e"

RDEPENDS:rust-deadpool-runtime+default-devel = " \
 cargo \
 rust-deadpool-runtime-devel \
 "
RDEPENDS:rust-deadpool-runtime+tokio_1-devel = " \
 cargo \
 rust-deadpool-runtime-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-deadpool-runtime-devel = " \
 cargo \
 rust \
 "
