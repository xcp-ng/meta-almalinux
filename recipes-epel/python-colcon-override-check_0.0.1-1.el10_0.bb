# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-override-check"
PV = "0.0.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-override-check \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-override-check-0.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c60e92866b5348a4a18d9c6766cb97557677eec56aae67991560c880f24bcc9f"

URI_x86_64_v2_python3-colcon-override-check = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-override-check-0.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-override-check;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-override-check}"
SRC_URI[x86_64_v2_python3-colcon-override-check.sha256sum] = "0d9f3bf71bb827d669100d9aa39ae2b6570efd2e254c7b45989a5d1142592aac"

URI_aarch64_python3-colcon-override-check = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-override-check-0.0.1-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-override-check;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-override-check}"
SRC_URI[aarch64_python3-colcon-override-check.sha256sum] = "902228fb7aaaf0ca31d11b1207b9259e40c7e3d7f7e21a89ee954f801c1e87fc"

RDEPENDS:python3-colcon-override-check = " \
 python3 \
 python3-colcon-core \
 python3-colcon-installed-package-information \
 "
