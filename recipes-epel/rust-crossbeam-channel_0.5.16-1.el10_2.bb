# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-channel"
PV = "0.5.16"
PR = "1.el10_2"
PACKAGES = " \
 rust-crossbeam-channel+default-devel \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-channel-0.5.16-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d858416fd1747077ef8e80643386a28f532ede3edcdbcc38a99b665d9b528dd"

URI_x86_64_v2_rust-crossbeam-channel+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel+default-devel-0.5.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-channel+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-channel+default-devel.sha256sum] = "3d45353f4958daed9fdcd695f5ffaca5e095de8549066729b327d73be95bdbee"

URI_x86_64_v2_rust-crossbeam-channel+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel+std-devel-0.5.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-channel+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-channel+std-devel.sha256sum] = "cdeb23c68e3b09acf3d632f8b374fdc180b81a46f7e2c34babbabad621d2eacd"

URI_x86_64_v2_rust-crossbeam-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel-devel-0.5.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-channel-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-channel-devel.sha256sum] = "3d21be83e7bf5bdf9ddc80187fdbf57dbbb6f5562feb44e97f3d23535467ef69"

URI_aarch64_rust-crossbeam-channel+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel+default-devel-0.5.16-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-channel+default-devel}"
SRC_URI[aarch64_rust-crossbeam-channel+default-devel.sha256sum] = "2dd7ddff5daaa29816b53ccd997c692388aa0e90bd59fdcf190119d7a57b185b"

URI_aarch64_rust-crossbeam-channel+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel+std-devel-0.5.16-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-channel+std-devel}"
SRC_URI[aarch64_rust-crossbeam-channel+std-devel.sha256sum] = "e00714987355eeb47a82e963d7ff32b299b5c23a4e3363f24ceb652bda113f19"

URI_aarch64_rust-crossbeam-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel-devel-0.5.16-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-channel-devel}"
SRC_URI[aarch64_rust-crossbeam-channel-devel.sha256sum] = "2d79953561df1187ad4eae22efc3076721a6feb3dcff12607347528ac2383dd1"

RDEPENDS:rust-crossbeam-channel+default-devel = " \
 cargo \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 "
RDEPENDS:rust-crossbeam-channel+std-devel = " \
 cargo \
 rust-crossbeam-channel-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-channel-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
