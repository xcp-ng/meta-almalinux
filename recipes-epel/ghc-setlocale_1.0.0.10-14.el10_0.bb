# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-setlocale"
PV = "1.0.0.10"
PR = "14.el10_0"
PACKAGES = " \
 ghc-setlocale \
 ghc-setlocale-devel \
 ghc-setlocale-doc \
 ghc-setlocale-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-setlocale-1.0.0.10-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96e1f43aa7264cccc25b90d9f6c59fa380c5ca4558897cdf70e285c98e51b47b"

URI_x86_64_v2_ghc-setlocale = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-setlocale-1.0.0.10-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-setlocale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-setlocale}"
SRC_URI[x86_64_v2_ghc-setlocale.sha256sum] = "a360c190b1420ad3cee1ba1f492490b2190fb9311c4584b382f99890bebfac19"

URI_x86_64_v2_ghc-setlocale-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-setlocale-devel-1.0.0.10-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-setlocale-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-setlocale-devel}"
SRC_URI[x86_64_v2_ghc-setlocale-devel.sha256sum] = "a9f2dfb03806b2c0153c535ec1a2f5707721cddaa123f4c0f46b0b7836a14523"

URI_x86_64_v2_ghc-setlocale-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-setlocale-doc-1.0.0.10-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-setlocale-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-setlocale-doc}"
SRC_URI[x86_64_v2_ghc-setlocale-doc.sha256sum] = "3fd3b369095434488245d07d9124ebbb2f32a1043b654faac352522685c1ac04"

URI_x86_64_v2_ghc-setlocale-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-setlocale-prof-1.0.0.10-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-setlocale-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-setlocale-prof}"
SRC_URI[x86_64_v2_ghc-setlocale-prof.sha256sum] = "fd2fdb4a07fecb8aa5c485a5eadcd0beae6a56131d5ae14c78d717dd67c7952f"

URI_aarch64_ghc-setlocale = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-setlocale-1.0.0.10-14.el10_0.aarch64.rpm;name=aarch64_ghc-setlocale;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-setlocale}"
SRC_URI[aarch64_ghc-setlocale.sha256sum] = "9aecbef4c7e7805f15e5c9ecc0843f1e263fe2c8a5c05ddc905be6beaa3bb964"

URI_aarch64_ghc-setlocale-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-setlocale-devel-1.0.0.10-14.el10_0.aarch64.rpm;name=aarch64_ghc-setlocale-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-setlocale-devel}"
SRC_URI[aarch64_ghc-setlocale-devel.sha256sum] = "bcb799f6fe00f0cb12bc573797d38dafcd4c8b8429bd2b1570a30e9a89abd84d"

URI_aarch64_ghc-setlocale-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-setlocale-doc-1.0.0.10-14.el10_0.noarch.rpm;name=aarch64_ghc-setlocale-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-setlocale-doc}"
SRC_URI[aarch64_ghc-setlocale-doc.sha256sum] = "062f84be46371e7867c55e7d0f0fb657f2dc4af4faf69228652496214a4ed6be"

URI_aarch64_ghc-setlocale-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-setlocale-prof-1.0.0.10-14.el10_0.aarch64.rpm;name=aarch64_ghc-setlocale-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-setlocale-prof}"
SRC_URI[aarch64_ghc-setlocale-prof.sha256sum] = "7c22f44028d3f04356eba48790bab244d8a0a76474692b6dd5ab889337046c08"

RDEPENDS:ghc-setlocale = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-setlocale-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-setlocale \
 "
RDEPENDS:ghc-setlocale-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-setlocale-prof = " \
 ghc-base-prof \
 ghc-setlocale-devel \
 "
