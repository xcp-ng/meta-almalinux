# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tinystr"
PV = "0.7.6"
PR = "4.el10_0"
PACKAGES = " \
 rust-tinystr+alloc-devel \
 rust-tinystr+databake-devel \
 rust-tinystr+default-devel \
 rust-tinystr+serde-devel \
 rust-tinystr+std-devel \
 rust-tinystr+zerovec-devel \
 rust-tinystr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tinystr-0.7.6-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78f5646a6f50f0617f4ed438fe861e53592555e066848c64c92f29cc46c38587"

URI_x86_64_v2_rust-tinystr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+alloc-devel-0.7.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+alloc-devel}"
SRC_URI[x86_64_v2_rust-tinystr+alloc-devel.sha256sum] = "f91c918155afb450423f9eb0c87bd6423fce0b1ff665758cfc031bc19e8c2353"

URI_x86_64_v2_rust-tinystr+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+databake-devel-0.7.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+databake-devel}"
SRC_URI[x86_64_v2_rust-tinystr+databake-devel.sha256sum] = "482f5d2698b5e19c70c99a5e7e2ae5d65bfe208ae3824ede528315852f5a604b"

URI_x86_64_v2_rust-tinystr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+default-devel-0.7.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+default-devel}"
SRC_URI[x86_64_v2_rust-tinystr+default-devel.sha256sum] = "662b2032c98762dc6336fad7152fb5216f3238dba753be66f869b8a702b9aa07"

URI_x86_64_v2_rust-tinystr+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+serde-devel-0.7.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+serde-devel}"
SRC_URI[x86_64_v2_rust-tinystr+serde-devel.sha256sum] = "ce77d09e87fbdfb9596467f1c92bfa221a9165d01872dcfabb41743fe5515514"

URI_x86_64_v2_rust-tinystr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+std-devel-0.7.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+std-devel}"
SRC_URI[x86_64_v2_rust-tinystr+std-devel.sha256sum] = "d6028b6919e24137b04565bbb8d354b3c6eac32f8f70ab039416549f88adedde"

URI_x86_64_v2_rust-tinystr+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+zerovec-devel-0.7.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+zerovec-devel}"
SRC_URI[x86_64_v2_rust-tinystr+zerovec-devel.sha256sum] = "ce00b1e45334e61fd228d3d49da37820fbbb0660ac932c223dc62eb292a33281"

URI_x86_64_v2_rust-tinystr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr-devel-0.7.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr-devel}"
SRC_URI[x86_64_v2_rust-tinystr-devel.sha256sum] = "eff785bce4eb2227c9233c2687f54ffb9a3066d797cb20a1f8ebc41451293662"

URI_aarch64_rust-tinystr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+alloc-devel-0.7.6-4.el10_0.noarch.rpm;name=aarch64_rust-tinystr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+alloc-devel}"
SRC_URI[aarch64_rust-tinystr+alloc-devel.sha256sum] = "f11659053ac235d8190834ee0199f59dd00dc5f5522504aca66e7830691874b7"

URI_aarch64_rust-tinystr+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+databake-devel-0.7.6-4.el10_0.noarch.rpm;name=aarch64_rust-tinystr+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+databake-devel}"
SRC_URI[aarch64_rust-tinystr+databake-devel.sha256sum] = "c2f43b648765869c9583e84559a84cf6572a5006ea43fcd1bb2153f2cb780148"

URI_aarch64_rust-tinystr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+default-devel-0.7.6-4.el10_0.noarch.rpm;name=aarch64_rust-tinystr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+default-devel}"
SRC_URI[aarch64_rust-tinystr+default-devel.sha256sum] = "7dc51f6ecde058aad090be8119a37e82db1282f77f1a61e8e50e640b98bab40e"

URI_aarch64_rust-tinystr+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+serde-devel-0.7.6-4.el10_0.noarch.rpm;name=aarch64_rust-tinystr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+serde-devel}"
SRC_URI[aarch64_rust-tinystr+serde-devel.sha256sum] = "31af53bbb7fc31859697ea1c84428bdf02e9eafa9cc945f423b4a7297387afef"

URI_aarch64_rust-tinystr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+std-devel-0.7.6-4.el10_0.noarch.rpm;name=aarch64_rust-tinystr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+std-devel}"
SRC_URI[aarch64_rust-tinystr+std-devel.sha256sum] = "d0244c638fa6e31bb961808be0893a8056182774b402804f558d4598d10bab88"

URI_aarch64_rust-tinystr+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+zerovec-devel-0.7.6-4.el10_0.noarch.rpm;name=aarch64_rust-tinystr+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+zerovec-devel}"
SRC_URI[aarch64_rust-tinystr+zerovec-devel.sha256sum] = "4914e6532fdf788563ba3e34905ca7212e340dcf7ec41a2e15aaa5746eee927c"

URI_aarch64_rust-tinystr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr-devel-0.7.6-4.el10_0.noarch.rpm;name=aarch64_rust-tinystr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr-devel}"
SRC_URI[aarch64_rust-tinystr-devel.sha256sum] = "bb1f8bfb9370bcf57e3215da6419189a4cff5e69250899285e341a79a8598306"

RDEPENDS:rust-tinystr+alloc-devel = " \
 cargo \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+databake-devel = " \
 cargo \
 rust-databake-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+default-devel = " \
 cargo \
 rust-tinystr+alloc-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+serde-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+std-devel = " \
 cargo \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+zerovec-devel = " \
 cargo \
 rust-tinystr-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-tinystr-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 "
