# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tera"
PV = "1.20.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-tera+builtins-devel \
 rust-tera+chrono-devel \
 rust-tera+chrono-tz-devel \
 rust-tera+date-locale-devel \
 rust-tera+default-devel \
 rust-tera+humansize-devel \
 rust-tera+percent-encoding-devel \
 rust-tera+preserve_order-devel \
 rust-tera+rand-devel \
 rust-tera+slug-devel \
 rust-tera+urlencode-devel \
 rust-tera-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tera-1.20.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea4153e97085dbcbd998d401830e113ef9f40380e632f8b8b0158b05ff230fe3"

URI_x86_64_v2_rust-tera+builtins-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+builtins-devel-1.20.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+builtins-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+builtins-devel}"
SRC_URI[x86_64_v2_rust-tera+builtins-devel.sha256sum] = "806d63da721af1debdb1ed755ed8ec905f0f7099dfd9c7d4871d43cad28355fc"

URI_x86_64_v2_rust-tera+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+chrono-devel-1.20.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+chrono-devel}"
SRC_URI[x86_64_v2_rust-tera+chrono-devel.sha256sum] = "2543555edec1a502c7fc143a15e28e1ad55c004714a21ed6eb805d7a416b733a"

URI_x86_64_v2_rust-tera+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+chrono-tz-devel-1.20.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-tera+chrono-tz-devel.sha256sum] = "386ebbfc21737a3f1310d26525ee4136506ce6333b830a4fdef52e4d26effc0d"

URI_x86_64_v2_rust-tera+date-locale-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+date-locale-devel-1.20.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+date-locale-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+date-locale-devel}"
SRC_URI[x86_64_v2_rust-tera+date-locale-devel.sha256sum] = "7a40a7a365a5234dd358d15932a7465b2ee82804e3cecc72b8153998aaf4363d"

URI_x86_64_v2_rust-tera+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+default-devel-1.20.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+default-devel}"
SRC_URI[x86_64_v2_rust-tera+default-devel.sha256sum] = "a93764be5d280affd1e92c3ae358048638a26d4a5b1e60abf03a72f639686565"

URI_x86_64_v2_rust-tera+humansize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+humansize-devel-1.20.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+humansize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+humansize-devel}"
SRC_URI[x86_64_v2_rust-tera+humansize-devel.sha256sum] = "80d27d66779dad31bf0622256785f468e74ce1a031b867fc50f5b7cd733d87ff"

URI_x86_64_v2_rust-tera+percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+percent-encoding-devel-1.20.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-tera+percent-encoding-devel.sha256sum] = "de239cf710a6b73ffe46a0c6fd903d251e3da8e3328a38ac9fde9e174e0e7db8"

URI_x86_64_v2_rust-tera+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+preserve_order-devel-1.20.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-tera+preserve_order-devel.sha256sum] = "d56927abed3a41afe5bf9139c41d615aab8623f2283d816ec5e76f026e3d45c8"

URI_x86_64_v2_rust-tera+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+rand-devel-1.20.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+rand-devel}"
SRC_URI[x86_64_v2_rust-tera+rand-devel.sha256sum] = "b613b73c1909c9718895540a85cb37d1683b6427549b6c6ae485e9e63d5633ee"

URI_x86_64_v2_rust-tera+slug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+slug-devel-1.20.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+slug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+slug-devel}"
SRC_URI[x86_64_v2_rust-tera+slug-devel.sha256sum] = "9ceee0eee868114fb6ec4a989378b910982b9bff324b42815c8e44fe55e2412b"

URI_x86_64_v2_rust-tera+urlencode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+urlencode-devel-1.20.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+urlencode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+urlencode-devel}"
SRC_URI[x86_64_v2_rust-tera+urlencode-devel.sha256sum] = "51120e7ab0f1caafe2ae28f6a7775d723f96c47e215799a2681c3bb92498540b"

URI_x86_64_v2_rust-tera-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera-devel-1.20.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera-devel}"
SRC_URI[x86_64_v2_rust-tera-devel.sha256sum] = "b18f1d2e7989336fee16e8b1c5b87d028a1fc3482579aa0c4950ec0951cc6b9a"

URI_aarch64_rust-tera+builtins-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+builtins-devel-1.20.0-3.el10_0.noarch.rpm;name=aarch64_rust-tera+builtins-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+builtins-devel}"
SRC_URI[aarch64_rust-tera+builtins-devel.sha256sum] = "58930f9339a4084995c4fed4436b3c860e713e2899c1f440bac6ae6cb56e1f55"

URI_aarch64_rust-tera+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+chrono-devel-1.20.0-3.el10_0.noarch.rpm;name=aarch64_rust-tera+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+chrono-devel}"
SRC_URI[aarch64_rust-tera+chrono-devel.sha256sum] = "80684faa0e556adfb4a3d0b420f221192a9a400f4cfe9941f6ad84e8406d832e"

URI_aarch64_rust-tera+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+chrono-tz-devel-1.20.0-3.el10_0.noarch.rpm;name=aarch64_rust-tera+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+chrono-tz-devel}"
SRC_URI[aarch64_rust-tera+chrono-tz-devel.sha256sum] = "fcc3a5620ad28773588be6994c0313140d03d291690e53bfa16cf8c59c49ac55"

URI_aarch64_rust-tera+date-locale-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+date-locale-devel-1.20.0-3.el10_0.noarch.rpm;name=aarch64_rust-tera+date-locale-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+date-locale-devel}"
SRC_URI[aarch64_rust-tera+date-locale-devel.sha256sum] = "e1e19b32a12cabf3c9efc05f63a6d50ef060183f13d36b79d9bacbd84dcd298c"

URI_aarch64_rust-tera+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+default-devel-1.20.0-3.el10_0.noarch.rpm;name=aarch64_rust-tera+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+default-devel}"
SRC_URI[aarch64_rust-tera+default-devel.sha256sum] = "ddc5c0a45de92976c6c4608f434860fa772aa6c4225d1a4f7bfc2df3471d2f7b"

URI_aarch64_rust-tera+humansize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+humansize-devel-1.20.0-3.el10_0.noarch.rpm;name=aarch64_rust-tera+humansize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+humansize-devel}"
SRC_URI[aarch64_rust-tera+humansize-devel.sha256sum] = "6326c0d76bcae700352aa26658946181ab8afef22918581e5363bb1ceb9f1db0"

URI_aarch64_rust-tera+percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+percent-encoding-devel-1.20.0-3.el10_0.noarch.rpm;name=aarch64_rust-tera+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+percent-encoding-devel}"
SRC_URI[aarch64_rust-tera+percent-encoding-devel.sha256sum] = "3746e1954f856f09cd87514c537fdfe2cfbf74ddbf74a4751c3a341a7b50b776"

URI_aarch64_rust-tera+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+preserve_order-devel-1.20.0-3.el10_0.noarch.rpm;name=aarch64_rust-tera+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+preserve_order-devel}"
SRC_URI[aarch64_rust-tera+preserve_order-devel.sha256sum] = "aeca2feb1e111eca7b03d6687da2d24341284b08418f98205f6a4c6e01a3f830"

URI_aarch64_rust-tera+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+rand-devel-1.20.0-3.el10_0.noarch.rpm;name=aarch64_rust-tera+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+rand-devel}"
SRC_URI[aarch64_rust-tera+rand-devel.sha256sum] = "5c0755c2e76d42e2bf974846b8f47ba94c85602372c08258fed42ca137c6a8a9"

URI_aarch64_rust-tera+slug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+slug-devel-1.20.0-3.el10_0.noarch.rpm;name=aarch64_rust-tera+slug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+slug-devel}"
SRC_URI[aarch64_rust-tera+slug-devel.sha256sum] = "34a707aa2304aa1cdb1cd282c9f6c3e0c696e642b0b878834bb2b6e18e06deaf"

URI_aarch64_rust-tera+urlencode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+urlencode-devel-1.20.0-3.el10_0.noarch.rpm;name=aarch64_rust-tera+urlencode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+urlencode-devel}"
SRC_URI[aarch64_rust-tera+urlencode-devel.sha256sum] = "0e6f1e98031594cb38f411b13e82315cd0ba41f466c25f1d82c746aa1c4ee62e"

URI_aarch64_rust-tera-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera-devel-1.20.0-3.el10_0.noarch.rpm;name=aarch64_rust-tera-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera-devel}"
SRC_URI[aarch64_rust-tera-devel.sha256sum] = "7315511c47abc3c96ad020f9a1eb882bf3c084005eadc59be3f538379509f731"

RDEPENDS:rust-tera+builtins-devel = " \
 cargo \
 rust-tera+chrono-devel \
 rust-tera+chrono-tz-devel \
 rust-tera+humansize-devel \
 rust-tera+rand-devel \
 rust-tera+slug-devel \
 rust-tera+urlencode-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+date-locale-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono+unstable-locales-devel \
 rust-chrono-devel \
 rust-tera+builtins-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+default-devel = " \
 cargo \
 rust-tera+builtins-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+humansize-devel = " \
 cargo \
 rust-humansize+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+percent-encoding-devel = " \
 cargo \
 rust-percent-encoding+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+preserve_order-devel = " \
 cargo \
 rust-serde_json+preserve_order-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+rand-devel = " \
 cargo \
 rust-rand0.8+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+slug-devel = " \
 cargo \
 rust-slug+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+urlencode-devel = " \
 cargo \
 rust-tera+percent-encoding-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera-devel = " \
 cargo \
 rust \
 rust-globwalk+default-devel \
 rust-lazy_static+default-devel \
 rust-pest+default-devel \
 rust-pest_derive+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 rust-unic-segment+default-devel \
 "
