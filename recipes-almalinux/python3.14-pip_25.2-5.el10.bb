# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-pip"
PV = "25.2"
PR = "5.el10"
PACKAGES = " \
 python3.14-pip \
 python3.14-pip-wheel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-pip-25.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5531837e5c02e21eb2135b9d0ca4bfe921e65cee01602bd882206f4d0f0648c"

URI_x86_64_v2_python3.14-pip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-pip-25.2-5.el10.noarch.rpm;name=x86_64_v2_python3.14-pip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-pip}"
SRC_URI[x86_64_v2_python3.14-pip.sha256sum] = "a6c96f99b4688602355a59df6cbd322fb61f1de772904d9f691306b660795be1"

URI_x86_64_v2_python3.14-pip-wheel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-pip-wheel-25.2-5.el10.noarch.rpm;name=x86_64_v2_python3.14-pip-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-pip-wheel}"
SRC_URI[x86_64_v2_python3.14-pip-wheel.sha256sum] = "6a23194d58e2361a431a586d4d22d6286b93c51902b92711ee16d3b1f3600bc3"

URI_aarch64_python3.14-pip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-pip-25.2-5.el10.noarch.rpm;name=aarch64_python3.14-pip;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-pip}"
SRC_URI[aarch64_python3.14-pip.sha256sum] = "a6c96f99b4688602355a59df6cbd322fb61f1de772904d9f691306b660795be1"

URI_aarch64_python3.14-pip-wheel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-pip-wheel-25.2-5.el10.noarch.rpm;name=aarch64_python3.14-pip-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-pip-wheel}"
SRC_URI[aarch64_python3.14-pip-wheel.sha256sum] = "6a23194d58e2361a431a586d4d22d6286b93c51902b92711ee16d3b1f3600bc3"

RDEPENDS:python3.14-pip = " \
 ca-certificates \
 python3.14 \
 "
RDEPENDS:python3.14-pip-wheel = " \
 ca-certificates \
 "
