# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krdc"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 krdc \
 krdc-devel \
 krdc-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krdc-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "145d720057f493364192d4ca06e5dce70ce28f45731bf99d1d99afff6dd9f086"

URI_x86_64_v2_krdc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdc}"
SRC_URI[x86_64_v2_krdc.sha256sum] = "130f1beb5a0661f6132ee7eaa5eb0ca0e6905c96d6f193dc9a407420a9759f45"

URI_x86_64_v2_krdc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdc-devel}"
SRC_URI[x86_64_v2_krdc-devel.sha256sum] = "3452849e413be9db8603b2421555115690869ce9cf7a4fd656fcdb1e65f1dfce"

URI_x86_64_v2_krdc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdc-libs}"
SRC_URI[x86_64_v2_krdc-libs.sha256sum] = "e53eae603c031b0e7ab5d9d928d33598cc19fced6426f8531fc8374ba0a581ac"

URI_aarch64_krdc = "${EPEL_MIRROR}/aarch64/Packages/k/krdc-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_krdc;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdc}"
SRC_URI[aarch64_krdc.sha256sum] = "b4a949450499836bd098535317d1e90a8c79ef16ef36fc6b63c8bd2e8d742853"

URI_aarch64_krdc-devel = "${EPEL_MIRROR}/aarch64/Packages/k/krdc-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_krdc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdc-devel}"
SRC_URI[aarch64_krdc-devel.sha256sum] = "c67689f4dc9fdc0bd9310ea457b92adf7c729dd5700a31b643f7e818ec7717db"

URI_aarch64_krdc-libs = "${EPEL_MIRROR}/aarch64/Packages/k/krdc-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_krdc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdc-libs}"
SRC_URI[aarch64_krdc-libs.sha256sum] = "8199c6868d010762f7880b3b4c6e12b7345753a5fe0343a58f18ab4662d0eb85"

RDEPENDS:krdc = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 krdc-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:krdc-devel = " \
 krdc-libs \
 "
RDEPENDS:krdc-libs = " \
 freerdp-libs \
 glibc \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 krdc \
 libssh \
 libstdc++ \
 libvncserver \
 libwinpr \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
