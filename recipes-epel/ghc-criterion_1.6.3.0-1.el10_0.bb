# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-criterion"
PV = "1.6.3.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-binary-orphans \
 ghc-binary-orphans-devel \
 ghc-binary-orphans-doc \
 ghc-binary-orphans-prof \
 ghc-criterion \
 ghc-criterion-devel \
 ghc-criterion-doc \
 ghc-criterion-measurement \
 ghc-criterion-measurement-devel \
 ghc-criterion-measurement-doc \
 ghc-criterion-measurement-prof \
 ghc-criterion-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-criterion-1.6.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ce69aff4674ce2ce83c6c58810713548d181c3173d247e27566585ede5f0b8b"

URI_x86_64_v2_ghc-binary-orphans = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-binary-orphans-1.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-binary-orphans;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-binary-orphans}"
SRC_URI[x86_64_v2_ghc-binary-orphans.sha256sum] = "8a53278d6385c37f8bfd91675416ed40a6aeab79b231d1051038f4f5d329c0e1"

URI_x86_64_v2_ghc-binary-orphans-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-binary-orphans-devel-1.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-binary-orphans-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-binary-orphans-devel}"
SRC_URI[x86_64_v2_ghc-binary-orphans-devel.sha256sum] = "f758218a84a5c40cd389be0cc56f5c7db687b28385fca639aa678f1823e347b3"

URI_x86_64_v2_ghc-binary-orphans-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-binary-orphans-doc-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-binary-orphans-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-binary-orphans-doc}"
SRC_URI[x86_64_v2_ghc-binary-orphans-doc.sha256sum] = "f86da36b8fb1d0aa64dd54ccb79df88e048662db165305e19c47e4c6acc63390"

URI_x86_64_v2_ghc-binary-orphans-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-binary-orphans-prof-1.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-binary-orphans-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-binary-orphans-prof}"
SRC_URI[x86_64_v2_ghc-binary-orphans-prof.sha256sum] = "c994784be2e1272b0b34e8c77b8473027b1f5508958e268afcc993c76d889ad4"

URI_x86_64_v2_ghc-criterion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-criterion-1.6.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-criterion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-criterion}"
SRC_URI[x86_64_v2_ghc-criterion.sha256sum] = "9ff933a25b607821d27365c323c5d1fe1d2ed3be390685b870de72a12022bda9"

URI_x86_64_v2_ghc-criterion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-criterion-devel-1.6.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-criterion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-criterion-devel}"
SRC_URI[x86_64_v2_ghc-criterion-devel.sha256sum] = "7a4b2613f17796fa16b02660224822deee8c0d36d053885e9ab3d5ca6003902b"

URI_x86_64_v2_ghc-criterion-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-criterion-doc-1.6.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-criterion-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-criterion-doc}"
SRC_URI[x86_64_v2_ghc-criterion-doc.sha256sum] = "c5ab550845802ceea0c73a2d30f084cbd7d08360434c41c6c314ce6f60bb6c3c"

URI_x86_64_v2_ghc-criterion-measurement = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-criterion-measurement-0.2.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-criterion-measurement;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-criterion-measurement}"
SRC_URI[x86_64_v2_ghc-criterion-measurement.sha256sum] = "b6127757c96edff256a653d37570ad03e95af0e762274177205eb1bc46289237"

URI_x86_64_v2_ghc-criterion-measurement-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-criterion-measurement-devel-0.2.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-criterion-measurement-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-criterion-measurement-devel}"
SRC_URI[x86_64_v2_ghc-criterion-measurement-devel.sha256sum] = "93bcab5c404b9e2e29993c936ad5c4697b40611abb9ab8ae2ef7c99b5823a19b"

URI_x86_64_v2_ghc-criterion-measurement-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-criterion-measurement-doc-0.2.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-criterion-measurement-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-criterion-measurement-doc}"
SRC_URI[x86_64_v2_ghc-criterion-measurement-doc.sha256sum] = "cf2f6307156f25d105410bd0ca072ef55ac97a06f4c0b51fd89483e58893092f"

URI_x86_64_v2_ghc-criterion-measurement-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-criterion-measurement-prof-0.2.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-criterion-measurement-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-criterion-measurement-prof}"
SRC_URI[x86_64_v2_ghc-criterion-measurement-prof.sha256sum] = "9ad4089cb1f414447e3f74239971f9d84f66f53b18d7441e0749b91d0a062ff1"

URI_x86_64_v2_ghc-criterion-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-criterion-prof-1.6.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-criterion-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-criterion-prof}"
SRC_URI[x86_64_v2_ghc-criterion-prof.sha256sum] = "ec652cc99ea02a0a9780f78038217ecab491bc5cb2cc59c4553b33f19e508ce4"

URI_aarch64_ghc-binary-orphans = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-binary-orphans-1.0.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-binary-orphans;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-binary-orphans}"
SRC_URI[aarch64_ghc-binary-orphans.sha256sum] = "20238f01f2a59e3614476f5f8be112ae7ab505a4af4a9868c0ab669b6f205ab1"

URI_aarch64_ghc-binary-orphans-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-binary-orphans-devel-1.0.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-binary-orphans-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-binary-orphans-devel}"
SRC_URI[aarch64_ghc-binary-orphans-devel.sha256sum] = "94429bae080a5add833ea0539d940de54e651183dd3a06b2ef75c88eec5650bf"

URI_aarch64_ghc-binary-orphans-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-binary-orphans-doc-1.0.5-1.el10_0.noarch.rpm;name=aarch64_ghc-binary-orphans-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-binary-orphans-doc}"
SRC_URI[aarch64_ghc-binary-orphans-doc.sha256sum] = "2bcfa7eccadfd35e05c4301b86d2f9f329ef39e44ff32a1528f6f5b2b69cd31c"

URI_aarch64_ghc-binary-orphans-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-binary-orphans-prof-1.0.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-binary-orphans-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-binary-orphans-prof}"
SRC_URI[aarch64_ghc-binary-orphans-prof.sha256sum] = "67833c92ee4471cafd76b39ac9e84c6fc0f26918c45829d58bab6e02efc386d7"

URI_aarch64_ghc-criterion = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-criterion-1.6.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-criterion;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-criterion}"
SRC_URI[aarch64_ghc-criterion.sha256sum] = "bb68dcf9f8fd8a6791ae4b34671ad50bd9a7c042e3b3e6b757b10efecae02d55"

URI_aarch64_ghc-criterion-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-criterion-devel-1.6.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-criterion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-criterion-devel}"
SRC_URI[aarch64_ghc-criterion-devel.sha256sum] = "829494ffea2e7179f7b4fdab759a039e161489e735feb0142b8f118607700963"

URI_aarch64_ghc-criterion-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-criterion-doc-1.6.3.0-1.el10_0.noarch.rpm;name=aarch64_ghc-criterion-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-criterion-doc}"
SRC_URI[aarch64_ghc-criterion-doc.sha256sum] = "c4059b449eaf85efe000bdea238565aae62403245daa4f472901420dcbeadd71"

URI_aarch64_ghc-criterion-measurement = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-criterion-measurement-0.2.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-criterion-measurement;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-criterion-measurement}"
SRC_URI[aarch64_ghc-criterion-measurement.sha256sum] = "b304dcfd359ac9a3f64ae704e769e4adcaa082fd779a944e782e823246ecb445"

URI_aarch64_ghc-criterion-measurement-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-criterion-measurement-devel-0.2.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-criterion-measurement-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-criterion-measurement-devel}"
SRC_URI[aarch64_ghc-criterion-measurement-devel.sha256sum] = "16a4473668a19f91dc3e5bd81ce7cf1bbd83db459f2332a6715e0cb3d09dfb8d"

URI_aarch64_ghc-criterion-measurement-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-criterion-measurement-doc-0.2.2.0-1.el10_0.noarch.rpm;name=aarch64_ghc-criterion-measurement-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-criterion-measurement-doc}"
SRC_URI[aarch64_ghc-criterion-measurement-doc.sha256sum] = "2562b10049f7fb9303e3bbc610139086c9804a95d9d6d289a02c85cab9756363"

URI_aarch64_ghc-criterion-measurement-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-criterion-measurement-prof-0.2.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-criterion-measurement-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-criterion-measurement-prof}"
SRC_URI[aarch64_ghc-criterion-measurement-prof.sha256sum] = "b6fa091430dc119477985a431e5ef52b4d06b8b29aae0050fa49ffbaa4efc991"

URI_aarch64_ghc-criterion-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-criterion-prof-1.6.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-criterion-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-criterion-prof}"
SRC_URI[aarch64_ghc-criterion-prof.sha256sum] = "8ad72af4300d359438218394d2bfe93a5e4cfdc0711d4d27b202c4bed6772096"

RDEPENDS:ghc-binary-orphans = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-binary-orphans-devel = " \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-binary-orphans \
 ghc-compiler \
 "
RDEPENDS:ghc-binary-orphans-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-binary-orphans-prof = " \
 ghc-base-prof \
 ghc-binary-orphans-devel \
 ghc-binary-prof \
 "
RDEPENDS:ghc-criterion = " \
 ghc-Glob \
 ghc-OneTuple \
 ghc-Only \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-binary-orphans \
 ghc-bitvec \
 ghc-bytestring \
 ghc-cassava \
 ghc-code-page \
 ghc-colour \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-criterion-measurement \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-dense-linear-algebra \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-js-chart \
 ghc-math-functions \
 ghc-microstache \
 ghc-mtl \
 ghc-mwc-random \
 ghc-optparse-applicative \
 ghc-os-string \
 ghc-parallel \
 ghc-parsec \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-statistics \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-binary-instances \
 ghc-vector-stream \
 ghc-vector-th-unbox \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-criterion-devel = " \
 ghc-Glob-devel \
 ghc-aeson-devel \
 ghc-base-compat-batteries-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-binary-orphans-devel \
 ghc-bytestring-devel \
 ghc-cassava-devel \
 ghc-code-page-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-criterion \
 ghc-criterion-measurement-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-js-chart-devel \
 ghc-microstache-devel \
 ghc-mtl-devel \
 ghc-mwc-random-devel \
 ghc-optparse-applicative-devel \
 ghc-parsec-devel \
 ghc-prettyprinter-ansi-terminal-devel \
 ghc-prettyprinter-devel \
 ghc-statistics-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-transformers-compat-devel \
 ghc-transformers-devel \
 ghc-vector-algorithms-devel \
 ghc-vector-devel \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc-criterion-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-criterion-measurement = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-criterion-measurement-devel = " \
 ghc-aeson-devel \
 ghc-base-compat-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-criterion-measurement \
 ghc-deepseq-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-criterion-measurement-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-criterion-measurement-prof = " \
 ghc-aeson-prof \
 ghc-base-compat-prof \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-containers-prof \
 ghc-criterion-measurement-devel \
 ghc-deepseq-prof \
 ghc-vector-prof \
 "
RDEPENDS:ghc-criterion-prof = " \
 ghc-Glob-prof \
 ghc-aeson-prof \
 ghc-base-compat-batteries-prof \
 ghc-base-prof \
 ghc-binary-orphans-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-cassava-prof \
 ghc-code-page-prof \
 ghc-containers-prof \
 ghc-criterion-devel \
 ghc-criterion-measurement-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-js-chart-prof \
 ghc-microstache-prof \
 ghc-mtl-prof \
 ghc-mwc-random-prof \
 ghc-optparse-applicative-prof \
 ghc-parsec-prof \
 ghc-prettyprinter-ansi-terminal-prof \
 ghc-prettyprinter-prof \
 ghc-statistics-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-transformers-compat-prof \
 ghc-transformers-prof \
 ghc-vector-algorithms-prof \
 ghc-vector-prof \
 "
