# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "t1lib"
PV = "5.1.2"
PR = "43.el10_3"
PACKAGES = " \
 t1lib \
 t1lib-apps \
 t1lib-devel \
 t1lib-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/t1lib-5.1.2-43.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b48628701df6349bd98113003e52f111e9eba35719a290635664dec458408e14"

URI_x86_64_v2_t1lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/t1lib-5.1.2-43.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_t1lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_t1lib}"
SRC_URI[x86_64_v2_t1lib.sha256sum] = "7bd131e019ef544ee686c54281150eac8b98fa970e04f4c7c7f71c1f205a7068"

URI_x86_64_v2_t1lib-apps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/t1lib-apps-5.1.2-43.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_t1lib-apps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_t1lib-apps}"
SRC_URI[x86_64_v2_t1lib-apps.sha256sum] = "f33ab11d05a134eaa7d7596edc3fd2caaa4def82c4491a9de4823d12a1831eb8"

URI_x86_64_v2_t1lib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/t1lib-devel-5.1.2-43.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_t1lib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_t1lib-devel}"
SRC_URI[x86_64_v2_t1lib-devel.sha256sum] = "906e6253cdd457b1ca85fd901264bb3c68fe57de14df1f403e6bab7d45399982"

URI_x86_64_v2_t1lib-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/t1lib-static-5.1.2-43.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_t1lib-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_t1lib-static}"
SRC_URI[x86_64_v2_t1lib-static.sha256sum] = "037abe19e1acf05455695d6a2e8e02d2d97cc603545ec995c6a3c1366410a090"

URI_aarch64_t1lib = "${EPEL_MIRROR}/aarch64/Packages/t/t1lib-5.1.2-43.el10_3.aarch64.rpm;name=aarch64_t1lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_t1lib}"
SRC_URI[aarch64_t1lib.sha256sum] = "13b7029740173447aca059aa5bff7da422cb887f8a62d788197c337ef393e848"

URI_aarch64_t1lib-apps = "${EPEL_MIRROR}/aarch64/Packages/t/t1lib-apps-5.1.2-43.el10_3.aarch64.rpm;name=aarch64_t1lib-apps;unpack=0"
SRC_URI:append = " ${URI_aarch64_t1lib-apps}"
SRC_URI[aarch64_t1lib-apps.sha256sum] = "0ec4ad65b2816211094dae7abfacb3a5de966a16e8b75c83172a332f716e8fab"

URI_aarch64_t1lib-devel = "${EPEL_MIRROR}/aarch64/Packages/t/t1lib-devel-5.1.2-43.el10_3.aarch64.rpm;name=aarch64_t1lib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_t1lib-devel}"
SRC_URI[aarch64_t1lib-devel.sha256sum] = "182d52a80684fba2077af6e64b0759e8faa1311b59e7320d21e089152bb778cb"

URI_aarch64_t1lib-static = "${EPEL_MIRROR}/aarch64/Packages/t/t1lib-static-5.1.2-43.el10_3.aarch64.rpm;name=aarch64_t1lib-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_t1lib-static}"
SRC_URI[aarch64_t1lib-static.sha256sum] = "14558dbfd8ed663e273afce63eba467f88661c61ec84b9d1172870556a29f492"

RDEPENDS:t1lib = " \
 bash \
 findutils \
 glibc \
 libX11 \
 virtual/coreutils \
 "
RDEPENDS:t1lib-apps = " \
 glibc \
 libX11 \
 libXaw \
 libXt \
 t1lib \
 "
RDEPENDS:t1lib-devel = " \
 t1lib \
 "
RDEPENDS:t1lib-static = " \
 t1lib-devel \
 "
