# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxml++"
PV = "2.42.3"
PR = "7.el10_1"
PACKAGES = " \
 libxml++ \
 libxml++-devel \
 libxml++-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libxml++-2.42.3-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a3c10fdf10360d3da3767f219e18276b73ead975b9b015323aeb38bb45788dd"

URI_x86_64_v2_libxml++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxml++-2.42.3-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxml++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxml++}"
SRC_URI[x86_64_v2_libxml++.sha256sum] = "83e4107843ecb667618db0c953c9b27c87ca470e23d0ba72c69a2f1603a555d6"

URI_x86_64_v2_libxml++-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxml++-devel-2.42.3-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxml++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxml++-devel}"
SRC_URI[x86_64_v2_libxml++-devel.sha256sum] = "8a5df676663a273171f696bd485e6c159e76872951aa5792140c0c573b1f9961"

URI_x86_64_v2_libxml++-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxml++-doc-2.42.3-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libxml++-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxml++-doc}"
SRC_URI[x86_64_v2_libxml++-doc.sha256sum] = "b21be91c3d9508e9e08b0a16ed8c8ed26b28e2510b128985745ebf6f62bcfecd"

URI_aarch64_libxml++ = "${EPEL_MIRROR}/aarch64/Packages/l/libxml++-2.42.3-7.el10_1.aarch64.rpm;name=aarch64_libxml++;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxml++}"
SRC_URI[aarch64_libxml++.sha256sum] = "d6a4f63c26b91c1717ff43d567c7da2e79d6f77653c0535265458de117f04ce3"

URI_aarch64_libxml++-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libxml++-devel-2.42.3-7.el10_1.aarch64.rpm;name=aarch64_libxml++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxml++-devel}"
SRC_URI[aarch64_libxml++-devel.sha256sum] = "5519ad6de48c7de44f5ddbfa0393b165e522a47d998922bf4e7afe3b4624cc6d"

URI_aarch64_libxml++-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libxml++-doc-2.42.3-7.el10_1.noarch.rpm;name=aarch64_libxml++-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxml++-doc}"
SRC_URI[aarch64_libxml++-doc.sha256sum] = "5e1897a9c8651ce9d94e86cbfcf22e8d8a36d0b61d8f23deb4719c386a73fab8"

RDEPENDS:libxml++ = " \
 glibc \
 glibmm2.4 \
 libgcc \
 libstdc++ \
 libxml2 \
 "
RDEPENDS:libxml++-devel = " \
 glibmm2.4-devel \
 libxml++ \
 libxml2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libxml++-doc = " \
 glibmm2.4-doc \
 libxml++ \
 "
