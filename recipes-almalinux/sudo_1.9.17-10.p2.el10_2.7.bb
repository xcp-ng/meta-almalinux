# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sudo"
PV = "1.9.17"
PR = "10.p2.el10_2.7"
PACKAGES = " \
 sudo \
 sudo-python-plugin \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sudo-1.9.17-10.p2.el10_2.7.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8e8fd704267c47021b3a99a4f758a7711d09ca11c50161ca840f42eef560e218"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sudo-1.9.17-10.p2.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_sudo;unpack=0"
SRC_URI[x86_64_v2_sudo.sha256sum] = "d9c534b91dc0b832254f8f6d9b9fc3bb6d4ab5f463f4abb7184a35c343c05304"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sudo-python-plugin-1.9.17-10.p2.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_sudo-python-plugin;unpack=0"
SRC_URI[x86_64_v2_sudo-python-plugin.sha256sum] = "4377464b2b26a84a1cf4d1722a7dd1c025bb6f8f27b6bc259dace3b0984c0fc8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sudo-1.9.17-10.p2.el10_2.7.aarch64.rpm;name=aarch64_sudo;unpack=0"
SRC_URI[aarch64_sudo.sha256sum] = "e9ba1ff396107fb284887838e9917f110e206278cfb1a7e7b6cbe27fa8984eb3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sudo-python-plugin-1.9.17-10.p2.el10_2.7.aarch64.rpm;name=aarch64_sudo-python-plugin;unpack=0"
SRC_URI[aarch64_sudo-python-plugin.sha256sum] = "cddeb2aa376046c28129cd3d4146fe9222477a42e77ac018dbf0a479e1a7b717"

RDEPENDS:sudo = " \
 audit-libs \
 glibc \
 libselinux \
 openldap \
 pam \
 pam-libs \
 zlib-ng-compat \
 "
RDEPENDS:sudo-python-plugin = " \
 glibc \
 python3-libs \
 sudo \
 "
