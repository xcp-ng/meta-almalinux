# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-21-openjdk"
PE = "1"
PV = "21.0.9.0.10"
PR = "1.el10.alma.1"
PACKAGES = " \
 java-21-openjdk \
 java-21-openjdk-demo \
 java-21-openjdk-demo-fastdebug \
 java-21-openjdk-demo-slowdebug \
 java-21-openjdk-devel \
 java-21-openjdk-devel-fastdebug \
 java-21-openjdk-devel-slowdebug \
 java-21-openjdk-fastdebug \
 java-21-openjdk-headless \
 java-21-openjdk-headless-fastdebug \
 java-21-openjdk-headless-slowdebug \
 java-21-openjdk-javadoc \
 java-21-openjdk-javadoc-zip \
 java-21-openjdk-jmods \
 java-21-openjdk-jmods-fastdebug \
 java-21-openjdk-jmods-slowdebug \
 java-21-openjdk-slowdebug \
 java-21-openjdk-src \
 java-21-openjdk-src-fastdebug \
 java-21-openjdk-src-slowdebug \
 java-21-openjdk-static-libs \
 java-21-openjdk-static-libs-fastdebug \
 java-21-openjdk-static-libs-slowdebug \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/java-21-openjdk-21.0.9.0.10-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d63b5ba4c2e7f522b2db7ece3d71844519da13b9e0a5a17908b132039de1b6ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk.sha256sum] = "623928904c8bc9f3c86b8bd968b239c1c6e9b6c56b1f8de8b586400df8729c53"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-demo-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-demo.sha256sum] = "8b0aeca1a5555cf489f7c7cb20fddb676c388978b7c1db04d80e956668b4245a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-demo-fastdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-demo-fastdebug.sha256sum] = "d1a0493823991693dcded3271656dbda83ba8f8017dbe5fed47704e8f8a131cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-demo-slowdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-demo-slowdebug.sha256sum] = "1fed05eefa2021bbbd0a21aef01bfe74e19678b9ecf3f870db6e8743726294f5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-devel-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-devel.sha256sum] = "37175f82b762464273b891daf7d37955e7d352d7810c4ea75c35fb72c7313a2b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-devel-fastdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-devel-fastdebug.sha256sum] = "867a4fc2e04fd1842565dd98804cb82db585b16373dccb3176ce2ae6b09fb4a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-devel-slowdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-devel-slowdebug.sha256sum] = "7b25b345609fd2e366117b85e80f62e05312d09a9a068ee5eb93da66fb98fe89"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-fastdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-fastdebug.sha256sum] = "9e43ab0893e1948fbcad140692b70a98b03cf38f2c67189c1ec2b3b918875311"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-headless-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-headless.sha256sum] = "c3921c4b88c623d5e4b5701eb9e1063471f69405577afc0054dc222fe93391d0"
RPROVIDES:java-21-openjdk-headless:append:x86_64_v2 = " virtual/java-headless_or_java-21-headless_or_java-25-headless"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-headless-fastdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-headless-fastdebug.sha256sum] = "f7ac15308ceed68eed2e3e5064960a539a0ee809c12cd7bdc19c3a748c2046cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-headless-slowdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-headless-slowdebug.sha256sum] = "6ea8eeea8585cd37e304701cbd78b9665e63706732f0817df56f77e7df63c3ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-javadoc-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-javadoc;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-javadoc.sha256sum] = "666eb3ac3594c838f9c60078a08c5e27d0536d5a03976d22e669240cdb40b7b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-javadoc-zip-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-javadoc-zip;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-javadoc-zip.sha256sum] = "5497f388bebbb7acfb95ca730e80d6e19cb50ad375a3d9a8b20f848a693ed0f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-jmods-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-jmods.sha256sum] = "4a00789cc1b13b5fe6885e6398dee5454d937f58242dabc87d5042d09d613fbb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-jmods-fastdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-jmods-fastdebug.sha256sum] = "8f842754d9714c50276355cf396b80b3d4b26dd34a15d08e3e1ede786c4d6d8e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-jmods-slowdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-jmods-slowdebug.sha256sum] = "6899c048607bfc7ac9b652462040b5d427fadeca925adc8ab9a7780b73791897"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-slowdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-slowdebug.sha256sum] = "7d0e65af269b3507c0106d6973077dd95b2adedb06a46df0b723b835adaf0d96"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-src-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-src.sha256sum] = "0783301d84d6409ef63e5853222bdd0078215bd3127533a82ba265eecb8e22d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-src-fastdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-src-fastdebug.sha256sum] = "2275eb712280421be62487c5eda01dbcc17697c06ae98c718484e0bc9c1b31ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-src-slowdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-src-slowdebug.sha256sum] = "6f5d1b46da2ea46eee5a8c3f59d76b4fae32b4d7a3e8385dcb281e09f285008f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-static-libs-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs.sha256sum] = "73db3b9ad8f9c960bed0b6accd9360735c006e3ef84a3f61be8404bed670b04f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-static-libs-fastdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs-fastdebug.sha256sum] = "f28ea855209e0d15cd3a98cec60c8e718f4b55282433d1093a153dd332d81459"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-static-libs-slowdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs-slowdebug.sha256sum] = "d633076d830824002779eb67f0aa683a05331b494cb2774296aa02440c760996"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk;unpack=0"
SRC_URI[aarch64_java-21-openjdk.sha256sum] = "dfad956ab7795f8e50ea01335aae95dabc59a8036c5efc209873d00654245129"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-demo-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-demo;unpack=0"
SRC_URI[aarch64_java-21-openjdk-demo.sha256sum] = "5704476e0941a96a18e4ca206a527e2f487b7e8af90a99b0a66f64d5ef7c27f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-demo-fastdebug-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-demo-fastdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-demo-fastdebug.sha256sum] = "458809e0d8fe0f3e47e73ed19ea8dc00c3b79cf3f9fdd224b260d4601b5171a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-demo-slowdebug-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-demo-slowdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-demo-slowdebug.sha256sum] = "168f0ee76afe61c5eb10cf53a7c135fd71c99b2fc69f5177d5b83bad2ceff28c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-devel-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-devel;unpack=0"
SRC_URI[aarch64_java-21-openjdk-devel.sha256sum] = "2f57cb347686e33255872f3d62ab29ae14f72781ac0c188f8ed9a6a7ab2273f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-devel-fastdebug-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-devel-fastdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-devel-fastdebug.sha256sum] = "0afe9386a5995c680f50438b814d4c606b40a722fbeab09182daacd51904482e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-devel-slowdebug-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-devel-slowdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-devel-slowdebug.sha256sum] = "0c2c5eef728683ff15ce11972bb220e2944efa89910153f20f6d641af4725843"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-fastdebug-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-fastdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-fastdebug.sha256sum] = "85945c7cd0c0e0f9979f98591e3b05434cc055e8e4cb42a34bb54c298d8dbf72"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-headless-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-headless;unpack=0"
SRC_URI[aarch64_java-21-openjdk-headless.sha256sum] = "11fd1525b0322bba3f5fc7a3346850d669886e1460f76cb1b52b4673d05b3069"
RPROVIDES:java-21-openjdk-headless:append:aarch64 = " virtual/java-headless_or_java-21-headless_or_java-25-headless"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-headless-fastdebug-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-headless-fastdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-headless-fastdebug.sha256sum] = "ca3c2c2c2b7269ae1f082066b9d616654950ed612a05cf50bfad90c2dc39f2bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-headless-slowdebug-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-headless-slowdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-headless-slowdebug.sha256sum] = "32d9a2743b619dcba3f46d7acfa3930d31dd7b77fe83401d940b9b3b89167cc9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-javadoc-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-javadoc;unpack=0"
SRC_URI[aarch64_java-21-openjdk-javadoc.sha256sum] = "37ba29c0ef4b913f373923cf13212c94878191ea06fceb99d1eb49b12038e9ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-javadoc-zip-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-javadoc-zip;unpack=0"
SRC_URI[aarch64_java-21-openjdk-javadoc-zip.sha256sum] = "efa06dacde182680bf57a06b33326d9894b3ed519ae45152a4ab2b46ea27630c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-jmods-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-jmods;unpack=0"
SRC_URI[aarch64_java-21-openjdk-jmods.sha256sum] = "d1252afe8792d960bf8717e0e2682f1ab63332f0f93c4d00652dec4809364a12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-jmods-fastdebug-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-jmods-fastdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-jmods-fastdebug.sha256sum] = "d72b8ee61179a4bb12c6b6ef3679c7b9da77cc971fc39052463a4feb3689b230"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-jmods-slowdebug-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-jmods-slowdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-jmods-slowdebug.sha256sum] = "493097a01df0e00a11a550a7050abe6fa68c4e59e8c4799e7824f5455d1750f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-slowdebug-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-slowdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-slowdebug.sha256sum] = "a7ac346f2c299dc5c9873ee9159db9f7e5d4d07580a53b24566a20450ed3e591"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-src-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-src;unpack=0"
SRC_URI[aarch64_java-21-openjdk-src.sha256sum] = "ade9d18650f61e8db40458255aba7d37c825e5383cc2fb63becd476145c9c832"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-src-fastdebug-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-src-fastdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-src-fastdebug.sha256sum] = "6f48a6b36546ce8069195ac1baa725f9c6047d499497690b3ddef7d0d9cc9236"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-src-slowdebug-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-src-slowdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-src-slowdebug.sha256sum] = "c28bd716bfb3c32022be2ad1e8f250cfaa68fb34e233c3c5209df09642e4f3e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-static-libs-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs;unpack=0"
SRC_URI[aarch64_java-21-openjdk-static-libs.sha256sum] = "63fa9239a5c1608d5f865a6ae34e89b23a474cdb9e8fb12ae91de0494e470e4a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-static-libs-fastdebug-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-static-libs-fastdebug.sha256sum] = "a38d5aad931d3880b4aa52a07243e5827002212dab24d446af2c99cbac85740e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-static-libs-slowdebug-21.0.9.0.10-1.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-static-libs-slowdebug.sha256sum] = "27473ea6972d1f175586efa54c11767dc7ec00e3118e8dc34a819590662b2aee"

RDEPENDS:java-21-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-21-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-demo = " \
 java-21-openjdk \
 "
RDEPENDS:java-21-openjdk-demo-fastdebug = " \
 java-21-openjdk-fastdebug \
 "
RDEPENDS:java-21-openjdk-demo-slowdebug = " \
 java-21-openjdk-slowdebug \
 "
RDEPENDS:java-21-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-21-openjdk \
 "
RDEPENDS:java-21-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 java-21-openjdk-fastdebug \
 "
RDEPENDS:java-21-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 java-21-openjdk-slowdebug \
 "
RDEPENDS:java-21-openjdk-fastdebug = " \
 bash \
 fontconfig \
 java-21-openjdk-headless-fastdebug \
 libXcomposite \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-headless-fastdebug = " \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-headless-slowdebug = " \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-javadoc = " \
 alternatives \
 bash \
 java-21-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-21-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 java-21-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-21-openjdk-jmods = " \
 java-21-openjdk-devel \
 "
RDEPENDS:java-21-openjdk-jmods-fastdebug = " \
 java-21-openjdk-devel-fastdebug \
 "
RDEPENDS:java-21-openjdk-jmods-slowdebug = " \
 java-21-openjdk-devel-slowdebug \
 "
RDEPENDS:java-21-openjdk-slowdebug = " \
 bash \
 fontconfig \
 java-21-openjdk-headless-slowdebug \
 libXcomposite \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-src = " \
 java-21-openjdk-headless \
 "
RDEPENDS:java-21-openjdk-src-fastdebug = " \
 java-21-openjdk-headless-fastdebug \
 "
RDEPENDS:java-21-openjdk-src-slowdebug = " \
 java-21-openjdk-headless-slowdebug \
 "
RDEPENDS:java-21-openjdk-static-libs = " \
 java-21-openjdk-devel \
 "
RDEPENDS:java-21-openjdk-static-libs-fastdebug = " \
 java-21-openjdk-devel-fastdebug \
 "
RDEPENDS:java-21-openjdk-static-libs-slowdebug = " \
 java-21-openjdk-devel-slowdebug \
 "
