# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-testing"
PV = "1.3.0"
PR = "4.el10"
PACKAGES = " \
 plexus-testing \
 plexus-testing-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/plexus-testing-1.3.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2a5c70b812dfe73dc6693897f679599ccc3a350048b66360a0d4701d98f061c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-testing-1.3.0-4.el10.noarch.rpm;name=x86_64_v2_plexus-testing;unpack=0"
SRC_URI[x86_64_v2_plexus-testing.sha256sum] = "d07dd0e545e477412beb0d3cb8e0bb9e6cf4a880544febb87c339b8358771202"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-testing-javadoc-1.3.0-4.el10.noarch.rpm;name=x86_64_v2_plexus-testing-javadoc;unpack=0"
SRC_URI[x86_64_v2_plexus-testing-javadoc.sha256sum] = "edf2614ba84f8e88269260d944c9312fa6cd95abafb8ed71e4175eca71581e16"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-testing-1.3.0-4.el10.noarch.rpm;name=aarch64_plexus-testing;unpack=0"
SRC_URI[aarch64_plexus-testing.sha256sum] = "d07dd0e545e477412beb0d3cb8e0bb9e6cf4a880544febb87c339b8358771202"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-testing-javadoc-1.3.0-4.el10.noarch.rpm;name=aarch64_plexus-testing-javadoc;unpack=0"
SRC_URI[aarch64_plexus-testing-javadoc.sha256sum] = "edf2614ba84f8e88269260d944c9312fa6cd95abafb8ed71e4175eca71581e16"

RDEPENDS:plexus-testing = " \
 google-guice \
 javapackages-filesystem \
 junit5 \
 sisu \
 "
RDEPENDS:plexus-testing-javadoc = " \
 javapackages-filesystem \
 "
