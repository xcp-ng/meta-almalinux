# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Name-FromLine"
PV = "0.13"
PR = "30.el10_0"
PACKAGES = " \
 perl-Test-Name-FromLine \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-Name-FromLine-0.13-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22b1246edeeffd9455d58cbd18cbb3ea274907e7cb69dc7d02df24f837133521"

URI_x86_64_v2_perl-Test-Name-FromLine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Name-FromLine-0.13-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Name-FromLine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Name-FromLine}"
SRC_URI[x86_64_v2_perl-Test-Name-FromLine.sha256sum] = "d147631da62e45c9a2ef6e63986ba4cc8a4b3f06b43c937fdea66028e9ee5ebe"

URI_aarch64_perl-Test-Name-FromLine = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Name-FromLine-0.13-30.el10_0.noarch.rpm;name=aarch64_perl-Test-Name-FromLine;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Name-FromLine}"
SRC_URI[aarch64_perl-Test-Name-FromLine.sha256sum] = "306ef5bfcef0ca96964149b5d09828b10ab13fe38a187b7f7afee93c5f83a7e8"

RDEPENDS:perl-Test-Name-FromLine = " \
 perl-File-Slurp \
 perl-PathTools \
 perl-Test-Simple \
 perl-libs \
 "
