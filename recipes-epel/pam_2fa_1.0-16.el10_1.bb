# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam_2fa"
PV = "1.0"
PR = "16.el10_1"
PACKAGES = " \
 pam_2fa \
 pam_ssh_user_auth \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam_2fa-1.0-16.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "827ffa9ec6b2524adb339eb138a0cb3f88d78bbf8ec4af16faca5a53b98733ca"

URI_x86_64_v2_pam_2fa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_2fa-1.0-16.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_2fa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_2fa}"
SRC_URI[x86_64_v2_pam_2fa.sha256sum] = "e40ed22e1a797c7e39872516fc4b16739f5695dea64dfb0cdde10431f1300da2"

URI_x86_64_v2_pam_ssh_user_auth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_ssh_user_auth-1.0-16.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_ssh_user_auth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_ssh_user_auth}"
SRC_URI[x86_64_v2_pam_ssh_user_auth.sha256sum] = "24c9b267392373543724eda3124d5fefcb1b98796fc58edfda1dbcea61186c1a"

URI_aarch64_pam_2fa = "${EPEL_MIRROR}/aarch64/Packages/p/pam_2fa-1.0-16.el10_1.aarch64.rpm;name=aarch64_pam_2fa;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_2fa}"
SRC_URI[aarch64_pam_2fa.sha256sum] = "be7cb6fe5d5de6f6eae840988ab2091e87b99735894191c682649cfa30398675"

URI_aarch64_pam_ssh_user_auth = "${EPEL_MIRROR}/aarch64/Packages/p/pam_ssh_user_auth-1.0-16.el10_1.aarch64.rpm;name=aarch64_pam_ssh_user_auth;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_ssh_user_auth}"
SRC_URI[aarch64_pam_ssh_user_auth.sha256sum] = "9d3746633f6bf6ababe68e5d8b3555e208e5b1eb1e3a715b554f2e7e51c882eb"

RDEPENDS:pam_2fa = " \
 glibc \
 openldap \
 pam \
 pam-libs \
 virtual/libcurl.so.4___64bit_ \
 ykclient \
 "
RDEPENDS:pam_ssh_user_auth = " \
 glibc \
 pam \
 pam-libs \
 "
