# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gh"
PV = "2.87.0"
PR = "2.el10_1"
PACKAGES = " \
 gh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gh-2.87.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64d50de5d6e808e0a980616b1065b3c596b4ab8651bf75ebfe8662b192cefe80"

URI_x86_64_v2_gh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gh-2.87.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gh}"
SRC_URI[x86_64_v2_gh.sha256sum] = "7c77cdf72a4b36e63874e3bc5585af15479aa2980e57dc802d0e16cc3c9e8e00"

URI_aarch64_gh = "${EPEL_MIRROR}/aarch64/Packages/g/gh-2.87.0-2.el10_1.aarch64.rpm;name=aarch64_gh;unpack=0"
SRC_URI:append = " ${URI_aarch64_gh}"
SRC_URI[aarch64_gh.sha256sum] = "36166acf2eb59bb58fe4adb385b3d4c73ac0836d2fa183bb83a2dfb436ecafb3"

RDEPENDS:gh = " \
 git-core \
 glibc \
 "
