# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "trousers"
PV = "0.3.15"
PR = "11.el10_0"
PACKAGES = " \
 trousers \
 trousers-devel \
 trousers-lib \
 trousers-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/trousers-0.3.15-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c74ff954f58133a06aea2a93424225a8e5718d36679913b3766ed5b33564162"

URI_x86_64_v2_trousers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trousers-0.3.15-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_trousers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trousers}"
SRC_URI[x86_64_v2_trousers.sha256sum] = "f6f1cf3fc8872b5da4060d94dd19a1fda9a1856c03632d8d12415b53a36bfba2"

URI_x86_64_v2_trousers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trousers-devel-0.3.15-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_trousers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trousers-devel}"
SRC_URI[x86_64_v2_trousers-devel.sha256sum] = "51198aa229e9c8e641e249facc3e519608dee5cfc9240defa2b33124d4b6fb36"

URI_x86_64_v2_trousers-lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trousers-lib-0.3.15-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_trousers-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trousers-lib}"
SRC_URI[x86_64_v2_trousers-lib.sha256sum] = "df211ec355ad675bf743edd09c1d877cedf397b480293dcaf1f197e62a56ccfe"

URI_x86_64_v2_trousers-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trousers-static-0.3.15-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_trousers-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trousers-static}"
SRC_URI[x86_64_v2_trousers-static.sha256sum] = "d4de9c948fbb9b56d27014543c7610e07377b1393a599fa60f07c730c4d2c86c"

URI_aarch64_trousers = "${EPEL_MIRROR}/aarch64/Packages/t/trousers-0.3.15-11.el10_0.aarch64.rpm;name=aarch64_trousers;unpack=0"
SRC_URI:append = " ${URI_aarch64_trousers}"
SRC_URI[aarch64_trousers.sha256sum] = "f6960bbbbff8da0211044a4922d3a1a5f601676dafb7fcac780b77c8b59a1025"

URI_aarch64_trousers-devel = "${EPEL_MIRROR}/aarch64/Packages/t/trousers-devel-0.3.15-11.el10_0.aarch64.rpm;name=aarch64_trousers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_trousers-devel}"
SRC_URI[aarch64_trousers-devel.sha256sum] = "160a6fddf8625dffa7b69fd03be83cee177c62c1e622ffdbc75e772d735fa4e5"

URI_aarch64_trousers-lib = "${EPEL_MIRROR}/aarch64/Packages/t/trousers-lib-0.3.15-11.el10_0.aarch64.rpm;name=aarch64_trousers-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_trousers-lib}"
SRC_URI[aarch64_trousers-lib.sha256sum] = "b99f0d813d7f0535af0059a1fbaef7efce0ff37954df454bb73311e7ae37f234"

URI_aarch64_trousers-static = "${EPEL_MIRROR}/aarch64/Packages/t/trousers-static-0.3.15-11.el10_0.aarch64.rpm;name=aarch64_trousers-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_trousers-static}"
SRC_URI[aarch64_trousers-static.sha256sum] = "e12245dfdb211f75572d0469ef70781a718bb01033e55b611fea98afd234ee91"

RDEPENDS:trousers = " \
 bash \
 glibc \
 openssl-libs \
 shadow-utils \
 systemd \
 trousers-lib \
 "
RDEPENDS:trousers-devel = " \
 trousers-lib \
 "
RDEPENDS:trousers-lib = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:trousers-static = " \
 trousers-devel \
 "
