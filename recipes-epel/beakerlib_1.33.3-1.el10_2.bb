# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "beakerlib"
PV = "1.33.3"
PR = "1.el10_2"
PACKAGES = " \
 beakerlib \
 beakerlib-vim-syntax \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/beakerlib-1.33.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb02ca03aea0476ed9947f880ceda326f4d27849d75627e0faa4df91f2feb404"

URI_x86_64_v2_beakerlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/beakerlib-1.33.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_beakerlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_beakerlib}"
SRC_URI[x86_64_v2_beakerlib.sha256sum] = "b489fc02ab054b514d24cb4deb88c5b420d07382368de5c88f90c4f8757a72ce"

URI_x86_64_v2_beakerlib-vim-syntax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/beakerlib-vim-syntax-1.33.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_beakerlib-vim-syntax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_beakerlib-vim-syntax}"
SRC_URI[x86_64_v2_beakerlib-vim-syntax.sha256sum] = "cfee405c8d938498205dc62ca0e054c0034047056104d9735d14c2d5bedf98b7"

URI_aarch64_beakerlib = "${EPEL_MIRROR}/aarch64/Packages/b/beakerlib-1.33.3-1.el10_2.noarch.rpm;name=aarch64_beakerlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_beakerlib}"
SRC_URI[aarch64_beakerlib.sha256sum] = "4459b342130464fc3bca511f7867553b6b98293778aec7e0c7b8ab930f39b314"

URI_aarch64_beakerlib-vim-syntax = "${EPEL_MIRROR}/aarch64/Packages/b/beakerlib-vim-syntax-1.33.3-1.el10_2.noarch.rpm;name=aarch64_beakerlib-vim-syntax;unpack=0"
SRC_URI:append = " ${URI_aarch64_beakerlib-vim-syntax}"
SRC_URI[aarch64_beakerlib-vim-syntax.sha256sum] = "0087122a8234ff8470f22e23b267f5d05db6da34e88e0967cf5c47f797f0d9c8"

RDEPENDS:beakerlib = " \
 bash \
 bc \
 dnf-plugins-core \
 grep \
 gzip \
 iproute \
 nfs-utils \
 python3-dnf \
 sed \
 tar \
 time \
 util-linux \
 virtual/coreutils \
 virtual/wget_or_curl \
 which \
 "
RDEPENDS:beakerlib-vim-syntax = " \
 vim-common \
 "
