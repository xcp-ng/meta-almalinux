# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kaccounts-integration"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kaccounts-integration-qt6 \
 kaccounts-integration-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kaccounts-integration-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "629b64ad38d89dc502ae7fa8a33412ac3a7d352cc829519db332ace18191b580"

URI_x86_64_v2_kaccounts-integration-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaccounts-integration-qt6-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaccounts-integration-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaccounts-integration-qt6}"
SRC_URI[x86_64_v2_kaccounts-integration-qt6.sha256sum] = "bac0960abcdc10637b5e749477f4a210824436060dd631ff9873cd1612dc710d"

URI_x86_64_v2_kaccounts-integration-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaccounts-integration-qt6-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaccounts-integration-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaccounts-integration-qt6-devel}"
SRC_URI[x86_64_v2_kaccounts-integration-qt6-devel.sha256sum] = "5f11b4211021c91d0116f0a2b628d672f39a63d3ee290fc76506233ebd16db32"

URI_aarch64_kaccounts-integration-qt6 = "${EPEL_MIRROR}/aarch64/Packages/k/kaccounts-integration-qt6-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kaccounts-integration-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaccounts-integration-qt6}"
SRC_URI[aarch64_kaccounts-integration-qt6.sha256sum] = "dd7b88683354efb36b99bfba01a7daac2a8ae2db3f9e0cbc089e24891580a9ef"

URI_aarch64_kaccounts-integration-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kaccounts-integration-qt6-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kaccounts-integration-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaccounts-integration-qt6-devel}"
SRC_URI[aarch64_kaccounts-integration-qt6-devel.sha256sum] = "89ef0b56275bd4d145aebce171483d00e7244d808e7ebb3fb7336f140b2621a0"

RDEPENDS:kaccounts-integration-qt6 = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwallet-libs \
 libaccounts-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 signon-qt6 \
 "
RDEPENDS:kaccounts-integration-qt6-devel = " \
 cmake-filesystem \
 intltool \
 kaccounts-integration-qt6 \
 kf6-kcoreaddons-devel \
 libaccounts-glib-devel \
 libaccounts-qt6-devel \
 qt6-qtbase-devel \
 signon-qt6-devel \
 "
