# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "socat"
PV = "1.7.4.4"
PR = "9.el10"
PACKAGES = " \
 socat \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/socat-1.7.4.4-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c8d711325047711391547b096b3d083f433f83be81f33410515396bc2a895993"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/socat-1.7.4.4-9.el10.x86_64_v2.rpm;name=x86_64_v2_socat;unpack=0"
SRC_URI[x86_64_v2_socat.sha256sum] = "f8c88ea017544f0f438e26ebb8e936273df6bd856adb2ae879258b36590cfccf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/socat-1.7.4.4-9.el10.aarch64.rpm;name=aarch64_socat;unpack=0"
SRC_URI[aarch64_socat.sha256sum] = "b34887984cd65311345e85da890b17a01777ad86f043ce0f7711bdad60af913f"

RDEPENDS:socat = " \
 glibc \
 openssl-libs \
 readline \
 "
