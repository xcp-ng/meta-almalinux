# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bindgen-cli"
PV = "0.72.0"
PR = "2.el10"
PACKAGES = " \
 bindgen-cli \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/rust-bindgen-cli-0.72.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "65de6e565ac23f153492728b3a25a4b10f206e6e9f56400461628cff2bb6db53"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bindgen-cli-0.72.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_bindgen-cli;unpack=0"
SRC_URI[x86_64_v2_bindgen-cli.sha256sum] = "827f58c661386e1fd3128c8a78ef7c3771704e9f86514d2a97795eb29855f5b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bindgen-cli-0.72.0-2.el10.aarch64.rpm;name=aarch64_bindgen-cli;unpack=0"
SRC_URI[aarch64_bindgen-cli.sha256sum] = "f68a0e9829f1d535e778395f5570cb249fc3b3a4994eabde6f38ae366e589964"

RDEPENDS:bindgen-cli = " \
 clang-libs \
 glibc \
 libgcc \
 "
