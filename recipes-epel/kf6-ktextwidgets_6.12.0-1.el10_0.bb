# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ktextwidgets"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-ktextwidgets \
 kf6-ktextwidgets-devel \
 kf6-ktextwidgets-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ktextwidgets-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "336c8874a5113660804dcc29b7c430c014a8a41856677355b53b985abb91334b"

URI_x86_64_v2_kf6-ktextwidgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktextwidgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktextwidgets}"
SRC_URI[x86_64_v2_kf6-ktextwidgets.sha256sum] = "aec4932113255b415e23c3553ae7302225762e69f34c90d618efa00afa391b55"

URI_x86_64_v2_kf6-ktextwidgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktextwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktextwidgets-devel}"
SRC_URI[x86_64_v2_kf6-ktextwidgets-devel.sha256sum] = "c1e4c6c8ed08da24a812b06261702db317d496a7b9097fb249dd03e25e6a75a8"

URI_x86_64_v2_kf6-ktextwidgets-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktextwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktextwidgets-doc}"
SRC_URI[x86_64_v2_kf6-ktextwidgets-doc.sha256sum] = "41f870de948db550138a6e9e686a761341ec9cc05b3ee81bf2c9c8a0a243b5d9"

URI_aarch64_kf6-ktextwidgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-ktextwidgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktextwidgets}"
SRC_URI[aarch64_kf6-ktextwidgets.sha256sum] = "8dc9717f148f0ef2b9a2a9e83389bc698a05673a374ae5af0d86e6aad56c070c"

URI_aarch64_kf6-ktextwidgets-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-ktextwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktextwidgets-devel}"
SRC_URI[aarch64_kf6-ktextwidgets-devel.sha256sum] = "54ead5f1f30fcb8c9c73b1a9c6dc441d4c5ed807eb54b3a270b67d6649867d38"

URI_aarch64_kf6-ktextwidgets-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-ktextwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktextwidgets-doc}"
SRC_URI[aarch64_kf6-ktextwidgets-doc.sha256sum] = "22fd614584b5bce78626a9b3fe34e3ff59090539ad313ff4d93ec54cf4b8373d"

RDEPENDS:kf6-ktextwidgets = " \
 glibc \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 "
RDEPENDS:kf6-ktextwidgets-devel = " \
 cmake-filesystem \
 glibc \
 kf6-ki18n-devel \
 kf6-ktextwidgets \
 kf6-sonnet-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-ktextwidgets-doc = " \
 "
