# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-darling"
PV = "0.21.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-darling+default-devel \
 rust-darling+diagnostics-devel \
 rust-darling+serde-devel \
 rust-darling+suggestions-devel \
 rust-darling-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-darling-0.21.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72fd5178d803645be4e7a1374b964e6a9b0de6657a9859efca2af52acc324530"

URI_x86_64_v2_rust-darling+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling+default-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling+default-devel}"
SRC_URI[x86_64_v2_rust-darling+default-devel.sha256sum] = "c6bd6df4b9f69a46372e8c8178befacea12289e9cef1dddd563c65bb6c82a317"

URI_x86_64_v2_rust-darling+diagnostics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling+diagnostics-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling+diagnostics-devel}"
SRC_URI[x86_64_v2_rust-darling+diagnostics-devel.sha256sum] = "5daf505922d7590a4992e0b4c7c043d4a6503a015ad83493ef38b1497f85cc0b"

URI_x86_64_v2_rust-darling+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling+serde-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling+serde-devel}"
SRC_URI[x86_64_v2_rust-darling+serde-devel.sha256sum] = "c1b5bc2a895ee207a641b49b20c4d8f8a89bc6d83a729c70964c1ebb4c98e305"

URI_x86_64_v2_rust-darling+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling+suggestions-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling+suggestions-devel}"
SRC_URI[x86_64_v2_rust-darling+suggestions-devel.sha256sum] = "fbb368a3ebc19804bf6bb1f96fe6373b615e2b34cc8084e78214618c4af4d192"

URI_x86_64_v2_rust-darling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling-devel}"
SRC_URI[x86_64_v2_rust-darling-devel.sha256sum] = "51866a77a21bead678cdf2cf7f8ef958bfbebdd9c5f74ae0c3e99164424f0d8b"

URI_aarch64_rust-darling+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling+default-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-darling+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling+default-devel}"
SRC_URI[aarch64_rust-darling+default-devel.sha256sum] = "63105f91943e9c1a741db8d912dfaa694f7e8894a07247dc347fc2e5ec257af5"

URI_aarch64_rust-darling+diagnostics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling+diagnostics-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-darling+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling+diagnostics-devel}"
SRC_URI[aarch64_rust-darling+diagnostics-devel.sha256sum] = "fe3921573db295ea0282f83b2828a4053e58c09a274557ea163f564a819da485"

URI_aarch64_rust-darling+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling+serde-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-darling+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling+serde-devel}"
SRC_URI[aarch64_rust-darling+serde-devel.sha256sum] = "abe25a5a348738f1fbaa80c2b7b7f40d60b0a1c68abd5d840fe2f2bdea7a7ef8"

URI_aarch64_rust-darling+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling+suggestions-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-darling+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling+suggestions-devel}"
SRC_URI[aarch64_rust-darling+suggestions-devel.sha256sum] = "c7d6a811465c7829891af30298f88049f62e2d1666e93396aa2419396746a551"

URI_aarch64_rust-darling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-darling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling-devel}"
SRC_URI[aarch64_rust-darling-devel.sha256sum] = "e33ac79e09dc88588540564879958b9d0da47d6ae94c931d50243e795e19ded3"

RDEPENDS:rust-darling+default-devel = " \
 cargo \
 rust-darling+suggestions-devel \
 rust-darling-devel \
 "
RDEPENDS:rust-darling+diagnostics-devel = " \
 cargo \
 rust-darling-devel \
 rust-darling_core+diagnostics-devel \
 "
RDEPENDS:rust-darling+serde-devel = " \
 cargo \
 rust-darling-devel \
 rust-darling_core+serde-devel \
 "
RDEPENDS:rust-darling+suggestions-devel = " \
 cargo \
 rust-darling-devel \
 rust-darling_core+suggestions-devel \
 "
RDEPENDS:rust-darling-devel = " \
 cargo \
 rust \
 rust-darling_core+default-devel \
 rust-darling_macro+default-devel \
 "
