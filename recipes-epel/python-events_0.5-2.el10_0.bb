# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-events"
PV = "0.5"
PR = "2.el10_0"
PACKAGES = " \
 python3-events \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-events-0.5-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4144efe9f0bb274fd54da4105e0b12438013f821ec8c7aeb9084f0f807de184"

URI_x86_64_v2_python3-events = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-events-0.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-events;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-events}"
SRC_URI[x86_64_v2_python3-events.sha256sum] = "2a57548c864bec866662068be590de606ef14ead7f7d1bfbab9521e07c47311b"

URI_aarch64_python3-events = "${EPEL_MIRROR}/aarch64/Packages/p/python3-events-0.5-2.el10_0.noarch.rpm;name=aarch64_python3-events;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-events}"
SRC_URI[aarch64_python3-events.sha256sum] = "7feaa62f8adc8a2b5150a61d9f9ec6dd521d406c5d0339e96d2e1d9e2d7e0972"

RDEPENDS:python3-events = " \
 python3 \
 "
