# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "duc"
PV = "1.4.6"
PR = "1.el10_3"
PACKAGES = " \
 duc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/duc-1.4.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c039b6cb2c73f2b397c4a55bce0de185e6e8706932ef54a6297ea9fc3c335b8d"

URI_x86_64_v2_duc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duc-1.4.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duc}"
SRC_URI[x86_64_v2_duc.sha256sum] = "aae2ef0dac346f52d55c85f6f613da300ce5b0be8af627f9a2d07f810c186da5"

URI_aarch64_duc = "${EPEL_MIRROR}/aarch64/Packages/d/duc-1.4.6-1.el10_3.aarch64.rpm;name=aarch64_duc;unpack=0"
SRC_URI:append = " ${URI_aarch64_duc}"
SRC_URI[aarch64_duc.sha256sum] = "f8a4cacaca19afa85749ddf7b8e92922b211ca4fca2ee10b65567a553f5e6b1e"

RDEPENDS:duc = " \
 cairo \
 glfw \
 glib2 \
 glibc \
 ncurses-libs \
 pango \
 tokyocabinet \
 "
