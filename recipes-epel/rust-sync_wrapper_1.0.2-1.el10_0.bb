# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sync_wrapper"
PV = "1.0.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-sync_wrapper+default-devel \
 rust-sync_wrapper+futures-core-devel \
 rust-sync_wrapper+futures-devel \
 rust-sync_wrapper-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sync_wrapper-1.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee5f869d9c55060dd32f760404f01d9dd6e148a045cd37dc2659e0893d26ea8b"

URI_x86_64_v2_rust-sync_wrapper+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sync_wrapper+default-devel-1.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sync_wrapper+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sync_wrapper+default-devel}"
SRC_URI[x86_64_v2_rust-sync_wrapper+default-devel.sha256sum] = "4f8f600b0106275ef7ef10082909f6e0d00420bfb67b37fb87951c4e0077e691"

URI_x86_64_v2_rust-sync_wrapper+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sync_wrapper+futures-core-devel-1.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sync_wrapper+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sync_wrapper+futures-core-devel}"
SRC_URI[x86_64_v2_rust-sync_wrapper+futures-core-devel.sha256sum] = "eadcd363744fecdbcfba08f791c86041b1c756ee79c35becb8fb838509aaa54b"

URI_x86_64_v2_rust-sync_wrapper+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sync_wrapper+futures-devel-1.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sync_wrapper+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sync_wrapper+futures-devel}"
SRC_URI[x86_64_v2_rust-sync_wrapper+futures-devel.sha256sum] = "68b925e32e1eb29262dc2bf683ad5982cff4ed73b2d3b75e189f0aacec869e66"

URI_x86_64_v2_rust-sync_wrapper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sync_wrapper-devel-1.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sync_wrapper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sync_wrapper-devel}"
SRC_URI[x86_64_v2_rust-sync_wrapper-devel.sha256sum] = "9f9d25a143536bb3486c2fe1c3339d627abc46155bf3cf176a9a4d0fb4dc095a"

URI_aarch64_rust-sync_wrapper+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sync_wrapper+default-devel-1.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-sync_wrapper+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sync_wrapper+default-devel}"
SRC_URI[aarch64_rust-sync_wrapper+default-devel.sha256sum] = "a666b82de150eb9748dddd2e50f837ea1e185759db0f6d55de13cdfcd877ee70"

URI_aarch64_rust-sync_wrapper+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sync_wrapper+futures-core-devel-1.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-sync_wrapper+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sync_wrapper+futures-core-devel}"
SRC_URI[aarch64_rust-sync_wrapper+futures-core-devel.sha256sum] = "39a1d86af329a6dcdc7782a75d86e6c011b01a7e0353538f95f2909b01da2f8f"

URI_aarch64_rust-sync_wrapper+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sync_wrapper+futures-devel-1.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-sync_wrapper+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sync_wrapper+futures-devel}"
SRC_URI[aarch64_rust-sync_wrapper+futures-devel.sha256sum] = "6afc8ff40c7eb690b8c2c4cddfb157cd4fc7e5dce35b6bb24b87ba750f781d44"

URI_aarch64_rust-sync_wrapper-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sync_wrapper-devel-1.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-sync_wrapper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sync_wrapper-devel}"
SRC_URI[aarch64_rust-sync_wrapper-devel.sha256sum] = "bdc66b95f7856e60afc4b981a40eba25b2942a5f2d5d130181853f5a2e5bae77"

RDEPENDS:rust-sync_wrapper+default-devel = " \
 cargo \
 rust-sync_wrapper-devel \
 "
RDEPENDS:rust-sync_wrapper+futures-core-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-sync_wrapper-devel \
 "
RDEPENDS:rust-sync_wrapper+futures-devel = " \
 cargo \
 rust-sync_wrapper+futures-core-devel \
 rust-sync_wrapper-devel \
 "
RDEPENDS:rust-sync_wrapper-devel = " \
 cargo \
 "
