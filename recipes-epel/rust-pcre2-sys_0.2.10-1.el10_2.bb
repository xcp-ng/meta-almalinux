# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pcre2-sys"
PV = "0.2.10"
PR = "1.el10_2"
PACKAGES = " \
 rust-pcre2-sys+default-devel \
 rust-pcre2-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pcre2-sys-0.2.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c317f71c4ada6f83d598eaf159ef690f8bfd565d224d7cd289091a47c46a0ec"

URI_x86_64_v2_rust-pcre2-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcre2-sys+default-devel-0.2.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcre2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcre2-sys+default-devel}"
SRC_URI[x86_64_v2_rust-pcre2-sys+default-devel.sha256sum] = "5d8336543cba604e8896bbf3f885e222428cf1d13931260bae40a66433987b25"

URI_x86_64_v2_rust-pcre2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcre2-sys-devel-0.2.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcre2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcre2-sys-devel}"
SRC_URI[x86_64_v2_rust-pcre2-sys-devel.sha256sum] = "87bdc491c2753d64d252f38790de459e52f0f9fb69b312f8fecf8090dc8d905e"

URI_aarch64_rust-pcre2-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcre2-sys+default-devel-0.2.10-1.el10_2.noarch.rpm;name=aarch64_rust-pcre2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcre2-sys+default-devel}"
SRC_URI[aarch64_rust-pcre2-sys+default-devel.sha256sum] = "035cc795194e4a9554c65805ebc4e6b15f70223eeb9a24a317fd1752f55b17ef"

URI_aarch64_rust-pcre2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcre2-sys-devel-0.2.10-1.el10_2.noarch.rpm;name=aarch64_rust-pcre2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcre2-sys-devel}"
SRC_URI[aarch64_rust-pcre2-sys-devel.sha256sum] = "01efede4872d47fe67334b29fbe295305b9383d08b3c88d9565e84af3481e97d"

RDEPENDS:rust-pcre2-sys+default-devel = " \
 cargo \
 rust-pcre2-sys-devel \
 "
RDEPENDS:rust-pcre2-sys-devel = " \
 cargo \
 pcre2-devel \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
