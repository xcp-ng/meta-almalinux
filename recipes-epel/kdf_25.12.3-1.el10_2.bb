# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdf"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdf-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4048fe1cb41543c7f79b9077f818a149821ee3ee4e6f031a9dd3a193ad05ee36"

URI_x86_64_v2_kdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdf-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdf}"
SRC_URI[x86_64_v2_kdf.sha256sum] = "bbd7750edcb3ee4f075221d45b87ac2e93c8ea5bc8e4995fed683cdb200c3520"

URI_aarch64_kdf = "${EPEL_MIRROR}/aarch64/Packages/k/kdf-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdf}"
SRC_URI[aarch64_kdf.sha256sum] = "86561b5b15d0f4097b28d74c17a784873c2c5025e1392813a0bd362f04bad4dc"

RDEPENDS:kdf = " \
 glibc \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
