# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "eot-utils"
PV = "1.1"
PR = "44.el10_0"
PACKAGES = " \
 eot-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/eot-utils-1.1-44.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07a0ad75e4cf3c20ff7ec7cce5a6c9fd7dc334b985211b8f7312a6c023576cb5"

URI_x86_64_v2_eot-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eot-utils-1.1-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eot-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eot-utils}"
SRC_URI[x86_64_v2_eot-utils.sha256sum] = "19a67db480d5b57144226e33118921f2f146764093e073bc0b97153d1e83939b"

URI_aarch64_eot-utils = "${EPEL_MIRROR}/aarch64/Packages/e/eot-utils-1.1-44.el10_0.aarch64.rpm;name=aarch64_eot-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_eot-utils}"
SRC_URI[aarch64_eot-utils.sha256sum] = "20c7e45728438162acb2452079ffcb95a31dae9392019d4884db60df2962e5bd"

RDEPENDS:eot-utils = " \
 glibc \
 "
