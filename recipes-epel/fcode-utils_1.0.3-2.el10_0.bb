# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fcode-utils"
PV = "1.0.3"
PR = "2.el10_0"
PACKAGES = " \
 fcode-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fcode-utils-1.0.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d330ba9d1cbc7d690d712314b6c17dd13673756fdc241ce5dbcb86d66fe5c240"

URI_x86_64_v2_fcode-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fcode-utils-1.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fcode-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fcode-utils}"
SRC_URI[x86_64_v2_fcode-utils.sha256sum] = "0931ca217a5cd4bd90afff4babe08298c849cb26edb97abc4556e8835172531e"

URI_aarch64_fcode-utils = "${EPEL_MIRROR}/aarch64/Packages/f/fcode-utils-1.0.3-2.el10_0.aarch64.rpm;name=aarch64_fcode-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_fcode-utils}"
SRC_URI[aarch64_fcode-utils.sha256sum] = "de6caa50fb48a00bf5120a005fdf56319d19e2d495433b7342b7c15b0d266ff8"

RDEPENDS:fcode-utils = " \
 glibc \
 "
