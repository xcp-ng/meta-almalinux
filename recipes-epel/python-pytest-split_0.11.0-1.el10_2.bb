# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-split"
PV = "0.11.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-pytest-split \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-split-0.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3439446c41a33ca095d95fd45736fba411fca54e675f7e270ca3906731776e94"

URI_x86_64_v2_python3-pytest-split = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-split-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-split;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-split}"
SRC_URI[x86_64_v2_python3-pytest-split.sha256sum] = "455c729908dd0cb77df4346342cf6cf66395fe38f13ce816a4c1e20e3e43d4f0"

URI_aarch64_python3-pytest-split = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-split-0.11.0-1.el10_2.noarch.rpm;name=aarch64_python3-pytest-split;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-split}"
SRC_URI[aarch64_python3-pytest-split.sha256sum] = "37058c1dd36857124085b40fb211f64b04ef20ab34e138c93bc9fc4f36cd8f12"

RDEPENDS:python3-pytest-split = " \
 python3 \
 python3-pytest \
 "
