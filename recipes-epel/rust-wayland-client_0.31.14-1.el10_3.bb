# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-client"
PV = "0.31.14"
PR = "1.el10_3"
PACKAGES = " \
 rust-wayland-client+default-devel \
 rust-wayland-client+dlopen-devel \
 rust-wayland-client+libwayland_1_23-devel \
 rust-wayland-client+log-devel \
 rust-wayland-client+system-devel \
 rust-wayland-client-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-client-0.31.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a589d8cfe0fa1532f11294ab170951abca993705da8276619e683c42a6d82682"

URI_x86_64_v2_rust-wayland-client+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+default-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-client+default-devel.sha256sum] = "51aaa57c4d098720e4ad87d43afc15b359f9d5e09d6cfc28cee76768aae613b7"

URI_x86_64_v2_rust-wayland-client+dlopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+dlopen-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client+dlopen-devel}"
SRC_URI[x86_64_v2_rust-wayland-client+dlopen-devel.sha256sum] = "6b1b1cfc4073532e1a43f6b2bc4e95d42b47c1b312eee60c3ba8b25a294e80d7"

URI_x86_64_v2_rust-wayland-client+libwayland_1_23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+libwayland_1_23-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+libwayland_1_23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client+libwayland_1_23-devel}"
SRC_URI[x86_64_v2_rust-wayland-client+libwayland_1_23-devel.sha256sum] = "f7a901caaa4b3a00785a5c304f5432d8b6e90041429d2ef955a83413c253520c"

URI_x86_64_v2_rust-wayland-client+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+log-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client+log-devel}"
SRC_URI[x86_64_v2_rust-wayland-client+log-devel.sha256sum] = "43991e62e0f999359ed9ab88f571354745e743265cf5f62b23cb527642826fbe"

URI_x86_64_v2_rust-wayland-client+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+system-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client+system-devel}"
SRC_URI[x86_64_v2_rust-wayland-client+system-devel.sha256sum] = "ddc12f9b42a099ab77baaaf559a6cd0b7bfb4dd2782e06d89f068053f899ff60"

URI_x86_64_v2_rust-wayland-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client-devel}"
SRC_URI[x86_64_v2_rust-wayland-client-devel.sha256sum] = "6021b16d01120e6ca1b6c7e40fa44286f9ee8d5ae13197839bdf0e3b21638d1d"

URI_aarch64_rust-wayland-client+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+default-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-client+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client+default-devel}"
SRC_URI[aarch64_rust-wayland-client+default-devel.sha256sum] = "4016f015fcf24bb021ff90716af61e8571b21d2ded8f88af73950871cb445ff5"

URI_aarch64_rust-wayland-client+dlopen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+dlopen-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-client+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client+dlopen-devel}"
SRC_URI[aarch64_rust-wayland-client+dlopen-devel.sha256sum] = "31e11aeea35658834364ee2c57ac99f3e9fb3d4d7afb6fed7f6a0440ccf4e6e3"

URI_aarch64_rust-wayland-client+libwayland_1_23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+libwayland_1_23-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-client+libwayland_1_23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client+libwayland_1_23-devel}"
SRC_URI[aarch64_rust-wayland-client+libwayland_1_23-devel.sha256sum] = "bca6105f1986f099853450b4513136797c042e7ddd59a57f351987220485f5e4"

URI_aarch64_rust-wayland-client+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+log-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-client+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client+log-devel}"
SRC_URI[aarch64_rust-wayland-client+log-devel.sha256sum] = "d84cbf854d396df24ca30af0136b6e7e9232903798ffccdd375b7062781b1002"

URI_aarch64_rust-wayland-client+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+system-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-client+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client+system-devel}"
SRC_URI[aarch64_rust-wayland-client+system-devel.sha256sum] = "73ce6c0fa1ae8274ac13f9692dbec111a9ea782dd7a87213e5ae38d863305669"

URI_aarch64_rust-wayland-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client-devel}"
SRC_URI[aarch64_rust-wayland-client-devel.sha256sum] = "47df823c8e5504b0bd68814bf4fbf14d8140f3639474c1372497a9ddbcbb14a9"

RDEPENDS:rust-wayland-client+default-devel = " \
 cargo \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client+dlopen-devel = " \
 cargo \
 rust-wayland-backend+dlopen-devel \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client+libwayland_1_23-devel = " \
 cargo \
 rust-wayland-backend+libwayland_client_1_23-devel \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client+system-devel = " \
 cargo \
 rust-wayland-backend+client_system-devel \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
