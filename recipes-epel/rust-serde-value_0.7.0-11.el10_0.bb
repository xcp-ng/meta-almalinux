# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde-value"
PV = "0.7.0"
PR = "11.el10_0"
PACKAGES = " \
 rust-serde-value+default-devel \
 rust-serde-value-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde-value-0.7.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d461ec4fb350f4440d57e23facbd63675f2e931ac79d66a7b616f9acda162d6e"

URI_x86_64_v2_rust-serde-value+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-value+default-devel-0.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-value+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde-value+default-devel}"
SRC_URI[x86_64_v2_rust-serde-value+default-devel.sha256sum] = "a41c4bd48678ee9349bf177f6f60d7303bf0a8b1114555efb2782fde7e55ff9a"

URI_x86_64_v2_rust-serde-value-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-value-devel-0.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-value-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde-value-devel}"
SRC_URI[x86_64_v2_rust-serde-value-devel.sha256sum] = "e9cb5555df37e838b053d758f7bce56e8d1a52f93abbf5303ff0d21c36460e5b"

URI_aarch64_rust-serde-value+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-value+default-devel-0.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-serde-value+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde-value+default-devel}"
SRC_URI[aarch64_rust-serde-value+default-devel.sha256sum] = "b0e61c01ce67dd66030c72b10f5ff2176f8347b8c571a8156b1efea10022a79d"

URI_aarch64_rust-serde-value-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-value-devel-0.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-serde-value-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde-value-devel}"
SRC_URI[aarch64_rust-serde-value-devel.sha256sum] = "3eff3bb0834ffc288fc5d55cc28fa20f0fd54cf68d22c774120eb8d0784c1283"

RDEPENDS:rust-serde-value+default-devel = " \
 cargo \
 rust-serde-value-devel \
 "
RDEPENDS:rust-serde-value-devel = " \
 cargo \
 rust-ordered-float2+default-devel \
 rust-serde+default-devel \
 "
