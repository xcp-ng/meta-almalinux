# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pure-rust-locales"
PV = "0.8.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-pure-rust-locales+default-devel \
 rust-pure-rust-locales-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pure-rust-locales-0.8.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb275af2826f83edd6a3bd8853aa4b5de5ad74d3bc43b2fc04f675f30baefff2"

URI_x86_64_v2_rust-pure-rust-locales+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pure-rust-locales+default-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pure-rust-locales+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pure-rust-locales+default-devel}"
SRC_URI[x86_64_v2_rust-pure-rust-locales+default-devel.sha256sum] = "b1703ecee09eaa64ca540ec1d932b72c41405eae5d0093ada8a178e276a4f288"

URI_x86_64_v2_rust-pure-rust-locales-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pure-rust-locales-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pure-rust-locales-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pure-rust-locales-devel}"
SRC_URI[x86_64_v2_rust-pure-rust-locales-devel.sha256sum] = "2b0ae863d6bd894dce72c3b8fc30d6d126913cc3247ac2bfd96cec10f3fd4adf"

URI_aarch64_rust-pure-rust-locales+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pure-rust-locales+default-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-pure-rust-locales+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pure-rust-locales+default-devel}"
SRC_URI[aarch64_rust-pure-rust-locales+default-devel.sha256sum] = "0aff01b9494d577a6028cc3a88ae85da7423d8b7c8ee13c65435b7e00aa63b69"

URI_aarch64_rust-pure-rust-locales-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pure-rust-locales-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-pure-rust-locales-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pure-rust-locales-devel}"
SRC_URI[aarch64_rust-pure-rust-locales-devel.sha256sum] = "4c318e306695d49f9d0703dd441c193129ad70357bf6b5858c784eccb6d2db30"

RDEPENDS:rust-pure-rust-locales+default-devel = " \
 cargo \
 rust-pure-rust-locales-devel \
 "
RDEPENDS:rust-pure-rust-locales-devel = " \
 cargo \
 rust \
 "
