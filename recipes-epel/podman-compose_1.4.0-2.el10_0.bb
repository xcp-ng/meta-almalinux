# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "podman-compose"
PV = "1.4.0"
PR = "2.el10_0"
PACKAGES = " \
 podman-compose \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/podman-compose-1.4.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "002f947f6359400a260a8026c0073c3909ddb59237f448bdd547d1907964cad9"

URI_x86_64_v2_podman-compose = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/podman-compose-1.4.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_podman-compose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-compose}"
SRC_URI[x86_64_v2_podman-compose.sha256sum] = "a253ff2e406660797d9020966ff6c8e2bf8fc6ffa9f2c97817e3f4f8beeec48f"

URI_aarch64_podman-compose = "${EPEL_MIRROR}/aarch64/Packages/p/podman-compose-1.4.0-2.el10_0.noarch.rpm;name=aarch64_podman-compose;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-compose}"
SRC_URI[aarch64_podman-compose.sha256sum] = "24b41e1bc15e6072bb5e646a3cfb3c529ed7d7a2404cc06113933da71ca9c956"

RDEPENDS:podman-compose = " \
 podman \
 python3 \
 python3-dotenv \
 python3-pyyaml \
 "
