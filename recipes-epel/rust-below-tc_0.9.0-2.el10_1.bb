# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-tc"
PV = "0.9.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-below-tc+default-devel \
 rust-below-tc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-tc-0.9.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf8d233162be06666a50683f9d05951b4801f81b0da1c8cf953fcace282ee90a"

URI_x86_64_v2_rust-below-tc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-tc+default-devel-0.9.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-tc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-tc+default-devel}"
SRC_URI[x86_64_v2_rust-below-tc+default-devel.sha256sum] = "43c1d6f220c12ff26936d0d85dff3b855d4eeb99e03d0f7c15b9f2f88aef1cdc"

URI_x86_64_v2_rust-below-tc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-tc-devel-0.9.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-tc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-tc-devel}"
SRC_URI[x86_64_v2_rust-below-tc-devel.sha256sum] = "c665f4670f75a763978ff06f7b99273b748ce4af285b98b2f8d209491eca3fd6"

URI_aarch64_rust-below-tc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-tc+default-devel-0.9.0-2.el10_1.noarch.rpm;name=aarch64_rust-below-tc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-tc+default-devel}"
SRC_URI[aarch64_rust-below-tc+default-devel.sha256sum] = "3421a104e8c3c515aedc2ed09b20b9d8528c957b8600f6996b85eada457eaabf"

URI_aarch64_rust-below-tc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-tc-devel-0.9.0-2.el10_1.noarch.rpm;name=aarch64_rust-below-tc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-tc-devel}"
SRC_URI[aarch64_rust-below-tc-devel.sha256sum] = "b171ef9a65e40827ea2fc55ae84cc7b809234344986557609b4c569b3a9351e4"

RDEPENDS:rust-below-tc+default-devel = " \
 cargo \
 rust-below-tc-devel \
 "
RDEPENDS:rust-below-tc-devel = " \
 cargo \
 rust-netlink-packet-core+default-devel \
 rust-netlink-packet-route+default-devel \
 rust-netlink-sys+default-devel \
 rust-nix0.29+default-devel \
 rust-nix0.29+dir-devel \
 rust-nix0.29+event-devel \
 rust-nix0.29+hostname-devel \
 rust-nix0.29+inotify-devel \
 rust-nix0.29+ioctl-devel \
 rust-nix0.29+mman-devel \
 rust-nix0.29+mount-devel \
 rust-nix0.29+net-devel \
 rust-nix0.29+poll-devel \
 rust-nix0.29+ptrace-devel \
 rust-nix0.29+reboot-devel \
 rust-nix0.29+resource-devel \
 rust-nix0.29+sched-devel \
 rust-nix0.29+signal-devel \
 rust-nix0.29+term-devel \
 rust-nix0.29+time-devel \
 rust-nix0.29+user-devel \
 rust-nix0.29+zerocopy-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-thiserror+default-devel \
 "
