# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalk"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kalk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kalk-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a33ba3c3b9314d890e877966b0c74bc9bad967dea5e6815496bae0fc7e704d4f"

URI_x86_64_v2_kalk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalk-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalk}"
SRC_URI[x86_64_v2_kalk.sha256sum] = "6740a0224dee876da5b35ab095920e122c865717f9b2f025cf99885e9a39aaa0"

URI_aarch64_kalk = "${EPEL_MIRROR}/aarch64/Packages/k/kalk-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kalk;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalk}"
SRC_URI[aarch64_kalk.sha256sum] = "f91b9fd4ff763a5135a674bc5a8286f346b616a61658eb5debf8bf5d976efc4d"

RDEPENDS:kalk = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kunitconversion \
 kf6-qqc2-desktop-style \
 kf6-sonnet \
 libqalculate \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
