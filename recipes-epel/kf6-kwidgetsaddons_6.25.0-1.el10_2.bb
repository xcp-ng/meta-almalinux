# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwidgetsaddons"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kwidgetsaddons \
 kf6-kwidgetsaddons-devel \
 kf6-kwidgetsaddons-doc \
 kf6-kwidgetsaddons-html \
 python3-kf6-kwidgetsaddons \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kwidgetsaddons-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "600ead8be5934299b854ce6d5735d26b11b3c4d2cb9fd207a1aa2f685b8affb2"

URI_x86_64_v2_kf6-kwidgetsaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwidgetsaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons.sha256sum] = "a3bf8e0d3cd8f8e44d900c66115cba20b194077d918db6d41a1810d83272e87f"

URI_x86_64_v2_kf6-kwidgetsaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwidgetsaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons-devel}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons-devel.sha256sum] = "f2c1c63e459489d4cd4c2f30d312d270b0e7e23cadb3be9ecaf67aab9a687a8f"

URI_x86_64_v2_kf6-kwidgetsaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwidgetsaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons-doc}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons-doc.sha256sum] = "2165fa2986c05d09fccee86c99fa9c8c3d88371c1779d5053c9e1066e4dc38e2"

URI_x86_64_v2_kf6-kwidgetsaddons-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwidgetsaddons-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons-html}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons-html.sha256sum] = "ce69a4aac63d7baf1e499ada9956304f2d0cd2ec76f5e8a3bec78b92d76abaa9"

URI_x86_64_v2_python3-kf6-kwidgetsaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kwidgetsaddons-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kwidgetsaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kwidgetsaddons}"
SRC_URI[x86_64_v2_python3-kf6-kwidgetsaddons.sha256sum] = "51fbf0c902bf6f79db1ced0e84f3a01331188aeb34aafb36772036ac7f697168"

URI_aarch64_kf6-kwidgetsaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kwidgetsaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons}"
SRC_URI[aarch64_kf6-kwidgetsaddons.sha256sum] = "715ca0439b7023443ab9c9d96a22825d2fac08c816bbbd7f7e19c4c35d9302a2"

URI_aarch64_kf6-kwidgetsaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kwidgetsaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons-devel}"
SRC_URI[aarch64_kf6-kwidgetsaddons-devel.sha256sum] = "7aa646fb50bac89e62e92d7cba40fcdf496d9301a4cef461fcb6b8970f441e23"

URI_aarch64_kf6-kwidgetsaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kwidgetsaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons-doc}"
SRC_URI[aarch64_kf6-kwidgetsaddons-doc.sha256sum] = "82060b5133c1f63268d9baab50d52dbd38f19796a8c1bc47b97bf51adb2959bd"

URI_aarch64_kf6-kwidgetsaddons-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kwidgetsaddons-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons-html}"
SRC_URI[aarch64_kf6-kwidgetsaddons-html.sha256sum] = "97b01c9785e742228a408c70a6998f85c27d1ea83375af375886e0317b0944e3"

URI_aarch64_python3-kf6-kwidgetsaddons = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kwidgetsaddons-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_python3-kf6-kwidgetsaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kwidgetsaddons}"
SRC_URI[aarch64_python3-kf6-kwidgetsaddons.sha256sum] = "2a2b4a670635ad69642dff31baaa93768e9c46bcf65ad835fb0267899aa32951"

RDEPENDS:kf6-kwidgetsaddons = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwidgetsaddons-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwidgetsaddons-doc = " \
 "
RDEPENDS:kf6-kwidgetsaddons-html = " \
 "
RDEPENDS:python3-kf6-kwidgetsaddons = " \
 glibc \
 kf6-kwidgetsaddons \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
