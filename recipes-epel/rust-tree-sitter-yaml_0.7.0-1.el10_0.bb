# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-yaml"
PV = "0.7.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-yaml+default-devel \
 rust-tree-sitter-yaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-yaml-0.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a850e130f25f09ba2b9a69068eb165d8ace5e3c69bd5afcd285ee676ab04d2f"

URI_x86_64_v2_rust-tree-sitter-yaml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-yaml+default-devel-0.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-yaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-yaml+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-yaml+default-devel.sha256sum] = "bd860e44d0301d5d30c2b0057ccefdb27d1c6c2ac40b23ce16182288b355b263"

URI_x86_64_v2_rust-tree-sitter-yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-yaml-devel-0.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-yaml-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-yaml-devel.sha256sum] = "4f04ddaf81178877dbe06fcf07ae1a0ff23a9d0c9dd00edffa5901427c9df7d0"

URI_aarch64_rust-tree-sitter-yaml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-yaml+default-devel-0.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-yaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-yaml+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-yaml+default-devel.sha256sum] = "25251e32b01458eebff1b8d98ebf14fe3f718b88303a7ff9ddb8cb86176a7cb2"

URI_aarch64_rust-tree-sitter-yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-yaml-devel-0.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-yaml-devel}"
SRC_URI[aarch64_rust-tree-sitter-yaml-devel.sha256sum] = "fc15958469ea3c82a75a075486fd7f8ceaf167634dfb498f634a1669903d2ab3"

RDEPENDS:rust-tree-sitter-yaml+default-devel = " \
 cargo \
 rust-tree-sitter-yaml-devel \
 "
RDEPENDS:rust-tree-sitter-yaml-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
