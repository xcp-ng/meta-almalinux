# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpublictransport"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kpublictransport \
 kpublictransport-devel \
 kpublictransport-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpublictransport-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5d57eb487459e98d9cd783888b23c8f34a15c20a39272416069048f7a8e1434"

URI_x86_64_v2_kpublictransport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpublictransport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpublictransport}"
SRC_URI[x86_64_v2_kpublictransport.sha256sum] = "23ac6f1ce7ed33df06ea286efc29ccb4e21efd1336ff12ebbddb93d217f83c8c"

URI_x86_64_v2_kpublictransport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpublictransport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpublictransport-devel}"
SRC_URI[x86_64_v2_kpublictransport-devel.sha256sum] = "6e5764b8a850215a75b80149730762a8d6f7ec13b082c7fc4858f2651709378b"

URI_x86_64_v2_kpublictransport-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kpublictransport-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpublictransport-doc}"
SRC_URI[x86_64_v2_kpublictransport-doc.sha256sum] = "21184fb4d7bddfcfdc398dd066f4779a2ef2881b3d1be11726dc3ed8ee6cc625"

URI_aarch64_kpublictransport = "${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kpublictransport;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpublictransport}"
SRC_URI[aarch64_kpublictransport.sha256sum] = "453bb786ad8802b18ac2228c2c4582f7e0a7ca487481890c5169e2291cb66ed4"

URI_aarch64_kpublictransport-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kpublictransport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpublictransport-devel}"
SRC_URI[aarch64_kpublictransport-devel.sha256sum] = "f73f12177d792400a16ad49e022f13debbe475ecb2ad09196a6202535d4e3577"

URI_aarch64_kpublictransport-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kpublictransport-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpublictransport-doc}"
SRC_URI[aarch64_kpublictransport-doc.sha256sum] = "da2508e551879edcc3c2438da266fdf150c3ae3359ea38f3ac05ca65d15fc1cc"

RDEPENDS:kpublictransport = " \
 glibc \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-networkmanager-qt \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:kpublictransport-devel = " \
 cmake-filesystem \
 kpublictransport \
 "
RDEPENDS:kpublictransport-doc = " \
 "
