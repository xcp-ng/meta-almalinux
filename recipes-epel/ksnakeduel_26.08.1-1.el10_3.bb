# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksnakeduel"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ksnakeduel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ksnakeduel-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2a9aceb96a099af3c6df7eb3f2761510b123dd71ccdb57ba353909e67a5249f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksnakeduel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksnakeduel;unpack=0"
SRC_URI[x86_64_v2_ksnakeduel.sha256sum] = "08c5443481deb9aae9785992fb571dbb3105b779e90e9765fb7d0fc5099cf268"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ksnakeduel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ksnakeduel;unpack=0"
SRC_URI[aarch64_ksnakeduel.sha256sum] = "c683fff9475f88ed939ff367cd57554f897488aa7f78c14e9d765b24db598c11"

RDEPENDS:ksnakeduel = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
