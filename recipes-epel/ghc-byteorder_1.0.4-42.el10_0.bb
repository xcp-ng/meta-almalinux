# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-byteorder"
PV = "1.0.4"
PR = "42.el10_0"
PACKAGES = " \
 ghc-byteorder \
 ghc-byteorder-devel \
 ghc-byteorder-doc \
 ghc-byteorder-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-byteorder-1.0.4-42.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6077b66b8156a11da62bf10aa5dc3718927ffa1affc9f71b7e782587523294b4"

URI_x86_64_v2_ghc-byteorder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-byteorder-1.0.4-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-byteorder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-byteorder}"
SRC_URI[x86_64_v2_ghc-byteorder.sha256sum] = "8d12300e96aeba39c190c2855f4e1286ee62d26d48cca89289824246307e73ac"

URI_x86_64_v2_ghc-byteorder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-byteorder-devel-1.0.4-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-byteorder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-byteorder-devel}"
SRC_URI[x86_64_v2_ghc-byteorder-devel.sha256sum] = "1d5a56174b7883bf41bfd10133ad05d221e1740bc2dd84d8cc3526e06999b3d7"

URI_x86_64_v2_ghc-byteorder-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-byteorder-doc-1.0.4-42.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-byteorder-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-byteorder-doc}"
SRC_URI[x86_64_v2_ghc-byteorder-doc.sha256sum] = "26e2f836ef4e51f1da3977ddc7e6d59ad1ab33b141662281191be23d739688e9"

URI_x86_64_v2_ghc-byteorder-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-byteorder-prof-1.0.4-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-byteorder-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-byteorder-prof}"
SRC_URI[x86_64_v2_ghc-byteorder-prof.sha256sum] = "b1aee616989c4ec9b7fcb55fc26627465b025149f7b8060270116e494a11a730"

URI_aarch64_ghc-byteorder = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-byteorder-1.0.4-42.el10_0.aarch64.rpm;name=aarch64_ghc-byteorder;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-byteorder}"
SRC_URI[aarch64_ghc-byteorder.sha256sum] = "58751646b596bcb71dacc54a2482635eaef6a32b779b09ff3a847fe36b9c17af"

URI_aarch64_ghc-byteorder-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-byteorder-devel-1.0.4-42.el10_0.aarch64.rpm;name=aarch64_ghc-byteorder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-byteorder-devel}"
SRC_URI[aarch64_ghc-byteorder-devel.sha256sum] = "c18c489953fe344eb7d1cf08b5b7237e0726615dc22992b3bbbac8acfb0a20a6"

URI_aarch64_ghc-byteorder-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-byteorder-doc-1.0.4-42.el10_0.noarch.rpm;name=aarch64_ghc-byteorder-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-byteorder-doc}"
SRC_URI[aarch64_ghc-byteorder-doc.sha256sum] = "05493f592c7a872bfcc23ce3636be2424457cd4281a1ad124c10b51a069067c2"

URI_aarch64_ghc-byteorder-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-byteorder-prof-1.0.4-42.el10_0.aarch64.rpm;name=aarch64_ghc-byteorder-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-byteorder-prof}"
SRC_URI[aarch64_ghc-byteorder-prof.sha256sum] = "fdcdc3dd22338c6d4887bfa43a3c2da7bdf16a0698e05918f5e920f72d159f6e"

RDEPENDS:ghc-byteorder = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-byteorder-devel = " \
 ghc-base-devel \
 ghc-byteorder \
 ghc-compiler \
 "
RDEPENDS:ghc-byteorder-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-byteorder-prof = " \
 ghc-base-prof \
 ghc-byteorder-devel \
 "
