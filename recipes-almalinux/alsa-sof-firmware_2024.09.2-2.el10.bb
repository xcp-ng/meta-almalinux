# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alsa-sof-firmware"
PV = "2024.09.2"
PR = "2.el10"
PACKAGES = " \
 alsa-sof-firmware \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/alsa-sof-firmware-2024.09.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58c0e411355e8b5c4c86e454ee025d454b8b6404832bef54528c492a8ef52007"

URI_x86_64_v2_alsa-sof-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-sof-firmware-2024.09.2-2.el10.noarch.rpm;name=x86_64_v2_alsa-sof-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alsa-sof-firmware}"
SRC_URI[x86_64_v2_alsa-sof-firmware.sha256sum] = "09a3ef60531490789653a054854413db524e57f7118145b3ee375197204b8bb5"

URI_aarch64_alsa-sof-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-sof-firmware-2024.09.2-2.el10.noarch.rpm;name=aarch64_alsa-sof-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_alsa-sof-firmware}"
SRC_URI[aarch64_alsa-sof-firmware.sha256sum] = "09a3ef60531490789653a054854413db524e57f7118145b3ee375197204b8bb5"

RDEPENDS:alsa-sof-firmware = " \
 "
