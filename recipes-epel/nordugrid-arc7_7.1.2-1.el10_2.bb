# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nordugrid-arc7"
PV = "7.1.2"
PR = "1.el10_2"
PACKAGES = " \
 nordugrid-arc7 \
 nordugrid-arc7-arc-exporter \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-archery-manage \
 nordugrid-arc7-arex \
 nordugrid-arc7-arex-lrms-contrib \
 nordugrid-arc7-client \
 nordugrid-arc7-community-rtes \
 nordugrid-arc7-datadelivery-service \
 nordugrid-arc7-devel \
 nordugrid-arc7-hed \
 nordugrid-arc7-infosys-ldap \
 nordugrid-arc7-monitor \
 nordugrid-arc7-plugins-gfal \
 nordugrid-arc7-plugins-globus \
 nordugrid-arc7-plugins-globus-common \
 nordugrid-arc7-plugins-gridftp \
 nordugrid-arc7-plugins-internal \
 nordugrid-arc7-plugins-lcas-lcmaps \
 nordugrid-arc7-plugins-needed \
 nordugrid-arc7-plugins-python \
 nordugrid-arc7-plugins-s3 \
 nordugrid-arc7-plugins-xrootd \
 nordugrid-arc7-test-utils \
 nordugrid-arc7-wn \
 python3-arcrest \
 python3-nordugrid-arc7 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nordugrid-arc7-7.1.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4ea50ec8149b447db8232d8e809229c4ddf0dc05ea1bd0e0a154bb90da9d79c"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - nordugrid-arc7-plugins-xrootd: libXrdCl.so.6()(64bit)
# - nordugrid-arc7-plugins-xrootd: libXrdPosix.so.6()(64bit)

URI_x86_64_v2_nordugrid-arc7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7}"
SRC_URI[x86_64_v2_nordugrid-arc7.sha256sum] = "8826621d5a1d1d181ffbeb87fae7b6b467df6b74da47834193d98790acba14b8"

URI_x86_64_v2_nordugrid-arc7-arc-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arc-exporter-7.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-arc-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arc-exporter}"
SRC_URI[x86_64_v2_nordugrid-arc7-arc-exporter.sha256sum] = "39d525094fd79252001b6cfa90a8bb17dc9cb7a88eeb06e21bdeaf7994f66b16"

URI_x86_64_v2_nordugrid-arc7-arcctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arcctl-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arcctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arcctl}"
SRC_URI[x86_64_v2_nordugrid-arc7-arcctl.sha256sum] = "c89d493e6d97e9d83b93aa41f78ea530deff35fc2136ff9340893bd5991e66ce"

URI_x86_64_v2_nordugrid-arc7-arcctl-service = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arcctl-service-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arcctl-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arcctl-service}"
SRC_URI[x86_64_v2_nordugrid-arc7-arcctl-service.sha256sum] = "966d57e09893d5941bb671c87664c0ede76ab6234dd9713c36ed2f989a05b898"

URI_x86_64_v2_nordugrid-arc7-archery-manage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-archery-manage-7.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-archery-manage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-archery-manage}"
SRC_URI[x86_64_v2_nordugrid-arc7-archery-manage.sha256sum] = "c71ebfb403fa8884b714eb31e6dd599a8d9e817b41df5e54f3d12893e1b6652c"

URI_x86_64_v2_nordugrid-arc7-arex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arex-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arex}"
SRC_URI[x86_64_v2_nordugrid-arc7-arex.sha256sum] = "73ce2226e0b087fa76183e3dfc7f8350e8eb26e88970676280b4f9d1b37c8e5c"

URI_x86_64_v2_nordugrid-arc7-arex-lrms-contrib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arex-lrms-contrib-7.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-arex-lrms-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arex-lrms-contrib}"
SRC_URI[x86_64_v2_nordugrid-arc7-arex-lrms-contrib.sha256sum] = "f47848a088d5948a4617690ef745cdf14c54bb936f32b77bb2e2165fb3da3906"

URI_x86_64_v2_nordugrid-arc7-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-client-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-client}"
SRC_URI[x86_64_v2_nordugrid-arc7-client.sha256sum] = "896825ecfe3369618da03ceda1868577a01fb8b73618cc58d953984436430603"

URI_x86_64_v2_nordugrid-arc7-community-rtes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-community-rtes-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-community-rtes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-community-rtes}"
SRC_URI[x86_64_v2_nordugrid-arc7-community-rtes.sha256sum] = "d32ef11d306fef1f1dc2258afe0751ff3874b5a3ec0687886923c9d3a15d40d1"

URI_x86_64_v2_nordugrid-arc7-datadelivery-service = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-datadelivery-service-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-datadelivery-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-datadelivery-service}"
SRC_URI[x86_64_v2_nordugrid-arc7-datadelivery-service.sha256sum] = "6f794b9d626fcaaead9612d10ca2811aa1a961d8308502d8b241211c40f1c01d"

URI_x86_64_v2_nordugrid-arc7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-devel-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-devel}"
SRC_URI[x86_64_v2_nordugrid-arc7-devel.sha256sum] = "2f092d3fe78fa63acbda10223f39432194f8f388dda74c989d9c3869ff7963c2"

URI_x86_64_v2_nordugrid-arc7-hed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-hed-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-hed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-hed}"
SRC_URI[x86_64_v2_nordugrid-arc7-hed.sha256sum] = "6e9c60d188b66ef20001268215e21b0006e104f4fe9cf365eb18296943dbf25c"

URI_x86_64_v2_nordugrid-arc7-infosys-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-infosys-ldap-7.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-infosys-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-infosys-ldap}"
SRC_URI[x86_64_v2_nordugrid-arc7-infosys-ldap.sha256sum] = "cf8ef6f2b9a33764d165ee7dab41e616662516ed9c14be3b0116900a5d2ee0e8"

URI_x86_64_v2_nordugrid-arc7-monitor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-monitor-7.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-monitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-monitor}"
SRC_URI[x86_64_v2_nordugrid-arc7-monitor.sha256sum] = "8de3d425d7e7abc340ab3833787e77225632b87b86f41222373654265180d3a2"

URI_x86_64_v2_nordugrid-arc7-plugins-gfal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-gfal-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-gfal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-gfal}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-gfal.sha256sum] = "3a8bac85affa6acedf0bc1cdc2ca794eef8b8057c813f3c555bf08234e2b0625"

URI_x86_64_v2_nordugrid-arc7-plugins-globus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-globus-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-globus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-globus}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-globus.sha256sum] = "f42d2d5b2c76b9f1028c38cc7bed8a07d5679b464521a5646c86e157dc81272d"

URI_x86_64_v2_nordugrid-arc7-plugins-globus-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-globus-common-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-globus-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-globus-common}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-globus-common.sha256sum] = "bd7b6e7bd1601dec9ffee2cfdcc83f13109cbafba894f3180ef229507197fa30"

URI_x86_64_v2_nordugrid-arc7-plugins-gridftp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-gridftp-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-gridftp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-gridftp}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-gridftp.sha256sum] = "1feb3f72e3bdef6ad02829a5ca1d77a25ee6436eac93a25b77feb18dfce230bd"

URI_x86_64_v2_nordugrid-arc7-plugins-internal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-internal-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-internal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-internal}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-internal.sha256sum] = "0cf7773f8d2c0c3528080aef1df65e54144bdddd0d2ffa474aa86fcd292bc42d"

URI_x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-lcas-lcmaps-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps.sha256sum] = "7998f17d5ab7fd4e8ea97f7301aa0d88a84d2cc46b2dc28a7e9dbfeb94a37120"

URI_x86_64_v2_nordugrid-arc7-plugins-needed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-needed-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-needed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-needed}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-needed.sha256sum] = "2683a97e4a3a12967301476b968524a633960a6e9f021cb28ae2708e83fff76d"

URI_x86_64_v2_nordugrid-arc7-plugins-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-python-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-python}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-python.sha256sum] = "92755609e57310ef58a7b6f1d47bf93cd8a20c50fe7b63f7796183e06b6963c3"

URI_x86_64_v2_nordugrid-arc7-plugins-s3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-s3-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-s3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-s3}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-s3.sha256sum] = "4fb63f4e71602d3f47d562b08f68ae585d1eef1ddb634f0317bec2ab4702ec8c"

URI_x86_64_v2_nordugrid-arc7-plugins-xrootd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-xrootd-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-xrootd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-xrootd}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-xrootd.sha256sum] = "364175be6e40ef615e1933cb9923f3033f7ec85e24fa314a1b408557a616505d"

URI_x86_64_v2_nordugrid-arc7-test-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-test-utils-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-test-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-test-utils}"
SRC_URI[x86_64_v2_nordugrid-arc7-test-utils.sha256sum] = "1dc5029de7fcf40551cb6105f8f89374b35e6cfaba29c9902ee557d7fa419969"

URI_x86_64_v2_nordugrid-arc7-wn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-wn-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-wn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-wn}"
SRC_URI[x86_64_v2_nordugrid-arc7-wn.sha256sum] = "d097e593a6dc40246bf935b7cbd74b66715d28c00231e3466aef7c0143ece448"

URI_x86_64_v2_python3-arcrest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-arcrest-7.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-arcrest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-arcrest}"
SRC_URI[x86_64_v2_python3-arcrest.sha256sum] = "8cbea51301363159e6cfc2a4a8978495badcb5f671f97d725d269cef48db8c55"

URI_x86_64_v2_python3-nordugrid-arc7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nordugrid-arc7-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nordugrid-arc7}"
SRC_URI[x86_64_v2_python3-nordugrid-arc7.sha256sum] = "18723e745007b800fcb270e0324d814a99a296ab044a662ddd335df49054dd29"

URI_aarch64_nordugrid-arc7 = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7}"
SRC_URI[aarch64_nordugrid-arc7.sha256sum] = "d02db182319d29988373830207c4172c1d49b88ad7f35cf9bb26f3e7a96eb2a2"

URI_aarch64_nordugrid-arc7-arc-exporter = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arc-exporter-7.1.2-1.el10_2.noarch.rpm;name=aarch64_nordugrid-arc7-arc-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arc-exporter}"
SRC_URI[aarch64_nordugrid-arc7-arc-exporter.sha256sum] = "420a2ee787398195fffbb91a31b3c8262095c9b7ae0279e7996e38dcc435f6a5"

URI_aarch64_nordugrid-arc7-arcctl = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arcctl-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-arcctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arcctl}"
SRC_URI[aarch64_nordugrid-arc7-arcctl.sha256sum] = "40c6134abed3d1acb11f932047f9e23d4806f9caedac6cd3e20e92557bd2b0c5"

URI_aarch64_nordugrid-arc7-arcctl-service = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arcctl-service-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-arcctl-service;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arcctl-service}"
SRC_URI[aarch64_nordugrid-arc7-arcctl-service.sha256sum] = "274c7d9f98802f0f81e174ecd27323629dc8193d0cac6daaaa0bf3ac1aa7f7c8"

URI_aarch64_nordugrid-arc7-archery-manage = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-archery-manage-7.1.2-1.el10_2.noarch.rpm;name=aarch64_nordugrid-arc7-archery-manage;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-archery-manage}"
SRC_URI[aarch64_nordugrid-arc7-archery-manage.sha256sum] = "b354141a22f4c97d1c4a3067d600bad5dc5a74b5535b537a9898fc8ab9f17d44"

URI_aarch64_nordugrid-arc7-arex = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arex-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-arex;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arex}"
SRC_URI[aarch64_nordugrid-arc7-arex.sha256sum] = "2def026e18202a3b8901bcb6e43dade511b2bf67e82f90156d00d87dde081634"

URI_aarch64_nordugrid-arc7-arex-lrms-contrib = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arex-lrms-contrib-7.1.2-1.el10_2.noarch.rpm;name=aarch64_nordugrid-arc7-arex-lrms-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arex-lrms-contrib}"
SRC_URI[aarch64_nordugrid-arc7-arex-lrms-contrib.sha256sum] = "78737fe7712fe630712b90036a0b248d87ce68359b8097601f667cc5a721ee8e"

URI_aarch64_nordugrid-arc7-client = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-client-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-client}"
SRC_URI[aarch64_nordugrid-arc7-client.sha256sum] = "323b06c22db8d890e22ce530300b21aca15ab186c8d94d6abb9fac650731d4dd"

URI_aarch64_nordugrid-arc7-community-rtes = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-community-rtes-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-community-rtes;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-community-rtes}"
SRC_URI[aarch64_nordugrid-arc7-community-rtes.sha256sum] = "2c20091bf2010ad3b7f27c9d80ac060725ef39c7446fc39ba7f540bf41128ccb"

URI_aarch64_nordugrid-arc7-datadelivery-service = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-datadelivery-service-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-datadelivery-service;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-datadelivery-service}"
SRC_URI[aarch64_nordugrid-arc7-datadelivery-service.sha256sum] = "a487cf39825ac7779383dbd4326db2f47582d39ff273f6f1623ad441995b5cc3"

URI_aarch64_nordugrid-arc7-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-devel-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-devel}"
SRC_URI[aarch64_nordugrid-arc7-devel.sha256sum] = "8bd4362f6377fe5b5e555ffa439a25b3f6ffa635d3492aea20508f7c66c48bfc"

URI_aarch64_nordugrid-arc7-hed = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-hed-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-hed;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-hed}"
SRC_URI[aarch64_nordugrid-arc7-hed.sha256sum] = "eb3af848159ae3b567b4a19943e8189512bba50365b6130ed53db50e869a459b"

URI_aarch64_nordugrid-arc7-infosys-ldap = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-infosys-ldap-7.1.2-1.el10_2.noarch.rpm;name=aarch64_nordugrid-arc7-infosys-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-infosys-ldap}"
SRC_URI[aarch64_nordugrid-arc7-infosys-ldap.sha256sum] = "ece4818ae5a473a21e909cfbf4d7b141b2477bedb876b4494465ac78a77e3719"

URI_aarch64_nordugrid-arc7-monitor = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-monitor-7.1.2-1.el10_2.noarch.rpm;name=aarch64_nordugrid-arc7-monitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-monitor}"
SRC_URI[aarch64_nordugrid-arc7-monitor.sha256sum] = "4fb2f93b9f84eda539d0abb471f8e77a66ff8707f33bd23d2235a1a120914c21"

URI_aarch64_nordugrid-arc7-plugins-gfal = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-gfal-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-gfal;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-gfal}"
SRC_URI[aarch64_nordugrid-arc7-plugins-gfal.sha256sum] = "b2387d76b38ffa4f645d964ffa8b228dcb8cb55d1d14b17b568a886faf1ab5bd"

URI_aarch64_nordugrid-arc7-plugins-globus = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-globus-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-globus;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-globus}"
SRC_URI[aarch64_nordugrid-arc7-plugins-globus.sha256sum] = "404acc0d86cea46eb1f631e0367fac510ea3c203f8912f25ba2e326847b0fadc"

URI_aarch64_nordugrid-arc7-plugins-globus-common = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-globus-common-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-globus-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-globus-common}"
SRC_URI[aarch64_nordugrid-arc7-plugins-globus-common.sha256sum] = "70e6f5ab51b75144998baee09eba5253c456c35dccbf6756bde10d034527019d"

URI_aarch64_nordugrid-arc7-plugins-gridftp = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-gridftp-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-gridftp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-gridftp}"
SRC_URI[aarch64_nordugrid-arc7-plugins-gridftp.sha256sum] = "b3bbaee71741eb2b2d34cffac1103f888177485424c49626d08c7c1e09edeb9f"

URI_aarch64_nordugrid-arc7-plugins-internal = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-internal-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-internal;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-internal}"
SRC_URI[aarch64_nordugrid-arc7-plugins-internal.sha256sum] = "1167de5db8d9be6ca62e8a215aaacdbca0a96949728c6ab8d284920fef7573dc"

URI_aarch64_nordugrid-arc7-plugins-lcas-lcmaps = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-lcas-lcmaps-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-lcas-lcmaps;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-lcas-lcmaps}"
SRC_URI[aarch64_nordugrid-arc7-plugins-lcas-lcmaps.sha256sum] = "53016ef93f7077c1ddb5441b68757792d18c43ca009812aada3f719235efa900"

URI_aarch64_nordugrid-arc7-plugins-needed = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-needed-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-needed;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-needed}"
SRC_URI[aarch64_nordugrid-arc7-plugins-needed.sha256sum] = "2e1f274deaca10560973db33601bf2c56ed7a02cd169a85a02c6a9597edb3846"

URI_aarch64_nordugrid-arc7-plugins-python = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-python-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-python}"
SRC_URI[aarch64_nordugrid-arc7-plugins-python.sha256sum] = "92bd3b1872e2769445162ad4d86e810864541de06ab3ffd6b74569852d7b10fe"

URI_aarch64_nordugrid-arc7-plugins-s3 = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-s3-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-s3;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-s3}"
SRC_URI[aarch64_nordugrid-arc7-plugins-s3.sha256sum] = "91c502153e18c49c755993c222536d17c686d813ea2f15deac5121015e7b0100"

URI_aarch64_nordugrid-arc7-plugins-xrootd = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-xrootd-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-xrootd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-xrootd}"
SRC_URI[aarch64_nordugrid-arc7-plugins-xrootd.sha256sum] = "7994c1c20eb2d4c257ba5803de5d28b5f94baa33dfe38068d42881a77e34ed03"

URI_aarch64_nordugrid-arc7-test-utils = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-test-utils-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-test-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-test-utils}"
SRC_URI[aarch64_nordugrid-arc7-test-utils.sha256sum] = "7b45e5e2e3f9715a2832a1ed8d6363b22e2292d23243c7faa507b1874d621da0"

URI_aarch64_nordugrid-arc7-wn = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-wn-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-wn;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-wn}"
SRC_URI[aarch64_nordugrid-arc7-wn.sha256sum] = "8d25bf1fd0b69a60e94b12ca1c498c0241bcaf44466c4d4c0f9b124660f4590e"

URI_aarch64_python3-arcrest = "${EPEL_MIRROR}/aarch64/Packages/p/python3-arcrest-7.1.2-1.el10_2.noarch.rpm;name=aarch64_python3-arcrest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-arcrest}"
SRC_URI[aarch64_python3-arcrest.sha256sum] = "7ecb8282c0c2e6a1f4a50f88258a084a0722ac71815b2b1612779536e88f86dd"

URI_aarch64_python3-nordugrid-arc7 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nordugrid-arc7-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_python3-nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nordugrid-arc7}"
SRC_URI[aarch64_python3-nordugrid-arc7.sha256sum] = "1c27ecbeb190366c431df10f82d6e89ece17ae18d3f2e5552b1923f7a44ecb7d"

RDEPENDS:nordugrid-arc7 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 hostname \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nspr \
 nss \
 nss-util \
 openssl \
 openssl-libs \
 python3 \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-arc-exporter = " \
 python3 \
 python3-prometheus_client \
 "
RDEPENDS:nordugrid-arc7-arcctl = " \
 nordugrid-arc7 \
 python3 \
 python3-jwcrypto \
 "
RDEPENDS:nordugrid-arc7-arcctl-service = " \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl \
 python3 \
 "
RDEPENDS:nordugrid-arc7-archery-manage = " \
 python3 \
 python3-dns \
 python3-ldap \
 "
RDEPENDS:nordugrid-arc7-arex = " \
 bash \
 findutils \
 glib2 \
 glibc \
 glibmm2.68 \
 hostname \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 logrotate \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-hed \
 nordugrid-arc7-plugins-needed \
 nspr \
 nss \
 nss-util \
 openssl \
 openssl-libs \
 perl-Data-Dumper \
 perl-Digest-SHA1 \
 perl-DirHandle \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-JSON-XS \
 perl-MIME-Base64 \
 perl-POSIX \
 perl-PathTools \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Time-Local \
 perl-XML-Simple \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-vars \
 procps-ng \
 python3 \
 sqlite-libs \
 systemd \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-arex-lrms-contrib = " \
 bash \
 nordugrid-arc7-arex \
 perl-DBI \
 perl-Data-Dumper \
 perl-Exporter \
 perl-POSIX \
 perl-Sys-Hostname \
 perl-XML-Simple \
 perl-libs \
 "
RDEPENDS:nordugrid-arc7-client = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-needed \
 openssl-libs \
 "
RDEPENDS:nordugrid-arc7-community-rtes = " \
 gnupg2 \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arex \
 python3 \
 python3-dns \
 "
RDEPENDS:nordugrid-arc7-datadelivery-service = " \
 bash \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 logrotate \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-hed \
 nordugrid-arc7-plugins-needed \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 systemd \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-devel = " \
 glib2 \
 glibc \
 glibmm2.68 \
 glibmm2.68-devel \
 libgcc \
 libstdc++ \
 libxml2-devel \
 nordugrid-arc7 \
 openssl-devel \
 "
RDEPENDS:nordugrid-arc7-hed = " \
 bash \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 systemd \
 systemd-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-infosys-ldap = " \
 bash \
 bdii \
 glue-schema \
 logrotate \
 nordugrid-arc7-arcctl-service \
 openldap-servers \
 policycoreutils-python-utils \
 systemd \
 "
RDEPENDS:nordugrid-arc7-monitor = " \
 nordugrid-arc7 \
 virtual/php \
 virtual/php-gd \
 virtual/php-ldap \
 "
RDEPENDS:nordugrid-arc7-plugins-gfal = " \
 gfal2 \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-globus = " \
 nordugrid-arc7-plugins-gridftp \
 nordugrid-arc7-plugins-lcas-lcmaps \
 "
RDEPENDS:nordugrid-arc7-plugins-globus-common = " \
 glib2 \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-gsi-callback \
 globus-gssapi-gsi \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-gridftp = " \
 glib2 \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-ftp-client \
 globus-ftp-control \
 globus-io \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-globus-common \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-internal = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nordugrid-arc7-arex \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-lcas-lcmaps = " \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gssapi-gsi \
 libgcc \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-globus-common \
 openssl-libs \
 "
RDEPENDS:nordugrid-arc7-plugins-needed = " \
 glib2 \
 glibc \
 glibmm2.68 \
 ldns \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-python = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 python3-libs \
 python3-nordugrid-arc7 \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-s3 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libs3 \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-xrootd:x86_64_v2 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
"
RDEPENDS:nordugrid-arc7-plugins-xrootd:aarch64 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 xrootd-client-libs \
 zlib-ng-compat \
"
RDEPENDS:nordugrid-arc7-test-utils = " \
 glibc \
 libgcc \
 libsigc++30 \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-needed \
 "
RDEPENDS:nordugrid-arc7-wn = " \
 glibc \
 "
RDEPENDS:python3-arcrest = " \
 python3 \
 python3-cryptography \
 "
RDEPENDS:python3-nordugrid-arc7 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 python3 \
 python3-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
