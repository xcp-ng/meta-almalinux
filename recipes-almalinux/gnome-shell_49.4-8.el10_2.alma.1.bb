# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell"
PV = "49.4"
PR = "8.el10_2.alma.1"
PACKAGES = " \
 gnome-shell \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-shell-49.4-8.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c24b4e731fab3097b744ce0e95536acdcc60c170ff5556c101d06608274fce88"

URI_x86_64_v2_gnome-shell = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-49.4-8.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_gnome-shell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell}"
SRC_URI[x86_64_v2_gnome-shell.sha256sum] = "3d12af3df54ae0fe150a12c71f1e19f90d8fe019ccdd1bdc7eb1f334d1f3e560"
RPROVIDES:gnome-shell:x86_64_v2 = "virtual/PolicyKit-authentication-agent"

URI_aarch64_gnome-shell = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-49.4-8.el10_2.alma.1.aarch64.rpm;name=aarch64_gnome-shell;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell}"
SRC_URI[aarch64_gnome-shell.sha256sum] = "9ebd14ed2706754dd97fb177ee543bdf200c1c0e8e2363ea645ea2b9ed1505df"
RPROVIDES:gnome-shell:aarch64 = "virtual/PolicyKit-authentication-agent"

RDEPENDS:gnome-shell = " \
 NetworkManager-libnm \
 accountsservice-libs \
 at-spi2-atk \
 atk \
 cairo \
 evolution-data-server \
 gcr \
 gcr-libs \
 gdk-pixbuf2 \
 gdm \
 geoclue2-libs \
 gettext \
 gjs \
 glib2 \
 glibc \
 gnome-autoar \
 gnome-control-center \
 gnome-desktop4 \
 gnome-settings-daemon \
 gobject-introspection \
 graphene \
 gsettings-desktop-schemas \
 gstreamer1 \
 gstreamer1-plugins-good \
 gtk4 \
 ibus-libs \
 json-glib \
 libX11 \
 libXext \
 libXfixes \
 libadwaita \
 libgcc \
 libglvnd-gles \
 libgweather \
 libical-glib \
 libnma-gtk4 \
 librsvg2 \
 libsecret \
 libsoup3 \
 mutter \
 pango \
 pipewire-gstreamer \
 pipewire-libs \
 polkit \
 polkit-libs \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 python3 \
 python3-argcomplete \
 switcheroo-control \
 systemd-libs \
 tecla \
 upower \
 xdg-desktop-portal-gnome \
 xdg-desktop-portal-gtk \
 xdg-user-dirs-gtk \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/PolicyKit-authentication-agent"

PROVIDES:append:aarch64 = " rpm/virtual/PolicyKit-authentication-agent"
