# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tpm2-tss"
PV = "4.1.3"
PR = "5.el10"
PACKAGES = " \
 tpm2-tss \
 tpm2-tss-devel \
 tpm2-tss-fapi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tpm2-tss-4.1.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5cabf0439a57af675af7517217e9c3371f885549d9b9b7c5a4793496f0262500"

URI_x86_64_v2_tpm2-tss = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tpm2-tss-4.1.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_tpm2-tss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tpm2-tss}"
SRC_URI[x86_64_v2_tpm2-tss.sha256sum] = "e766b03a9ad582b23fa1167b82fb3ed85302475580830cf50955319246190532"

URI_x86_64_v2_tpm2-tss-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/tpm2-tss-devel-4.1.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_tpm2-tss-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tpm2-tss-devel}"
SRC_URI[x86_64_v2_tpm2-tss-devel.sha256sum] = "c656e4f166ce41aae552fc5a865cd36f615bf2b9ee80529f260bfc61e1a2bc5a"

URI_x86_64_v2_tpm2-tss-fapi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tpm2-tss-fapi-4.1.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_tpm2-tss-fapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tpm2-tss-fapi}"
SRC_URI[x86_64_v2_tpm2-tss-fapi.sha256sum] = "658978f43bf5b473a4901f4627628b24cb7f908d2a4e9ad641d9191521b375ca"

URI_aarch64_tpm2-tss = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tpm2-tss-4.1.3-5.el10.aarch64.rpm;name=aarch64_tpm2-tss;unpack=0"
SRC_URI:append = " ${URI_aarch64_tpm2-tss}"
SRC_URI[aarch64_tpm2-tss.sha256sum] = "c3829da671458f171c02e2b4d5a392d0be4b693096357233b3530ebac0a886ac"

URI_aarch64_tpm2-tss-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/tpm2-tss-devel-4.1.3-5.el10.aarch64.rpm;name=aarch64_tpm2-tss-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tpm2-tss-devel}"
SRC_URI[aarch64_tpm2-tss-devel.sha256sum] = "df5ab7319f156f1df58ba0ac0b1f9372ebe4825690dcf642d80a8a7596bbc2b4"

URI_aarch64_tpm2-tss-fapi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tpm2-tss-fapi-4.1.3-5.el10.aarch64.rpm;name=aarch64_tpm2-tss-fapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_tpm2-tss-fapi}"
SRC_URI[aarch64_tpm2-tss-fapi.sha256sum] = "713ca2bf80b0ac63d80bb204b87b491af66512634d0f1c2c91daa4fdd39d5b4d"

RDEPENDS:tpm2-tss = " \
 bash \
 glibc \
 json-c \
 libuuid \
 openssl-libs \
 shadow-utils \
 "
RDEPENDS:tpm2-tss-devel = " \
 json-c-devel \
 libcurl-devel \
 libuuid-devel \
 openssl-devel \
 pkgconf-pkg-config \
 tpm2-tss \
 tpm2-tss-devel \
 tpm2-tss-fapi \
 "
RDEPENDS:tpm2-tss-fapi = " \
 glibc \
 json-c \
 libuuid \
 openssl-libs \
 tpm2-tss \
 virtual/libcurl.so.4___64bit_ \
 "
