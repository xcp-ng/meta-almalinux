# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xsimd"
PV = "13.0.0"
PR = "2.el10_0"
PACKAGES = " \
 xsimd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xsimd-13.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1e85d54f2792c58ce626fb16ff12bd53d8411f6be40d3c738e031768e7ffea4"

URI_x86_64_v2_xsimd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xsimd-devel-13.0.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xsimd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xsimd-devel}"
SRC_URI[x86_64_v2_xsimd-devel.sha256sum] = "5116e3783f8f5984c0fc00e84bff190b9a6975363ddae54a50cba607aaca3a83"

URI_aarch64_xsimd-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xsimd-devel-13.0.0-2.el10_0.aarch64.rpm;name=aarch64_xsimd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xsimd-devel}"
SRC_URI[aarch64_xsimd-devel.sha256sum] = "43ce368b6efb027f156abee59a61a0a20425baaa707ca0143987441186ced142"

RDEPENDS:xsimd-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
