# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-desktop-portal-gtk"
PV = "1.15.1"
PR = "8.el10"
PACKAGES = " \
 xdg-desktop-portal-gtk \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xdg-desktop-portal-gtk-1.15.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a0559b76170fec18803fcfc088f388e03aea8446552abfc73098b7c69729af7"

URI_x86_64_v2_xdg-desktop-portal-gtk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xdg-desktop-portal-gtk-1.15.1-8.el10.x86_64_v2.rpm;name=x86_64_v2_xdg-desktop-portal-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-desktop-portal-gtk}"
SRC_URI[x86_64_v2_xdg-desktop-portal-gtk.sha256sum] = "1c999a031af25a6ef83abfa080a41092dd9b59687abb6851b3eef6b46ed1c818"

URI_aarch64_xdg-desktop-portal-gtk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xdg-desktop-portal-gtk-1.15.1-8.el10.aarch64.rpm;name=aarch64_xdg-desktop-portal-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-desktop-portal-gtk}"
SRC_URI[aarch64_xdg-desktop-portal-gtk.sha256sum] = "e73eb4a53d6436c23d0015a84e95d1c240b509c7ac98b3d7673050a7e6e5c6ae"

RDEPENDS:xdg-desktop-portal-gtk = " \
 bash \
 dbus \
 fontconfig \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gsettings-desktop-schemas \
 gtk3 \
 libgcc \
 xdg-desktop-portal \
 "
