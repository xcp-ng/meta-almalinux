# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-image-builder"
PV = "113"
PR = "1.el10"
PACKAGES = " \
 cockpit-image-builder \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-image-builder-113-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "03c3d0178d223153f831b1f69779fe366b695788c527664ff45a944ae597270b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-image-builder-113-1.el10.noarch.rpm;name=x86_64_v2_cockpit-image-builder;unpack=0"
SRC_URI[x86_64_v2_cockpit-image-builder.sha256sum] = "870c1b24bf6a5b74d42ad1722bb9401c25963a266553f1b5d42a9e66c763e085"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-image-builder-113-1.el10.noarch.rpm;name=aarch64_cockpit-image-builder;unpack=0"
SRC_URI[aarch64_cockpit-image-builder.sha256sum] = "870c1b24bf6a5b74d42ad1722bb9401c25963a266553f1b5d42a9e66c763e085"

RDEPENDS:cockpit-image-builder = " \
 cockpit \
 cockpit-files \
 image-builder \
 "
