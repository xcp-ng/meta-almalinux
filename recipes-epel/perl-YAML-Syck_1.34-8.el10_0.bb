# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-YAML-Syck"
PV = "1.34"
PR = "8.el10_0"
PACKAGES = " \
 perl-YAML-Syck \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-YAML-Syck-1.34-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "336fe6f32f648b957ff0bfbacd44dd625b4c165f8b1b624b15d7168a324349f7"

URI_x86_64_v2_perl-YAML-Syck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-YAML-Syck-1.34-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-YAML-Syck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-YAML-Syck}"
SRC_URI[x86_64_v2_perl-YAML-Syck.sha256sum] = "97c2466f03d6e5bedebd355f00e76d769240b26264dc4c56c2c5f12d0a3984f0"

URI_aarch64_perl-YAML-Syck = "${EPEL_MIRROR}/aarch64/Packages/p/perl-YAML-Syck-1.34-8.el10_0.aarch64.rpm;name=aarch64_perl-YAML-Syck;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-YAML-Syck}"
SRC_URI[aarch64_perl-YAML-Syck.sha256sum] = "d3785e27275d3e7a81f322850de55a1858e5b22a379e8663f63fdab6eaffd23f"

RDEPENDS:perl-YAML-Syck = " \
 glibc \
 perl-Exporter \
 perl-YAML-Syck \
 perl-constant \
 perl-libs \
 "
