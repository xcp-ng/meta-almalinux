# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gram_grep"
PV = "0.10.2"
PR = "4.el10_3"
PACKAGES = " \
 gram_grep \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gram_grep-0.10.2-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1811af10dcb1cd432cb84f0b02604617ec6e1d6783c8f50cc8f62beff284652"

URI_x86_64_v2_gram_grep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gram_grep-0.10.2-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gram_grep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gram_grep}"
SRC_URI[x86_64_v2_gram_grep.sha256sum] = "e494903d9b7204965bea0196306abe2eeb2b0837a1d40922ba22a31cd073bd92"

URI_aarch64_gram_grep = "${EPEL_MIRROR}/aarch64/Packages/g/gram_grep-0.10.2-4.el10_3.aarch64.rpm;name=aarch64_gram_grep;unpack=0"
SRC_URI:append = " ${URI_aarch64_gram_grep}"
SRC_URI[aarch64_gram_grep.sha256sum] = "0da148d92dcf4808e42e98f4444e140f9b63c9da1df3e429aad7acf2a4ddf04a"

RDEPENDS:gram_grep = " \
 glibc \
 libgcc \
 libstdc++ \
 "
