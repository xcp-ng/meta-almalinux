# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest_generator"
PV = "2.8.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-pest_generator+default-devel \
 rust-pest_generator+export-internal-devel \
 rust-pest_generator+grammar-extras-devel \
 rust-pest_generator+std-devel \
 rust-pest_generator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest_generator-2.8.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5be2d75f83ceeede04e22c3006cd497b7400a34f785cbf6fa11a852d4829329c"

URI_x86_64_v2_rust-pest_generator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+default-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+default-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+default-devel.sha256sum] = "6388f8fb53dbd3b8ea4e74f24ad3a832d09ac6767d15754cbc19b74e4b040801"

URI_x86_64_v2_rust-pest_generator+export-internal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+export-internal-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+export-internal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+export-internal-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+export-internal-devel.sha256sum] = "e4f7948950808125c6e3eab0e9cfa9ebb09c8679ff76ef6189c950584df27208"

URI_x86_64_v2_rust-pest_generator+grammar-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+grammar-extras-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+grammar-extras-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+grammar-extras-devel.sha256sum] = "04b3755646bde30ab39c124a2a05f6a813821e4c90deb01c98a5c5f583fbfbba"

URI_x86_64_v2_rust-pest_generator+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+std-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+std-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+std-devel.sha256sum] = "b6707370279a713477460662402e87f5059d168e166a7140b8998e1a733d88ae"

URI_x86_64_v2_rust-pest_generator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator-devel}"
SRC_URI[x86_64_v2_rust-pest_generator-devel.sha256sum] = "9f91b05dc858f2a3b538dd774df4fd4335f285f95cb8052c19c2ba86b90118cc"

URI_aarch64_rust-pest_generator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+default-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+default-devel}"
SRC_URI[aarch64_rust-pest_generator+default-devel.sha256sum] = "bf4270bc289e28d424e20ea3838fab97f2e986dc7d6fcf6ab2b29e7d56804a75"

URI_aarch64_rust-pest_generator+export-internal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+export-internal-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest_generator+export-internal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+export-internal-devel}"
SRC_URI[aarch64_rust-pest_generator+export-internal-devel.sha256sum] = "bf900aa6c63464fb393800b081ad587f6c1244f7ae14b04740f29dfcb7358379"

URI_aarch64_rust-pest_generator+grammar-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+grammar-extras-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest_generator+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+grammar-extras-devel}"
SRC_URI[aarch64_rust-pest_generator+grammar-extras-devel.sha256sum] = "b4ca2203a27fc67272dcd8433508fa9e23a11e463dd0ce79a2208577af56beb9"

URI_aarch64_rust-pest_generator+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+std-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest_generator+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+std-devel}"
SRC_URI[aarch64_rust-pest_generator+std-devel.sha256sum] = "5a1d7c55f5eefdb228ba4aee0a60df69b8fd329e90615c5fa5a14c4e6087eebe"

URI_aarch64_rust-pest_generator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest_generator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator-devel}"
SRC_URI[aarch64_rust-pest_generator-devel.sha256sum] = "e8f8b1929fd98d1bd24d48e6a1bb0adfbbc84e8e04587f260b34ebb480686bc6"

RDEPENDS:rust-pest_generator+default-devel = " \
 cargo \
 rust-pest_generator+std-devel \
 rust-pest_generator-devel \
 "
RDEPENDS:rust-pest_generator+export-internal-devel = " \
 cargo \
 rust-pest_generator-devel \
 "
RDEPENDS:rust-pest_generator+grammar-extras-devel = " \
 cargo \
 rust-pest_generator-devel \
 rust-pest_meta+grammar-extras-devel \
 "
RDEPENDS:rust-pest_generator+std-devel = " \
 cargo \
 rust-pest+std-devel \
 rust-pest_generator-devel \
 "
RDEPENDS:rust-pest_generator-devel = " \
 cargo \
 rust \
 rust-pest-devel \
 rust-pest_meta+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
