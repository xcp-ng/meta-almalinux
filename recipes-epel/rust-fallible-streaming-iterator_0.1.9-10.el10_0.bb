# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fallible-streaming-iterator"
PV = "0.1.9"
PR = "10.el10_0"
PACKAGES = " \
 rust-fallible-streaming-iterator+default-devel \
 rust-fallible-streaming-iterator+std-devel \
 rust-fallible-streaming-iterator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fallible-streaming-iterator-0.1.9-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6fddd2dc5b7a66c8a51f882327b8382352a745e281d6468305d190d29d79802"

URI_x86_64_v2_rust-fallible-streaming-iterator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fallible-streaming-iterator+default-devel-0.1.9-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fallible-streaming-iterator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fallible-streaming-iterator+default-devel}"
SRC_URI[x86_64_v2_rust-fallible-streaming-iterator+default-devel.sha256sum] = "8d5a7ef93970fd6a87079d381b255cf4e4dd3f2df1624a2a78ba9cf3729d81a1"

URI_x86_64_v2_rust-fallible-streaming-iterator+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fallible-streaming-iterator+std-devel-0.1.9-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fallible-streaming-iterator+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fallible-streaming-iterator+std-devel}"
SRC_URI[x86_64_v2_rust-fallible-streaming-iterator+std-devel.sha256sum] = "b5476057277d2ad8a7aeb7ee781a88af8887fc3553a3a2b80a37fd9d00b3bf4d"

URI_x86_64_v2_rust-fallible-streaming-iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fallible-streaming-iterator-devel-0.1.9-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fallible-streaming-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fallible-streaming-iterator-devel}"
SRC_URI[x86_64_v2_rust-fallible-streaming-iterator-devel.sha256sum] = "6caba07ba892eeb0f1eda03e20f02cd3275985cbabbb6e7354cf1483765618b9"

URI_aarch64_rust-fallible-streaming-iterator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fallible-streaming-iterator+default-devel-0.1.9-10.el10_0.noarch.rpm;name=aarch64_rust-fallible-streaming-iterator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fallible-streaming-iterator+default-devel}"
SRC_URI[aarch64_rust-fallible-streaming-iterator+default-devel.sha256sum] = "3e7f2aca22ba8f6cbaf79b31018a66c6c1e56f025dff3455a14d223c02587220"

URI_aarch64_rust-fallible-streaming-iterator+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fallible-streaming-iterator+std-devel-0.1.9-10.el10_0.noarch.rpm;name=aarch64_rust-fallible-streaming-iterator+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fallible-streaming-iterator+std-devel}"
SRC_URI[aarch64_rust-fallible-streaming-iterator+std-devel.sha256sum] = "518503faa309c120dbec9342ec083ecfeb21797e7ade549e5e1f34d7477020ca"

URI_aarch64_rust-fallible-streaming-iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fallible-streaming-iterator-devel-0.1.9-10.el10_0.noarch.rpm;name=aarch64_rust-fallible-streaming-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fallible-streaming-iterator-devel}"
SRC_URI[aarch64_rust-fallible-streaming-iterator-devel.sha256sum] = "38bf0577629a235c0c715efef4313706eb48b7b81af3dc7dc9302b74bcd25182"

RDEPENDS:rust-fallible-streaming-iterator+default-devel = " \
 cargo \
 rust-fallible-streaming-iterator-devel \
 "
RDEPENDS:rust-fallible-streaming-iterator+std-devel = " \
 cargo \
 rust-fallible-streaming-iterator-devel \
 "
RDEPENDS:rust-fallible-streaming-iterator-devel = " \
 cargo \
 "
