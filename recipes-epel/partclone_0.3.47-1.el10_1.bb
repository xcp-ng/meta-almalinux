# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "partclone"
PV = "0.3.47"
PR = "1.el10_1"
PACKAGES = " \
 partclone \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/partclone-0.3.47-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0d38e3916f08ca809b3f20dff12b011f13cb14b3874f6130e046ce83d9a10e6"

URI_x86_64_v2_partclone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/partclone-0.3.47-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_partclone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_partclone}"
SRC_URI[x86_64_v2_partclone.sha256sum] = "0663c25e67cda480c03e4d778309b0a1e8bf0bae754c374ca3146dee3204786d"

URI_aarch64_partclone = "${EPEL_MIRROR}/aarch64/Packages/p/partclone-0.3.47-1.el10_1.aarch64.rpm;name=aarch64_partclone;unpack=0"
SRC_URI:append = " ${URI_aarch64_partclone}"
SRC_URI[aarch64_partclone.sha256sum] = "9e6a5853364094e1af9a689ad0b402e6f7a52a36e097e9a0e646c74246cba8c0"

RDEPENDS:partclone = " \
 e2fsprogs-libs \
 fuse3-libs \
 glibc \
 libblkid \
 libuuid \
 ncurses-libs \
 ntfs-3g-libs \
 openssl-libs \
 userspace-rcu \
 xxhash-libs \
 "
