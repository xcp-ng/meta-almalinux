# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audit"
PV = "4.0.3"
PR = "4.el10"
PACKAGES = " \
 audispd-plugins \
 audispd-plugins-zos \
 audit \
 audit-libs \
 audit-libs-devel \
 audit-rules \
 python3-audit \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/audit-4.0.3-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "339955a7918e41bee07eea546a5d1dc38bfc9fed9b2f20fdf19a84f8e5c947a9"

URI_x86_64_v2_audispd-plugins = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audispd-plugins-4.0.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_audispd-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audispd-plugins}"
SRC_URI[x86_64_v2_audispd-plugins.sha256sum] = "b60849e3c3ece9e119bf405f2c49764d005e2090f7d5f25b4d24ccd97dd0cd1f"

URI_x86_64_v2_audispd-plugins-zos = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audispd-plugins-zos-4.0.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_audispd-plugins-zos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audispd-plugins-zos}"
SRC_URI[x86_64_v2_audispd-plugins-zos.sha256sum] = "20b7c5912e37fedd4a69e9a0e63738e1e2d0c5a24e3c977c9b43766f9a37d3dc"

URI_x86_64_v2_audit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audit-4.0.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_audit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audit}"
SRC_URI[x86_64_v2_audit.sha256sum] = "6771e6c41e8380b5c6dc82500bc9d49f6464abec1277a235cb54760ff7d401c1"

URI_x86_64_v2_audit-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audit-libs-4.0.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_audit-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audit-libs}"
SRC_URI[x86_64_v2_audit-libs.sha256sum] = "904d8cb2f12141f178f9d9e4cd8d0c98e6739d039b3347b4cfbbe01262141134"

URI_x86_64_v2_audit-libs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/audit-libs-devel-4.0.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_audit-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audit-libs-devel}"
SRC_URI[x86_64_v2_audit-libs-devel.sha256sum] = "fdbdc79debfe34b5de9de1196efc6646575cf5b5736004693eac1f8fa505c3d5"

URI_x86_64_v2_audit-rules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audit-rules-4.0.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_audit-rules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audit-rules}"
SRC_URI[x86_64_v2_audit-rules.sha256sum] = "c0449acf06efdc319dcdef14e588e18a80c13c535eb0c78996129345f65d4176"

URI_x86_64_v2_python3-audit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-audit-4.0.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_python3-audit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-audit}"
SRC_URI[x86_64_v2_python3-audit.sha256sum] = "57eff9753ad4c31eec5e4395dba6728b483bcdc8928e789b47672dcb30b9576f"

URI_aarch64_audispd-plugins = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audispd-plugins-4.0.3-4.el10.aarch64.rpm;name=aarch64_audispd-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_audispd-plugins}"
SRC_URI[aarch64_audispd-plugins.sha256sum] = "5b3a03f00f12c6a0330e1567fc5502e3f7ff626d69d0d44a60adcd45c35d89aa"

URI_aarch64_audispd-plugins-zos = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audispd-plugins-zos-4.0.3-4.el10.aarch64.rpm;name=aarch64_audispd-plugins-zos;unpack=0"
SRC_URI:append = " ${URI_aarch64_audispd-plugins-zos}"
SRC_URI[aarch64_audispd-plugins-zos.sha256sum] = "454de4c605e67bf5caa67afa47bfb2a02edb503075e0213b1d9d18277c0f59e0"

URI_aarch64_audit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audit-4.0.3-4.el10.aarch64.rpm;name=aarch64_audit;unpack=0"
SRC_URI:append = " ${URI_aarch64_audit}"
SRC_URI[aarch64_audit.sha256sum] = "d3243e01a27561463615d76367ec72976661441e3a0aa5be72a82297f54f2896"

URI_aarch64_audit-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audit-libs-4.0.3-4.el10.aarch64.rpm;name=aarch64_audit-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_audit-libs}"
SRC_URI[aarch64_audit-libs.sha256sum] = "6e470bb0a5d18e60583b55b99cc0db30c96b9cd6dcc877c77cdb7bf7d9b738eb"

URI_aarch64_audit-libs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/audit-libs-devel-4.0.3-4.el10.aarch64.rpm;name=aarch64_audit-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_audit-libs-devel}"
SRC_URI[aarch64_audit-libs-devel.sha256sum] = "85d0228fcbeff9bc452801ba87e3f5b42041da057ab4e672f3e51d3b8b11a8f6"

URI_aarch64_audit-rules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audit-rules-4.0.3-4.el10.aarch64.rpm;name=aarch64_audit-rules;unpack=0"
SRC_URI:append = " ${URI_aarch64_audit-rules}"
SRC_URI[aarch64_audit-rules.sha256sum] = "dadb07a2da2d46a194cd5aebbe8b79184fb0a7da8a971e7c78c78b50389601f9"

URI_aarch64_python3-audit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-audit-4.0.3-4.el10.aarch64.rpm;name=aarch64_python3-audit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-audit}"
SRC_URI[aarch64_python3-audit.sha256sum] = "0ab448209755c5dd66a3b1cd5a91cc4b3352c3f5635085073ccd518921732145"

RDEPENDS:audispd-plugins = " \
 audit \
 audit-libs \
 glibc \
 krb5-libs \
 libcap-ng \
 "
RDEPENDS:audispd-plugins-zos = " \
 audit \
 audit-libs \
 glibc \
 libcap-ng \
 openldap \
 "
RDEPENDS:audit = " \
 audit-libs \
 bash \
 glibc \
 krb5-libs \
 systemd \
 virtual/coreutils \
 "
RDEPENDS:audit-libs = " \
 glibc \
 libcap-ng \
 "
RDEPENDS:audit-libs-devel = " \
 audit-libs \
 kernel-headers \
 libcap-ng-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:audit-rules = " \
 audit-libs \
 bash \
 glibc \
 "
RDEPENDS:python3-audit = " \
 audit-libs \
 glibc \
 libcap-ng \
 python3 \
 "
