# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libaccounts-glib"
PV = "1.25"
PR = "15.el10_0"
PACKAGES = " \
 libaccounts-glib \
 libaccounts-glib-devel \
 libaccounts-glib-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libaccounts-glib-1.25-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc8dd5bf617964077af42a15c67da8541a632ca3e5aa9d6deaf8c9b183c5f8cf"

URI_x86_64_v2_libaccounts-glib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaccounts-glib-1.25-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaccounts-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaccounts-glib}"
SRC_URI[x86_64_v2_libaccounts-glib.sha256sum] = "928299d608681de45ab958bd11381ff13c31ce8936b1196d8ea2501121f9a078"

URI_x86_64_v2_libaccounts-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaccounts-glib-devel-1.25-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaccounts-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaccounts-glib-devel}"
SRC_URI[x86_64_v2_libaccounts-glib-devel.sha256sum] = "d40e65876d637ec21832443ea4d9d65453ba0155848efd9776bc0eb6b87466e3"

URI_x86_64_v2_libaccounts-glib-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaccounts-glib-docs-1.25-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libaccounts-glib-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaccounts-glib-docs}"
SRC_URI[x86_64_v2_libaccounts-glib-docs.sha256sum] = "5540c83370dff51f9b36fafd682cdc47bc38cb68ed4f8835f9c8f26874ec6bd0"

URI_aarch64_libaccounts-glib = "${EPEL_MIRROR}/aarch64/Packages/l/libaccounts-glib-1.25-15.el10_0.aarch64.rpm;name=aarch64_libaccounts-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaccounts-glib}"
SRC_URI[aarch64_libaccounts-glib.sha256sum] = "58c424a36d49ff40d4d6d52bc9312c37f7dabeed58142b7e0aa48531a996f660"

URI_aarch64_libaccounts-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libaccounts-glib-devel-1.25-15.el10_0.aarch64.rpm;name=aarch64_libaccounts-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaccounts-glib-devel}"
SRC_URI[aarch64_libaccounts-glib-devel.sha256sum] = "f7aad022713331ffa9d2237fdb95993fb90356c7c57153ca54bf24c1524d2603"

URI_aarch64_libaccounts-glib-docs = "${EPEL_MIRROR}/aarch64/Packages/l/libaccounts-glib-docs-1.25-15.el10_0.noarch.rpm;name=aarch64_libaccounts-glib-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaccounts-glib-docs}"
SRC_URI[aarch64_libaccounts-glib-docs.sha256sum] = "027c0d80cfeddc1103eef0b9f5f295be843b7ca804dcbc9d953c1c0066e85684"

RDEPENDS:libaccounts-glib = " \
 glib2 \
 glibc \
 libxml2 \
 python3 \
 python3-gobject \
 sqlite-libs \
 "
RDEPENDS:libaccounts-glib-devel = " \
 glib2-devel \
 libaccounts-glib \
 libxml2-devel \
 pkgconf-pkg-config \
 sqlite-devel \
 "
RDEPENDS:libaccounts-glib-docs = " \
 "
