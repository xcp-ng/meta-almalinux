# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "whichfont"
PV = "2.3.0"
PR = "1.el10_1"
PACKAGES = " \
 whichfont \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/whichfont-2.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "473bc27746b1157495619d1c31ef60f0bf093de9ff31da08e17c46b10e3aa2f0"

URI_x86_64_v2_whichfont = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/whichfont-2.3.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_whichfont;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_whichfont}"
SRC_URI[x86_64_v2_whichfont.sha256sum] = "62e4b846e8c1f2d9d3c25d20900390ecd4e423c2b5f723fa6ff4c06b119b28b6"

URI_aarch64_whichfont = "${EPEL_MIRROR}/aarch64/Packages/w/whichfont-2.3.0-1.el10_1.aarch64.rpm;name=aarch64_whichfont;unpack=0"
SRC_URI:append = " ${URI_aarch64_whichfont}"
SRC_URI[aarch64_whichfont.sha256sum] = "d54765fadb03fc224af0306c9e50eafba76668366a372b4bd8226354c705134e"

RDEPENDS:whichfont = " \
 fontconfig \
 glibc \
 "
