# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdxflib"
PV = "3.26.4"
PR = "19.el10_0"
PACKAGES = " \
 libdxflib \
 libdxflib-devel \
 libdxflib-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdxflib-3.26.4-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfa65291ce232cdd98e1959c22e324e57d7aa0112ae910893c638e680341f9a7"

URI_x86_64_v2_libdxflib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdxflib-3.26.4-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdxflib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdxflib}"
SRC_URI[x86_64_v2_libdxflib.sha256sum] = "5fad8e7139f7bbd72b28ed56c8ba6e478d77cf6ee5d1aaa7214595f318131592"

URI_x86_64_v2_libdxflib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdxflib-devel-3.26.4-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdxflib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdxflib-devel}"
SRC_URI[x86_64_v2_libdxflib-devel.sha256sum] = "a7530023f84199c8d435836bcf198415a364345f36c0810c2bf1d09433cd5693"

URI_x86_64_v2_libdxflib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdxflib-doc-3.26.4-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libdxflib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdxflib-doc}"
SRC_URI[x86_64_v2_libdxflib-doc.sha256sum] = "10200fc90f2e011272b664c22f5f30068f44efd6e803be57b633a725fd91ebe5"

URI_aarch64_libdxflib = "${EPEL_MIRROR}/aarch64/Packages/l/libdxflib-3.26.4-19.el10_0.aarch64.rpm;name=aarch64_libdxflib;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdxflib}"
SRC_URI[aarch64_libdxflib.sha256sum] = "f4793b7a093a0634058e2921900803c86675f9f384f686ea367dd9212924b37b"

URI_aarch64_libdxflib-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdxflib-devel-3.26.4-19.el10_0.aarch64.rpm;name=aarch64_libdxflib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdxflib-devel}"
SRC_URI[aarch64_libdxflib-devel.sha256sum] = "a897238fe95b8fd3b500ff5e44d995cff01f229fefd90a4db05e9c3cc4e432c8"

URI_aarch64_libdxflib-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libdxflib-doc-3.26.4-19.el10_0.noarch.rpm;name=aarch64_libdxflib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdxflib-doc}"
SRC_URI[aarch64_libdxflib-doc.sha256sum] = "78260d76eeca1c7c37f2f445e685f07b0c6bff8478830ab1ffdd982b6d8db66b"

RDEPENDS:libdxflib = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libdxflib-devel = " \
 libdxflib \
 pkgconf-pkg-config \
 "
RDEPENDS:libdxflib-doc = " \
 "
