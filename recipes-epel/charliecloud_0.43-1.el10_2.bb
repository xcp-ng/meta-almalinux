# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "charliecloud"
PV = "0.43"
PR = "1.el10_2"
PACKAGES = " \
 charliecloud \
 charliecloud-docs \
 charliecloud-image \
 charliecloud-test \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/charliecloud-0.43-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "691cc9b2011d2224daca6827203a2a6da443a55aade814fc92af9e6a2781e817"

URI_x86_64_v2_charliecloud = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/charliecloud-0.43-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_charliecloud;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_charliecloud}"
SRC_URI[x86_64_v2_charliecloud.sha256sum] = "d3b123f8a034830f3c09f9b4444d535a3511fe31773209a7783d0280be2bdb98"

URI_x86_64_v2_charliecloud-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/charliecloud-docs-0.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_charliecloud-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_charliecloud-docs}"
SRC_URI[x86_64_v2_charliecloud-docs.sha256sum] = "f414147ac27b024716daa29fbf4a5bff6e3bff040ed1da68ac92fb0ec481584f"

URI_x86_64_v2_charliecloud-image = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/charliecloud-image-0.43-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_charliecloud-image;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_charliecloud-image}"
SRC_URI[x86_64_v2_charliecloud-image.sha256sum] = "aafe83f1a234859af67bb1097dfa32048f22094610659c1f0d8a7a3b841baa48"

URI_x86_64_v2_charliecloud-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/charliecloud-test-0.43-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_charliecloud-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_charliecloud-test}"
SRC_URI[x86_64_v2_charliecloud-test.sha256sum] = "f8f03bfa3010691bf73cf11898227cf655f383556b04f39b5ee46cb975598835"

URI_aarch64_charliecloud = "${EPEL_MIRROR}/aarch64/Packages/c/charliecloud-0.43-1.el10_2.aarch64.rpm;name=aarch64_charliecloud;unpack=0"
SRC_URI:append = " ${URI_aarch64_charliecloud}"
SRC_URI[aarch64_charliecloud.sha256sum] = "16e46638ee6260bb04380543f7bfc321f86190cab5da6186efe13d4e483d450d"

URI_aarch64_charliecloud-docs = "${EPEL_MIRROR}/aarch64/Packages/c/charliecloud-docs-0.43-1.el10_2.noarch.rpm;name=aarch64_charliecloud-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_charliecloud-docs}"
SRC_URI[aarch64_charliecloud-docs.sha256sum] = "34fb006f0ef19c8661957804bf6747489e4f288048751cff02156e5e09d7c144"

URI_aarch64_charliecloud-image = "${EPEL_MIRROR}/aarch64/Packages/c/charliecloud-image-0.43-1.el10_2.aarch64.rpm;name=aarch64_charliecloud-image;unpack=0"
SRC_URI:append = " ${URI_aarch64_charliecloud-image}"
SRC_URI[aarch64_charliecloud-image.sha256sum] = "d3498dc0ae8e3e60a1359ebac767e1c003fe063d60e5041cdc65552dedca9cd4"

URI_aarch64_charliecloud-test = "${EPEL_MIRROR}/aarch64/Packages/c/charliecloud-test-0.43-1.el10_2.aarch64.rpm;name=aarch64_charliecloud-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_charliecloud-test}"
SRC_URI[aarch64_charliecloud-test.sha256sum] = "46abeda0d197a3bc8ea67a6e9637f02f93d5f129f8fe4c5bd04f00a716d80f55"

RDEPENDS:charliecloud = " \
 bash \
 cjson \
 fuse3 \
 fuse3-libs \
 glibc \
 python3 \
 squashfuse \
 squashfuse-libs \
 "
RDEPENDS:charliecloud-docs = " \
 "
RDEPENDS:charliecloud-image = " \
 charliecloud \
 git \
 python3 \
 python3-requests \
 "
RDEPENDS:charliecloud-test = " \
 bash \
 bats \
 charliecloud \
 charliecloud-image \
 glibc \
 python3 \
 "
