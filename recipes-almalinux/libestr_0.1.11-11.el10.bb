# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libestr"
PV = "0.1.11"
PR = "11.el10"
PACKAGES = " \
 libestr \
 libestr-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libestr-0.1.11-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6716fcb13cd5631c7a6a4f268929ce4871566351d86ce3ace830881af818bb0"

URI_x86_64_v2_libestr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libestr-0.1.11-11.el10.x86_64_v2.rpm;name=x86_64_v2_libestr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libestr}"
SRC_URI[x86_64_v2_libestr.sha256sum] = "08e0f314018ba9614bc281bdc41a00f455681b56e7d746d0cdc374baaed49308"

URI_x86_64_v2_libestr-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libestr-devel-0.1.11-11.el10.x86_64_v2.rpm;name=x86_64_v2_libestr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libestr-devel}"
SRC_URI[x86_64_v2_libestr-devel.sha256sum] = "14953a245b64ebfd0f0a9cea1046b3054621d8e417bd6670c3dc2eebfb231fca"

URI_aarch64_libestr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libestr-0.1.11-11.el10.aarch64.rpm;name=aarch64_libestr;unpack=0"
SRC_URI:append = " ${URI_aarch64_libestr}"
SRC_URI[aarch64_libestr.sha256sum] = "df55b67f7452376b5ee210da55efcd12d8cdb778a2f876d3b9f70b701ddd9826"

URI_aarch64_libestr-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libestr-devel-0.1.11-11.el10.aarch64.rpm;name=aarch64_libestr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libestr-devel}"
SRC_URI[aarch64_libestr-devel.sha256sum] = "f2df72ab3ed0c67fb270dc380a09e0aed36b6b996ed8bd5917cb0679a378a10a"

RDEPENDS:libestr = " \
 glibc \
 "
RDEPENDS:libestr-devel = " \
 libestr \
 pkgconf-pkg-config \
 "
