# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtiff"
PV = "4.6.0"
PR = "8.el10_2.4"
PACKAGES = " \
 libtiff \
 libtiff-devel \
 libtiff-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libtiff-4.6.0-8.el10_2.4.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6dab1ab636747469e8061e340f0f5c19dd8cddce11303ab9be0ae7ce36923005"

URI_x86_64_v2_libtiff = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtiff-4.6.0-8.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_libtiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtiff}"
SRC_URI[x86_64_v2_libtiff.sha256sum] = "cdbd80887d980d5bef58853094b48aa7a48560bb501799b674f143ae8c228e15"
RPROVIDES:libtiff:x86_64_v2 = "virtual/libtiffxx.so.6___64bit_"

URI_x86_64_v2_libtiff-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtiff-devel-4.6.0-8.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_libtiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtiff-devel}"
SRC_URI[x86_64_v2_libtiff-devel.sha256sum] = "8b13ab18868edbbad1f250c53345c2120e3adf12a46979a085c14e6bc0492309"

URI_x86_64_v2_libtiff-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libtiff-tools-4.6.0-8.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_libtiff-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtiff-tools}"
SRC_URI[x86_64_v2_libtiff-tools.sha256sum] = "7249a80e6718ac756502f9d94877587b9617265d0db318f347c0260e59b0fdcb"

URI_aarch64_libtiff = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtiff-4.6.0-8.el10_2.4.aarch64.rpm;name=aarch64_libtiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtiff}"
SRC_URI[aarch64_libtiff.sha256sum] = "96718d60a21ab60c5c5912df9507c0449031eb028cb29b600a1e54395b85d84e"
RPROVIDES:libtiff:aarch64 = "virtual/libtiffxx.so.6___64bit_"

URI_aarch64_libtiff-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtiff-devel-4.6.0-8.el10_2.4.aarch64.rpm;name=aarch64_libtiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtiff-devel}"
SRC_URI[aarch64_libtiff-devel.sha256sum] = "55aa13d9f6c3ac04642cf66eff904c150232ba2184b9948a95b711b6daa5f89b"

URI_aarch64_libtiff-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libtiff-tools-4.6.0-8.el10_2.4.aarch64.rpm;name=aarch64_libtiff-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtiff-tools}"
SRC_URI[aarch64_libtiff-tools.sha256sum] = "b5cabe550e184560f0a3cf1b74b3f4079f21605a64b04d9f21628c30b104861c"

RDEPENDS:libtiff = " \
 glibc \
 jbigkit-libs \
 libgcc \
 libjpeg-turbo \
 liblerc \
 libstdc++ \
 libwebp \
 libzstd \
 zlib-ng-compat \
 "
RDEPENDS:libtiff-devel = " \
 libjpeg-turbo-devel \
 libtiff \
 libwebp-devel \
 libzstd-devel \
 pkgconf-pkg-config \
 virtual/libtiffxx.so.6___64bit_ \
 zlib-ng-compat-devel \
 "
RDEPENDS:libtiff-tools = " \
 glibc \
 libtiff \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libtiffxx.so.6___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libtiffxx.so.6___64bit_"
