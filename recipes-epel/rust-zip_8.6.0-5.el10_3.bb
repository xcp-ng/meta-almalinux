# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zip"
PV = "8.6.0"
PR = "5.el10_3"
PACKAGES = " \
 rust-zip+_arbitrary-devel \
 rust-zip+_bzip2_any-devel \
 rust-zip+_deflate-any-devel \
 rust-zip+aes-crypto-devel \
 rust-zip+bitstream-io-devel \
 rust-zip+bzip2-devel \
 rust-zip+bzip2-rs-devel \
 rust-zip+chrono-devel \
 rust-zip+default-devel \
 rust-zip+deflate-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip+deflate-flate2-zlib-devel \
 rust-zip+deflate-flate2-zlib-ng-devel \
 rust-zip+deflate-flate2-zlib-rs-devel \
 rust-zip+deflate-zopfli-devel \
 rust-zip+deflate64-devel \
 rust-zip+deprecated-time-devel \
 rust-zip+getrandom-devel \
 rust-zip+jiff-02-devel \
 rust-zip+legacy-zip-devel \
 rust-zip+lzma-devel \
 rust-zip+ppmd-devel \
 rust-zip+time-devel \
 rust-zip+unreserved-devel \
 rust-zip+xz-devel \
 rust-zip+zstd-devel \
 rust-zip-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-zip-8.6.0-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3afed04330ecc62f83f98fa077e7c7e8c729aba0e0ee8b3c57534cb5b9ff3a96"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+_arbitrary-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+_arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+_arbitrary-devel.sha256sum] = "c44dc9c4a16227996b41a0ec4a012aacceb6938f8a1ea381a6079464cbff5eb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+_bzip2_any-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+_bzip2_any-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+_bzip2_any-devel.sha256sum] = "311b03124a964c2e86850a3482b70a395800c451f9aece6bf1081ee5fe5a9e95"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+_deflate-any-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+_deflate-any-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+_deflate-any-devel.sha256sum] = "50ed70c83f02c76a654ee5b1c2fb27c844a23327a218b9bcb9120e06abb829cb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+aes-crypto-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+aes-crypto-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+aes-crypto-devel.sha256sum] = "417845510c25171b4f0bac6a4baa02d46b32a3e737d57dc0356b3bbf0f74ef88"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+bitstream-io-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+bitstream-io-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+bitstream-io-devel.sha256sum] = "93958635ae7d522b4fea61d8c5ec3c12d2880806ba1928fe42fd9a7a2bae9442"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+bzip2-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+bzip2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+bzip2-devel.sha256sum] = "fa4aea7becf2961ae74cb6123267474bdb5636fac217c3d185330d5b1f27326d"
RPROVIDES:rust-zip+bzip2-devel:append:x86_64_v2 = " virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_9.0.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+bzip2-rs-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+bzip2-rs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+bzip2-rs-devel.sha256sum] = "0d674a241b31da6ae66e6dcd7f1122d117cf818c88c7e541b1320f56e97de7e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+chrono-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+chrono-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+chrono-devel.sha256sum] = "56861b29f0b971af3ed050ad35cfaedc2fb0555448142b67889b648ded1e1bd1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+default-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+default-devel.sha256sum] = "ee2ccebfc21a8519f89847d2e0d400bc4c9f95d6793eb31d94c244c489a39bdb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+deflate-devel.sha256sum] = "8fc5fc7dcff17c8460dd5d676ea302ac9ad6455f866ccc8ad12c308f0e645243"
RPROVIDES:rust-zip+deflate-devel:append:x86_64_v2 = " virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_9.0.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-flate2-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-flate2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+deflate-flate2-devel.sha256sum] = "8d4bd4f9f567c8e14d8f328909d525f0a18ef279cffba03c1399eb40e8bdc20d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-flate2-zlib-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-flate2-zlib-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+deflate-flate2-zlib-devel.sha256sum] = "cac5297d67fc4eb0e5849f3958dfa9a18955bd6c0fe6e015fc1fd00719a2963c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-flate2-zlib-ng-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-flate2-zlib-ng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+deflate-flate2-zlib-ng-devel.sha256sum] = "7b3d9012a63a616844bc55dfd74b594973ac34708a553350549c566eb6ac9c3f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-flate2-zlib-rs-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-flate2-zlib-rs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+deflate-flate2-zlib-rs-devel.sha256sum] = "b649b9179a120fa28cb51cf0a684eea43cd727f0fe3c24c0cea5eb8fa8b0dbb4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-zopfli-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-zopfli-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+deflate-zopfli-devel.sha256sum] = "f0068416014b0ca080569ec47f3511fe3feaeb910733838e5d8247b5fb171912"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate64-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate64-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+deflate64-devel.sha256sum] = "9a72ea6e454e39be612346df40fc01d2d3a01e13f4d52fc1bcd3a2944f7304cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deprecated-time-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deprecated-time-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+deprecated-time-devel.sha256sum] = "1a46cfd2bbe780dccbc3272ef208a2b630bb4c4c07eb5d096ff002d60530d8b1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+getrandom-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+getrandom-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+getrandom-devel.sha256sum] = "c0ecbd24d1f2d1acbafcca2603aab796724ac273b23d32334d74d3a9c8699a11"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+jiff-02-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+jiff-02-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+jiff-02-devel.sha256sum] = "52bf19c0a30b9027c1eab47170ce9197df19c892780ac6ca7cd044e7b3d8fb89"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+legacy-zip-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+legacy-zip-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+legacy-zip-devel.sha256sum] = "6e0943a1f3368e3c7a9a217cf98c0e47d74478fb174f72c51231c0bd5c151206"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+lzma-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+lzma-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+lzma-devel.sha256sum] = "245df0a4dd8d4c139583abb0a4fd02667b15575b009208fe2904140ef363c372"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+ppmd-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+ppmd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+ppmd-devel.sha256sum] = "d512e5e41307cf11d39207c527519533115f0f0e704c2806e8842ca62ce5cabb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+time-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+time-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+time-devel.sha256sum] = "be45970e14c9ec27f7ac3c9d60865934ec0dbab66f22371ca3a987467a4cc33f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+unreserved-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+unreserved-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+unreserved-devel.sha256sum] = "3171c49d14a799da4e351e543026cf4e21606737614e588c2652b66aba5f1980"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+xz-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+xz-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+xz-devel.sha256sum] = "33f46ea2b3c281fe309020b243416a5d21da2a8ac3d1632a231e0f9454dec425"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+zstd-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+zstd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip+zstd-devel.sha256sum] = "c96372f9372526ae82d5cf63624b69af36ae1ae0873f173fd23413a25a8fc920"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip-devel-8.6.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zip-devel.sha256sum] = "694955e5583b6915ca7eba9255e2b515e402ac4964bebede8a3d3ef47d57c649"
RPROVIDES:rust-zip-devel:append:x86_64_v2 = " virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_9.0.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+_arbitrary-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+_arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-zip+_arbitrary-devel.sha256sum] = "3ad796f2af64b3f6b0613b6f8289ab6750226809f7b85ba7355b4f796527f96b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+_bzip2_any-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+_bzip2_any-devel;unpack=0"
SRC_URI[aarch64_rust-zip+_bzip2_any-devel.sha256sum] = "ca15a9c9875f5b75c058add4dfdef4456a62f3054bb9f512ae4d25d2989eaee6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+_deflate-any-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+_deflate-any-devel;unpack=0"
SRC_URI[aarch64_rust-zip+_deflate-any-devel.sha256sum] = "c61a6a236b4d29335b0007f56fa91e531c60ba3bc19d6b69615b7b4d9d96a7ec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+aes-crypto-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+aes-crypto-devel;unpack=0"
SRC_URI[aarch64_rust-zip+aes-crypto-devel.sha256sum] = "800160249909c802618dc62d24fc15cc9e5c2c4c07a235af63822b7d1f85c294"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+bitstream-io-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+bitstream-io-devel;unpack=0"
SRC_URI[aarch64_rust-zip+bitstream-io-devel.sha256sum] = "0115a6963f3665d1a38c8c8a7996fab5b73af1f104359993dbad44e88d9bbffd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+bzip2-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+bzip2-devel;unpack=0"
SRC_URI[aarch64_rust-zip+bzip2-devel.sha256sum] = "03ef23aaf88d9c0e3504cf17918b13b8419a9fcf7db02a5beb969f92affe94de"
RPROVIDES:rust-zip+bzip2-devel:append:aarch64 = " virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_9.0.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+bzip2-rs-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+bzip2-rs-devel;unpack=0"
SRC_URI[aarch64_rust-zip+bzip2-rs-devel.sha256sum] = "acac269b2388c2981eb94bf57a780f89b4eb8bc1ea738dbf4b8cac62c36fd46c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+chrono-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+chrono-devel;unpack=0"
SRC_URI[aarch64_rust-zip+chrono-devel.sha256sum] = "f336c661fe5248aac9464f1fa9d8cfbe8b1efdded7e7a41ce244631618e4d4cd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+default-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+default-devel;unpack=0"
SRC_URI[aarch64_rust-zip+default-devel.sha256sum] = "1d7c85841ca0d5f7e65deb28737defcfd6f7822620881ad9d1eaff65338e3462"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+deflate-devel;unpack=0"
SRC_URI[aarch64_rust-zip+deflate-devel.sha256sum] = "57464066d526dc71b74921af6870ae55a4c01d44e2c94cebe0b1ad7938e96c39"
RPROVIDES:rust-zip+deflate-devel:append:aarch64 = " virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_9.0.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-flate2-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+deflate-flate2-devel;unpack=0"
SRC_URI[aarch64_rust-zip+deflate-flate2-devel.sha256sum] = "ba1121c61c96f2ac07af6911ac6c7e234d6c7ed7411f873b02951cdc47452d3d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-flate2-zlib-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+deflate-flate2-zlib-devel;unpack=0"
SRC_URI[aarch64_rust-zip+deflate-flate2-zlib-devel.sha256sum] = "445ae8925ab83b364790503660339113e946df8938140b87d98164bd977f2fcc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-flate2-zlib-ng-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+deflate-flate2-zlib-ng-devel;unpack=0"
SRC_URI[aarch64_rust-zip+deflate-flate2-zlib-ng-devel.sha256sum] = "ff7721d057371f31193a4b34a47b4e0ea73b66a8ef3b7e315b4c0cea9147126f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-flate2-zlib-rs-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+deflate-flate2-zlib-rs-devel;unpack=0"
SRC_URI[aarch64_rust-zip+deflate-flate2-zlib-rs-devel.sha256sum] = "abc778c391602a11031eac2057cae9773a76d6c306ba962ae1ffa74fb11555ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-zopfli-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+deflate-zopfli-devel;unpack=0"
SRC_URI[aarch64_rust-zip+deflate-zopfli-devel.sha256sum] = "befc63968be052acffd976afe11f4e5e6cdc5feefa8af6cb09b6113caa7b85bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate64-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+deflate64-devel;unpack=0"
SRC_URI[aarch64_rust-zip+deflate64-devel.sha256sum] = "c9c9488b51fd2ad7ac6973840af96826bf348305b8ca136c32b03f31bcea00e3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deprecated-time-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+deprecated-time-devel;unpack=0"
SRC_URI[aarch64_rust-zip+deprecated-time-devel.sha256sum] = "ef113b1160e365e7b1f4f600d44cd5bd222c42bc49e2ad4ec1c8d61430a7bb90"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+getrandom-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+getrandom-devel;unpack=0"
SRC_URI[aarch64_rust-zip+getrandom-devel.sha256sum] = "106ae808688c1ad39676b6008a63dc25cec05e71d1727a32c0d200ca944342a4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+jiff-02-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+jiff-02-devel;unpack=0"
SRC_URI[aarch64_rust-zip+jiff-02-devel.sha256sum] = "47b1fc7d3e2e5915eab830e05f1e62a560cad733b8b420a3854004962c907fc2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+legacy-zip-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+legacy-zip-devel;unpack=0"
SRC_URI[aarch64_rust-zip+legacy-zip-devel.sha256sum] = "0f6428c0979934c83fe8a5297c0d8f8312abaa64fa5eb4a3815be1eec56188e1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+lzma-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+lzma-devel;unpack=0"
SRC_URI[aarch64_rust-zip+lzma-devel.sha256sum] = "284070f2ced9b94caef15c82e4f0817a7084f712a79a1c71a4f59fb54b9524d6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+ppmd-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+ppmd-devel;unpack=0"
SRC_URI[aarch64_rust-zip+ppmd-devel.sha256sum] = "c490fc6c5ccffdb7a7d85fadaa677700d1ae079a1436482b9f11909217c3ab2b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+time-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+time-devel;unpack=0"
SRC_URI[aarch64_rust-zip+time-devel.sha256sum] = "b9c5615f76774a199343310185ce6d062bf58c1c30afebe56c6c731c5d7dbb0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+unreserved-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+unreserved-devel;unpack=0"
SRC_URI[aarch64_rust-zip+unreserved-devel.sha256sum] = "c8b74472aaee28b7098767d4522968c8551dd11f1d227e8ee21a0fdcaf9e5515"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+xz-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+xz-devel;unpack=0"
SRC_URI[aarch64_rust-zip+xz-devel.sha256sum] = "0467e87f9270a64aee29b116c9090ff9d04dd69389851580ca1d4e154859ec57"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+zstd-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip+zstd-devel;unpack=0"
SRC_URI[aarch64_rust-zip+zstd-devel.sha256sum] = "753c0b513306cfb76252b6f028ae94aa38d910d8684e2ab40fc22ab023f36df7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zip-devel-8.6.0-5.el10_3.noarch.rpm;name=aarch64_rust-zip-devel;unpack=0"
SRC_URI[aarch64_rust-zip-devel.sha256sum] = "64af0087a7475688c54846709d612f3086c49d828c8128b62c0709f14dd6f908"
RPROVIDES:rust-zip-devel:append:aarch64 = " virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_9.0.0~"

RDEPENDS:rust-zip+_arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+_bzip2_any-devel = " \
 cargo \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+_deflate-any-devel = " \
 cargo \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+aes-crypto-devel = " \
 cargo \
 rust-aes+default-devel \
 rust-constant_time_eq+default-devel \
 rust-getrandom+std-devel \
 rust-getrandom-devel \
 rust-hmac+default-devel \
 rust-hmac+zeroize-devel \
 rust-pbkdf2+default-devel \
 rust-sha1+default-devel \
 rust-zeroize+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+bitstream-io-devel = " \
 cargo \
 rust-bitstream-io+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-bzip2-devel \
 rust-zip+_bzip2_any-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+bzip2-rs-devel = " \
 cargo \
 rust-bzip2+bzip2-sys-devel \
 rust-bzip2-devel \
 rust-zip+_bzip2_any-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+chrono-devel = " \
 cargo \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+default-devel = " \
 cargo \
 rust-zip+aes-crypto-devel \
 rust-zip+bzip2-devel \
 rust-zip+deflate-devel \
 rust-zip+deflate64-devel \
 rust-zip+lzma-devel \
 rust-zip+ppmd-devel \
 rust-zip+time-devel \
 rust-zip+xz-devel \
 rust-zip+zstd-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-devel = " \
 cargo \
 rust-zip+deflate-flate2-zlib-rs-devel \
 rust-zip+deflate-zopfli-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-flate2-devel = " \
 cargo \
 rust-flate2-devel \
 rust-zip+_deflate-any-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-flate2-zlib-devel = " \
 cargo \
 rust-flate2+zlib-devel \
 rust-flate2-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-flate2-zlib-ng-devel = " \
 cargo \
 rust-flate2+zlib-ng-devel \
 rust-flate2-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-flate2-zlib-rs-devel = " \
 cargo \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-zopfli-devel = " \
 cargo \
 rust-zip+_deflate-any-devel \
 rust-zip-devel \
 rust-zopfli+default-devel \
 "
RDEPENDS:rust-zip+deflate64-devel = " \
 cargo \
 rust-deflate64+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deprecated-time-devel = " \
 cargo \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+getrandom-devel = " \
 cargo \
 rust-getrandom-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+jiff-02-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+legacy-zip-devel = " \
 cargo \
 rust-zip+bitstream-io-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+lzma-devel = " \
 cargo \
 rust-lzma-rust2+encoder-devel \
 rust-lzma-rust2+optimization-devel \
 rust-lzma-rust2+std-devel \
 rust-lzma-rust2+xz-devel \
 rust-lzma-rust2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+ppmd-devel = " \
 cargo \
 rust-ppmd-rust+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+time-devel = " \
 cargo \
 rust-time+std-devel \
 rust-time-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+unreserved-devel = " \
 cargo \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+xz-devel = " \
 cargo \
 rust-lzma-rust2+encoder-devel \
 rust-lzma-rust2+optimization-devel \
 rust-lzma-rust2+std-devel \
 rust-lzma-rust2+xz-devel \
 rust-lzma-rust2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+zstd-devel = " \
 cargo \
 rust-zip-devel \
 rust-zstd-devel \
 "
RDEPENDS:rust-zip-devel = " \
 cargo \
 rust \
 rust-crc32fast+default-devel \
 rust-indexmap+default-devel \
 rust-memchr+default-devel \
 rust-typed-path+default-devel \
 "
