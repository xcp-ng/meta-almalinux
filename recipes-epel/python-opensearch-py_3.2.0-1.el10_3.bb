# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-opensearch-py"
PV = "3.2.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-opensearch-py \
 python3-opensearch-py+async \
 python3-opensearch-py+kerberos \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-opensearch-py-3.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "944f0195e9418518a49f2f513d9566ae3520c5f4c109da92ff1c4e6184abb44b"

URI_x86_64_v2_python3-opensearch-py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opensearch-py-3.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-opensearch-py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opensearch-py}"
SRC_URI[x86_64_v2_python3-opensearch-py.sha256sum] = "2b97bcf6e1400fcd527f5834b0e80fc55999aaa87b5e4d544a39c62a915d0274"

URI_x86_64_v2_python3-opensearch-py+async = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opensearch-py+async-3.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-opensearch-py+async;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opensearch-py+async}"
SRC_URI[x86_64_v2_python3-opensearch-py+async.sha256sum] = "746a8e38197e45d2ce70f58d76cd721c5e3fc04b14ee1a7abe8310ab059092c9"

URI_x86_64_v2_python3-opensearch-py+kerberos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opensearch-py+kerberos-3.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-opensearch-py+kerberos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opensearch-py+kerberos}"
SRC_URI[x86_64_v2_python3-opensearch-py+kerberos.sha256sum] = "226a8d829750089bc9487831a6436f10c61fba203c471c0c73c2d01c18fa4809"

URI_aarch64_python3-opensearch-py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opensearch-py-3.2.0-1.el10_3.noarch.rpm;name=aarch64_python3-opensearch-py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opensearch-py}"
SRC_URI[aarch64_python3-opensearch-py.sha256sum] = "3ebf292e9c65912b424f56b378d04acf5d5f59c1a0b51afeb1a97186373f3bfe"

URI_aarch64_python3-opensearch-py+async = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opensearch-py+async-3.2.0-1.el10_3.noarch.rpm;name=aarch64_python3-opensearch-py+async;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opensearch-py+async}"
SRC_URI[aarch64_python3-opensearch-py+async.sha256sum] = "2bf24c7c3a6a08bd1c3170edad569b9bb0dc6a2a7a5338a32070a1cf8dab0567"

URI_aarch64_python3-opensearch-py+kerberos = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opensearch-py+kerberos-3.2.0-1.el10_3.noarch.rpm;name=aarch64_python3-opensearch-py+kerberos;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opensearch-py+kerberos}"
SRC_URI[aarch64_python3-opensearch-py+kerberos.sha256sum] = "bf5963ab2b046b2b0329a3bc90350cf0da9bc2b989ad5450ac73d8780f8c48eb"

RDEPENDS:python3-opensearch-py = " \
 python3 \
 python3-certifi \
 python3-dateutil \
 python3-events \
 python3-requests \
 python3-urllib3 \
 "
RDEPENDS:python3-opensearch-py+async = " \
 python3 \
 python3-aiohttp \
 python3-opensearch-py \
 "
RDEPENDS:python3-opensearch-py+kerberos = " \
 python3 \
 python3-opensearch-py \
 python3-requests-kerberos \
 "
