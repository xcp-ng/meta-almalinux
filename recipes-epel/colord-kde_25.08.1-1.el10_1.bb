# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "colord-kde"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 colord-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/colord-kde-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "166d63d5742b826f0d0cc5f9110086743e96742697a37fbce4603628e3985023"

URI_x86_64_v2_colord-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/colord-kde-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_colord-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colord-kde}"
SRC_URI[x86_64_v2_colord-kde.sha256sum] = "8353439df75571e3907dca8d789150d91007bc81d3d8c6946611153bf3d25d7d"

URI_aarch64_colord-kde = "${EPEL_MIRROR}/aarch64/Packages/c/colord-kde-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_colord-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_colord-kde}"
SRC_URI[aarch64_colord-kde.sha256sum] = "006348b82faed376829e89489cffd5d6f08ac1354cac72f32c25fb63ecdd4d8e"

RDEPENDS:colord-kde = " \
 colord \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami-addons \
 kf6-kwidgetsaddons \
 lcms2 \
 libX11 \
 libXrandr \
 libstdc++ \
 plasma-systemsettings \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
