# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nmstate"
PV = "2.2.60"
PR = "3.el10_2"
PACKAGES = " \
 nmstate \
 nmstate-devel \
 nmstate-libs \
 nmstate-static \
 python3-libnmstate \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nmstate-2.2.60-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2506cab9d9e5477cc1d5afe39ff6fe0f4a3963ce902a5078a8b0b059b06534c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nmstate-2.2.60-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nmstate;unpack=0"
SRC_URI[x86_64_v2_nmstate.sha256sum] = "acdb9e89b9e7e7c6f95a4693101cfa6a03a48f7ae3a814132ddf0bcfe52c42bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nmstate-devel-2.2.60-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nmstate-devel;unpack=0"
SRC_URI[x86_64_v2_nmstate-devel.sha256sum] = "ce67ef382f955614b7030a92428932335d250f5bf22d8d104550b4bc5372a692"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nmstate-libs-2.2.60-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nmstate-libs;unpack=0"
SRC_URI[x86_64_v2_nmstate-libs.sha256sum] = "9e7990282f45e958495f1ea78840e4891667cef7a9922d36ef77de55d2d507ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nmstate-static-2.2.60-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nmstate-static;unpack=0"
SRC_URI[x86_64_v2_nmstate-static.sha256sum] = "e459036333e6a0ad6acee1d3c4e91fcefa4c39a3fa0f0d086c621bb2885d39c3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnmstate-2.2.60-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-libnmstate;unpack=0"
SRC_URI[x86_64_v2_python3-libnmstate.sha256sum] = "38c649106c61c141c922fe499e62b70b140d5ed91f4cbf198150b4877d95735b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nmstate-2.2.60-3.el10_2.aarch64.rpm;name=aarch64_nmstate;unpack=0"
SRC_URI[aarch64_nmstate.sha256sum] = "936be8c97581e2aa58559626428cce34f104db3a33c19342c5635d7cc23e1f59"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nmstate-devel-2.2.60-3.el10_2.aarch64.rpm;name=aarch64_nmstate-devel;unpack=0"
SRC_URI[aarch64_nmstate-devel.sha256sum] = "e1c969dae184296b6adbed7822ba44f966f32dc8163a5daddc95b4128168227f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nmstate-libs-2.2.60-3.el10_2.aarch64.rpm;name=aarch64_nmstate-libs;unpack=0"
SRC_URI[aarch64_nmstate-libs.sha256sum] = "ddd4e6dfe29f3baa94c1b5cf121ae8d4581a5ad5f2ca5f9de118e46f98d84f29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nmstate-static-2.2.60-3.el10_2.aarch64.rpm;name=aarch64_nmstate-static;unpack=0"
SRC_URI[aarch64_nmstate-static.sha256sum] = "8cdc3b6618b0d233141d8ea9ff54d6904d7082ad01fe0332448a4708b58030d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnmstate-2.2.60-3.el10_2.aarch64.rpm;name=aarch64_python3-libnmstate;unpack=0"
SRC_URI[aarch64_python3-libnmstate.sha256sum] = "f059a0d55d56589a99d1cf977ed2903e846bcc7321b468b7527022875e10ec90"

RDEPENDS:nmstate = " \
 glibc \
 libgcc \
 nmstate-libs \
 "
RDEPENDS:nmstate-devel = " \
 nmstate-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:nmstate-libs = " \
 glibc \
 libgcc \
 "
RDEPENDS:nmstate-static = " \
 nmstate-devel \
 "
RDEPENDS:python3-libnmstate = " \
 nmstate-libs \
 python3 \
 python3-pyyaml \
 "
