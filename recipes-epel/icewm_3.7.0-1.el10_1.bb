# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "icewm"
PV = "3.7.0"
PR = "1.el10_1"
PACKAGES = " \
 icewm \
 icewm-data \
 icewm-minimal-session \
 icewm-themes \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/icewm-3.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b739e1eb4a8fb01a9af33c352f65b3af44ab7b8879313506a5dd0a003925b06a"

URI_x86_64_v2_icewm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icewm-3.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_icewm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icewm}"
SRC_URI[x86_64_v2_icewm.sha256sum] = "1bec46e719d8e878e0a451a4488922969b7ddcea2fa4f68b3ab696db14f04cdf"

URI_x86_64_v2_icewm-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icewm-data-3.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_icewm-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icewm-data}"
SRC_URI[x86_64_v2_icewm-data.sha256sum] = "de40b6843a79c722642a218ab134da5750938e585516be491dd30cc628deb4ea"

URI_x86_64_v2_icewm-minimal-session = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icewm-minimal-session-3.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_icewm-minimal-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icewm-minimal-session}"
SRC_URI[x86_64_v2_icewm-minimal-session.sha256sum] = "98e285389ad7d81ee4149aec007a66090b366c4d94a64dfae5052d6b10119225"

URI_x86_64_v2_icewm-themes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icewm-themes-3.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_icewm-themes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icewm-themes}"
SRC_URI[x86_64_v2_icewm-themes.sha256sum] = "38ab529a775b60fb63ae25ccecd8faa6d8ce2ce51164afb226dbc5097e00d584"

URI_aarch64_icewm = "${EPEL_MIRROR}/aarch64/Packages/i/icewm-3.7.0-1.el10_1.aarch64.rpm;name=aarch64_icewm;unpack=0"
SRC_URI:append = " ${URI_aarch64_icewm}"
SRC_URI[aarch64_icewm.sha256sum] = "f7d1648922049d3cc94cab7b2caf53d0b45d630b58d71cecc79d3414f84abe68"

URI_aarch64_icewm-data = "${EPEL_MIRROR}/aarch64/Packages/i/icewm-data-3.7.0-1.el10_1.noarch.rpm;name=aarch64_icewm-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_icewm-data}"
SRC_URI[aarch64_icewm-data.sha256sum] = "0e27ed539666f278b02bc5b06449f5e24618dab4045a269284a54353dbb358f0"

URI_aarch64_icewm-minimal-session = "${EPEL_MIRROR}/aarch64/Packages/i/icewm-minimal-session-3.7.0-1.el10_1.noarch.rpm;name=aarch64_icewm-minimal-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_icewm-minimal-session}"
SRC_URI[aarch64_icewm-minimal-session.sha256sum] = "1d2ec87e95cd034db062a5d6e4374985a4c24b150e8cf73d891ce723715eb04d"

URI_aarch64_icewm-themes = "${EPEL_MIRROR}/aarch64/Packages/i/icewm-themes-3.7.0-1.el10_1.noarch.rpm;name=aarch64_icewm-themes;unpack=0"
SRC_URI:append = " ${URI_aarch64_icewm-themes}"
SRC_URI[aarch64_icewm-themes.sha256sum] = "54f187ff6e9d94deb84f6a40bb503188cac2284b3c2ac6d2af3bbeb7b64480c1"

RDEPENDS:icewm = " \
 alsa-lib \
 bash \
 fribidi \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 icewm-data \
 imlib2 \
 libICE \
 libSM \
 libX11 \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXft \
 libXinerama \
 libXpm \
 libXrandr \
 libXrender \
 libao \
 libgcc \
 librsvg2 \
 libsndfile \
 libstdc++ \
 perl-interpreter \
 xdg-utils \
 "
RDEPENDS:icewm-data = " \
 icewm \
 "
RDEPENDS:icewm-minimal-session = " \
 icewm \
 "
RDEPENDS:icewm-themes = " \
 icewm \
 "
