# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx-build"
PV = "1.0.168"
PR = "1.el10_1"
PACKAGES = " \
 rust-cxx-build+default-devel \
 rust-cxx-build+parallel-devel \
 rust-cxx-build-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-build-1.0.168-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06fc75e06207b7f9d2d81631d8f5a97ab6b127ed2ecc0e2af4d3b5895182b68a"

URI_x86_64_v2_rust-cxx-build+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build+default-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-build+default-devel}"
SRC_URI[x86_64_v2_rust-cxx-build+default-devel.sha256sum] = "b5d766951f967c6c11440e2c0f64be51f27b11ffc32808efea212b722db12056"

URI_x86_64_v2_rust-cxx-build+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build+parallel-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-build+parallel-devel}"
SRC_URI[x86_64_v2_rust-cxx-build+parallel-devel.sha256sum] = "8ca5707dd274128fc28b9982f24246925855ec83a46d552d49351191bbada386"

URI_x86_64_v2_rust-cxx-build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-build-devel}"
SRC_URI[x86_64_v2_rust-cxx-build-devel.sha256sum] = "6ab16521746ff08a5638aaf066731426b1751c9cec8f7ccbebdff3654d842059"

URI_aarch64_rust-cxx-build+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build+default-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxx-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-build+default-devel}"
SRC_URI[aarch64_rust-cxx-build+default-devel.sha256sum] = "dd4ae08533babdab5dacd24ad73bc1780ffc657fd029414ddcac09984d0c0ce5"

URI_aarch64_rust-cxx-build+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build+parallel-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxx-build+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-build+parallel-devel}"
SRC_URI[aarch64_rust-cxx-build+parallel-devel.sha256sum] = "a9735b8cae456e07778596f2d159edd67f9c6e96c950933363e66d5612d9f07c"

URI_aarch64_rust-cxx-build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxx-build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-build-devel}"
SRC_URI[aarch64_rust-cxx-build-devel.sha256sum] = "99e89d5de7e03bba19ecbd21034f987cc15dcb781a332bd9bb5c78a8c0b0eed5"

RDEPENDS:rust-cxx-build+default-devel = " \
 cargo \
 rust-cxx-build-devel \
 "
RDEPENDS:rust-cxx-build+parallel-devel = " \
 cargo \
 rust-cc+parallel-devel \
 rust-cxx-build-devel \
 "
RDEPENDS:rust-cxx-build-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-codespan-reporting+default-devel \
 rust-indexmap+default-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-scratch+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
