# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opentelemetry-collector"
PV = "0.152.1"
PR = "1.el10"
PACKAGES = " \
 opentelemetry-collector \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/opentelemetry-collector-0.152.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "367d77bf24003372d494d50d835045069d445bb9d52a247494df8b7b86d11d78"

URI_x86_64_v2_opentelemetry-collector = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/opentelemetry-collector-0.152.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_opentelemetry-collector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opentelemetry-collector}"
SRC_URI[x86_64_v2_opentelemetry-collector.sha256sum] = "3b9210ff044b3222763fa629a73559bf121ce6f8dd0c2a28e82d17d812f1944c"

URI_aarch64_opentelemetry-collector = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/opentelemetry-collector-0.152.1-1.el10.aarch64.rpm;name=aarch64_opentelemetry-collector;unpack=0"
SRC_URI:append = " ${URI_aarch64_opentelemetry-collector}"
SRC_URI[aarch64_opentelemetry-collector.sha256sum] = "0fda06b6820a931b89ef212e74a221e39c8639146f17b4f23c3608d6e92739a7"

RDEPENDS:opentelemetry-collector = " \
 bash \
 glibc \
 glibc-common \
 shadow-utils \
 systemd \
 util-linux \
 "
