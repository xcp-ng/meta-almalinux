# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-shallow"
PV = "0.12.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-shallow+default-devel \
 rust-gix-shallow+serde-devel \
 rust-gix-shallow+sha1-devel \
 rust-gix-shallow+sha256-devel \
 rust-gix-shallow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-shallow-0.12.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6843701d87f17fea35905faa72a706cb2c1804d9ae67ca07caaa443079166cd0"

URI_x86_64_v2_rust-gix-shallow+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-shallow+default-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-shallow+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-shallow+default-devel}"
SRC_URI[x86_64_v2_rust-gix-shallow+default-devel.sha256sum] = "afac501bd7a138f70613aaa7a3e45b14f1a45419b058dc751bcca0d2fc472fc6"

URI_x86_64_v2_rust-gix-shallow+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-shallow+serde-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-shallow+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-shallow+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-shallow+serde-devel.sha256sum] = "f5becc39dab9b68f80a71145f646776064ddaf8bee56ba953caa78f035c3ff30"

URI_x86_64_v2_rust-gix-shallow+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-shallow+sha1-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-shallow+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-shallow+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-shallow+sha1-devel.sha256sum] = "e03353561e6e20eb4cc6b3988656f802d286f6f945417d4efd786709770c31f4"

URI_x86_64_v2_rust-gix-shallow+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-shallow+sha256-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-shallow+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-shallow+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-shallow+sha256-devel.sha256sum] = "d9dcbe78b4c94ab8480ee11274e3f08d817e2c4cb49213ed610a3d8474688785"

URI_x86_64_v2_rust-gix-shallow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-shallow-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-shallow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-shallow-devel}"
SRC_URI[x86_64_v2_rust-gix-shallow-devel.sha256sum] = "1be1021f0030bb2801fba83be68fdb6eb1076a1fe0da612d5f6081154c750d2d"

URI_aarch64_rust-gix-shallow+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-shallow+default-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-shallow+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-shallow+default-devel}"
SRC_URI[aarch64_rust-gix-shallow+default-devel.sha256sum] = "63ec540ba56d543cb951d2362a05098621ad89a8cd5ee835a0f06791f00773c7"

URI_aarch64_rust-gix-shallow+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-shallow+serde-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-shallow+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-shallow+serde-devel}"
SRC_URI[aarch64_rust-gix-shallow+serde-devel.sha256sum] = "0341d5f58cbeb9a9753527195aad96d72949039b11edd7952b211549bedfefda"

URI_aarch64_rust-gix-shallow+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-shallow+sha1-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-shallow+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-shallow+sha1-devel}"
SRC_URI[aarch64_rust-gix-shallow+sha1-devel.sha256sum] = "3ffa9752a90127f59b1bac0b7affa420c9a0dee149370c396758d7752dba79b0"

URI_aarch64_rust-gix-shallow+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-shallow+sha256-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-shallow+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-shallow+sha256-devel}"
SRC_URI[aarch64_rust-gix-shallow+sha256-devel.sha256sum] = "ce21c2f1533df5090fde83520452978e1a0c2b0b92867181642066639ef5690b"

URI_aarch64_rust-gix-shallow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-shallow-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-shallow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-shallow-devel}"
SRC_URI[aarch64_rust-gix-shallow-devel.sha256sum] = "c2e229d3b18f05bb1e77456a97e126b5844aec32d8d76029324f22a81608a2ee"

RDEPENDS:rust-gix-shallow+default-devel = " \
 cargo \
 rust-gix-shallow-devel \
 "
RDEPENDS:rust-gix-shallow+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-shallow-devel \
 rust-nonempty+serialize-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-shallow+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-shallow-devel \
 "
RDEPENDS:rust-gix-shallow+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-shallow-devel \
 "
RDEPENDS:rust-gix-shallow-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-hash+default-devel \
 rust-gix-lock+default-devel \
 rust-nonempty+default-devel \
 rust-thiserror+default-devel \
 "
