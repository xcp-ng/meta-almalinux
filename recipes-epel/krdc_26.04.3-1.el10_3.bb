# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krdc"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 krdc \
 krdc-devel \
 krdc-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krdc-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c9d30c26ebaa1d9f2b604ca72d6eaa37c0118447e88b0862c9cf272a7c77e45"

URI_x86_64_v2_krdc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdc}"
SRC_URI[x86_64_v2_krdc.sha256sum] = "35c4064838a73f9b65e9cf9420522cd3342f26fe54ebcbc16f6cf4777c3476c2"

URI_x86_64_v2_krdc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdc-devel}"
SRC_URI[x86_64_v2_krdc-devel.sha256sum] = "e8bc7357feeff0f5aa3894b8e6c56595593f10b98feef98a3a607dd76f59307e"

URI_x86_64_v2_krdc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdc-libs}"
SRC_URI[x86_64_v2_krdc-libs.sha256sum] = "c80b44c9ef6391898846e9ec9dffb70e9283ad639d62e835c41cc270847ecd52"

URI_aarch64_krdc = "${EPEL_MIRROR}/aarch64/Packages/k/krdc-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_krdc;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdc}"
SRC_URI[aarch64_krdc.sha256sum] = "71c449e9c3130b4c1c207f5c49de62b6156637f5a1b1a6f781fcb420e96d23d0"

URI_aarch64_krdc-devel = "${EPEL_MIRROR}/aarch64/Packages/k/krdc-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_krdc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdc-devel}"
SRC_URI[aarch64_krdc-devel.sha256sum] = "68989400f105a69d9eb0a95177e30e80a2d73ef3cd072d46ceecd6cd623e269e"

URI_aarch64_krdc-libs = "${EPEL_MIRROR}/aarch64/Packages/k/krdc-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_krdc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdc-libs}"
SRC_URI[aarch64_krdc-libs.sha256sum] = "94104ebd130c26c1182bdea4fb5c111c736f0710ec895c5bd0ceb95b5e54f425"

RDEPENDS:krdc = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 krdc-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:krdc-devel = " \
 krdc-libs \
 "
RDEPENDS:krdc-libs = " \
 freerdp-libs \
 glibc \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 krdc \
 libssh \
 libstdc++ \
 libvncserver \
 libwinpr \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
