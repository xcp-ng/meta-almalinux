# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bpftrace"
PV = "0.24.2"
PR = "1.el10"
PACKAGES = " \
 bpftrace \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bpftrace-0.24.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee31db9fd5dc8aaca60e8883890030bed771669b17ade2d8a823a816a1d78af8"

URI_x86_64_v2_bpftrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bpftrace-0.24.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_bpftrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bpftrace}"
SRC_URI[x86_64_v2_bpftrace.sha256sum] = "1711b7020ee6b2372eeb2cb71a1c517220173b730bedb5b167503866397d0fea"

URI_aarch64_bpftrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bpftrace-0.24.2-1.el10.aarch64.rpm;name=aarch64_bpftrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_bpftrace}"
SRC_URI[aarch64_bpftrace.sha256sum] = "908b45a454071e725cf17cf1a72733d9748a8c28d2432743f7553ef5a454a725"

RDEPENDS:bpftrace = " \
 bcc \
 clang-libs \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbpf \
 libgcc \
 libstdc++ \
 llvm-libs \
 zlib-ng-compat \
 "
