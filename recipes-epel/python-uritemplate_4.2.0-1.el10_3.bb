# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-uritemplate"
PV = "4.2.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-uritemplate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-uritemplate-4.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d23f9d8a7f8a04398254e15959ac3c76abe8ba752220f8663555dbb4e5944fb"

URI_x86_64_v2_python3-uritemplate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-uritemplate-4.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-uritemplate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-uritemplate}"
SRC_URI[x86_64_v2_python3-uritemplate.sha256sum] = "99cb903eca4672e8e5f9d85a7b08c3e5b3dc32301a755629d980b10f39b745af"

URI_aarch64_python3-uritemplate = "${EPEL_MIRROR}/aarch64/Packages/p/python3-uritemplate-4.2.0-1.el10_3.noarch.rpm;name=aarch64_python3-uritemplate;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-uritemplate}"
SRC_URI[aarch64_python3-uritemplate.sha256sum] = "cd7d4cdc9c8f8ec3e1b683c7b5f1835d4464781154b83e912102ccdd090ad41c"

RDEPENDS:python3-uritemplate = " \
 python3 \
 "
