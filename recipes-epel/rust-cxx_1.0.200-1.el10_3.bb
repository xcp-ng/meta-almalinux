# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx"
PV = "1.0.200"
PR = "1.el10_3"
PACKAGES = " \
 rust-cxx+alloc-devel \
 rust-cxx+c++14-devel \
 rust-cxx+c++17-devel \
 rust-cxx+c++20-devel \
 rust-cxx+default-devel \
 rust-cxx+std-devel \
 rust-cxx-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-1.0.200-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "21e7575b397e1df15c691ccd01a0033f5a737d40a2aa7a8f6978aa1002fe76d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+alloc-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxx+alloc-devel.sha256sum] = "8aaada7f125692e8b4912aff031dbb92954977ca92502d86b4f3ffcfca75acd2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++14-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++14-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxx+c++14-devel.sha256sum] = "2c908f1f928cb6b44f4c241b057ea90baab3a362191e3a8d48e3a9166870fec4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++17-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++17-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxx+c++17-devel.sha256sum] = "0b97bef093da9197d6088c77730a02dbb85950e9baf97fb96b0b09370039c07e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++20-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++20-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxx+c++20-devel.sha256sum] = "e75a9982aaad1f41bd11794e37cc4bd58a9419258e37341ca90fa64c21200c31"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+default-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxx+default-devel.sha256sum] = "d292261207394a98d972526ee10c0f114eaaee3f2585857f945567b3ecf2ce6a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+std-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxx+std-devel.sha256sum] = "3592956627f60018d6c8341df8a8e1d380406e77a3fb36584cc5610901bf3ec4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxx-devel.sha256sum] = "0a1d13ebe63def399b59a47d3d5ccf5771a9acd75564d095b7efc8e3fb7e306b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+alloc-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxx+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-cxx+alloc-devel.sha256sum] = "94b7d829b8355cd2835302fd9593941e4c0c58e2128a09951c520e822f611aaf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++14-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxx+c++14-devel;unpack=0"
SRC_URI[aarch64_rust-cxx+c++14-devel.sha256sum] = "cfd9c08cf7747b08dc7cadb0f0f41ba8e31e83e52dca9db14e9efe918cae17b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++17-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxx+c++17-devel;unpack=0"
SRC_URI[aarch64_rust-cxx+c++17-devel.sha256sum] = "9a334daf4775d5568a1da2662bd4bbdd172e650d569b3730bd69c40a608b2d6c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++20-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxx+c++20-devel;unpack=0"
SRC_URI[aarch64_rust-cxx+c++20-devel.sha256sum] = "071dfdd3e698f89f368cadba19caa9e5553f586f33441476371811f30235f71f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+default-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxx+default-devel;unpack=0"
SRC_URI[aarch64_rust-cxx+default-devel.sha256sum] = "a775c2e3e1d670a060c78147cc23c9f89088a18274b955569b24073dedcf7b4f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+std-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxx+std-devel;unpack=0"
SRC_URI[aarch64_rust-cxx+std-devel.sha256sum] = "e625e304a3b15476116b7f71b3a887bf5c5519b5bd743e0205eec15c1ba18d85"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxx-devel;unpack=0"
SRC_URI[aarch64_rust-cxx-devel.sha256sum] = "609eec16304419664d365198a5c0ca51c83998c1c86216d49cc6bf53d0e406b7"

RDEPENDS:rust-cxx+alloc-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++14-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++17-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++20-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+default-devel = " \
 cargo \
 rust-cxx+std-devel \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+std-devel = " \
 cargo \
 rust-cxx+alloc-devel \
 rust-cxx-devel \
 rust-foldhash+std-devel \
 "
RDEPENDS:rust-cxx-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-cxxbridge-flags-devel \
 rust-cxxbridge-macro+default-devel \
 rust-foldhash-devel \
 rust-link-cplusplus+default-devel \
 "
