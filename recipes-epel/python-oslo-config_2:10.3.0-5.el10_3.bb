# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslo-config"
PE = "2"
PV = "10.3.0"
PR = "5.el10_3"
PACKAGES = " \
 python-oslo-config-doc \
 python3-oslo-config \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-oslo-config-10.3.0-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "96c56ba4dc573897aba014ee9d8cbb311b0b37c5e4ce7c6b0692a575be66657f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-config-doc-10.3.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-config-doc;unpack=0"
SRC_URI[x86_64_v2_python-oslo-config-doc.sha256sum] = "d80252a78d68cbdb3fcb20d30f943cac8cc38a5f092c973824bf6aef357dc124"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-config-10.3.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-config;unpack=0"
SRC_URI[x86_64_v2_python3-oslo-config.sha256sum] = "7db18f38ee1edb0a01f31cf0dcd30ddc17b262daebb1e93317d2ecd424de82f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-config-doc-10.3.0-5.el10_3.noarch.rpm;name=aarch64_python-oslo-config-doc;unpack=0"
SRC_URI[aarch64_python-oslo-config-doc.sha256sum] = "ca2e959d7e2e08263754774c7e813bbb1192257f254fbc1fe7effac7044c0a33"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-config-10.3.0-5.el10_3.noarch.rpm;name=aarch64_python3-oslo-config;unpack=0"
SRC_URI[aarch64_python3-oslo-config.sha256sum] = "ea945a13d52967ded2a81b4d3e476134b2892e30445fda813d92ea00c397791c"

RDEPENDS:python-oslo-config-doc = " \
 "
RDEPENDS:python3-oslo-config = " \
 python3 \
 python3-netaddr \
 python3-oslo-i18n \
 python3-pyyaml \
 python3-requests \
 python3-rfc3986 \
 python3-stevedore \
 "
