# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kaccounts-integration"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kaccounts-integration-qt6 \
 kaccounts-integration-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kaccounts-integration-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2fbb68131d33c213a552205674bb9be08438e445613601da0df3b83b9d1890d"

URI_x86_64_v2_kaccounts-integration-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaccounts-integration-qt6-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaccounts-integration-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaccounts-integration-qt6}"
SRC_URI[x86_64_v2_kaccounts-integration-qt6.sha256sum] = "72af9cd96ae8e95324b15477dad1e0c823b8783709bd4ff85bfc7d81ba589668"

URI_x86_64_v2_kaccounts-integration-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaccounts-integration-qt6-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaccounts-integration-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaccounts-integration-qt6-devel}"
SRC_URI[x86_64_v2_kaccounts-integration-qt6-devel.sha256sum] = "08de45b78aafa3e7d565d94ad0ffd21edd364cc45ffc325f70330976c2000046"

URI_aarch64_kaccounts-integration-qt6 = "${EPEL_MIRROR}/aarch64/Packages/k/kaccounts-integration-qt6-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kaccounts-integration-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaccounts-integration-qt6}"
SRC_URI[aarch64_kaccounts-integration-qt6.sha256sum] = "edbe1c98d4a7514f29bb479c7ee95eba54e053ab7cdcf3d0c68efd88ebdc5365"

URI_aarch64_kaccounts-integration-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kaccounts-integration-qt6-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kaccounts-integration-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaccounts-integration-qt6-devel}"
SRC_URI[aarch64_kaccounts-integration-qt6-devel.sha256sum] = "f79fcda4ff31307f9ad9639b0d7d750c366eb67386389a790b1e8cba3f72ea23"

RDEPENDS:kaccounts-integration-qt6 = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwallet-libs \
 libaccounts-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 signon-qt6 \
 "
RDEPENDS:kaccounts-integration-qt6-devel = " \
 cmake-filesystem \
 intltool \
 kaccounts-integration-qt6 \
 kf6-kcoreaddons-devel \
 libaccounts-glib-devel \
 libaccounts-qt6-devel \
 qt6-qtbase-devel \
 signon-qt6-devel \
 "
