# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-ncw-swift"
PV = "1.0.52"
PR = "16.el10_0"
PACKAGES = " \
 golang-github-ncw-swift-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-ncw-swift-1.0.52-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12a2dadb6385768e4460131cdc541e8321ac3fc7de982ef0993d837d9def7eaf"

URI_x86_64_v2_golang-github-ncw-swift-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-ncw-swift-devel-1.0.52-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-ncw-swift-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-ncw-swift-devel}"
SRC_URI[x86_64_v2_golang-github-ncw-swift-devel.sha256sum] = "05e450c3f47c6d6ea913035bf6bbca4383cdaf69c5f59cb53543283b9d060772"

URI_aarch64_golang-github-ncw-swift-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-ncw-swift-devel-1.0.52-16.el10_0.noarch.rpm;name=aarch64_golang-github-ncw-swift-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-ncw-swift-devel}"
SRC_URI[aarch64_golang-github-ncw-swift-devel.sha256sum] = "bfc5d08525494bfc76362818a2c587a33114a7b5a9c9b2b207f3a3437cd5262a"

RDEPENDS:golang-github-ncw-swift-devel = " \
 go-filesystem \
 "
