# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strum_macros"
PV = "0.27.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-strum_macros+default-devel \
 rust-strum_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strum_macros-0.27.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "852ce229334999060bfd0bc8338c0d7c26da2c990ad9a46b7d46d72de80e16b4"

URI_x86_64_v2_rust-strum_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum_macros+default-devel-0.27.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum_macros+default-devel}"
SRC_URI[x86_64_v2_rust-strum_macros+default-devel.sha256sum] = "3de3b82c807db8f75b6c1d703ad22442da5381f6089495f5036b253bd9266c7e"

URI_x86_64_v2_rust-strum_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum_macros-devel-0.27.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum_macros-devel}"
SRC_URI[x86_64_v2_rust-strum_macros-devel.sha256sum] = "c65dc2bd58032f57fc3ffd0dc3028345826eee334022460e26e1d4e29a933b72"

URI_aarch64_rust-strum_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum_macros+default-devel-0.27.1-1.el10_1.noarch.rpm;name=aarch64_rust-strum_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum_macros+default-devel}"
SRC_URI[aarch64_rust-strum_macros+default-devel.sha256sum] = "ff9c06b87415352b1af30bf8e4a55708e1c4c82c0847412dbdb474d12bb30c5d"

URI_aarch64_rust-strum_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum_macros-devel-0.27.1-1.el10_1.noarch.rpm;name=aarch64_rust-strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum_macros-devel}"
SRC_URI[aarch64_rust-strum_macros-devel.sha256sum] = "d3c4c25aad5611a0d08dfcad5f1a4f12eea050ffe5c6791479e1abcf4922a548"

RDEPENDS:rust-strum_macros+default-devel = " \
 cargo \
 rust-strum_macros-devel \
 "
RDEPENDS:rust-strum_macros-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-rustversion+default-devel \
 rust-syn+default-devel \
 rust-syn+parsing-devel \
 "
