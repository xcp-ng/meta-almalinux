# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-crypto-api"
PV = "0.13.3"
PR = "32.el10_0"
PACKAGES = " \
 ghc-crypto-api \
 ghc-crypto-api-devel \
 ghc-crypto-api-doc \
 ghc-crypto-api-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-crypto-api-0.13.3-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0ece4761c4b9efa353d0cc3b026e4961e9c58d4f8429f4fcfd47b7ae0c9ee54"

URI_x86_64_v2_ghc-crypto-api = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypto-api-0.13.3-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypto-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypto-api}"
SRC_URI[x86_64_v2_ghc-crypto-api.sha256sum] = "76cb5fb56276853e7558bf5b28e452d4e2938af520a974f0cd6633555c743069"

URI_x86_64_v2_ghc-crypto-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypto-api-devel-0.13.3-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypto-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypto-api-devel}"
SRC_URI[x86_64_v2_ghc-crypto-api-devel.sha256sum] = "f7ffacbf89a395e7a55808368799e35d940fd11aa9923603285b1c21c4ee280c"

URI_x86_64_v2_ghc-crypto-api-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypto-api-doc-0.13.3-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-crypto-api-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypto-api-doc}"
SRC_URI[x86_64_v2_ghc-crypto-api-doc.sha256sum] = "eaa12d891f3d775c241fb54e36ce78e455822ba292af27f0b5a3c31ca64fd60e"

URI_x86_64_v2_ghc-crypto-api-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypto-api-prof-0.13.3-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypto-api-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypto-api-prof}"
SRC_URI[x86_64_v2_ghc-crypto-api-prof.sha256sum] = "63b9112dee0195d5910bb1964e40313357656a6081da8089e9172104d8b94393"

URI_aarch64_ghc-crypto-api = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypto-api-0.13.3-32.el10_0.aarch64.rpm;name=aarch64_ghc-crypto-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypto-api}"
SRC_URI[aarch64_ghc-crypto-api.sha256sum] = "614b42adb77e3b357ea7c5fe8cb3c6727107e7381ee14af72c851a525a067323"

URI_aarch64_ghc-crypto-api-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypto-api-devel-0.13.3-32.el10_0.aarch64.rpm;name=aarch64_ghc-crypto-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypto-api-devel}"
SRC_URI[aarch64_ghc-crypto-api-devel.sha256sum] = "1bac173f4508c67b0c20a1a5686a194da4a2d6b234c6097ce309899db064cacf"

URI_aarch64_ghc-crypto-api-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypto-api-doc-0.13.3-32.el10_0.noarch.rpm;name=aarch64_ghc-crypto-api-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypto-api-doc}"
SRC_URI[aarch64_ghc-crypto-api-doc.sha256sum] = "778003f7c5dc40c49e8a5c725e07b4cda0d2fc18c71bd8109110b5ec585a4ee6"

URI_aarch64_ghc-crypto-api-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypto-api-prof-0.13.3-32.el10_0.aarch64.rpm;name=aarch64_ghc-crypto-api-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypto-api-prof}"
SRC_URI[aarch64_ghc-crypto-api-prof.sha256sum] = "447ace396063cc427de3b7afa22826c6043a6f2591420c717c334eab839b4674"

RDEPENDS:ghc-crypto-api = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-cereal \
 ghc-containers \
 ghc-deepseq \
 ghc-entropy \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-tagged \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-crypto-api-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-cereal-devel \
 ghc-compiler \
 ghc-crypto-api \
 ghc-entropy-devel \
 ghc-tagged-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-crypto-api-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-crypto-api-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cereal-prof \
 ghc-crypto-api-devel \
 ghc-entropy-prof \
 ghc-tagged-prof \
 ghc-transformers-prof \
 "
