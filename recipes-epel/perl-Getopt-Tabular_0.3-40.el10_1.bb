# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Getopt-Tabular"
PV = "0.3"
PR = "40.el10_1"
PACKAGES = " \
 perl-Getopt-Tabular \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Getopt-Tabular-0.3-40.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6a727f6e62f153288887023130a9875743dcf7bc9ea8c3ea2dd55516d87783e"

URI_x86_64_v2_perl-Getopt-Tabular = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Getopt-Tabular-0.3-40.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Getopt-Tabular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Getopt-Tabular}"
SRC_URI[x86_64_v2_perl-Getopt-Tabular.sha256sum] = "2da748f8937db684c3f98b23075d1a214f83a4258d3d9e0b6dcc3194a97dcb56"

URI_aarch64_perl-Getopt-Tabular = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Getopt-Tabular-0.3-40.el10_1.noarch.rpm;name=aarch64_perl-Getopt-Tabular;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Getopt-Tabular}"
SRC_URI[aarch64_perl-Getopt-Tabular.sha256sum] = "a25e4b4dc853620e287e017eb96d0fe999a4903629f6af94a582d6cc8b1d2c9a"

RDEPENDS:perl-Getopt-Tabular = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
