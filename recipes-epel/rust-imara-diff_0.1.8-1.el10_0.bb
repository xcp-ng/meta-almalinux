# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-imara-diff"
PV = "0.1.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-imara-diff+default-devel \
 rust-imara-diff+unified_diff-devel \
 rust-imara-diff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-imara-diff-0.1.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8dee3e47941fdd6a2185f2e1524c0af728594f4285eaf34b902eda11787f5c47"

URI_x86_64_v2_rust-imara-diff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imara-diff+default-devel-0.1.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imara-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imara-diff+default-devel}"
SRC_URI[x86_64_v2_rust-imara-diff+default-devel.sha256sum] = "243e49b53aa8956b8f2e6659990bf53473d7fbf6de02c7d159afaab889f43ec3"

URI_x86_64_v2_rust-imara-diff+unified_diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imara-diff+unified_diff-devel-0.1.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imara-diff+unified_diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imara-diff+unified_diff-devel}"
SRC_URI[x86_64_v2_rust-imara-diff+unified_diff-devel.sha256sum] = "6a997eedcbae20c86f7997b975557690d7639c0f738fe96a5f38fe4b89422454"

URI_x86_64_v2_rust-imara-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imara-diff-devel-0.1.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imara-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imara-diff-devel}"
SRC_URI[x86_64_v2_rust-imara-diff-devel.sha256sum] = "1876999431cc712adc57fe8244a711915c1c856be1752fef925b0a06ccf8ba4f"

URI_aarch64_rust-imara-diff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imara-diff+default-devel-0.1.8-1.el10_0.noarch.rpm;name=aarch64_rust-imara-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imara-diff+default-devel}"
SRC_URI[aarch64_rust-imara-diff+default-devel.sha256sum] = "53cce504a17f3fad8744a7106f77057748cf6bcbb3cb4852bc778119b4853201"

URI_aarch64_rust-imara-diff+unified_diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imara-diff+unified_diff-devel-0.1.8-1.el10_0.noarch.rpm;name=aarch64_rust-imara-diff+unified_diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imara-diff+unified_diff-devel}"
SRC_URI[aarch64_rust-imara-diff+unified_diff-devel.sha256sum] = "38f2425b4967448ee685e8295e74ec02c3d8776486b935ea23476c7c9d4938dc"

URI_aarch64_rust-imara-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imara-diff-devel-0.1.8-1.el10_0.noarch.rpm;name=aarch64_rust-imara-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imara-diff-devel}"
SRC_URI[aarch64_rust-imara-diff-devel.sha256sum] = "20fbae17447a06f2e39fbe9b8e2b5fd025f1f117230722a477b3fe8ed2d9a595"

RDEPENDS:rust-imara-diff+default-devel = " \
 cargo \
 rust-imara-diff+unified_diff-devel \
 rust-imara-diff-devel \
 "
RDEPENDS:rust-imara-diff+unified_diff-devel = " \
 cargo \
 rust-imara-diff-devel \
 "
RDEPENDS:rust-imara-diff-devel = " \
 cargo \
 rust \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown-devel \
 "
