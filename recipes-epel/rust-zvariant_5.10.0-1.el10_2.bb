# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zvariant"
PV = "5.10.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-zvariant+arrayvec-devel \
 rust-zvariant+camino-devel \
 rust-zvariant+chrono-devel \
 rust-zvariant+default-devel \
 rust-zvariant+enumflags2-devel \
 rust-zvariant+gvariant-devel \
 rust-zvariant+option-as-array-devel \
 rust-zvariant+ostree-tests-devel \
 rust-zvariant+serde_bytes-devel \
 rust-zvariant+time-devel \
 rust-zvariant+url-devel \
 rust-zvariant+uuid-devel \
 rust-zvariant-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zvariant-5.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e46c753f760059004a8580862523e1b46de9b17ddce506cd6cf1d6abf1b19e9d"

URI_x86_64_v2_rust-zvariant+arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+arrayvec-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+arrayvec-devel}"
SRC_URI[x86_64_v2_rust-zvariant+arrayvec-devel.sha256sum] = "52e4824f7cb623c97c005e72abfe5f267975a37d2794b210a6b09e6b84a038dd"

URI_x86_64_v2_rust-zvariant+camino-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+camino-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+camino-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+camino-devel}"
SRC_URI[x86_64_v2_rust-zvariant+camino-devel.sha256sum] = "c45c61e3d4a99dc8facc24d1b31b8fce513a2d5ce64af384649e63755451535c"

URI_x86_64_v2_rust-zvariant+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+chrono-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+chrono-devel}"
SRC_URI[x86_64_v2_rust-zvariant+chrono-devel.sha256sum] = "a338514a0ca763a735cfc159b638f504646a17d0fc0609bf18fc2c22bff13d20"

URI_x86_64_v2_rust-zvariant+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+default-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+default-devel}"
SRC_URI[x86_64_v2_rust-zvariant+default-devel.sha256sum] = "e79e06489aa2a2e966d4d5df30944f1f638f61c11467d43577f3a0e54d558da4"

URI_x86_64_v2_rust-zvariant+enumflags2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+enumflags2-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+enumflags2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+enumflags2-devel}"
SRC_URI[x86_64_v2_rust-zvariant+enumflags2-devel.sha256sum] = "77d3ceabedeeba4c7fcc0a7cb35aa29035c2beab882b6397f9fc74861d9807d0"

URI_x86_64_v2_rust-zvariant+gvariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+gvariant-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+gvariant-devel}"
SRC_URI[x86_64_v2_rust-zvariant+gvariant-devel.sha256sum] = "a48b72bc2b0c614508a30f099189aa110a32e7bca8480eb8f38b42f2ece4a629"

URI_x86_64_v2_rust-zvariant+option-as-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+option-as-array-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+option-as-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+option-as-array-devel}"
SRC_URI[x86_64_v2_rust-zvariant+option-as-array-devel.sha256sum] = "48f51e1692be9f64a4037865468773ca9eb2754ae0a7a5c6627bfc3f0b3c544b"

URI_x86_64_v2_rust-zvariant+ostree-tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+ostree-tests-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+ostree-tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+ostree-tests-devel}"
SRC_URI[x86_64_v2_rust-zvariant+ostree-tests-devel.sha256sum] = "16779cfe3fbd3966234c6607548d965e0ebe6f54db4103fb9c33025f0fc2179c"

URI_x86_64_v2_rust-zvariant+serde_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+serde_bytes-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+serde_bytes-devel}"
SRC_URI[x86_64_v2_rust-zvariant+serde_bytes-devel.sha256sum] = "77c7b98ed0b6716fb9cdd1e598d5bdf1d690fc77600c7191e4a04606026484cc"

URI_x86_64_v2_rust-zvariant+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+time-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+time-devel}"
SRC_URI[x86_64_v2_rust-zvariant+time-devel.sha256sum] = "15c4723d6a676cd97029bec25f8114ce5784aad200961d9ad46bbfbb5b8aefb8"

URI_x86_64_v2_rust-zvariant+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+url-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+url-devel}"
SRC_URI[x86_64_v2_rust-zvariant+url-devel.sha256sum] = "e746bc85ecc8281807546ff742b59593a4b82eebf1b593891432d24bd6ffa0ee"

URI_x86_64_v2_rust-zvariant+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+uuid-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+uuid-devel}"
SRC_URI[x86_64_v2_rust-zvariant+uuid-devel.sha256sum] = "e66999f17f26bfcc307e098e82c2d385c5b681d745c66005cfa31aedd081ea99"

URI_x86_64_v2_rust-zvariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant-devel}"
SRC_URI[x86_64_v2_rust-zvariant-devel.sha256sum] = "8db9911bc5ca68befbe9d5b8a5bd3e4d887bdb01bc4805f4fe1c0d5cfcdc9a84"

URI_aarch64_rust-zvariant+arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+arrayvec-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+arrayvec-devel}"
SRC_URI[aarch64_rust-zvariant+arrayvec-devel.sha256sum] = "c21a1b0245cf7789eb0959620753fdb4172bd4c237dc7a951ff6232360839e6e"

URI_aarch64_rust-zvariant+camino-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+camino-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant+camino-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+camino-devel}"
SRC_URI[aarch64_rust-zvariant+camino-devel.sha256sum] = "4749b6e334b9bf62591be8f1a9b1d5c39c57b1f783c3da8a9006788f8a871d1c"

URI_aarch64_rust-zvariant+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+chrono-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+chrono-devel}"
SRC_URI[aarch64_rust-zvariant+chrono-devel.sha256sum] = "13040c85535de19e0e8507e733f9f69db2ac6a8cecf31d138cc117abbac813bf"

URI_aarch64_rust-zvariant+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+default-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+default-devel}"
SRC_URI[aarch64_rust-zvariant+default-devel.sha256sum] = "3168a7e5309e56e7066736a94fe5d0e7eaeb99a2b8acb917097f74e57c7c2e2d"

URI_aarch64_rust-zvariant+enumflags2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+enumflags2-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant+enumflags2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+enumflags2-devel}"
SRC_URI[aarch64_rust-zvariant+enumflags2-devel.sha256sum] = "4241421080905a66ad1abc49fd9aff7128f2ef6b566fc71e980aca39ed0ddf35"

URI_aarch64_rust-zvariant+gvariant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+gvariant-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+gvariant-devel}"
SRC_URI[aarch64_rust-zvariant+gvariant-devel.sha256sum] = "50ea13993f055de260eabd67d6e2479c9dc33643481a0ef5c5a172fab9090202"

URI_aarch64_rust-zvariant+option-as-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+option-as-array-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant+option-as-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+option-as-array-devel}"
SRC_URI[aarch64_rust-zvariant+option-as-array-devel.sha256sum] = "703ba23e050f14bb848b94f11a706fdf1d7b559dd621ede54eeadaa693ffd4ca"

URI_aarch64_rust-zvariant+ostree-tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+ostree-tests-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant+ostree-tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+ostree-tests-devel}"
SRC_URI[aarch64_rust-zvariant+ostree-tests-devel.sha256sum] = "697cc0da2779d15ffc62ae1e39a1446559247af4459531b97bbd755fca484a75"

URI_aarch64_rust-zvariant+serde_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+serde_bytes-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+serde_bytes-devel}"
SRC_URI[aarch64_rust-zvariant+serde_bytes-devel.sha256sum] = "b9ae1a4618c2b6e94cbb15cad00674eba56824b8ed1bd87e9f84484d7006ac39"

URI_aarch64_rust-zvariant+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+time-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+time-devel}"
SRC_URI[aarch64_rust-zvariant+time-devel.sha256sum] = "14883f4609d502036a61329056d11827e003c8c01b696c0510c31672d9fc9d00"

URI_aarch64_rust-zvariant+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+url-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+url-devel}"
SRC_URI[aarch64_rust-zvariant+url-devel.sha256sum] = "2edadb4d05b923010194b85051a70da291829450536e3fea67d76017c455bfb2"

URI_aarch64_rust-zvariant+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+uuid-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+uuid-devel}"
SRC_URI[aarch64_rust-zvariant+uuid-devel.sha256sum] = "2d926d334abd17cc3fdd747c406f7b2e5fb9ad4737983d35e44c6c0e5cabdd9f"

URI_aarch64_rust-zvariant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant-devel}"
SRC_URI[aarch64_rust-zvariant-devel.sha256sum] = "5a560d955455df80388c307ac0fc8f6f6a52c5d96521663945ca3533609b7d03"

RDEPENDS:rust-zvariant+arrayvec-devel = " \
 cargo \
 rust-arrayvec+default-devel \
 rust-arrayvec+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+camino-devel = " \
 cargo \
 rust-camino+default-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+chrono-devel = " \
 cargo \
 rust-chrono+serde-devel \
 rust-chrono-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+default-devel = " \
 cargo \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+enumflags2-devel = " \
 cargo \
 rust-enumflags2+default-devel \
 rust-enumflags2+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+gvariant-devel = " \
 cargo \
 rust-zvariant-devel \
 rust-zvariant_derive+gvariant-devel \
 rust-zvariant_utils+gvariant-devel \
 "
RDEPENDS:rust-zvariant+option-as-array-devel = " \
 cargo \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+ostree-tests-devel = " \
 cargo \
 rust-zvariant+gvariant-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+serde_bytes-devel = " \
 cargo \
 rust-serde_bytes+default-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+time-devel = " \
 cargo \
 rust-time+default-devel \
 rust-time+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+url-devel = " \
 cargo \
 rust-url+default-devel \
 rust-url+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+uuid-devel = " \
 cargo \
 rust-uuid+default-devel \
 rust-uuid+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant-devel = " \
 cargo \
 rust \
 rust-endi+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-winnow+default-devel \
 rust-zvariant_derive+default-devel \
 rust-zvariant_utils+default-devel \
 "
