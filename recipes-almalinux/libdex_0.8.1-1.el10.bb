# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdex"
PV = "0.8.1"
PR = "1.el10"
PACKAGES = " \
 libdex \
 libdex-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libdex-0.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6793cc18eb353865591985b5e7ccd1d2c0fe025aedce219bbb579665ba4db3e5"

URI_x86_64_v2_libdex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libdex-0.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libdex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdex}"
SRC_URI[x86_64_v2_libdex.sha256sum] = "12ba0cd2e87bc54c1f3704c02f5b79547d00fd1c564dd925e991bc176b775062"

URI_x86_64_v2_libdex-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdex-devel-0.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libdex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdex-devel}"
SRC_URI[x86_64_v2_libdex-devel.sha256sum] = "0e4ecbc3122c7ba05d77b2a09fc54b62236520346cfeb8873b8f8102223eae89"

URI_aarch64_libdex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libdex-0.8.1-1.el10.aarch64.rpm;name=aarch64_libdex;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdex}"
SRC_URI[aarch64_libdex.sha256sum] = "78465e807681e1feb491b1d04dee356d4eff65b437eeff6bd8ad2ed0745537f6"

URI_aarch64_libdex-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdex-devel-0.8.1-1.el10.aarch64.rpm;name=aarch64_libdex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdex-devel}"
SRC_URI[aarch64_libdex-devel.sha256sum] = "50107f43f777a4cc59541c49235d181b75e223c7077fb8ddba305c23cdb102e0"

RDEPENDS:libdex = " \
 glib2 \
 glibc \
 libatomic \
 libgcc \
 liburing \
 "
RDEPENDS:libdex-devel = " \
 glib2-devel \
 libdex \
 pkgconf-pkg-config \
 "
