# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-compat53"
PV = "0.7"
PR = "8.el10_0"
PACKAGES = " \
 lua5.1-compat53 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-compat53-0.7-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "896d48d7553ae242c7718a576e18044e8f1e257a104a844ec35157cc151f4619"

URI_x86_64_v2_lua5.1-compat53 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-compat53-0.7-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua5.1-compat53;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-compat53}"
SRC_URI[x86_64_v2_lua5.1-compat53.sha256sum] = "001f8f44369d3ab6cfc88791fda1efb009c517d5512f0401fa6b6beaa1ef7d8d"

URI_aarch64_lua5.1-compat53 = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-compat53-0.7-8.el10_0.aarch64.rpm;name=aarch64_lua5.1-compat53;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-compat53}"
SRC_URI[aarch64_lua5.1-compat53.sha256sum] = "6bacdab1cba2f9834b2d63b259ce3d10ec870df007217a71f1fe0d5c5b288b12"

RDEPENDS:lua5.1-compat53 = " \
 compat-lua-libs \
 glibc \
 "
