# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-robotframework"
PV = "7.1.1"
PR = "3.el10_1"
PACKAGES = " \
 python3-robotframework \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-robotframework-7.1.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e84bacefd72ce59c277cc5c164962b893adc662fc937bee2abaacc33808ecbd6"

URI_x86_64_v2_python3-robotframework = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-robotframework-7.1.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-robotframework;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-robotframework}"
SRC_URI[x86_64_v2_python3-robotframework.sha256sum] = "999d892eaaa60f5a38f797539f6792471f4c8cd9aab2b981ece3f032c45d3fa3"

URI_aarch64_python3-robotframework = "${EPEL_MIRROR}/aarch64/Packages/p/python3-robotframework-7.1.1-3.el10_1.noarch.rpm;name=aarch64_python3-robotframework;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-robotframework}"
SRC_URI[aarch64_python3-robotframework.sha256sum] = "a06054218f5423566b3784bf15f46d29c285796b1246589714d82c64d6b79f97"

RDEPENDS:python3-robotframework = " \
 python3 \
 "
