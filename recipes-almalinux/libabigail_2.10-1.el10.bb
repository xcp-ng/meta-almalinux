# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libabigail"
PV = "2.10"
PR = "1.el10"
PACKAGES = " \
 libabigail \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/libabigail-2.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b590813716c71997fe744d0c1368eaef916d17086b86ccae51974b53e7b59cf7"

URI_x86_64_v2_libabigail = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libabigail-2.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libabigail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libabigail}"
SRC_URI[x86_64_v2_libabigail.sha256sum] = "33a95f27863039f63969af1a48e0548f60f1f65379019eee34f7f5cef7dc4d0b"

URI_aarch64_libabigail = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libabigail-2.10-1.el10.aarch64.rpm;name=aarch64_libabigail;unpack=0"
SRC_URI:append = " ${URI_aarch64_libabigail}"
SRC_URI[aarch64_libabigail.sha256sum] = "40e334da58279f0cbcbbabfce8c74a770fc8ec32ab04f2957a9c7bfb3d2785a7"

RDEPENDS:libabigail = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbpf \
 libgcc \
 libstdc++ \
 libxml2 \
 virtual/libctf.so.0_LIBCTF_1.0__64bit_ \
 virtual/libctf.so.0_LIBCTF_1.1__64bit_ \
 virtual/libctf.so.0_LIBCTF_1.2__64bit_ \
 virtual/libctf.so.0___64bit_ \
 xz-libs \
 "
