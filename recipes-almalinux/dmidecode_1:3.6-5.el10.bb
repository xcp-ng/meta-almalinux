# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dmidecode"
PE = "1"
PV = "3.6"
PR = "5.el10"
PACKAGES = " \
 dmidecode \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dmidecode-3.6-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94dfcc9da7f6d9b0bdcce15c6b7ae0139ad2876a887ed62804cc2f4676172aad"

URI_x86_64_v2_dmidecode = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dmidecode-3.6-5.el10.x86_64_v2.rpm;name=x86_64_v2_dmidecode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dmidecode}"
SRC_URI[x86_64_v2_dmidecode.sha256sum] = "d723aa694ed013555af0a240ee589443fdbd2b14a4e93371106590537e794b1e"

URI_aarch64_dmidecode = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dmidecode-3.6-5.el10.aarch64.rpm;name=aarch64_dmidecode;unpack=0"
SRC_URI:append = " ${URI_aarch64_dmidecode}"
SRC_URI[aarch64_dmidecode.sha256sum] = "609012c6d8a388bf5445f13437d1992640588f4c73cd538d0cd77ecb07b405df"

RDEPENDS:dmidecode = " \
 glibc \
 "
