# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "neochat"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 neochat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/neochat-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6cf4f2397873a7404fb7b7750fe463d3bbc0616f2dddf45c16c4334a5b72ccf2"

URI_x86_64_v2_neochat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/neochat-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_neochat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_neochat}"
SRC_URI[x86_64_v2_neochat.sha256sum] = "c28ba47151e1a1b29645f921b03273d19caf207ecd2533e390a3a2513397f2dc"

URI_aarch64_neochat = "${EPEL_MIRROR}/aarch64/Packages/n/neochat-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_neochat;unpack=0"
SRC_URI:append = " ${URI_aarch64_neochat}"
SRC_URI[aarch64_neochat.sha256sum] = "d3c8087915c58a303896d2566dfb2ed1eddc9b293bedebec040ea58df43de8d4"

RDEPENDS:neochat = " \
 breeze-icon-theme \
 cmark-lib \
 glibc \
 hicolor-icon-theme \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kquickcharts \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kf6-prison \
 kf6-purpose \
 kf6-qqc2-desktop-style \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kquickimageeditor-qt6 \
 kunifiedpush \
 libicu \
 libquotient-qt6 \
 libstdc++ \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qt6-qtspeech \
 qt6-qtwebview \
 qtkeychain-qt6 \
 "
