# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libktorrent"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 libktorrent \
 libktorrent-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libktorrent-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d10a6d3415b28dba36694bf055ef9c903cb1fd538bbbd1ce94aa3a3934a5d53f"

URI_x86_64_v2_libktorrent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libktorrent-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libktorrent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libktorrent}"
SRC_URI[x86_64_v2_libktorrent.sha256sum] = "c43bb2b439128e1ef6e2e5e59e98557a0d389dfa1b0bf3f677e617386373fe2b"

URI_x86_64_v2_libktorrent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libktorrent-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libktorrent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libktorrent-devel}"
SRC_URI[x86_64_v2_libktorrent-devel.sha256sum] = "5890cf9cd35a87552442c0117c8c0ac0964d4afcd9f5dfeb66f3772327d17a80"

URI_aarch64_libktorrent = "${EPEL_MIRROR}/aarch64/Packages/l/libktorrent-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libktorrent;unpack=0"
SRC_URI:append = " ${URI_aarch64_libktorrent}"
SRC_URI[aarch64_libktorrent.sha256sum] = "4e44181674f5175791c7e26aa88a7f526cd2e50214179ddcbe47856ef90c4e3a"

URI_aarch64_libktorrent-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libktorrent-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libktorrent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libktorrent-devel}"
SRC_URI[aarch64_libktorrent-devel.sha256sum] = "79e63b5a1589fea4a1464181113a490d1912afa72562d44866addc207d516f77"

RDEPENDS:libktorrent = " \
 glibc \
 gmp \
 kf6-karchive \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libgcc \
 libgcrypt \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 "
RDEPENDS:libktorrent-devel = " \
 boost-devel \
 cmake-filesystem \
 gmp-devel \
 kf6-karchive-devel \
 kf6-kconfig-devel \
 kf6-kio-devel \
 libgcrypt-devel \
 libktorrent \
 qt6-qtbase-devel \
 "
