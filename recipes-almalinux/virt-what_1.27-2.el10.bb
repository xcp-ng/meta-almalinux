# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virt-what"
PV = "1.27"
PR = "2.el10"
PACKAGES = " \
 virt-what \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/virt-what-1.27-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10f849a7757dff987f4bc6383ad381e6c5142ba240d61910d7faf15524fed174"

URI_x86_64_v2_virt-what = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/virt-what-1.27-2.el10.x86_64_v2.rpm;name=x86_64_v2_virt-what;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-what}"
SRC_URI[x86_64_v2_virt-what.sha256sum] = "0b6365c2211fcb965e0824140b22f562b3e52443fbed3ebbb0b42d3548ade911"

URI_aarch64_virt-what = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/virt-what-1.27-2.el10.aarch64.rpm;name=aarch64_virt-what;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-what}"
SRC_URI[aarch64_virt-what.sha256sum] = "f970046e3e0b0d36c844d59c5dbbbe0311219211eeac892363f9ff27cc772ab0"

RDEPENDS:virt-what = " \
 bash \
 dmidecode \
 glibc \
 util-linux \
 which \
 "
