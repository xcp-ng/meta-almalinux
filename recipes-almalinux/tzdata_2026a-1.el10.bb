# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tzdata"
PV = "2026a"
PR = "1.el10"
PACKAGES = " \
 tzdata \
 tzdata-java \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tzdata-2026a-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02cd30f12c22ee8a4d5f1e0fc72cdf5062326ea9673b051e9b81a35d1cd3746a"

URI_x86_64_v2_tzdata = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tzdata-2026a-1.el10.noarch.rpm;name=x86_64_v2_tzdata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tzdata}"
SRC_URI[x86_64_v2_tzdata.sha256sum] = "b61ebfa25b9fb43bd8fc184e867cb6940ef676515eb742e00e4c7eb5a1718605"

URI_x86_64_v2_tzdata-java = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tzdata-java-2026a-1.el10.noarch.rpm;name=x86_64_v2_tzdata-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tzdata-java}"
SRC_URI[x86_64_v2_tzdata-java.sha256sum] = "cd2a74ae546ed51e3c15fbb951a7ef3f7d64b6eba3ecf197330c18bb4d7c9cac"

URI_aarch64_tzdata = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tzdata-2026a-1.el10.noarch.rpm;name=aarch64_tzdata;unpack=0"
SRC_URI:append = " ${URI_aarch64_tzdata}"
SRC_URI[aarch64_tzdata.sha256sum] = "b61ebfa25b9fb43bd8fc184e867cb6940ef676515eb742e00e4c7eb5a1718605"

URI_aarch64_tzdata-java = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tzdata-java-2026a-1.el10.noarch.rpm;name=aarch64_tzdata-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_tzdata-java}"
SRC_URI[aarch64_tzdata-java.sha256sum] = "cd2a74ae546ed51e3c15fbb951a7ef3f7d64b6eba3ecf197330c18bb4d7c9cac"

RDEPENDS:tzdata = " \
 "
RDEPENDS:tzdata-java = " \
 "
