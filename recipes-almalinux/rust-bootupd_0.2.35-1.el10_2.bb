# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bootupd"
PV = "0.2.35"
PR = "1.el10_2"
PACKAGES = " \
 bootupd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-bootupd-0.2.35-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b633514427f4d4bbd2b7abbbb2a7c3e3c86b92cae90cf28304be0a0f9c8d4c7"

URI_x86_64_v2_bootupd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bootupd-0.2.35-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_bootupd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bootupd}"
SRC_URI[x86_64_v2_bootupd.sha256sum] = "70b5b381963e83d3c0279e170beb48cf64c1ac8596fb000a28ca31a5e4aa878b"

URI_aarch64_bootupd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bootupd-0.2.35-1.el10_2.aarch64.rpm;name=aarch64_bootupd;unpack=0"
SRC_URI:append = " ${URI_aarch64_bootupd}"
SRC_URI[aarch64_bootupd.sha256sum] = "c483c60b5c1f45c601af7eb74ed035be26e95382c17f12b60d1038ebfecf28af"

RDEPENDS:bootupd = " \
 glibc \
 libgcc \
 openssl-libs \
 systemd \
 "
