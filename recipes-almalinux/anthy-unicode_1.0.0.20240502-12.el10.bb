# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "anthy-unicode"
PV = "1.0.0.20240502"
PR = "12.el10"
PACKAGES = " \
 anthy-unicode \
 anthy-unicode-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/anthy-unicode-1.0.0.20240502-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c43761e03bf3a50a2a547e6a4aec70ca8257ead533dbd18a958c041d46a464e2"

URI_x86_64_v2_anthy-unicode = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anthy-unicode-1.0.0.20240502-12.el10.x86_64_v2.rpm;name=x86_64_v2_anthy-unicode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anthy-unicode}"
SRC_URI[x86_64_v2_anthy-unicode.sha256sum] = "af596386f79462869ecc4833fa0f9974c60bd42a907584f83b7b4b1b720b989a"

URI_x86_64_v2_anthy-unicode-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/anthy-unicode-devel-1.0.0.20240502-12.el10.x86_64_v2.rpm;name=x86_64_v2_anthy-unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anthy-unicode-devel}"
SRC_URI[x86_64_v2_anthy-unicode-devel.sha256sum] = "a3072c5a819cb2fece678cd324ccb18ef5ba27f56a259431a230ae3ab00956f2"

URI_aarch64_anthy-unicode = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anthy-unicode-1.0.0.20240502-12.el10.aarch64.rpm;name=aarch64_anthy-unicode;unpack=0"
SRC_URI:append = " ${URI_aarch64_anthy-unicode}"
SRC_URI[aarch64_anthy-unicode.sha256sum] = "b3fb66f37ee5fc59b717043aedb6158937a01754af8b1ef651da3e2e428f0c92"

URI_aarch64_anthy-unicode-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/anthy-unicode-devel-1.0.0.20240502-12.el10.aarch64.rpm;name=aarch64_anthy-unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_anthy-unicode-devel}"
SRC_URI[aarch64_anthy-unicode-devel.sha256sum] = "747df8ef695abaf53d6ceece5796a5419a226cb08021584bbea07d0f02908ea4"

RDEPENDS:anthy-unicode = " \
 glibc \
 "
RDEPENDS:anthy-unicode-devel = " \
 anthy-unicode \
 pkgconf-pkg-config \
 "
