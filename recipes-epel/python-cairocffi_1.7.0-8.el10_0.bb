# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cairocffi"
PV = "1.7.0"
PR = "8.el10_0"
PACKAGES = " \
 python3-cairocffi \
 python3-cairocffi+xcb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cairocffi-1.7.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcac4b1a24e6f4451abd0a17352c380ab3131a93bcbeca98b8b7ac8fa0adc426"

URI_x86_64_v2_python3-cairocffi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cairocffi-1.7.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cairocffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cairocffi}"
SRC_URI[x86_64_v2_python3-cairocffi.sha256sum] = "175f147f284618969cd49b8c7d2d7341610d7ba6b1be856d6e4aed95d7f8ee2c"

URI_x86_64_v2_python3-cairocffi+xcb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cairocffi+xcb-1.7.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cairocffi+xcb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cairocffi+xcb}"
SRC_URI[x86_64_v2_python3-cairocffi+xcb.sha256sum] = "396714f96e5ba53ac3ad42318dee63370fd13ed3380e7af6efdaa168751c9b45"

URI_aarch64_python3-cairocffi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cairocffi-1.7.0-8.el10_0.noarch.rpm;name=aarch64_python3-cairocffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cairocffi}"
SRC_URI[aarch64_python3-cairocffi.sha256sum] = "781db592fdd8afb8d2b5011a4f37ec9621d0073c3dbf25e0e7087c376d3097df"

URI_aarch64_python3-cairocffi+xcb = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cairocffi+xcb-1.7.0-8.el10_0.noarch.rpm;name=aarch64_python3-cairocffi+xcb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cairocffi+xcb}"
SRC_URI[aarch64_python3-cairocffi+xcb.sha256sum] = "d0308d89599b93a87f5cbf33101eeb42b7ce7d4bf80c203b9a534340ffaccb41"

RDEPENDS:python3-cairocffi = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 gtk3 \
 python3 \
 python3-cffi \
 "
RDEPENDS:python3-cairocffi+xcb = " \
 python3 \
 python3-cairocffi \
 python3-xcffib \
 "
