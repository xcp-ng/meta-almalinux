# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rapidyaml"
PV = "0.7.2"
PR = "8.el10_2"
PACKAGES = " \
 python3-rapidyaml \
 rapidyaml \
 rapidyaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rapidyaml-0.7.2-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9694647d47a4a613f2871325e7095e3ce9aefedddcc35889604736aa5dd7bc64"

URI_x86_64_v2_python3-rapidyaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rapidyaml-0.7.2-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-rapidyaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rapidyaml}"
SRC_URI[x86_64_v2_python3-rapidyaml.sha256sum] = "4f4283be3fea529b8d2e607217d1def8efda87ece238adcda22462e4c31f9773"

URI_x86_64_v2_rapidyaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rapidyaml-0.7.2-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rapidyaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rapidyaml}"
SRC_URI[x86_64_v2_rapidyaml.sha256sum] = "fcef8edd50039894d7703f1c12d97770e93b9fa132fa162f3b65d6ef608cd931"

URI_x86_64_v2_rapidyaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rapidyaml-devel-0.7.2-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rapidyaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rapidyaml-devel}"
SRC_URI[x86_64_v2_rapidyaml-devel.sha256sum] = "532d325c31b5ee5dc9d53fdeeee910dc8e22682b49f1a274b35ff65c2d71d6b5"

URI_aarch64_python3-rapidyaml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rapidyaml-0.7.2-8.el10_2.aarch64.rpm;name=aarch64_python3-rapidyaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rapidyaml}"
SRC_URI[aarch64_python3-rapidyaml.sha256sum] = "eac4e8412bc7e6d83f1cd4af401192b7df91f9b1c4b7350e013a89c4cd398673"

URI_aarch64_rapidyaml = "${EPEL_MIRROR}/aarch64/Packages/r/rapidyaml-0.7.2-8.el10_2.aarch64.rpm;name=aarch64_rapidyaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_rapidyaml}"
SRC_URI[aarch64_rapidyaml.sha256sum] = "c68b7ab1a65f181dceda42fa0207a4cc05a23c86f3451b4e59b6e405435db110"

URI_aarch64_rapidyaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rapidyaml-devel-0.7.2-8.el10_2.aarch64.rpm;name=aarch64_rapidyaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rapidyaml-devel}"
SRC_URI[aarch64_rapidyaml-devel.sha256sum] = "306a403dc7f4d62ad201dc3dd37eca9dc165ef2811a2983beb670c06f488582a"

RDEPENDS:python3-rapidyaml = " \
 c4core \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-deprecation \
 "
RDEPENDS:rapidyaml = " \
 c4core \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:rapidyaml-devel = " \
 c4core-devel \
 cmake-filesystem \
 rapidyaml \
 "
