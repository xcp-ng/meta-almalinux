# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "massif-visualizer"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 massif-visualizer \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/massif-visualizer-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4f6eb3b743163e4a23093ecbaa5edd287809817b36bef52d822e133234388f6e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/massif-visualizer-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_massif-visualizer;unpack=0"
SRC_URI[x86_64_v2_massif-visualizer.sha256sum] = "d49447e86c7a8886270740f33d4f18e37af8416db223fc09c1038cc2fef0358d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/massif-visualizer-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_massif-visualizer;unpack=0"
SRC_URI[aarch64_massif-visualizer.sha256sum] = "2223eaf871bfe2d1189a035d6522a5c266615b368ae59c0b63a2bfe9075fda29"

RDEPENDS:massif-visualizer = " \
 glibc \
 kdiagram \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
