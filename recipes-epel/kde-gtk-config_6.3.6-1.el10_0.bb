# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-gtk-config"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kde-gtk-config \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-gtk-config-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "638bfdd742eb731189409d757a9fbe78c59e1ec50e4ece7cade718b1d37a5157"

URI_x86_64_v2_kde-gtk-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-gtk-config-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-gtk-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-gtk-config}"
SRC_URI[x86_64_v2_kde-gtk-config.sha256sum] = "4794630106829c528986e340f7e667566b3f304a49fbb823f5ea5b180b185e73"

URI_aarch64_kde-gtk-config = "${EPEL_MIRROR}/aarch64/Packages/k/kde-gtk-config-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kde-gtk-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-gtk-config}"
SRC_URI[aarch64_kde-gtk-config.sha256sum] = "237e8d6c1abe2f94715caf824da066203496659b1f773d86df6e09392a0c088b"

RDEPENDS:kde-gtk-config = " \
 bash \
 breeze-gtk-common \
 glib2 \
 glibc \
 gtk3 \
 kde-cli-tools \
 kdecoration \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
