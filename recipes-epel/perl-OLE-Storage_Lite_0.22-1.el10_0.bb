# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-OLE-Storage_Lite"
PV = "0.22"
PR = "1.el10_0"
PACKAGES = " \
 perl-OLE-Storage_Lite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-OLE-Storage_Lite-0.22-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc26284c9f181a9f0de8446c310b6d74cec29809be79b67b3988a3d0376bc4d2"

URI_x86_64_v2_perl-OLE-Storage_Lite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-OLE-Storage_Lite-0.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-OLE-Storage_Lite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-OLE-Storage_Lite}"
SRC_URI[x86_64_v2_perl-OLE-Storage_Lite.sha256sum] = "6c268c8eccc7ff2755702696e0315e35b3efa66e1247858aecaea743b10a0d2f"

URI_aarch64_perl-OLE-Storage_Lite = "${EPEL_MIRROR}/aarch64/Packages/p/perl-OLE-Storage_Lite-0.22-1.el10_0.noarch.rpm;name=aarch64_perl-OLE-Storage_Lite;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-OLE-Storage_Lite}"
SRC_URI[aarch64_perl-OLE-Storage_Lite.sha256sum] = "a7117a5a1200e2fa2cd7ff05c458f547ff08426ddee088e1701b63dc6d4148b1"

RDEPENDS:perl-OLE-Storage_Lite = " \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-IO \
 perl-IO-stringy \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-Time-Local \
 perl-constant \
 perl-libs \
 perl-vars \
 "
