# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-hvac"
PV = "2.3.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-hvac \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-hvac-2.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f8bbb143e0f9fb55ec8c3254d5da1c63bc1f3ca9f03cdf030666b9c7a78a7fe"

URI_x86_64_v2_python3-hvac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hvac-2.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hvac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hvac}"
SRC_URI[x86_64_v2_python3-hvac.sha256sum] = "29ad682bcb5ce1f7c8ea1cdafa52840c9500a377983b7758375d65b5bfa99b1b"

URI_aarch64_python3-hvac = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hvac-2.3.0-1.el10_0.noarch.rpm;name=aarch64_python3-hvac;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hvac}"
SRC_URI[aarch64_python3-hvac.sha256sum] = "6310600ba8f8b3cf31f1824a89d92360e7e7cc97024adf113ab3ea5a1cc7dffa"

RDEPENDS:python3-hvac = " \
 python3 \
 python3-requests \
 "
