# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-recursive-crawl"
PV = "0.2.3"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-recursive-crawl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-recursive-crawl-0.2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55b6648b1832ca7538581ee216031e9eff692a6e4142f67a11da1bc91a2578ab"

URI_x86_64_v2_python3-colcon-recursive-crawl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-recursive-crawl-0.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-recursive-crawl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-recursive-crawl}"
SRC_URI[x86_64_v2_python3-colcon-recursive-crawl.sha256sum] = "958774d74f2cef9dc0013b805e4303af380cb686c981e40479220dad70047f2e"

URI_aarch64_python3-colcon-recursive-crawl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-recursive-crawl-0.2.3-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-recursive-crawl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-recursive-crawl}"
SRC_URI[aarch64_python3-colcon-recursive-crawl.sha256sum] = "32a2fde6b7b69b72154729e04d9249ad83c5fd0b940902ecfe8dc60b36921cc9"

RDEPENDS:python3-colcon-recursive-crawl = " \
 python3 \
 python3-colcon-core \
 "
