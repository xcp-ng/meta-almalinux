# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cookie-factory"
PV = "0.3.3"
PR = "3.el10_1"
PACKAGES = " \
 rust-cookie-factory+async-devel \
 rust-cookie-factory+default-devel \
 rust-cookie-factory+futures-devel \
 rust-cookie-factory+std-devel \
 rust-cookie-factory-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cookie-factory-0.3.3-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76624011b7518b66e1979105880baa9d8489be4b238109fb8c4aaa376796c1e3"

URI_x86_64_v2_rust-cookie-factory+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie-factory+async-devel-0.3.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie-factory+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie-factory+async-devel}"
SRC_URI[x86_64_v2_rust-cookie-factory+async-devel.sha256sum] = "dfafe5ed47557303b0cd8781828a43e1b55b0ccb14f0b1890334424289819b2b"

URI_x86_64_v2_rust-cookie-factory+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie-factory+default-devel-0.3.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie-factory+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie-factory+default-devel}"
SRC_URI[x86_64_v2_rust-cookie-factory+default-devel.sha256sum] = "e67e7a971e704745611dcf457fd953c641891b9b764f7aaa9e7f10f661272779"

URI_x86_64_v2_rust-cookie-factory+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie-factory+futures-devel-0.3.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie-factory+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie-factory+futures-devel}"
SRC_URI[x86_64_v2_rust-cookie-factory+futures-devel.sha256sum] = "418ebdf3c5674a64c4224b20d973a3ec422050c6782c2b9c069428aab635b33c"

URI_x86_64_v2_rust-cookie-factory+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie-factory+std-devel-0.3.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie-factory+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie-factory+std-devel}"
SRC_URI[x86_64_v2_rust-cookie-factory+std-devel.sha256sum] = "fd34d68625c3480f10e855cfbe4b0cc289bbf044f7f3f2b213403c486612d707"

URI_x86_64_v2_rust-cookie-factory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie-factory-devel-0.3.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie-factory-devel}"
SRC_URI[x86_64_v2_rust-cookie-factory-devel.sha256sum] = "54ae17f7dc75fafd00133a0ecab6cce262add9b63ddf9ce9628c611d2c188ab3"

URI_aarch64_rust-cookie-factory+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie-factory+async-devel-0.3.3-3.el10_1.noarch.rpm;name=aarch64_rust-cookie-factory+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie-factory+async-devel}"
SRC_URI[aarch64_rust-cookie-factory+async-devel.sha256sum] = "7158b9e7e91220387aaf4e720b4f863b04aa92b3c13816b9b6f8ab69b8d5365c"

URI_aarch64_rust-cookie-factory+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie-factory+default-devel-0.3.3-3.el10_1.noarch.rpm;name=aarch64_rust-cookie-factory+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie-factory+default-devel}"
SRC_URI[aarch64_rust-cookie-factory+default-devel.sha256sum] = "a105d4ee2712106083cba2247ad0297048f8fe2d4415f4d0bb379abf54e09c33"

URI_aarch64_rust-cookie-factory+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie-factory+futures-devel-0.3.3-3.el10_1.noarch.rpm;name=aarch64_rust-cookie-factory+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie-factory+futures-devel}"
SRC_URI[aarch64_rust-cookie-factory+futures-devel.sha256sum] = "af7a82aab40882b07d2ae1a33776bbb115807ff208fd09d3eda1d23eea3e3993"

URI_aarch64_rust-cookie-factory+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie-factory+std-devel-0.3.3-3.el10_1.noarch.rpm;name=aarch64_rust-cookie-factory+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie-factory+std-devel}"
SRC_URI[aarch64_rust-cookie-factory+std-devel.sha256sum] = "9b57ee0b123766daf44e162e2a70dd6d9db8cc4ce1b85f9cbb761514e92a8013"

URI_aarch64_rust-cookie-factory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie-factory-devel-0.3.3-3.el10_1.noarch.rpm;name=aarch64_rust-cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie-factory-devel}"
SRC_URI[aarch64_rust-cookie-factory-devel.sha256sum] = "5003aae28bfbc93aa57fd7d2aa00420aa1aaa57ebf3e94208dec1430356936a2"

RDEPENDS:rust-cookie-factory+async-devel = " \
 cargo \
 rust-cookie-factory+futures-devel \
 rust-cookie-factory-devel \
 "
RDEPENDS:rust-cookie-factory+default-devel = " \
 cargo \
 rust-cookie-factory+async-devel \
 rust-cookie-factory+std-devel \
 rust-cookie-factory-devel \
 "
RDEPENDS:rust-cookie-factory+futures-devel = " \
 cargo \
 rust-cookie-factory-devel \
 rust-futures+default-devel \
 "
RDEPENDS:rust-cookie-factory+std-devel = " \
 cargo \
 rust-cookie-factory-devel \
 "
RDEPENDS:rust-cookie-factory-devel = " \
 cargo \
 "
