# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_pattern"
PV = "0.4.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_pattern+alloc-devel \
 rust-icu_pattern+databake-devel \
 rust-icu_pattern+default-devel \
 rust-icu_pattern+litemap-devel \
 rust-icu_pattern+serde-devel \
 rust-icu_pattern+yoke-devel \
 rust-icu_pattern+zerovec-devel \
 rust-icu_pattern-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_pattern-0.4.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4d88318aafd744b1202ed612a25a05bce7daa4eeea355ecae3f93d78b4a7162"

URI_x86_64_v2_rust-icu_pattern+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern+alloc-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern+alloc-devel.sha256sum] = "ff0e4d6f54146e825cb2580c0fb665037830784a87d9f62a68945b4c18ca1b96"

URI_x86_64_v2_rust-icu_pattern+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern+databake-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern+databake-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern+databake-devel.sha256sum] = "a726a05e842e8d780a186e82d4c5d00ac9dca90d741c6b4eff7a7c6c758e67a8"

URI_x86_64_v2_rust-icu_pattern+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern+default-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern+default-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern+default-devel.sha256sum] = "41a14b996501c55d231eee104cef714060a2bc081fb21ab9af601b413cc3479a"

URI_x86_64_v2_rust-icu_pattern+litemap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern+litemap-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern+litemap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern+litemap-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern+litemap-devel.sha256sum] = "273e01d5d5153cf326fa0c7801a4bf38e6873cc346fcee83c8380c8fbd352ca4"

URI_x86_64_v2_rust-icu_pattern+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern+serde-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern+serde-devel.sha256sum] = "113fe1f89bcda13a2c63e4ac9450b0af74b0bab33227470a917ccd6bee1ea2a7"

URI_x86_64_v2_rust-icu_pattern+yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern+yoke-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern+yoke-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern+yoke-devel.sha256sum] = "e417efa0c102ce0b6f9cf11c92ee5eeb4d01c84842b1f330751018a348dbf1cd"

URI_x86_64_v2_rust-icu_pattern+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern+zerovec-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern+zerovec-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern+zerovec-devel.sha256sum] = "93ad2f1c1598b28cc64256c811718d728b1fd8719846e24d2e4b31ba41e8b41c"

URI_x86_64_v2_rust-icu_pattern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern-devel.sha256sum] = "f7156697bb8a3963e89314569ecc301212ad463a32e0c46b41918510cea9d7f4"

URI_aarch64_rust-icu_pattern+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern+alloc-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-icu_pattern+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern+alloc-devel}"
SRC_URI[aarch64_rust-icu_pattern+alloc-devel.sha256sum] = "24ac0c6b9982e12bd55b794753b597ab4dc5409ad743132993540b426b11ce76"

URI_aarch64_rust-icu_pattern+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern+databake-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-icu_pattern+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern+databake-devel}"
SRC_URI[aarch64_rust-icu_pattern+databake-devel.sha256sum] = "6790dff72467b136deef1d6d4cc85a0c786848cc885bb59e5f677cad748b775f"

URI_aarch64_rust-icu_pattern+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern+default-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-icu_pattern+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern+default-devel}"
SRC_URI[aarch64_rust-icu_pattern+default-devel.sha256sum] = "89d964c44185da92fd142ff55eb7ed3470188bb6e8d98b2bd96123bb1bf28784"

URI_aarch64_rust-icu_pattern+litemap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern+litemap-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-icu_pattern+litemap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern+litemap-devel}"
SRC_URI[aarch64_rust-icu_pattern+litemap-devel.sha256sum] = "dd52dd332f729775f3e6715add46f76cff00e6c8524d9a380b8ad361983fc772"

URI_aarch64_rust-icu_pattern+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern+serde-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-icu_pattern+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern+serde-devel}"
SRC_URI[aarch64_rust-icu_pattern+serde-devel.sha256sum] = "9ea44181504d8e3b41eaf70154bfe9a583039a6f336bcfe3d6cdc91a5f3c2652"

URI_aarch64_rust-icu_pattern+yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern+yoke-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-icu_pattern+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern+yoke-devel}"
SRC_URI[aarch64_rust-icu_pattern+yoke-devel.sha256sum] = "17d0becb3544d4fa229238036e01e61c8c155bf2a38136a13771a5a026b18435"

URI_aarch64_rust-icu_pattern+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern+zerovec-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-icu_pattern+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern+zerovec-devel}"
SRC_URI[aarch64_rust-icu_pattern+zerovec-devel.sha256sum] = "64058c263077da11ca159b84ffe7feef0b92c6ce72dfc4a2620bc5935ab765b3"

URI_aarch64_rust-icu_pattern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-icu_pattern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern-devel}"
SRC_URI[aarch64_rust-icu_pattern-devel.sha256sum] = "ce22f4b81d50ee96ab3c7de570bdab79468add7783ddc4134b91026878485f17"

RDEPENDS:rust-icu_pattern+alloc-devel = " \
 cargo \
 rust-icu_pattern-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-writeable+alloc-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-icu_pattern+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_pattern-devel \
 "
RDEPENDS:rust-icu_pattern+default-devel = " \
 cargo \
 rust-icu_pattern-devel \
 "
RDEPENDS:rust-icu_pattern+litemap-devel = " \
 cargo \
 rust-icu_pattern-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-icu_pattern+serde-devel = " \
 cargo \
 rust-icu_pattern+alloc-devel \
 rust-icu_pattern-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-icu_pattern+yoke-devel = " \
 cargo \
 rust-icu_pattern-devel \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 "
RDEPENDS:rust-icu_pattern+zerovec-devel = " \
 cargo \
 rust-icu_pattern+alloc-devel \
 rust-icu_pattern-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-icu_pattern-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-either-devel \
 rust-writeable+either-devel \
 rust-writeable-devel \
 "
