# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdeclarative"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kdeclarative \
 kf6-kdeclarative-devel \
 kf6-kdeclarative-doc \
 kf6-kdeclarative-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdeclarative-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6c41998b30ab0db925440374099c2f372e68fa563965bd8cfb94814d1ee32a4"

URI_x86_64_v2_kf6-kdeclarative = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdeclarative;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative}"
SRC_URI[x86_64_v2_kf6-kdeclarative.sha256sum] = "201828216cc5934003ec948d9f2f9618a5a7e1d12a523551aee2c8999ad925e4"

URI_x86_64_v2_kf6-kdeclarative-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative-devel}"
SRC_URI[x86_64_v2_kf6-kdeclarative-devel.sha256sum] = "bdeec83ef6dd02488436f05f93c3e1c0ad0af587bd9fc5c48d0ead383f586679"

URI_x86_64_v2_kf6-kdeclarative-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdeclarative-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative-doc}"
SRC_URI[x86_64_v2_kf6-kdeclarative-doc.sha256sum] = "965d7d5156c3163c773d193bcc0650bd74141ab91ebadfc9db97f280fab424ae"

URI_x86_64_v2_kf6-kdeclarative-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdeclarative-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative-html}"
SRC_URI[x86_64_v2_kf6-kdeclarative-html.sha256sum] = "ab3964588b7231bb75cabe8597a6d55856d7c7f8b48eac0d2c7cab1470207191"

URI_aarch64_kf6-kdeclarative = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kdeclarative;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative}"
SRC_URI[aarch64_kf6-kdeclarative.sha256sum] = "f631fef6dd0e76c661ab6bd1279a268154d665a80ff3047417d77d2cada0cf05"

URI_aarch64_kf6-kdeclarative-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative-devel}"
SRC_URI[aarch64_kf6-kdeclarative-devel.sha256sum] = "a6e4140c9d066888717c5115da3c5dc5f114149db04b3ce92f1d645c468b36ff"

URI_aarch64_kf6-kdeclarative-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kdeclarative-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative-doc}"
SRC_URI[aarch64_kf6-kdeclarative-doc.sha256sum] = "21a3af89452000c3294f081b8f885d19dd3e4f89df8d4dd2d230c324ab8ee7e1"

URI_aarch64_kf6-kdeclarative-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kdeclarative-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative-html}"
SRC_URI[aarch64_kf6-kdeclarative-html.sha256sum] = "ff004ee11e3196eeda86b1b2cba6a11eac5feb9c3a7a86687998cda7002dc032"

RDEPENDS:kf6-kdeclarative = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kdeclarative-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kdeclarative \
 kf6-kpackage-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kdeclarative-doc = " \
 "
RDEPENDS:kf6-kdeclarative-html = " \
 "
