# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-logos"
PV = "0.14.4"
PR = "3.el10_3"
PACKAGES = " \
 rust-logos+debug-devel \
 rust-logos+default-devel \
 rust-logos+export_derive-devel \
 rust-logos+forbid_unsafe-devel \
 rust-logos+logos-derive-devel \
 rust-logos+std-devel \
 rust-logos-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-logos-0.14.4-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2905f5826469baf0d84de134152ba17628e3d274926e907edda84dc6ecb233b7"

URI_x86_64_v2_rust-logos+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos+debug-devel-0.14.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos+debug-devel}"
SRC_URI[x86_64_v2_rust-logos+debug-devel.sha256sum] = "e1e547ff8f497cdd0fcca7f2a3f609c76611b0cf6cd036e2e662ec3ace8c7549"

URI_x86_64_v2_rust-logos+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos+default-devel-0.14.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos+default-devel}"
SRC_URI[x86_64_v2_rust-logos+default-devel.sha256sum] = "cf2f3d2f6ef94c51dd2447646d696e7f4321d5eba6a26e3d6ed3579e9aadb592"

URI_x86_64_v2_rust-logos+export_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos+export_derive-devel-0.14.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos+export_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos+export_derive-devel}"
SRC_URI[x86_64_v2_rust-logos+export_derive-devel.sha256sum] = "7fca3312307fefa6f21c6988f40eb0f1ea9f93a50aef3540934904f83a84a0ce"

URI_x86_64_v2_rust-logos+forbid_unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos+forbid_unsafe-devel-0.14.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos+forbid_unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos+forbid_unsafe-devel}"
SRC_URI[x86_64_v2_rust-logos+forbid_unsafe-devel.sha256sum] = "2e9523317e8eb21f60cce054079d027624fd135965665281912eff8e16c78e0c"

URI_x86_64_v2_rust-logos+logos-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos+logos-derive-devel-0.14.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos+logos-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos+logos-derive-devel}"
SRC_URI[x86_64_v2_rust-logos+logos-derive-devel.sha256sum] = "d1c4a92e1c1437ed0e433622bf7d07c260a5e90cd16ccc88648d5e60b289e465"

URI_x86_64_v2_rust-logos+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos+std-devel-0.14.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos+std-devel}"
SRC_URI[x86_64_v2_rust-logos+std-devel.sha256sum] = "9ab83b3325591c745efcbd8153a0e95829471003eb6f86d8b92765db48c8ac23"

URI_x86_64_v2_rust-logos-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos-devel-0.14.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos-devel}"
SRC_URI[x86_64_v2_rust-logos-devel.sha256sum] = "84b1a267ec04ec29b4e4142cdf2433760b2081ac96c606059d03ac1995cd06bc"

URI_aarch64_rust-logos+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos+debug-devel-0.14.4-3.el10_3.noarch.rpm;name=aarch64_rust-logos+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos+debug-devel}"
SRC_URI[aarch64_rust-logos+debug-devel.sha256sum] = "7b69a61c7824d48a2fd35fa92167f2ba0a72e0d62dbed2249be1be6d7cb76ea0"

URI_aarch64_rust-logos+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos+default-devel-0.14.4-3.el10_3.noarch.rpm;name=aarch64_rust-logos+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos+default-devel}"
SRC_URI[aarch64_rust-logos+default-devel.sha256sum] = "e0e6f53387bdee7a478d2c32838996a3de1dc1be009bd09ad92358fabdcc4e87"

URI_aarch64_rust-logos+export_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos+export_derive-devel-0.14.4-3.el10_3.noarch.rpm;name=aarch64_rust-logos+export_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos+export_derive-devel}"
SRC_URI[aarch64_rust-logos+export_derive-devel.sha256sum] = "5b7eed19c136b6859942dacf04411e4f066691cf5ffe316ac17c30ead1be8f4a"

URI_aarch64_rust-logos+forbid_unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos+forbid_unsafe-devel-0.14.4-3.el10_3.noarch.rpm;name=aarch64_rust-logos+forbid_unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos+forbid_unsafe-devel}"
SRC_URI[aarch64_rust-logos+forbid_unsafe-devel.sha256sum] = "5c238ce60b9895a01c10160adc7f18482c3f6920c31628ba786e0521fe81c592"

URI_aarch64_rust-logos+logos-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos+logos-derive-devel-0.14.4-3.el10_3.noarch.rpm;name=aarch64_rust-logos+logos-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos+logos-derive-devel}"
SRC_URI[aarch64_rust-logos+logos-derive-devel.sha256sum] = "565e6d82ea4c9f3c1609dcbd481a7ecbd8bddeec60cb463175601b0c36d5e584"

URI_aarch64_rust-logos+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos+std-devel-0.14.4-3.el10_3.noarch.rpm;name=aarch64_rust-logos+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos+std-devel}"
SRC_URI[aarch64_rust-logos+std-devel.sha256sum] = "351251a4da4c3a5c4b595a67eb84074887b2b4395415eda095d8c578bd58c219"

URI_aarch64_rust-logos-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos-devel-0.14.4-3.el10_3.noarch.rpm;name=aarch64_rust-logos-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos-devel}"
SRC_URI[aarch64_rust-logos-devel.sha256sum] = "67d63ea605d104beecb476d65086172b9dc257ed35ab12fdc3f25adde5beee90"

RDEPENDS:rust-logos+debug-devel = " \
 cargo \
 rust-logos-derive+debug-devel \
 rust-logos-derive+default-devel \
 rust-logos-devel \
 "
RDEPENDS:rust-logos+default-devel = " \
 cargo \
 rust-logos+export_derive-devel \
 rust-logos+std-devel \
 rust-logos-devel \
 "
RDEPENDS:rust-logos+export_derive-devel = " \
 cargo \
 rust-logos+logos-derive-devel \
 rust-logos-devel \
 "
RDEPENDS:rust-logos+forbid_unsafe-devel = " \
 cargo \
 rust-logos-derive+default-devel \
 rust-logos-derive+forbid_unsafe-devel \
 rust-logos-devel \
 "
RDEPENDS:rust-logos+logos-derive-devel = " \
 cargo \
 rust-logos-derive+default-devel \
 rust-logos-devel \
 "
RDEPENDS:rust-logos+std-devel = " \
 cargo \
 rust-logos-devel \
 "
RDEPENDS:rust-logos-devel = " \
 cargo \
 rust \
 "
