# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enumset_derive"
PV = "0.11.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-enumset_derive+default-devel \
 rust-enumset_derive+proc-macro-crate-devel \
 rust-enumset_derive+serde-devel \
 rust-enumset_derive+std_deprecation_warning-devel \
 rust-enumset_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enumset_derive-0.11.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a64483f3fe688b13a5be4d3269583bc33b77834ef2a4941c75ff986ac7df726"

URI_x86_64_v2_rust-enumset_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset_derive+default-devel-0.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset_derive+default-devel}"
SRC_URI[x86_64_v2_rust-enumset_derive+default-devel.sha256sum] = "5e62fa35c5401c42101dafe3c2e6a04d13c274816c598fce95fd0e37d173236f"

URI_x86_64_v2_rust-enumset_derive+proc-macro-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset_derive+proc-macro-crate-devel-0.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset_derive+proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset_derive+proc-macro-crate-devel}"
SRC_URI[x86_64_v2_rust-enumset_derive+proc-macro-crate-devel.sha256sum] = "530a1cc987bab19a21d2a630ead15881fb6dc762b871b7035f7016760116d46b"

URI_x86_64_v2_rust-enumset_derive+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset_derive+serde-devel-0.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset_derive+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset_derive+serde-devel}"
SRC_URI[x86_64_v2_rust-enumset_derive+serde-devel.sha256sum] = "df0e7a2bd2bfef31d84841402734ff37027c9812683af632e230a6d61f902acf"

URI_x86_64_v2_rust-enumset_derive+std_deprecation_warning-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset_derive+std_deprecation_warning-devel-0.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset_derive+std_deprecation_warning-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset_derive+std_deprecation_warning-devel}"
SRC_URI[x86_64_v2_rust-enumset_derive+std_deprecation_warning-devel.sha256sum] = "20165d7a98b1dd41d3a04774c87118920e4e869848b8fd249e6348a9409b8de1"

URI_x86_64_v2_rust-enumset_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset_derive-devel-0.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset_derive-devel}"
SRC_URI[x86_64_v2_rust-enumset_derive-devel.sha256sum] = "e0ab4c826ab98dd109396a457989ecde2bde421a8992c4d66ad77a9b536b9368"

URI_aarch64_rust-enumset_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset_derive+default-devel-0.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-enumset_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset_derive+default-devel}"
SRC_URI[aarch64_rust-enumset_derive+default-devel.sha256sum] = "45b627c72aacb64ba768786bb4bc2e2d5fc52ffc9f65447051899ca01cede846"

URI_aarch64_rust-enumset_derive+proc-macro-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset_derive+proc-macro-crate-devel-0.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-enumset_derive+proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset_derive+proc-macro-crate-devel}"
SRC_URI[aarch64_rust-enumset_derive+proc-macro-crate-devel.sha256sum] = "e3f1bbc870608a888270446e61640c9e9a2b86ee419194a19ef29ea0bf06d0be"

URI_aarch64_rust-enumset_derive+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset_derive+serde-devel-0.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-enumset_derive+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset_derive+serde-devel}"
SRC_URI[aarch64_rust-enumset_derive+serde-devel.sha256sum] = "86eb122df2fed2035490259f245fb0fb2b43e81cde095aaa2ad3e938564d4b30"

URI_aarch64_rust-enumset_derive+std_deprecation_warning-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset_derive+std_deprecation_warning-devel-0.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-enumset_derive+std_deprecation_warning-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset_derive+std_deprecation_warning-devel}"
SRC_URI[aarch64_rust-enumset_derive+std_deprecation_warning-devel.sha256sum] = "93d2e3af090e43df15e38d111643481b1e6543d3085846d244662557faf79cbc"

URI_aarch64_rust-enumset_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset_derive-devel-0.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-enumset_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset_derive-devel}"
SRC_URI[aarch64_rust-enumset_derive-devel.sha256sum] = "0183223efc97a1fd78c389d46f07b5fbb92dc7257e59cb7c543be52f0524f439"

RDEPENDS:rust-enumset_derive+default-devel = " \
 cargo \
 rust-enumset_derive-devel \
 "
RDEPENDS:rust-enumset_derive+proc-macro-crate-devel = " \
 cargo \
 rust-enumset_derive-devel \
 rust-proc-macro-crate+default-devel \
 "
RDEPENDS:rust-enumset_derive+serde-devel = " \
 cargo \
 rust-enumset_derive-devel \
 "
RDEPENDS:rust-enumset_derive+std_deprecation_warning-devel = " \
 cargo \
 rust-enumset_derive-devel \
 "
RDEPENDS:rust-enumset_derive-devel = " \
 cargo \
 rust-darling-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
