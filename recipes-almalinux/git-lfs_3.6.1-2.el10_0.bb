# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-lfs"
PV = "3.6.1"
PR = "2.el10_0"
PACKAGES = " \
 git-lfs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/git-lfs-3.6.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2e5ab2292214ae44393c7ca2187afbcc7ec21887864573fc11897f4bb0d8b16"

URI_x86_64_v2_git-lfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-lfs-3.6.1-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_git-lfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-lfs}"
SRC_URI[x86_64_v2_git-lfs.sha256sum] = "0ddc4048140681e92918b5c2013902f0aee004ccc17e21817794281d7a44921e"

URI_aarch64_git-lfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-lfs-3.6.1-2.el10_0.aarch64.rpm;name=aarch64_git-lfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-lfs}"
SRC_URI[aarch64_git-lfs.sha256sum] = "5d864d44c6d2a5709e8b60fb68313760904187fa6b407fdf48b78887d43ff34f"

RDEPENDS:git-lfs = " \
 bash \
 git-core \
 glibc \
 "
