# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-wai-logger"
PV = "2.4.0"
PR = "7.el10_0"
PACKAGES = " \
 ghc-wai-logger \
 ghc-wai-logger-devel \
 ghc-wai-logger-doc \
 ghc-wai-logger-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-wai-logger-2.4.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d39878da71b1ebdc7f5b773f8c31498e9d7d0ff5a961ff364c01e280da08214"

URI_x86_64_v2_ghc-wai-logger = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-logger-2.4.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wai-logger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-logger}"
SRC_URI[x86_64_v2_ghc-wai-logger.sha256sum] = "4b3b42f6f84b0cf781522ad2bb3a2030c5117284e3c6b827d1e47e1a5a1361c1"

URI_x86_64_v2_ghc-wai-logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-logger-devel-2.4.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wai-logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-logger-devel}"
SRC_URI[x86_64_v2_ghc-wai-logger-devel.sha256sum] = "9b4bc84f9b83a68bcf09f54e49be4c7e0cfb878d2d1c5dc42886a518ff870fec"

URI_x86_64_v2_ghc-wai-logger-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-logger-doc-2.4.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-wai-logger-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-logger-doc}"
SRC_URI[x86_64_v2_ghc-wai-logger-doc.sha256sum] = "3d70111b4ce987de4f83b4566ad07f19269c026a106f0bab37b41d950d1b605a"

URI_x86_64_v2_ghc-wai-logger-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-logger-prof-2.4.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wai-logger-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-logger-prof}"
SRC_URI[x86_64_v2_ghc-wai-logger-prof.sha256sum] = "059b217c16e49da8417be6f171c9dff8a092cf644d49b529106cbca31aabcc26"

URI_aarch64_ghc-wai-logger = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-logger-2.4.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-wai-logger;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-logger}"
SRC_URI[aarch64_ghc-wai-logger.sha256sum] = "50af94fcfef7fda1d5fb86909fd10afa839c5e573a7be6b42305266662be392a"

URI_aarch64_ghc-wai-logger-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-logger-devel-2.4.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-wai-logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-logger-devel}"
SRC_URI[aarch64_ghc-wai-logger-devel.sha256sum] = "8d8cca9209b6edbce92c778e8b45d92cc8d477e50b8f545fc883e383cea758f5"

URI_aarch64_ghc-wai-logger-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-logger-doc-2.4.0-7.el10_0.noarch.rpm;name=aarch64_ghc-wai-logger-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-logger-doc}"
SRC_URI[aarch64_ghc-wai-logger-doc.sha256sum] = "02648bc5314539c71b4517a103f2dfc0ef2f9bb5b2e049f6d4176c6378ec0170"

URI_aarch64_ghc-wai-logger-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-logger-prof-2.4.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-wai-logger-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-logger-prof}"
SRC_URI[aarch64_ghc-wai-logger-prof.sha256sum] = "f458ebc0728dcbe224a659dce2e20abfcecfb0187c922065c379ac8767cb9939"

RDEPENDS:ghc-wai-logger = " \
 ghc-array \
 ghc-auto-update \
 ghc-base \
 ghc-binary \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-easy-file \
 ghc-exceptions \
 ghc-fast-logger \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-http-types \
 ghc-mtl \
 ghc-network \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unordered-containers \
 ghc-vault \
 ghc-wai \
 glibc \
 gmp \
 "
RDEPENDS:ghc-wai-logger-devel = " \
 ghc-base-devel \
 ghc-byteorder-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-fast-logger-devel \
 ghc-http-types-devel \
 ghc-network-devel \
 ghc-wai-devel \
 ghc-wai-logger \
 "
RDEPENDS:ghc-wai-logger-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-wai-logger-prof = " \
 ghc-base-prof \
 ghc-byteorder-prof \
 ghc-bytestring-prof \
 ghc-fast-logger-prof \
 ghc-http-types-prof \
 ghc-network-prof \
 ghc-wai-logger-devel \
 ghc-wai-prof \
 "
