# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "epel-rpm-macros"
PV = "10"
PR = "4.el10_0"
PACKAGES = " \
 epel-rpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/epel-rpm-macros-10-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "913818ee256b28d77d3b9c62d409084fa8b7795c277cd7970f6f2b534fae0a49"

URI_x86_64_v2_epel-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/epel-rpm-macros-10-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_epel-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_epel-rpm-macros}"
SRC_URI[x86_64_v2_epel-rpm-macros.sha256sum] = "817c936d48b6a7caa936a7f8dcf53acb34e2acd49f6e80fac811fc41148baa6d"

URI_aarch64_epel-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/e/epel-rpm-macros-10-4.el10_0.noarch.rpm;name=aarch64_epel-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_epel-rpm-macros}"
SRC_URI[aarch64_epel-rpm-macros.sha256sum] = "870e39c9a738fd0022eabdf8b98ee5226938710a826937b05bfffd4754f28e62"

RDEPENDS:epel-rpm-macros = " \
 almalinux-release \
 ansible-srpm-macros \
 ghc-srpm-macros \
 "
