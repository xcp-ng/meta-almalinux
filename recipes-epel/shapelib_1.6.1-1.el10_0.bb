# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shapelib"
PV = "1.6.1"
PR = "1.el10_0"
PACKAGES = " \
 shapelib \
 shapelib-devel \
 shapelib-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/shapelib-1.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "624269dd635c51e6fbe898686f84c6fe990dfa21bf929a4976c6cc5bd91a7c05"

URI_x86_64_v2_shapelib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shapelib-1.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_shapelib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shapelib}"
SRC_URI[x86_64_v2_shapelib.sha256sum] = "1be0cbe28fd7e5aece585190583a52e64c18cd6898e52f2e79ac7d820b633edb"

URI_x86_64_v2_shapelib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shapelib-devel-1.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_shapelib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shapelib-devel}"
SRC_URI[x86_64_v2_shapelib-devel.sha256sum] = "f582cbcba6d6e6ab47c7acee6de7a4b88a52eea5356a77f102bd2c4e3baa507e"

URI_x86_64_v2_shapelib-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shapelib-tools-1.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_shapelib-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shapelib-tools}"
SRC_URI[x86_64_v2_shapelib-tools.sha256sum] = "77244d8042c5cef29bbc4f4a724fb58564148751fcd956011fae7dd34f8d3dc0"

URI_aarch64_shapelib = "${EPEL_MIRROR}/aarch64/Packages/s/shapelib-1.6.1-1.el10_0.aarch64.rpm;name=aarch64_shapelib;unpack=0"
SRC_URI:append = " ${URI_aarch64_shapelib}"
SRC_URI[aarch64_shapelib.sha256sum] = "023d1e022a806afb3b038dff45b043d529d7ac6dea74a874b725bd03374f0d84"

URI_aarch64_shapelib-devel = "${EPEL_MIRROR}/aarch64/Packages/s/shapelib-devel-1.6.1-1.el10_0.aarch64.rpm;name=aarch64_shapelib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_shapelib-devel}"
SRC_URI[aarch64_shapelib-devel.sha256sum] = "b1d3e420f905b36347f96cf94aa3f8ea2dfee7fd52858f01137890bfa4c722f7"

URI_aarch64_shapelib-tools = "${EPEL_MIRROR}/aarch64/Packages/s/shapelib-tools-1.6.1-1.el10_0.aarch64.rpm;name=aarch64_shapelib-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_shapelib-tools}"
SRC_URI[aarch64_shapelib-tools.sha256sum] = "4722b1864fce66aace732a35d3616aadb6008832f7c8aaf2c312d992124a53ef"

RDEPENDS:shapelib = " \
 glibc \
 "
RDEPENDS:shapelib-devel = " \
 pkgconf-pkg-config \
 shapelib \
 "
RDEPENDS:shapelib-tools = " \
 glibc \
 libstdc++ \
 shapelib \
 "
