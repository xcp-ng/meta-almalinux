# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-escape8259"
PV = "0.5.3"
PR = "3.el10_1"
PACKAGES = " \
 rust-escape8259+default-devel \
 rust-escape8259-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-escape8259-0.5.3-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ced0d9e0bdc4fab5ff5dcb7c9c7e9b094f33727652c8b10804383921ac2d0f5"

URI_x86_64_v2_rust-escape8259+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-escape8259+default-devel-0.5.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-escape8259+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-escape8259+default-devel}"
SRC_URI[x86_64_v2_rust-escape8259+default-devel.sha256sum] = "51d4bf4505e50312eb868addf7d78b135843b06219d8155f42405f2b349828f1"

URI_x86_64_v2_rust-escape8259-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-escape8259-devel-0.5.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-escape8259-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-escape8259-devel}"
SRC_URI[x86_64_v2_rust-escape8259-devel.sha256sum] = "d45f47107d1fc62328dbf21bf8c3c01e1abc3933c4fb23fd7e02120af765c191"

URI_aarch64_rust-escape8259+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-escape8259+default-devel-0.5.3-3.el10_1.noarch.rpm;name=aarch64_rust-escape8259+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-escape8259+default-devel}"
SRC_URI[aarch64_rust-escape8259+default-devel.sha256sum] = "fec22e34eaf5566dfc5312a07b09c19e4c4428c69198da0a677d26db1b42709a"

URI_aarch64_rust-escape8259-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-escape8259-devel-0.5.3-3.el10_1.noarch.rpm;name=aarch64_rust-escape8259-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-escape8259-devel}"
SRC_URI[aarch64_rust-escape8259-devel.sha256sum] = "16f8ed2fd4956d0528fab01c78aaf01540b67ef30789ee9576a761c9e6081e0d"

RDEPENDS:rust-escape8259+default-devel = " \
 cargo \
 rust-escape8259-devel \
 "
RDEPENDS:rust-escape8259-devel = " \
 cargo \
 "
