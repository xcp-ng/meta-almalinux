# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-Diff"
PV = "1.45"
PR = "24.el10"
PACKAGES = " \
 perl-Text-Diff \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Text-Diff-1.45-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4df264cb25a2e71d52d80b8defc47977ebe71edf5cef1d79a483704ac18e7090"

URI_x86_64_v2_perl-Text-Diff = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Text-Diff-1.45-24.el10.noarch.rpm;name=x86_64_v2_perl-Text-Diff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-Diff}"
SRC_URI[x86_64_v2_perl-Text-Diff.sha256sum] = "f6a26df2078138be4b3d30e5ca9b04fd5b179d993efe953a77031aa1213d4a3c"

URI_aarch64_perl-Text-Diff = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Text-Diff-1.45-24.el10.noarch.rpm;name=aarch64_perl-Text-Diff;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-Diff}"
SRC_URI[aarch64_perl-Text-Diff.sha256sum] = "f6a26df2078138be4b3d30e5ca9b04fd5b179d993efe953a77031aa1213d4a3c"

RDEPENDS:perl-Text-Diff = " \
 perl-Algorithm-Diff \
 perl-Carp \
 perl-Exporter \
 perl-Text-Diff \
 perl-constant \
 perl-libs \
 "
