# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "basez"
PV = "1.6.2"
PR = "1.el10_0"
PACKAGES = " \
 basez \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/basez-1.6.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d198fa3628acc8b883be3d3d8f69ab1653423e1b1677daf2ba5a62425f8036dd"

URI_x86_64_v2_basez = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/basez-1.6.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_basez;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_basez}"
SRC_URI[x86_64_v2_basez.sha256sum] = "ed7dcdba6f07799a0d49d624fbd6c3811df7663faa86478fcf87a2f1c2a351a1"

URI_aarch64_basez = "${EPEL_MIRROR}/aarch64/Packages/b/basez-1.6.2-1.el10_0.aarch64.rpm;name=aarch64_basez;unpack=0"
SRC_URI:append = " ${URI_aarch64_basez}"
SRC_URI[aarch64_basez.sha256sum] = "0fb859046f124e2d7c78d96a73a30925268db0a1ba197f5225b8d8b9f89a70a6"

RDEPENDS:basez = " \
 glibc \
 "
