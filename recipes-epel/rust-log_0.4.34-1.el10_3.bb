# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-log"
PV = "0.4.34"
PR = "1.el10_3"
PACKAGES = " \
 rust-log+alloc-devel \
 rust-log+default-devel \
 rust-log+kv-devel \
 rust-log+max_level_debug-devel \
 rust-log+max_level_error-devel \
 rust-log+max_level_info-devel \
 rust-log+max_level_off-devel \
 rust-log+max_level_trace-devel \
 rust-log+max_level_warn-devel \
 rust-log+release_max_level_debug-devel \
 rust-log+release_max_level_error-devel \
 rust-log+release_max_level_info-devel \
 rust-log+release_max_level_off-devel \
 rust-log+release_max_level_trace-devel \
 rust-log+release_max_level_warn-devel \
 rust-log+serde-devel \
 rust-log+serde_core-devel \
 rust-log+std-devel \
 rust-log-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-log-0.4.34-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6c01c05522685c8f06b79a2d5db98e91b66de4664e05a191026bb8f3f998585d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+alloc-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+alloc-devel.sha256sum] = "868daf95caeb448cf4ad742d8c2c4a1513a06c7d2569de7ad326d43d3e5f856f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+default-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+default-devel.sha256sum] = "b2dd8a9cc21000f6ead77e42a1863e0ad18657e2abfce5ac7e46dbaa94b6252b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+kv-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+kv-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+kv-devel.sha256sum] = "4e80bf9ff4a23bc5e261272a445eb050aada5a6683d74ef918dc02c797565abf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_debug-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+max_level_debug-devel.sha256sum] = "666552e0097c35c2ec41b0b197070ff4bd109baa895cbc0e9e14865e36e22539"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_error-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_error-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+max_level_error-devel.sha256sum] = "4c50bcb75ad000931ebdfb7135948f491a865baff33bbd51bfd8abb0c8112127"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_info-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_info-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+max_level_info-devel.sha256sum] = "8a15b267b11082a0022f1ab3f3191c4b24ad5ea6d341d4dcdb3f78ae459f5fef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_off-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_off-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+max_level_off-devel.sha256sum] = "18849ecd8bcd3ae37bceead271fa07ae5e4ce9c5d48da550560232f47655abbe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_trace-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_trace-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+max_level_trace-devel.sha256sum] = "12ed1780776e82af823964e37801e58ff4b8aa23f9a67f2300a3c2af9b8c80f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_warn-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_warn-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+max_level_warn-devel.sha256sum] = "25819d7b4803db30c38158ee29347d773a9686f3b01429153a8eb4571387a354"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_debug-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+release_max_level_debug-devel.sha256sum] = "56f854561e23d01dba6841f72789d44c7d6084dcbfdf989f6d103890c3dfc32b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_error-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_error-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+release_max_level_error-devel.sha256sum] = "7abda08dc8dcfa47e40132d45424b25121824c1929d6523ecfdab9e58934e409"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_info-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_info-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+release_max_level_info-devel.sha256sum] = "96dc3e834fdff9826cdf553894bad9ea0b79b496d717a6f0e447ac352c463b18"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_off-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_off-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+release_max_level_off-devel.sha256sum] = "fc6c528b5c5cc004ed9edccdcd14cb9d98c9d292fe4cfbdc86630b33d64fd2de"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_trace-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_trace-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+release_max_level_trace-devel.sha256sum] = "7efb50a6fd082c3961879bb685f89c4f50c93f22822f904a64f52c135599a58a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_warn-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_warn-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+release_max_level_warn-devel.sha256sum] = "08e3b1f4b9bf73e541e9cbb292e2e3fa2366d5f4475d2d783d609e21506f97db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+serde-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+serde-devel.sha256sum] = "b5c3cd5cdb89244f8d66da174099737448cb505faedf88da294985caebf0ef5a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+serde_core-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+serde_core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+serde_core-devel.sha256sum] = "22b8ad67770438b585ff5e286db6a91a4f9760d15d4a1d54186f4dd8073f1d0c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+std-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+std-devel.sha256sum] = "0d8adb3b2cca109fbfb46f9e854602da26a1b6e4d55e792d52eaa71d2189e789"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log-devel-0.4.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log-devel.sha256sum] = "66f86f1e2a5ae6fdf7a60d14b2fa4dabc4ec7c93c3495a9fa7c16e37fd36ecf9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+alloc-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-log+alloc-devel.sha256sum] = "366c2cca4e02d2917ea2f6542a45febb92f6f7d6ad6d62b1c261090b46040ece"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+default-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+default-devel;unpack=0"
SRC_URI[aarch64_rust-log+default-devel.sha256sum] = "1c032aede03c9b002e450c14893ff43f1ad0c81401f2dd7abb9b63c683179f93"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+kv-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+kv-devel;unpack=0"
SRC_URI[aarch64_rust-log+kv-devel.sha256sum] = "6a99098a6973ba0112006ebe9bfe4681497a8c3ab4eade019f87f526488f3061"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_debug-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+max_level_debug-devel;unpack=0"
SRC_URI[aarch64_rust-log+max_level_debug-devel.sha256sum] = "788301a038a3722fd95f2fc268fbe31d5c704c09cbd619fbe8c9a51289d0ab2c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_error-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+max_level_error-devel;unpack=0"
SRC_URI[aarch64_rust-log+max_level_error-devel.sha256sum] = "b6a070d916b4a79a4ee174ce44838e398348877b9fb42cacaa504979af4b924f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_info-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+max_level_info-devel;unpack=0"
SRC_URI[aarch64_rust-log+max_level_info-devel.sha256sum] = "968bc14eb22e93a4c5748a04a411af8a2dd1954178b7811b989adf38e5b6e623"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_off-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+max_level_off-devel;unpack=0"
SRC_URI[aarch64_rust-log+max_level_off-devel.sha256sum] = "adce131827267fbc802fd4d7c26a46a1babbfd3d27e56c04a0f84d6cdd5b2cf1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_trace-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+max_level_trace-devel;unpack=0"
SRC_URI[aarch64_rust-log+max_level_trace-devel.sha256sum] = "7ef2fd7c0bf405d1c9c9f57174784e05e5bf7aaad023f9e0bdb5dac91da24aec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_warn-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+max_level_warn-devel;unpack=0"
SRC_URI[aarch64_rust-log+max_level_warn-devel.sha256sum] = "046cc4fd701e640a0b7a2e2e17948af7a759af1a566bf9ff615cfe4f8b06af54"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_debug-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+release_max_level_debug-devel;unpack=0"
SRC_URI[aarch64_rust-log+release_max_level_debug-devel.sha256sum] = "c629635431b5121195652da535e9c551dbe29a489be0215fdd983b0c6b1ff0bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_error-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+release_max_level_error-devel;unpack=0"
SRC_URI[aarch64_rust-log+release_max_level_error-devel.sha256sum] = "46eb59c02e4e07d3201636472ecf128bcdf4543edda1a146047a9c12d5e62500"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_info-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+release_max_level_info-devel;unpack=0"
SRC_URI[aarch64_rust-log+release_max_level_info-devel.sha256sum] = "2d8530e58c2ca289a11e6de6d3e6fd0d27d1a47040183825fa451e9f86fdcf4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_off-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+release_max_level_off-devel;unpack=0"
SRC_URI[aarch64_rust-log+release_max_level_off-devel.sha256sum] = "b3b5105663644fcb3d47e63922a94947ce632786c1c7bac5e30b0746b083f230"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_trace-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+release_max_level_trace-devel;unpack=0"
SRC_URI[aarch64_rust-log+release_max_level_trace-devel.sha256sum] = "0498b61684e309ff5597982c344c89eaa6fff3daea6385135ed676f61d0eb6ea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_warn-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+release_max_level_warn-devel;unpack=0"
SRC_URI[aarch64_rust-log+release_max_level_warn-devel.sha256sum] = "08764163ad6b4349373c6c5fb7782e5ae607f1011b0ea641a63f600c798f2a3f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+serde-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+serde-devel;unpack=0"
SRC_URI[aarch64_rust-log+serde-devel.sha256sum] = "5b19e21c025648fe0a2c74b7ee570d2d949f7a16f457579f20fee166cb17f32a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+serde_core-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+serde_core-devel;unpack=0"
SRC_URI[aarch64_rust-log+serde_core-devel.sha256sum] = "d3590e0c7dc050e4cd1fbad2a76e21d25e58c3e9fafbf5b9039edd3e1638b26b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+std-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log+std-devel;unpack=0"
SRC_URI[aarch64_rust-log+std-devel.sha256sum] = "1f7386b660e3ccdb8963e97f2f37387b7170c80127abbb0f44e4e024788ad921"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log-devel-0.4.34-1.el10_3.noarch.rpm;name=aarch64_rust-log-devel;unpack=0"
SRC_URI[aarch64_rust-log-devel.sha256sum] = "9595b9feb6eaa18eb2fefa3d9917968bb726b22fde81daaceaf11724b78fea11"

RDEPENDS:rust-log+alloc-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+default-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+kv-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_debug-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_error-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_info-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_off-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_trace-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_warn-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_debug-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_error-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_info-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_off-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_trace-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_warn-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+serde-devel = " \
 cargo \
 rust-log+serde_core-devel \
 rust-log-devel \
 "
RDEPENDS:rust-log+serde_core-devel = " \
 cargo \
 rust-log-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-log+std-devel = " \
 cargo \
 rust-log+alloc-devel \
 rust-log-devel \
 "
RDEPENDS:rust-log-devel = " \
 cargo \
 rust \
 "
