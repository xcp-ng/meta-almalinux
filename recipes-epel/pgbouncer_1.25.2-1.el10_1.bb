# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pgbouncer"
PV = "1.25.2"
PR = "1.el10_1"
PACKAGES = " \
 pgbouncer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pgbouncer-1.25.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "616d4506b58862bee6e2df1952c94a6f248db94463904a5fee335e7ef947ea6e"

URI_x86_64_v2_pgbouncer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pgbouncer-1.25.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pgbouncer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pgbouncer}"
SRC_URI[x86_64_v2_pgbouncer.sha256sum] = "df7fd8a1df9621bf2bfa6b235ab1bbe8f9347c173c63c8ddf75c55b44fe9326c"

URI_aarch64_pgbouncer = "${EPEL_MIRROR}/aarch64/Packages/p/pgbouncer-1.25.2-1.el10_1.aarch64.rpm;name=aarch64_pgbouncer;unpack=0"
SRC_URI:append = " ${URI_aarch64_pgbouncer}"
SRC_URI[aarch64_pgbouncer.sha256sum] = "e1debe3d49faf726c48b18c81e0f8f4ab859292760df10ca9afe639a5c40a432"

RDEPENDS:pgbouncer = " \
 bash \
 c-ares \
 glibc \
 libevent \
 logrotate \
 openldap \
 openssl-libs \
 pam-libs \
 python3 \
 python3-psycopg2 \
 shadow-utils \
 systemd \
 systemd-libs \
 "
