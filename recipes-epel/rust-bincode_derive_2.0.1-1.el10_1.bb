# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bincode_derive"
PV = "2.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-bincode_derive+default-devel \
 rust-bincode_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bincode_derive-2.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "526996868c85f95400767bbe2c37be1b2fea4977241cf39e64c7c89ab6257cc7"

URI_x86_64_v2_rust-bincode_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bincode_derive+default-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bincode_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bincode_derive+default-devel}"
SRC_URI[x86_64_v2_rust-bincode_derive+default-devel.sha256sum] = "8ea045393df9883d556982d52288c156ea7b2159e80a0c19c14dc441d81ad5a5"

URI_x86_64_v2_rust-bincode_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bincode_derive-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bincode_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bincode_derive-devel}"
SRC_URI[x86_64_v2_rust-bincode_derive-devel.sha256sum] = "c9ac7da3ec96ca7fe00d1d0bfcc208a5b572d8af242070de83fccbf2b65cdfff"

URI_aarch64_rust-bincode_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bincode_derive+default-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-bincode_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bincode_derive+default-devel}"
SRC_URI[aarch64_rust-bincode_derive+default-devel.sha256sum] = "c749b44ab7eb785cf46123662079730826d7758f7a73cad53b040fb5c53d463b"

URI_aarch64_rust-bincode_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bincode_derive-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-bincode_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bincode_derive-devel}"
SRC_URI[aarch64_rust-bincode_derive-devel.sha256sum] = "52e73d57b952d62514999716b44cedf166ad8207e4bf8f64da30e2e666fcb869"

RDEPENDS:rust-bincode_derive+default-devel = " \
 cargo \
 rust-bincode_derive-devel \
 "
RDEPENDS:rust-bincode_derive-devel = " \
 cargo \
 rust \
 rust-virtue+default-devel \
 "
