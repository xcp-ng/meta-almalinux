# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdnssd"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kdnssd \
 kf6-kdnssd-devel \
 kf6-kdnssd-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kdnssd-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "de516f3c0ccc2b4c1e02dbf8071b2b3838faf4c571c2e6da4b6914bc5c31675c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdnssd;unpack=0"
SRC_URI[x86_64_v2_kf6-kdnssd.sha256sum] = "d70e78608da9a99a500c566c747322d299277974298fec5077769cc788336510"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdnssd-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kdnssd-devel.sha256sum] = "7eaedb79399bcbcba55a3a9857635aa8d5401b46aa4fcd53ef31d0f00d4753a4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdnssd-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kdnssd-doc.sha256sum] = "30aa0f9873191bf30e113640f7b62297aee5983b1947cd47bf43c8a1935fcc05"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kdnssd;unpack=0"
SRC_URI[aarch64_kf6-kdnssd.sha256sum] = "c3feb8a41abad21704869b1951c802b26aff34c44ceb430cccf2d64cfbb66bd6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kdnssd-devel;unpack=0"
SRC_URI[aarch64_kf6-kdnssd-devel.sha256sum] = "3ffca0b199149f07d17e3edaae47b3cffa0eef33007b347c5981d67295ad9436"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kdnssd-doc;unpack=0"
SRC_URI[aarch64_kf6-kdnssd-doc.sha256sum] = "57e56d76796a988f126b21893f276f1101963d90b839572b14707ada90b0ac30"

RDEPENDS:kf6-kdnssd = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 nss-mdns \
 qt6-qtbase \
 "
RDEPENDS:kf6-kdnssd-devel = " \
 cmake-filesystem \
 kf6-kdnssd \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdnssd-doc = " \
 "
