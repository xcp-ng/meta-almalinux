# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-httpx"
PV = "0.28.1"
PR = "4.el10_3"
PACKAGES = " \
 python3-httpx \
 python3-httpx+brotli \
 python3-httpx+cli \
 python3-httpx+http2 \
 python3-httpx+socks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-httpx-0.28.1-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "393e06b3f7099b629d331c2d47b6a29d6c9094cfd05734d69a13d92d7d071a05"

URI_x86_64_v2_python3-httpx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx-0.28.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx}"
SRC_URI[x86_64_v2_python3-httpx.sha256sum] = "c3c7a68ab5ab7d6759bc24be6f79f42779c39271fa8a2e9a717e49ca47bbadf5"

URI_x86_64_v2_python3-httpx+brotli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+brotli-0.28.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+brotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+brotli}"
SRC_URI[x86_64_v2_python3-httpx+brotli.sha256sum] = "58f111c1640897c044b9d338af6effc68f06be84609adebe40f1673e65b821b3"

URI_x86_64_v2_python3-httpx+cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+cli-0.28.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+cli}"
SRC_URI[x86_64_v2_python3-httpx+cli.sha256sum] = "bca7cd42ac308e3443f26a7ad848c9152cfcb2ffb97baaca3dae4679318d1054"

URI_x86_64_v2_python3-httpx+http2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+http2-0.28.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+http2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+http2}"
SRC_URI[x86_64_v2_python3-httpx+http2.sha256sum] = "1ea64f659799a8c7ba346abbbcd719d93aa3b63c52bef3f9354c1f2e6c209b70"

URI_x86_64_v2_python3-httpx+socks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+socks-0.28.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+socks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+socks}"
SRC_URI[x86_64_v2_python3-httpx+socks.sha256sum] = "9f8e351b45fdad3d60fae956544cde6cc477355862a4b74a492c85a20698d572"

URI_aarch64_python3-httpx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx-0.28.1-4.el10_3.noarch.rpm;name=aarch64_python3-httpx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx}"
SRC_URI[aarch64_python3-httpx.sha256sum] = "7653d0d7e2c1d057d70c488fb4851768bdff1c6a252da0a244568dcf027ce928"

URI_aarch64_python3-httpx+brotli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+brotli-0.28.1-4.el10_3.noarch.rpm;name=aarch64_python3-httpx+brotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+brotli}"
SRC_URI[aarch64_python3-httpx+brotli.sha256sum] = "29498a1e0589c8093cbda1deb29e1ec03257aa41b6ee847cde20fd8bc57a6e31"

URI_aarch64_python3-httpx+cli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+cli-0.28.1-4.el10_3.noarch.rpm;name=aarch64_python3-httpx+cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+cli}"
SRC_URI[aarch64_python3-httpx+cli.sha256sum] = "ed0f272d756ebec9ec8bcabe9d23f9b1eb3e53270c8ab1d4d48d82008edae964"

URI_aarch64_python3-httpx+http2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+http2-0.28.1-4.el10_3.noarch.rpm;name=aarch64_python3-httpx+http2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+http2}"
SRC_URI[aarch64_python3-httpx+http2.sha256sum] = "215d3acf5047b51485d90859834d273eb22b617942dadb1765a6e9de733fd278"

URI_aarch64_python3-httpx+socks = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+socks-0.28.1-4.el10_3.noarch.rpm;name=aarch64_python3-httpx+socks;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+socks}"
SRC_URI[aarch64_python3-httpx+socks.sha256sum] = "be7b81536e377d9f9e571a32fe14eff08e997b81b75812563171b02b744421c2"

RDEPENDS:python3-httpx = " \
 python3 \
 python3-anyio \
 python3-certifi \
 python3-httpcore \
 python3-idna \
 "
RDEPENDS:python3-httpx+brotli = " \
 python3 \
 python3-brotli \
 python3-httpx \
 "
RDEPENDS:python3-httpx+cli = " \
 python3 \
 python3-click \
 python3-httpx \
 python3-pygments \
 python3-rich \
 "
RDEPENDS:python3-httpx+http2 = " \
 python3 \
 python3-h2 \
 python3-httpx \
 "
RDEPENDS:python3-httpx+socks = " \
 python3 \
 python3-httpx \
 python3-socksio \
 "
