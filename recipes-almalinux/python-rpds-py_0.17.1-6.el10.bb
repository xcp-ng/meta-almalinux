# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rpds-py"
PV = "0.17.1"
PR = "6.el10"
PACKAGES = " \
 python3-rpds-py \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-rpds-py-0.17.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "525001367df8ed8a6db3d1d7d856d1cebb45df2b68811498649d47a45ce1d00e"

URI_x86_64_v2_python3-rpds-py = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-rpds-py-0.17.1-6.el10.x86_64_v2.rpm;name=x86_64_v2_python3-rpds-py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpds-py}"
SRC_URI[x86_64_v2_python3-rpds-py.sha256sum] = "4325866c8a203fa3f441376ef94a5b9b09edc55664955c6fdf64275d3b849c72"

URI_aarch64_python3-rpds-py = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-rpds-py-0.17.1-6.el10.aarch64.rpm;name=aarch64_python3-rpds-py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpds-py}"
SRC_URI[aarch64_python3-rpds-py.sha256sum] = "b515d285e544b41e2bb72f7fd1d2fa229180b046182158357dbd80a536dc8b3b"

RDEPENDS:python3-rpds-py = " \
 glibc \
 libgcc \
 python3 \
 "
