# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtdatavis3d"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtdatavis3d \
 qt5-qtdatavis3d-devel \
 qt5-qtdatavis3d-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtdatavis3d-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e14721d0c3f49f358f9d31ccc1ca1c73824ab964eaa1f520afe29588f3d8765"

URI_x86_64_v2_qt5-qtdatavis3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdatavis3d-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdatavis3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdatavis3d}"
SRC_URI[x86_64_v2_qt5-qtdatavis3d.sha256sum] = "8085fd51d86a2df985c3187e1d5ff9f12a2e11b216204ecd0d5bc42d5cb46533"

URI_x86_64_v2_qt5-qtdatavis3d-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdatavis3d-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdatavis3d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdatavis3d-devel}"
SRC_URI[x86_64_v2_qt5-qtdatavis3d-devel.sha256sum] = "228389a5aafad45799e34355ac037e74ea6ae01d174e0969398b17e38159e7a2"

URI_x86_64_v2_qt5-qtdatavis3d-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdatavis3d-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdatavis3d-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdatavis3d-examples}"
SRC_URI[x86_64_v2_qt5-qtdatavis3d-examples.sha256sum] = "d032eb3a68331ecdee9dd03a6f0411809446588b5eea44a503e5305ba393797e"

URI_aarch64_qt5-qtdatavis3d = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdatavis3d-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtdatavis3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdatavis3d}"
SRC_URI[aarch64_qt5-qtdatavis3d.sha256sum] = "d8866bdcbe54c6862a33e3f87408e31293c6d122581fdb26e21a4d6aceb8a68e"

URI_aarch64_qt5-qtdatavis3d-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdatavis3d-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtdatavis3d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdatavis3d-devel}"
SRC_URI[aarch64_qt5-qtdatavis3d-devel.sha256sum] = "818b470c2b5a74d1ff6138b963b8ddec402d15ffac3c934688ec7b1f0a38347e"

URI_aarch64_qt5-qtdatavis3d-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdatavis3d-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtdatavis3d-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdatavis3d-examples}"
SRC_URI[aarch64_qt5-qtdatavis3d-examples.sha256sum] = "db7022234f69ca12951f5d4cd5e3aec785673b3c4d1f86a6760bc58ce0f8b58a"

RDEPENDS:qt5-qtdatavis3d = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtdatavis3d-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdatavis3d \
 qt5-qtdeclarative-devel \
 "
RDEPENDS:qt5-qtdatavis3d-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdatavis3d \
 qt5-qtdeclarative \
 "
