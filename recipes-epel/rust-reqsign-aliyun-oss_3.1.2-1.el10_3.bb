# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-aliyun-oss"
PV = "3.1.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-aliyun-oss+default-devel \
 rust-reqsign-aliyun-oss-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-aliyun-oss-3.1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "010b86dfe43d8f6538bc71146508d88a9d267065124d03b74077cb631f1f7909"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aliyun-oss+default-devel-3.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aliyun-oss+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-aliyun-oss+default-devel.sha256sum] = "7cf5376a4d506667e150c87edf30186cd2e1d798ee0c8dac9c2ecae832bb2eba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aliyun-oss-devel-3.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aliyun-oss-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-aliyun-oss-devel.sha256sum] = "1d69ca6680fcfe0786d8d8a1995ef4f758d78d3778f812e182c7afbfda977894"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aliyun-oss+default-devel-3.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-aliyun-oss+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-aliyun-oss+default-devel.sha256sum] = "012584f4d28c689bd071de2269701b7674b0c191fc450380880045424650d167"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aliyun-oss-devel-3.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-aliyun-oss-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-aliyun-oss-devel.sha256sum] = "cf2cd3fab0422e062873149e5c804915e622f82d9d6d2fcefa66135d45a2e47e"

RDEPENDS:rust-reqsign-aliyun-oss+default-devel = " \
 cargo \
 rust-reqsign-aliyun-oss-devel \
 "
RDEPENDS:rust-reqsign-aliyun-oss-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-form_urlencoded+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 rust-rust-ini+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
