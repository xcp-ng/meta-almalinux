# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-rpm-macros"
PV = "2.11"
PR = "1.el10_3"
PACKAGES = " \
 ghc-rpm-macros \
 ghc-rpm-macros-extra \
 ghc-rpm-macros-quick \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-rpm-macros-2.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "059361c2e1566b08a1055c15a3f4f58552f1ce30a5379360570b70a1b2b044db"

URI_x86_64_v2_ghc-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpm-macros-2.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpm-macros}"
SRC_URI[x86_64_v2_ghc-rpm-macros.sha256sum] = "1ebfb39ef1842854237bf1c1a01cb8758b4014851ec036eae0066ae7ab23b4e0"

URI_x86_64_v2_ghc-rpm-macros-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpm-macros-extra-2.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-rpm-macros-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpm-macros-extra}"
SRC_URI[x86_64_v2_ghc-rpm-macros-extra.sha256sum] = "2807a932be675c0ed0eb555ced10170a090a5ecc509ecfaec30618ea7c5d2b73"

URI_x86_64_v2_ghc-rpm-macros-quick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpm-macros-quick-2.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-rpm-macros-quick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpm-macros-quick}"
SRC_URI[x86_64_v2_ghc-rpm-macros-quick.sha256sum] = "7ed0dd25e8a255465072c08976eb45b0b6f9dcdcf523c4581fe3bb659e01ad9c"

URI_aarch64_ghc-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpm-macros-2.11-1.el10_3.noarch.rpm;name=aarch64_ghc-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpm-macros}"
SRC_URI[aarch64_ghc-rpm-macros.sha256sum] = "bde55913384f6b860ceac6255d34d1f8625a1650058a0dc11951ba5440235ddf"

URI_aarch64_ghc-rpm-macros-extra = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpm-macros-extra-2.11-1.el10_3.noarch.rpm;name=aarch64_ghc-rpm-macros-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpm-macros-extra}"
SRC_URI[aarch64_ghc-rpm-macros-extra.sha256sum] = "f3ef834412c20b4dc95a1b9032e205b4d13e1d42fbe09161b53cf0f8b96ac77e"

URI_aarch64_ghc-rpm-macros-quick = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpm-macros-quick-2.11-1.el10_3.noarch.rpm;name=aarch64_ghc-rpm-macros-quick;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpm-macros-quick}"
SRC_URI[aarch64_ghc-rpm-macros-quick.sha256sum] = "2596389685289c8920d196e06a787a79021df4a2b2152fd517215335862b2071"

RDEPENDS:ghc-rpm-macros = " \
 bash \
 chrpath \
 redhat-rpm-config \
 "
RDEPENDS:ghc-rpm-macros-extra = " \
 ghc-rpm-macros \
 "
RDEPENDS:ghc-rpm-macros-quick = " \
 ghc-rpm-macros \
 "
