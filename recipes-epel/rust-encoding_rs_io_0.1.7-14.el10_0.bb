# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-encoding_rs_io"
PV = "0.1.7"
PR = "14.el10_0"
PACKAGES = " \
 rust-encoding_rs_io+default-devel \
 rust-encoding_rs_io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-encoding_rs_io-0.1.7-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56aee64b318692b59a8638194546deba3d14cc86c12c10251e9abe6eb9660de0"

URI_x86_64_v2_rust-encoding_rs_io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs_io+default-devel-0.1.7-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs_io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs_io+default-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs_io+default-devel.sha256sum] = "cc7c17818e6865b9e81885561623065a7a251c51a42fbd9bc80d2d26cac59478"

URI_x86_64_v2_rust-encoding_rs_io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs_io-devel-0.1.7-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs_io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs_io-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs_io-devel.sha256sum] = "582997eb3f35f5821a16356aedf94f0269c207979f0f7fa00b716d01a4f1bc82"

URI_aarch64_rust-encoding_rs_io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs_io+default-devel-0.1.7-14.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs_io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs_io+default-devel}"
SRC_URI[aarch64_rust-encoding_rs_io+default-devel.sha256sum] = "40e61260fa3d3e9db898f96d756d273626dc79025b54e49bca5f5306ad652019"

URI_aarch64_rust-encoding_rs_io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs_io-devel-0.1.7-14.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs_io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs_io-devel}"
SRC_URI[aarch64_rust-encoding_rs_io-devel.sha256sum] = "61cca5c8ec600bb49735a0460fc56260d3088c04d83caf73c48cc2d011123ad2"

RDEPENDS:rust-encoding_rs_io+default-devel = " \
 cargo \
 rust-encoding_rs_io-devel \
 "
RDEPENDS:rust-encoding_rs_io-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 "
