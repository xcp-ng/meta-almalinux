# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xerces-c"
PV = "3.2.5"
PR = "5.el10_0"
PACKAGES = " \
 xerces-c \
 xerces-c-devel \
 xerces-c-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xerces-c-3.2.5-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76ebd3c55be033362b4b74102095bd46f72aa9181416399b81bd5e2f5f425fc3"

URI_x86_64_v2_xerces-c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xerces-c-3.2.5-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xerces-c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xerces-c}"
SRC_URI[x86_64_v2_xerces-c.sha256sum] = "08e2300b7c4dda5c2d05d2bb87342462d1196e644a34b4385ea8b1d8e97b7674"

URI_x86_64_v2_xerces-c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xerces-c-devel-3.2.5-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xerces-c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xerces-c-devel}"
SRC_URI[x86_64_v2_xerces-c-devel.sha256sum] = "0c1abe6cf51d98a3d26d04f403eca40a502cc0de87d844ef56e3e92c190404f9"

URI_x86_64_v2_xerces-c-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xerces-c-doc-3.2.5-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_xerces-c-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xerces-c-doc}"
SRC_URI[x86_64_v2_xerces-c-doc.sha256sum] = "cea9c96f851fdf563ced28c86a28b23f83b1a9f2e0fe59588c1fcd7721b46208"

URI_aarch64_xerces-c = "${EPEL_MIRROR}/aarch64/Packages/x/xerces-c-3.2.5-5.el10_0.aarch64.rpm;name=aarch64_xerces-c;unpack=0"
SRC_URI:append = " ${URI_aarch64_xerces-c}"
SRC_URI[aarch64_xerces-c.sha256sum] = "f5d1a0bdf36bc45ab2c296f71d38de8358b6ad3f6385ef7a36c5425dda662831"

URI_aarch64_xerces-c-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xerces-c-devel-3.2.5-5.el10_0.aarch64.rpm;name=aarch64_xerces-c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xerces-c-devel}"
SRC_URI[aarch64_xerces-c-devel.sha256sum] = "0ff9244594d0df6befeae388b163a4174895605f5e00bf2b9d978a33f4309687"

URI_aarch64_xerces-c-doc = "${EPEL_MIRROR}/aarch64/Packages/x/xerces-c-doc-3.2.5-5.el10_0.noarch.rpm;name=aarch64_xerces-c-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_xerces-c-doc}"
SRC_URI[aarch64_xerces-c-doc.sha256sum] = "03d8ea63c57c86e93da77f5113433b2b1b2248be6e5e8048a1f7d8066aca655c"

RDEPENDS:xerces-c = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:xerces-c-devel = " \
 pkgconf-pkg-config \
 xerces-c \
 "
RDEPENDS:xerces-c-doc = " \
 "
