# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-meson"
PV = "0.6.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-meson \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-meson-0.6.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dd2dd260756f31db49497a759a88b0dbacd3def0e5a81b6e6b1d7b1f45128fbf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-meson-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-meson;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-meson.sha256sum] = "b7be87feafe9bdb6ef96852f5230e76c4b8bb2839b1ea081a9466284ec3afc23"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-meson-0.6.1-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-meson;unpack=0"
SRC_URI[aarch64_python3-colcon-meson.sha256sum] = "3017bc8847b1816a32fce74ed692b9dc00332c11dc0515d4cd017d9eff0c9d9b"

RDEPENDS:python3-colcon-meson = " \
 meson \
 python3 \
 python3-colcon-core \
 python3-colcon-library-path \
 "
