# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thiserror-impl"
PV = "2.0.16"
PR = "1.el10_0"
PACKAGES = " \
 rust-thiserror-impl+default-devel \
 rust-thiserror-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thiserror-impl-2.0.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1699eb7e75414e6c053f8f77a52d47eda73602623acd9290ad9fc32ccc3d467f"

URI_x86_64_v2_rust-thiserror-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-impl+default-devel-2.0.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror-impl+default-devel}"
SRC_URI[x86_64_v2_rust-thiserror-impl+default-devel.sha256sum] = "9113ac9cc50ce1d69adc585ad685b9bb292bcc05bb749e6fd3058645c4f99ec6"

URI_x86_64_v2_rust-thiserror-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-impl-devel-2.0.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror-impl-devel}"
SRC_URI[x86_64_v2_rust-thiserror-impl-devel.sha256sum] = "253571c51efc8467968d3db3082f6484f960e4546f81b5ecf0d5291f41452ed6"

URI_aarch64_rust-thiserror-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-impl+default-devel-2.0.16-1.el10_0.noarch.rpm;name=aarch64_rust-thiserror-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror-impl+default-devel}"
SRC_URI[aarch64_rust-thiserror-impl+default-devel.sha256sum] = "d97f3bdc780986ce9b919d7f94f2447e10324fc677abb851ddbc062e5585a3f2"

URI_aarch64_rust-thiserror-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-impl-devel-2.0.16-1.el10_0.noarch.rpm;name=aarch64_rust-thiserror-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror-impl-devel}"
SRC_URI[aarch64_rust-thiserror-impl-devel.sha256sum] = "d0712a9a72eaebcc08474ff6808ddaa14d0f206b8cf4a9e44ef0686e1fae8694"

RDEPENDS:rust-thiserror-impl+default-devel = " \
 cargo \
 rust-thiserror-impl-devel \
 "
RDEPENDS:rust-thiserror-impl-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
