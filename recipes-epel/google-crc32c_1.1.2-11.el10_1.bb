# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-crc32c"
PV = "1.1.2"
PR = "11.el10_1"
PACKAGES = " \
 google-crc32c \
 google-crc32c-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/google-crc32c-1.1.2-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd62c757e2f0b9294267423e025f409526f7f4f63e9a073d4192c0f69323d954"

URI_x86_64_v2_google-crc32c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-crc32c-1.1.2-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_google-crc32c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-crc32c}"
SRC_URI[x86_64_v2_google-crc32c.sha256sum] = "3b273e679fee0baa750828fa844ab2e74b51a2cf8c7ba603b92b0c38ced1d5e4"

URI_x86_64_v2_google-crc32c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-crc32c-devel-1.1.2-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_google-crc32c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-crc32c-devel}"
SRC_URI[x86_64_v2_google-crc32c-devel.sha256sum] = "b5060c4d8579a6cac5db3b341518ba8887bacb750686011ecb5cc7b1cbc7f9ba"

URI_aarch64_google-crc32c = "${EPEL_MIRROR}/aarch64/Packages/g/google-crc32c-1.1.2-11.el10_1.aarch64.rpm;name=aarch64_google-crc32c;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-crc32c}"
SRC_URI[aarch64_google-crc32c.sha256sum] = "8ccb9248655bbd9f333e40ec18942d0b40078b0b6f080b140c51c3df3dd52272"

URI_aarch64_google-crc32c-devel = "${EPEL_MIRROR}/aarch64/Packages/g/google-crc32c-devel-1.1.2-11.el10_1.aarch64.rpm;name=aarch64_google-crc32c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-crc32c-devel}"
SRC_URI[aarch64_google-crc32c-devel.sha256sum] = "4f22d674851f9ca7925a75340b7d5f6b8a2e04fde04091cbfbcb46e6aa617b7b"

RDEPENDS:google-crc32c = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:google-crc32c-devel = " \
 cmake-filesystem \
 google-crc32c \
 "
