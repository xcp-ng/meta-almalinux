# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jakarta-annotations"
PV = "1.3.5"
PR = "23.el10"
PACKAGES = " \
 jakarta-annotations \
 jakarta-annotations-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jakarta-annotations-1.3.5-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1051c2a2710b531d2fd137f86c5981cf3f4c66764efac335dfe418ff5e388f1"

URI_x86_64_v2_jakarta-annotations = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jakarta-annotations-1.3.5-23.el10.noarch.rpm;name=x86_64_v2_jakarta-annotations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jakarta-annotations}"
SRC_URI[x86_64_v2_jakarta-annotations.sha256sum] = "bd734a52c9daa265b3bded05b6216a39fc014348ed19a8adc8f2d7de7f2520af"

URI_x86_64_v2_jakarta-annotations-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jakarta-annotations-javadoc-1.3.5-23.el10.noarch.rpm;name=x86_64_v2_jakarta-annotations-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jakarta-annotations-javadoc}"
SRC_URI[x86_64_v2_jakarta-annotations-javadoc.sha256sum] = "4b2ff4787b13ba2ae119d1ba1099be9a45903e08e6f61e975663c8ed7b14af5b"

URI_aarch64_jakarta-annotations = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jakarta-annotations-1.3.5-23.el10.noarch.rpm;name=aarch64_jakarta-annotations;unpack=0"
SRC_URI:append = " ${URI_aarch64_jakarta-annotations}"
SRC_URI[aarch64_jakarta-annotations.sha256sum] = "bd734a52c9daa265b3bded05b6216a39fc014348ed19a8adc8f2d7de7f2520af"

URI_aarch64_jakarta-annotations-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jakarta-annotations-javadoc-1.3.5-23.el10.noarch.rpm;name=aarch64_jakarta-annotations-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jakarta-annotations-javadoc}"
SRC_URI[aarch64_jakarta-annotations-javadoc.sha256sum] = "4b2ff4787b13ba2ae119d1ba1099be9a45903e08e6f61e975663c8ed7b14af5b"

RDEPENDS:jakarta-annotations = " \
 javapackages-filesystem \
 "
RDEPENDS:jakarta-annotations-javadoc = " \
 javapackages-filesystem \
 "
