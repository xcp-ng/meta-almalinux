# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-lcov-result"
PV = "0.5.3"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-lcov-result \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-lcov-result-0.5.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d97ded4ffcd0e53a7be7df65532c60d82d83370ac60b64189462f4b85ce948d5"

URI_x86_64_v2_python3-colcon-lcov-result = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-lcov-result-0.5.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-lcov-result;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-lcov-result}"
SRC_URI[x86_64_v2_python3-colcon-lcov-result.sha256sum] = "cff9c6ee44851a68f7cb9c06ef07bba640a6782e73d9f3d1c89cc00fd3d4b84b"

URI_aarch64_python3-colcon-lcov-result = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-lcov-result-0.5.3-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-lcov-result;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-lcov-result}"
SRC_URI[aarch64_python3-colcon-lcov-result.sha256sum] = "25be77b2d08dd4143e94ef5bac9f618dc30edcdef30a9b7e92295263a3ccc048"

RDEPENDS:python3-colcon-lcov-result = " \
 python3 \
 python3-colcon-core \
 "
