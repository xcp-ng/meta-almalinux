# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krita"
PV = "6.0.2.1"
PR = "1.el10_3"
PACKAGES = " \
 krita \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krita-6.0.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "470aaee530b775a032163a09042650e5da4c39cd39b48cb6bf2f8f503876098d"

URI_x86_64_v2_krita = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krita-6.0.2.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krita;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krita}"
SRC_URI[x86_64_v2_krita.sha256sum] = "8865f9392e72c06980ace9c0cd0c42e8520a627ba359719ee704e224366a4857"

URI_aarch64_krita = "${EPEL_MIRROR}/aarch64/Packages/k/krita-6.0.2.1-1.el10_3.aarch64.rpm;name=aarch64_krita;unpack=0"
SRC_URI:append = " ${URI_aarch64_krita}"
SRC_URI[aarch64_krita.sha256sum] = "f260d85ecc4b5459496895b6ff5ffe13ac375427ef8807a97718ad50d9a1d5c5"

RDEPENDS:krita = " \
 OpenColorIO \
 exiv2-libs \
 fftw-libs-double \
 fontconfig \
 freetype \
 fribidi \
 giflib \
 glibc \
 gsl \
 harfbuzz \
 hicolor-icon-theme \
 imath \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kseexpr \
 lcms2 \
 libX11 \
 libgcc \
 libgomp \
 libheif \
 libjpeg-turbo \
 libjxl \
 libkdcraw \
 libmypaint \
 libpng \
 libstdc++ \
 libtiff \
 libunibreak \
 libwayland-client \
 libwebp \
 libxkbcommon \
 mlt \
 openexr-libs \
 openjpeg2 \
 poppler-qt6 \
 python3-libs \
 python3-pyqt6-base \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 quazip-qt6 \
 turbojpeg \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
