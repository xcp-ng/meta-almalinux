# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmime"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kmime \
 kmime-devel \
 kmime-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmime-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9df2e5c5035de8b06fb524730bae175be8f3ced042af570c76f8d1a2e51adf7"

URI_x86_64_v2_kmime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmime-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmime}"
SRC_URI[x86_64_v2_kmime.sha256sum] = "609bb24a0d941e54faf24c5dbc9d90e4c6528de2f1c0315be43c215f56074fa3"

URI_x86_64_v2_kmime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmime-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmime-devel}"
SRC_URI[x86_64_v2_kmime-devel.sha256sum] = "256be8694b07256949fc5a905ee421a734a5121c2a63cf32f65edc7b857931bc"

URI_x86_64_v2_kmime-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmime-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kmime-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmime-doc}"
SRC_URI[x86_64_v2_kmime-doc.sha256sum] = "b7c13fe6dfdf7dd1e1c90f2bb9a9d33a34cb3b737196064e8e3fe76130fb87bc"

URI_aarch64_kmime = "${EPEL_MIRROR}/aarch64/Packages/k/kmime-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmime;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmime}"
SRC_URI[aarch64_kmime.sha256sum] = "84ab2edae65ef2431ef10ac2beae144c92add0504d9d03576917b22fec57cccb"

URI_aarch64_kmime-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kmime-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmime-devel}"
SRC_URI[aarch64_kmime-devel.sha256sum] = "378888ea74a4b613e8b5e5ca90425787fd5a75f7666fc00f9d479e1bb50146c0"

URI_aarch64_kmime-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kmime-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kmime-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmime-doc}"
SRC_URI[aarch64_kmime-doc.sha256sum] = "d9fa4b24cc2f7d6a09619cc829e1892036e62d7188711742eb224267f7a4a8c5"

RDEPENDS:kmime = " \
 glibc \
 kf6-kcodecs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kmime-devel = " \
 boost-devel \
 cmake-filesystem \
 kf6-kcodecs-devel \
 kmime \
 "
RDEPENDS:kmime-doc = " \
 "
