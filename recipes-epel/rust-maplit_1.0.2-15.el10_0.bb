# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-maplit"
PV = "1.0.2"
PR = "15.el10_0"
PACKAGES = " \
 rust-maplit+default-devel \
 rust-maplit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-maplit-1.0.2-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf681ee8b8333bc596829a2e5a79e5bcb3d706b874c79ae61ad2bbb9e2fa4765"

URI_x86_64_v2_rust-maplit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maplit+default-devel-1.0.2-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maplit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-maplit+default-devel}"
SRC_URI[x86_64_v2_rust-maplit+default-devel.sha256sum] = "9ac47adc9f1971942ababd5e2a0db54abd78767e18232266da16ea6e8d4793e5"

URI_x86_64_v2_rust-maplit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maplit-devel-1.0.2-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maplit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-maplit-devel}"
SRC_URI[x86_64_v2_rust-maplit-devel.sha256sum] = "e47f49e82b14e9d6e18fb1d6c5433d77f8cb8d5176d6911390989664958d2c7e"

URI_aarch64_rust-maplit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-maplit+default-devel-1.0.2-15.el10_0.noarch.rpm;name=aarch64_rust-maplit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-maplit+default-devel}"
SRC_URI[aarch64_rust-maplit+default-devel.sha256sum] = "511ce2b7a8c8ddbfe43f05721b0c9c2d4ee228145419b7f0550d9a0e5964c298"

URI_aarch64_rust-maplit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-maplit-devel-1.0.2-15.el10_0.noarch.rpm;name=aarch64_rust-maplit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-maplit-devel}"
SRC_URI[aarch64_rust-maplit-devel.sha256sum] = "c07f1548f9fae44846b011eb17c53cbc9979c5d98e5c9eb98fbc1483c1dee4c9"

RDEPENDS:rust-maplit+default-devel = " \
 cargo \
 rust-maplit-devel \
 "
RDEPENDS:rust-maplit-devel = " \
 cargo \
 "
