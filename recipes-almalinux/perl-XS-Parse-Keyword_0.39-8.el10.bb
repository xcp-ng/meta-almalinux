# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XS-Parse-Keyword"
PV = "0.39"
PR = "8.el10"
PACKAGES = " \
 perl-XS-Parse-Keyword \
 perl-XS-Parse-Keyword-Builder \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-XS-Parse-Keyword-0.39-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ded69f68be8d2b9054258b0d0b4a9bf3ba50da5eaf0c93b6e228769dfd20c940"

URI_x86_64_v2_perl-XS-Parse-Keyword = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-XS-Parse-Keyword-0.39-8.el10.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Keyword;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Keyword}"
SRC_URI[x86_64_v2_perl-XS-Parse-Keyword.sha256sum] = "13a4c0ed817ef9dbbf44f1848b49303420811e4dd2e4cfd2d066bd411a6619c6"

URI_x86_64_v2_perl-XS-Parse-Keyword-Builder = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-XS-Parse-Keyword-Builder-0.39-8.el10.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Keyword-Builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Keyword-Builder}"
SRC_URI[x86_64_v2_perl-XS-Parse-Keyword-Builder.sha256sum] = "dbd98a1a167356155b1594e9da166f611c47934ae0b95c00c9f3647a3b116d93"

URI_aarch64_perl-XS-Parse-Keyword = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-XS-Parse-Keyword-0.39-8.el10.aarch64.rpm;name=aarch64_perl-XS-Parse-Keyword;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Keyword}"
SRC_URI[aarch64_perl-XS-Parse-Keyword.sha256sum] = "817248419ec7aa906396f2bc11acea8d0a0a1bb8024aa129608140ea867b0c64"

URI_aarch64_perl-XS-Parse-Keyword-Builder = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-XS-Parse-Keyword-Builder-0.39-8.el10.aarch64.rpm;name=aarch64_perl-XS-Parse-Keyword-Builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Keyword-Builder}"
SRC_URI[aarch64_perl-XS-Parse-Keyword-Builder.sha256sum] = "48946d28973de6cab9d1e7897cbffaf9c72952c401a09be5a414b53ab6e498e3"

RDEPENDS:perl-XS-Parse-Keyword = " \
 glibc \
 perl-XS-Parse-Keyword \
 perl-libs \
 "
RDEPENDS:perl-XS-Parse-Keyword-Builder = " \
 perl-XS-Parse-Keyword \
 perl-XS-Parse-Keyword-Builder \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
