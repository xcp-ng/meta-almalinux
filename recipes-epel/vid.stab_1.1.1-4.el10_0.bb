# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vid.stab"
PV = "1.1.1"
PR = "4.el10_0"
PACKAGES = " \
 vid.stab \
 vid.stab-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vid.stab-1.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83b85c929e53c9ff3cceb43cc86164aca1de9a49c8ef9454a2b680096328b492"

URI_x86_64_v2_vid.stab = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vid.stab-1.1.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vid.stab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vid.stab}"
SRC_URI[x86_64_v2_vid.stab.sha256sum] = "988ac09a32a3ff6de3d13c4a5f42a7967ab611980eca17ff0e5d1727b5735253"

URI_x86_64_v2_vid.stab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vid.stab-devel-1.1.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vid.stab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vid.stab-devel}"
SRC_URI[x86_64_v2_vid.stab-devel.sha256sum] = "990c2b14bfb8b092fd04c2e794685648c3e18726f150b06c20c5dd3acd8294ec"

URI_aarch64_vid.stab = "${EPEL_MIRROR}/aarch64/Packages/v/vid.stab-1.1.1-4.el10_0.aarch64.rpm;name=aarch64_vid.stab;unpack=0"
SRC_URI:append = " ${URI_aarch64_vid.stab}"
SRC_URI[aarch64_vid.stab.sha256sum] = "eab79e2ecdc89a2f6153adbb8aaab5bc46df29cfdfb0fd7efb283069c91b75e3"

URI_aarch64_vid.stab-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vid.stab-devel-1.1.1-4.el10_0.aarch64.rpm;name=aarch64_vid.stab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vid.stab-devel}"
SRC_URI[aarch64_vid.stab-devel.sha256sum] = "6f26b04c03d3dd34d6921f6ec184ed133e6830cbf7a3ba5db45359df7dabf760"

RDEPENDS:vid.stab = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:vid.stab-devel = " \
 pkgconf-pkg-config \
 vid.stab \
 "
