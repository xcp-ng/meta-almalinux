# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiounittest"
PV = "1.5.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-aiounittest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aiounittest-1.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3989f72acbf6fe4deb9716402a5cb4bf24e53bf762ff5d9680b1508bcc2f6bc"

URI_x86_64_v2_python3-aiounittest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiounittest-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aiounittest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiounittest}"
SRC_URI[x86_64_v2_python3-aiounittest.sha256sum] = "6570ec340be6afea7eda4d857e200a33c0c13c6464e1084421476c0ac8a9198a"

URI_aarch64_python3-aiounittest = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiounittest-1.5.0-1.el10_1.noarch.rpm;name=aarch64_python3-aiounittest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiounittest}"
SRC_URI[aarch64_python3-aiounittest.sha256sum] = "6e8e51e4b610928855490bf3aff32b4c20f7c49e398f4308424f21309e1898a4"

RDEPENDS:python3-aiounittest = " \
 python3 \
 python3-wrapt \
 "
