# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-stone"
PV = "3.2.1"
PR = "22.el10_2"
PACKAGES = " \
 python3-stone \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-stone-3.2.1-22.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91af1158f5857fab9cb522d9ab6f6452072fb665c85ed37264cd3a11bb64e8ca"

URI_x86_64_v2_python3-stone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-stone-3.2.1-22.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-stone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-stone}"
SRC_URI[x86_64_v2_python3-stone.sha256sum] = "56fecf6407bae59b459fd48677381d6b0f43de50bf6038ace22adef6de41fa34"

URI_aarch64_python3-stone = "${EPEL_MIRROR}/aarch64/Packages/p/python3-stone-3.2.1-22.el10_2.noarch.rpm;name=aarch64_python3-stone;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-stone}"
SRC_URI[aarch64_python3-stone.sha256sum] = "430f62239c82c28613f35a59c9b8a0df523cf4e9b9bba9c460914426753d063c"

RDEPENDS:python3-stone = " \
 python3 \
 python3-ply \
 python3-six \
 "
