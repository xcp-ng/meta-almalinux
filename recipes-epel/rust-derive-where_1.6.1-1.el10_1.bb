# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive-where"
PV = "1.6.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-derive-where+default-devel \
 rust-derive-where+nightly-devel \
 rust-derive-where+safe-devel \
 rust-derive-where+serde-devel \
 rust-derive-where+zeroize-devel \
 rust-derive-where+zeroize-on-drop-devel \
 rust-derive-where-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derive-where-1.6.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5efd5b1d14782c00c8527c2d83214606f858d229e9286f6af9428acbcce8cbe"

URI_x86_64_v2_rust-derive-where+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+default-devel-1.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+default-devel}"
SRC_URI[x86_64_v2_rust-derive-where+default-devel.sha256sum] = "4f14cd08754750589c83d10eebcb56b456bdf1ec14edc420acc8ae22ca6f66c4"

URI_x86_64_v2_rust-derive-where+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+nightly-devel-1.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+nightly-devel}"
SRC_URI[x86_64_v2_rust-derive-where+nightly-devel.sha256sum] = "6d5d1d90044fbcbfd95aa7430188593a4e8a5067ff2ef7e1e0effbf5ae45532a"

URI_x86_64_v2_rust-derive-where+safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+safe-devel-1.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+safe-devel}"
SRC_URI[x86_64_v2_rust-derive-where+safe-devel.sha256sum] = "37943a9550568b83a240c4cff97a78129324b0b2bfa696f4815589b13c887cd2"

URI_x86_64_v2_rust-derive-where+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+serde-devel-1.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+serde-devel}"
SRC_URI[x86_64_v2_rust-derive-where+serde-devel.sha256sum] = "929fe75b2f81a101fc32005e60a75f092cbb5b79662ccdf8aaf22b3fe98e689e"

URI_x86_64_v2_rust-derive-where+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+zeroize-devel-1.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+zeroize-devel}"
SRC_URI[x86_64_v2_rust-derive-where+zeroize-devel.sha256sum] = "67fbb8a6b129ed5a66a4d43d99a7fef1bf603e73e0145bfbf770922368ddb12a"

URI_x86_64_v2_rust-derive-where+zeroize-on-drop-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+zeroize-on-drop-devel-1.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+zeroize-on-drop-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+zeroize-on-drop-devel}"
SRC_URI[x86_64_v2_rust-derive-where+zeroize-on-drop-devel.sha256sum] = "5bf27fd30d90da9898458acaf0ca101f235a9c36cb28f13144ffb4ce511127f6"

URI_x86_64_v2_rust-derive-where-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where-devel-1.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where-devel}"
SRC_URI[x86_64_v2_rust-derive-where-devel.sha256sum] = "53d9d3262d2445aef471b2f2b0ee36a9cb817736396c9c285087c12a1bfe1ed9"

URI_aarch64_rust-derive-where+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+default-devel-1.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-derive-where+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+default-devel}"
SRC_URI[aarch64_rust-derive-where+default-devel.sha256sum] = "e19de9b7f5ade5deb17d9ab32d2ae6ca84cc287300981ab21018e32e63702a18"

URI_aarch64_rust-derive-where+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+nightly-devel-1.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-derive-where+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+nightly-devel}"
SRC_URI[aarch64_rust-derive-where+nightly-devel.sha256sum] = "2f5e03897c9bde98e976256bfe4dc104e5b391bffab4c067aff76d40ac1420f7"

URI_aarch64_rust-derive-where+safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+safe-devel-1.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-derive-where+safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+safe-devel}"
SRC_URI[aarch64_rust-derive-where+safe-devel.sha256sum] = "8d784224e733e00e4a34be7e2b85eca1ece04eb2e89b34f477bc0ae53979e577"

URI_aarch64_rust-derive-where+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+serde-devel-1.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-derive-where+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+serde-devel}"
SRC_URI[aarch64_rust-derive-where+serde-devel.sha256sum] = "89e2cb6a0a8770f310761de89545e563babddf4db0d9cdfd93f5d0daa3e0f21c"

URI_aarch64_rust-derive-where+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+zeroize-devel-1.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-derive-where+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+zeroize-devel}"
SRC_URI[aarch64_rust-derive-where+zeroize-devel.sha256sum] = "b4c366dc63c8250b3551a0b037886c8b92f252593844669e4d8c9641930cd0bd"

URI_aarch64_rust-derive-where+zeroize-on-drop-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+zeroize-on-drop-devel-1.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-derive-where+zeroize-on-drop-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+zeroize-on-drop-devel}"
SRC_URI[aarch64_rust-derive-where+zeroize-on-drop-devel.sha256sum] = "7606431a4cdd02505d6df302bc1b58f537b2b9e3611512a86103081ef25bfb7d"

URI_aarch64_rust-derive-where-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where-devel-1.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-derive-where-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where-devel}"
SRC_URI[aarch64_rust-derive-where-devel.sha256sum] = "260fce6118dc9bb621b6ffd221cd617989146b9ad4b708ac1e87c39f44d9781a"

RDEPENDS:rust-derive-where+default-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+nightly-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+safe-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+serde-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+zeroize-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+zeroize-on-drop-devel = " \
 cargo \
 rust-derive-where+zeroize-devel \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
