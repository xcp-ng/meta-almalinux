# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-io-extras"
PV = "0.19.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-io-extras+async-std-devel \
 rust-io-extras+default-devel \
 rust-io-extras+mio-devel \
 rust-io-extras+os_pipe-devel \
 rust-io-extras+socket2-devel \
 rust-io-extras+tokio-devel \
 rust-io-extras+use_async_std-devel \
 rust-io-extras+use_mio_net-devel \
 rust-io-extras+use_mio_os_ext-devel \
 rust-io-extras+use_os_pipe-devel \
 rust-io-extras+use_socket2-devel \
 rust-io-extras+use_tokio-devel \
 rust-io-extras-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-io-extras-0.19.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "91fd7baa7504b3c2ba994cdcef513dc3052140545cea2995a0ef8d50c89a9f85"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+async-std-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+async-std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-io-extras+async-std-devel.sha256sum] = "ff9c3546bcf0290dad590c03a73482a91dfbe9fcaed62bff7e7f751ed8572ffc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+default-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-io-extras+default-devel.sha256sum] = "f5abbc628eb5847ae708599ff85f7ef5155e24456f85099002ef35e03b5492f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+mio-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+mio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-io-extras+mio-devel.sha256sum] = "2d093749b0c3515b43eebab59e9bb4962a9f6f552a782faa0a7203815df2c27f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+os_pipe-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+os_pipe-devel;unpack=0"
SRC_URI[x86_64_v2_rust-io-extras+os_pipe-devel.sha256sum] = "582d5703e3b263f24f4e3dc995163421df4c04416d2f85c830abd32d9ac2c09f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+socket2-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+socket2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-io-extras+socket2-devel.sha256sum] = "ae0ff49b38d2472fd569684aeb732a3a0b83ead680d6a61b6c04108a96b15d46"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+tokio-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-io-extras+tokio-devel.sha256sum] = "5a023f45d4ca50584b989bec36c498607ebc698b65127e23224c6f5bbef68a6a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+use_async_std-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+use_async_std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-io-extras+use_async_std-devel.sha256sum] = "4f8ae19fa21b7f3b63be8407c4c7a28761544747711aac3861ce99ad89632646"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+use_mio_net-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+use_mio_net-devel;unpack=0"
SRC_URI[x86_64_v2_rust-io-extras+use_mio_net-devel.sha256sum] = "1a692581a6bcba13c38ba3ac35a547d19dd3986e61b8a9ce6404197ffd9f8a6f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+use_mio_os_ext-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+use_mio_os_ext-devel;unpack=0"
SRC_URI[x86_64_v2_rust-io-extras+use_mio_os_ext-devel.sha256sum] = "d5ecb2ba5cfe0ee6e02bba01d06e95901193c95b0c824d3fcb509a6ff74e2ea9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+use_os_pipe-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+use_os_pipe-devel;unpack=0"
SRC_URI[x86_64_v2_rust-io-extras+use_os_pipe-devel.sha256sum] = "55e2307fc4b607731943ddcf83a6a2def17b83e9c6d75d5f9a6a173f040a6e01"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+use_socket2-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+use_socket2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-io-extras+use_socket2-devel.sha256sum] = "ec112696e1688f5f36f5e676d0d50072940f201477132266062c4afc98cd92e3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+use_tokio-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+use_tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-io-extras+use_tokio-devel.sha256sum] = "68393b4bf25893088597d0b79209334e92ff06eab239b2053e0e76c3c0723169"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras-devel;unpack=0"
SRC_URI[x86_64_v2_rust-io-extras-devel.sha256sum] = "fbc9ea591aa958cceb7213ff5cb2feb31c5479330dbc17c04eacffd5a47dd52b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+async-std-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-io-extras+async-std-devel;unpack=0"
SRC_URI[aarch64_rust-io-extras+async-std-devel.sha256sum] = "68cbe7f398509c1151265d43ced88578490fd4f324586f967758439f55254b51"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+default-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-io-extras+default-devel;unpack=0"
SRC_URI[aarch64_rust-io-extras+default-devel.sha256sum] = "dc06128ff122df67d0369e7e2ea4a509e0f9af29b967d45b12b8dbfb82b20810"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+mio-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-io-extras+mio-devel;unpack=0"
SRC_URI[aarch64_rust-io-extras+mio-devel.sha256sum] = "e08f4ce9bdb003a27cb14363a27deb0241ff4394cb006e3a07003a00fd8d68f7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+os_pipe-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-io-extras+os_pipe-devel;unpack=0"
SRC_URI[aarch64_rust-io-extras+os_pipe-devel.sha256sum] = "d1da8867de4a8a32472acb4a9abc0bcccb688433321ce85c35b2a0b9f0615837"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+socket2-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-io-extras+socket2-devel;unpack=0"
SRC_URI[aarch64_rust-io-extras+socket2-devel.sha256sum] = "f17f9c19d004d2bd784ce377dbe62a9234a2a8d94f685ad8e4b65fb29c543771"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+tokio-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-io-extras+tokio-devel;unpack=0"
SRC_URI[aarch64_rust-io-extras+tokio-devel.sha256sum] = "df5f4fb0e07503b9cfeb73029b7229caa97ea80c1620e3c24486afb0c7062ecb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+use_async_std-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-io-extras+use_async_std-devel;unpack=0"
SRC_URI[aarch64_rust-io-extras+use_async_std-devel.sha256sum] = "2525b7f6048a55ebf72161d961e73a6f3a16a144e44f334fcbfe4fcf8e0fde8a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+use_mio_net-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-io-extras+use_mio_net-devel;unpack=0"
SRC_URI[aarch64_rust-io-extras+use_mio_net-devel.sha256sum] = "c81757ec4459408f14a47a91210a324a608d576262f2d153d4a92fdece119e70"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+use_mio_os_ext-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-io-extras+use_mio_os_ext-devel;unpack=0"
SRC_URI[aarch64_rust-io-extras+use_mio_os_ext-devel.sha256sum] = "1ef13ca57693e553a8dfa76eb15fc38c9790ccee453204738a24c5f45fb00d7f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+use_os_pipe-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-io-extras+use_os_pipe-devel;unpack=0"
SRC_URI[aarch64_rust-io-extras+use_os_pipe-devel.sha256sum] = "74e4fbdfc63b68ef802edb4fc1dbc3b131dd0b46a7eef2bccc7fabbb1500cb25"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+use_socket2-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-io-extras+use_socket2-devel;unpack=0"
SRC_URI[aarch64_rust-io-extras+use_socket2-devel.sha256sum] = "26d9afb0cf63f2891e611a5de830bf67337369734720314184e68762ff6807aa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+use_tokio-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-io-extras+use_tokio-devel;unpack=0"
SRC_URI[aarch64_rust-io-extras+use_tokio-devel.sha256sum] = "62a05c0d343f5f70ecb05a84c024e88776a64f92cb492d4b86b23656a86ffe10"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-io-extras-devel;unpack=0"
SRC_URI[aarch64_rust-io-extras-devel.sha256sum] = "88794a4eec65067c23167b8ca0d94e2dc317108cf8d623a0996c93f5c92e83b0"

RDEPENDS:rust-io-extras+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-async-std+io_safety-devel \
 rust-io-extras-devel \
 "
RDEPENDS:rust-io-extras+default-devel = " \
 cargo \
 rust-io-extras-devel \
 "
RDEPENDS:rust-io-extras+mio-devel = " \
 cargo \
 rust-io-extras-devel \
 rust-mio+default-devel \
 "
RDEPENDS:rust-io-extras+os_pipe-devel = " \
 cargo \
 rust-io-extras-devel \
 rust-os_pipe+default-devel \
 "
RDEPENDS:rust-io-extras+socket2-devel = " \
 cargo \
 rust-io-extras-devel \
 rust-socket2+default-devel \
 "
RDEPENDS:rust-io-extras+tokio-devel = " \
 cargo \
 rust-io-extras-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-std-devel \
 rust-tokio+net-devel \
 rust-tokio+process-devel \
 "
RDEPENDS:rust-io-extras+use_async_std-devel = " \
 cargo \
 rust-io-extras+async-std-devel \
 rust-io-extras-devel \
 "
RDEPENDS:rust-io-extras+use_mio_net-devel = " \
 cargo \
 rust-io-extras+mio-devel \
 rust-io-extras-devel \
 rust-mio+default-devel \
 rust-mio+net-devel \
 "
RDEPENDS:rust-io-extras+use_mio_os_ext-devel = " \
 cargo \
 rust-io-extras+mio-devel \
 rust-io-extras-devel \
 rust-mio+default-devel \
 rust-mio+os-ext-devel \
 "
RDEPENDS:rust-io-extras+use_os_pipe-devel = " \
 cargo \
 rust-io-extras+os_pipe-devel \
 rust-io-extras-devel \
 "
RDEPENDS:rust-io-extras+use_socket2-devel = " \
 cargo \
 rust-io-extras+socket2-devel \
 rust-io-extras-devel \
 "
RDEPENDS:rust-io-extras+use_tokio-devel = " \
 cargo \
 rust-io-extras+tokio-devel \
 rust-io-extras-devel \
 "
RDEPENDS:rust-io-extras-devel = " \
 cargo \
 rust \
 rust-io-lifetimes+default-devel \
 "
