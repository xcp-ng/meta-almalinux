# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fs-set-times"
PV = "0.20.3"
PR = "5.el10_3"
PACKAGES = " \
 rust-fs-set-times+default-devel \
 rust-fs-set-times-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-fs-set-times-0.20.3-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8c640b395fd46d4a80213efb66f83ad8914de9e53a9d78d71f95dceb4c0acfd9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-set-times+default-devel-0.20.3-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-set-times+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fs-set-times+default-devel.sha256sum] = "aba25dd620f6e8ac141323271a7e6e8d89b2ad83941a61208cf9e22903659340"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-set-times-devel-0.20.3-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-set-times-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fs-set-times-devel.sha256sum] = "7957a907dee2a5bc5722e3f43524a862f391f0cffd6d8df5c8b77ee2d020b8bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-set-times+default-devel-0.20.3-5.el10_3.noarch.rpm;name=aarch64_rust-fs-set-times+default-devel;unpack=0"
SRC_URI[aarch64_rust-fs-set-times+default-devel.sha256sum] = "1047fc212ec79f821256c8a88cdcf0d8b0c047acce2c6a06ed73082cf8e2061c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-set-times-devel-0.20.3-5.el10_3.noarch.rpm;name=aarch64_rust-fs-set-times-devel;unpack=0"
SRC_URI[aarch64_rust-fs-set-times-devel.sha256sum] = "5a9fa93cef927adc5085ac3004e30f0c827db989ed26b49ae908e7b67775e12b"

RDEPENDS:rust-fs-set-times+default-devel = " \
 cargo \
 rust-fs-set-times-devel \
 "
RDEPENDS:rust-fs-set-times-devel = " \
 cargo \
 rust-io-lifetimes-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+time-devel \
 "
