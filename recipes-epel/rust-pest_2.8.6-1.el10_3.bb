# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest"
PV = "2.8.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-pest+const_prec_climber-devel \
 rust-pest+default-devel \
 rust-pest+memchr-devel \
 rust-pest+miette-error-devel \
 rust-pest+pretty-print-devel \
 rust-pest+std-devel \
 rust-pest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest-2.8.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea71beb0c51802babac490e9ecb9688e083abf9605e5136d23ac4f2027d98f93"

URI_x86_64_v2_rust-pest+const_prec_climber-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+const_prec_climber-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+const_prec_climber-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+const_prec_climber-devel}"
SRC_URI[x86_64_v2_rust-pest+const_prec_climber-devel.sha256sum] = "9b5427296ef2e6fedd70210d3af39c94d2c3da339a0f37ac09b7eb9a036d77e5"

URI_x86_64_v2_rust-pest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+default-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+default-devel}"
SRC_URI[x86_64_v2_rust-pest+default-devel.sha256sum] = "36690e6946468e7cb71082c7df8df5e73cc7049c3f0abd58e589d5f2d9a958dd"

URI_x86_64_v2_rust-pest+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+memchr-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+memchr-devel}"
SRC_URI[x86_64_v2_rust-pest+memchr-devel.sha256sum] = "059795439cee8120ad0833927743c46a89c99a7ea06f74946f37e4a749fc4b85"

URI_x86_64_v2_rust-pest+miette-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+miette-error-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+miette-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+miette-error-devel}"
SRC_URI[x86_64_v2_rust-pest+miette-error-devel.sha256sum] = "99b4edc41f93454c8bac7130e4ad27b7675958702aaa127f6c9fa43d6402d4c8"

URI_x86_64_v2_rust-pest+pretty-print-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+pretty-print-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+pretty-print-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+pretty-print-devel}"
SRC_URI[x86_64_v2_rust-pest+pretty-print-devel.sha256sum] = "3548ab4fc6aafe86545fb7ac4b75ae86816313dbb8fa9500dd4372a65c67827d"

URI_x86_64_v2_rust-pest+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+std-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+std-devel}"
SRC_URI[x86_64_v2_rust-pest+std-devel.sha256sum] = "cf081f743fd6f5898456fd73bda5e481548861fb35d7b355da857a79deef2ff2"

URI_x86_64_v2_rust-pest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest-devel}"
SRC_URI[x86_64_v2_rust-pest-devel.sha256sum] = "c482ac875fe3a39c3a3c0b68f0ef7bacebc3dd2c3b5bed8e77fb452efc0a8739"

URI_aarch64_rust-pest+const_prec_climber-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+const_prec_climber-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest+const_prec_climber-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+const_prec_climber-devel}"
SRC_URI[aarch64_rust-pest+const_prec_climber-devel.sha256sum] = "e432d329b6e0bb882a66f96ef2163b84ff156a87c25615d0c528c8c43e195d60"

URI_aarch64_rust-pest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+default-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+default-devel}"
SRC_URI[aarch64_rust-pest+default-devel.sha256sum] = "4224c7b2b67d2a75555e234a2436671e2259e26c15f2ad637235c5cecf0db9bc"

URI_aarch64_rust-pest+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+memchr-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+memchr-devel}"
SRC_URI[aarch64_rust-pest+memchr-devel.sha256sum] = "1ea9586108f33b453b088ed0153e505f1a5344f467250e73485910c64973aba7"

URI_aarch64_rust-pest+miette-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+miette-error-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest+miette-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+miette-error-devel}"
SRC_URI[aarch64_rust-pest+miette-error-devel.sha256sum] = "fee90134e17f60b9eb2e4441ccc55d631e3173399802c0b34e00440099c56cca"

URI_aarch64_rust-pest+pretty-print-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+pretty-print-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest+pretty-print-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+pretty-print-devel}"
SRC_URI[aarch64_rust-pest+pretty-print-devel.sha256sum] = "fbd62aae775f8192d7d6529b31d1945921987ee5c16a9b9e830c58d9330de950"

URI_aarch64_rust-pest+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+std-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+std-devel}"
SRC_URI[aarch64_rust-pest+std-devel.sha256sum] = "13433e18c7f6efd9bacd2560cbf924565ab5f49fe2e8f3c8fd9fcf3dacfb0472"

URI_aarch64_rust-pest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest-devel}"
SRC_URI[aarch64_rust-pest-devel.sha256sum] = "1ccc37113fbdf42a4a2967c09b545e434219866159ea6a95ca2d90aeb357e101"

RDEPENDS:rust-pest+const_prec_climber-devel = " \
 cargo \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+default-devel = " \
 cargo \
 rust-pest+memchr-devel \
 rust-pest+std-devel \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+memchr-devel = " \
 cargo \
 rust-memchr+default-devel \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+miette-error-devel = " \
 cargo \
 rust-miette+default-devel \
 rust-miette+fancy-devel \
 rust-pest+pretty-print-devel \
 rust-pest+std-devel \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+pretty-print-devel = " \
 cargo \
 rust-pest-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-pest+std-devel = " \
 cargo \
 rust-pest-devel \
 rust-ucd-trie+std-devel \
 "
RDEPENDS:rust-pest-devel = " \
 cargo \
 rust \
 rust-ucd-trie-devel \
 "
