# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdbusaddons"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kdbusaddons \
 kf6-kdbusaddons-devel \
 kf6-kdbusaddons-doc \
 kf6-kdbusaddons-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kdbusaddons-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "15faedf68854dfe156e5f2eece94da2e782e608b4d00fab38c5269e3299d02b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdbusaddons;unpack=0"
SRC_URI[x86_64_v2_kf6-kdbusaddons.sha256sum] = "84495cc4e39050df9787166f5a041719d12eb7bdf002ea26ed2a881314ab1f95"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdbusaddons-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kdbusaddons-devel.sha256sum] = "b28a720f2c815a99a9953b25aed33eeec69bd59e9e999de554f09552e459d9e3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdbusaddons-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kdbusaddons-doc.sha256sum] = "8b1066108340db0dc05a482c08f8c5e6deaaf2f27b8a8f439453b27a72c6340c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdbusaddons-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kdbusaddons-html.sha256sum] = "babd78eba2121d3421d68a44477c569c7b43db4acf6530dd888ef72f95f5e93e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdbusaddons;unpack=0"
SRC_URI[aarch64_kf6-kdbusaddons.sha256sum] = "42bfcbd47547414c33a4a5de7ae80dcee4a82758a8bc6df814415a08eaea5c5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdbusaddons-devel;unpack=0"
SRC_URI[aarch64_kf6-kdbusaddons-devel.sha256sum] = "8ba6c752f61ffd19525e7b95909b99f03689e6bab24183d63b295182b35b98eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdbusaddons-doc;unpack=0"
SRC_URI[aarch64_kf6-kdbusaddons-doc.sha256sum] = "b91bcf5789e9a5cbb32f50e903961102bae1e959ecae410fcc6727d8d66d6383"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdbusaddons-html;unpack=0"
SRC_URI[aarch64_kf6-kdbusaddons-html.sha256sum] = "6ca3c0be76c66255b46877af907278812194c7fde7ffe0e906275465258efd96"

RDEPENDS:kf6-kdbusaddons = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kdbusaddons-devel = " \
 cmake-filesystem \
 kf6-kdbusaddons \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdbusaddons-doc = " \
 "
RDEPENDS:kf6-kdbusaddons-html = " \
 "
