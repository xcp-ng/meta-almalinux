# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-lossy"
PV = "1.1.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-anstyle-lossy+default-devel \
 rust-anstyle-lossy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-lossy-1.1.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8ffe040510939874585b8a096ade41d712c649104ef446e3ea4edfed88bf816"

URI_x86_64_v2_rust-anstyle-lossy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-lossy+default-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-lossy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-lossy+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-lossy+default-devel.sha256sum] = "c415b5a5768e5d1d1e3a7363d533992c41d01e4d01ab916b505946df8dd85545"

URI_x86_64_v2_rust-anstyle-lossy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-lossy-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-lossy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-lossy-devel}"
SRC_URI[x86_64_v2_rust-anstyle-lossy-devel.sha256sum] = "82c66e512dd4c733a9ec71bbaf75a130536ac3964ba4ab7cbd6ec89380d854e4"

URI_aarch64_rust-anstyle-lossy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-lossy+default-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-anstyle-lossy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-lossy+default-devel}"
SRC_URI[aarch64_rust-anstyle-lossy+default-devel.sha256sum] = "98bbbd71132f625d3e4b1ea5d40e9386026ac0059e3ddf24d44c7621a1e2403f"

URI_aarch64_rust-anstyle-lossy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-lossy-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-anstyle-lossy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-lossy-devel}"
SRC_URI[aarch64_rust-anstyle-lossy-devel.sha256sum] = "7886676c02bb9490c06f9c16f152750bdd1c7133b388a8e8bf7b66a87c251487"

RDEPENDS:rust-anstyle-lossy+default-devel = " \
 cargo \
 rust-anstyle-lossy-devel \
 "
RDEPENDS:rust-anstyle-lossy-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 "
