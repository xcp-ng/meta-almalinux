# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sdbus-cpp"
PV = "2.1.0"
PR = "1.el10_1"
PACKAGES = " \
 sdbus-cpp \
 sdbus-cpp-devel \
 sdbus-cpp-devel-doc \
 sdbus-cpp-tests \
 sdbus-cpp-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sdbus-cpp-2.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56675a5593aa6855b312cbd4ffa3915fa2532e50c1a6b3bf185aa6bdc21029aa"

URI_x86_64_v2_sdbus-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sdbus-cpp-2.1.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sdbus-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sdbus-cpp}"
SRC_URI[x86_64_v2_sdbus-cpp.sha256sum] = "27ba4047a965bb100fe02bef53802f0f09fa493c7bc3a85cb66db624fbf70631"

URI_x86_64_v2_sdbus-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sdbus-cpp-devel-2.1.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sdbus-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sdbus-cpp-devel}"
SRC_URI[x86_64_v2_sdbus-cpp-devel.sha256sum] = "21b9d4dabf9d0886b7686e1bc39eea88f10e4db5b598788f23867b0b0c770dda"

URI_x86_64_v2_sdbus-cpp-devel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sdbus-cpp-devel-doc-2.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_sdbus-cpp-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sdbus-cpp-devel-doc}"
SRC_URI[x86_64_v2_sdbus-cpp-devel-doc.sha256sum] = "38ffb287a61878e0757b5b134786159782b8a4b701b345f205add75b48967049"

URI_x86_64_v2_sdbus-cpp-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sdbus-cpp-tests-2.1.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sdbus-cpp-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sdbus-cpp-tests}"
SRC_URI[x86_64_v2_sdbus-cpp-tests.sha256sum] = "560b13120c25d6caf71cd37295689ebdece995f73cb4994bc61542ea2ac8f6b6"

URI_x86_64_v2_sdbus-cpp-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sdbus-cpp-tools-2.1.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sdbus-cpp-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sdbus-cpp-tools}"
SRC_URI[x86_64_v2_sdbus-cpp-tools.sha256sum] = "4442d54eb4e16cd0f938f34a97f84e846449126961de66dbaea17b46959dbd1c"

URI_aarch64_sdbus-cpp = "${EPEL_MIRROR}/aarch64/Packages/s/sdbus-cpp-2.1.0-1.el10_1.aarch64.rpm;name=aarch64_sdbus-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_sdbus-cpp}"
SRC_URI[aarch64_sdbus-cpp.sha256sum] = "3d82c6a52a2f13250da08f4d530345bac8fdbfe4614dd2ef6f51a2ed955accba"

URI_aarch64_sdbus-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sdbus-cpp-devel-2.1.0-1.el10_1.aarch64.rpm;name=aarch64_sdbus-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sdbus-cpp-devel}"
SRC_URI[aarch64_sdbus-cpp-devel.sha256sum] = "6ea842be1992aad3d1bb0d2bd0c191f6437ca21048c5f15aa1260bf97a17c9bf"

URI_aarch64_sdbus-cpp-devel-doc = "${EPEL_MIRROR}/aarch64/Packages/s/sdbus-cpp-devel-doc-2.1.0-1.el10_1.noarch.rpm;name=aarch64_sdbus-cpp-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_sdbus-cpp-devel-doc}"
SRC_URI[aarch64_sdbus-cpp-devel-doc.sha256sum] = "1eddcaa4599e290af7d1e53092b80e633b7d0ac29e014719115e0f3ae6ce1e52"

URI_aarch64_sdbus-cpp-tests = "${EPEL_MIRROR}/aarch64/Packages/s/sdbus-cpp-tests-2.1.0-1.el10_1.aarch64.rpm;name=aarch64_sdbus-cpp-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_sdbus-cpp-tests}"
SRC_URI[aarch64_sdbus-cpp-tests.sha256sum] = "cc741c41947032bf57633d69611a410ad3392efb242dca84a7b5cfc9afe4d769"

URI_aarch64_sdbus-cpp-tools = "${EPEL_MIRROR}/aarch64/Packages/s/sdbus-cpp-tools-2.1.0-1.el10_1.aarch64.rpm;name=aarch64_sdbus-cpp-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_sdbus-cpp-tools}"
SRC_URI[aarch64_sdbus-cpp-tools.sha256sum] = "af87658b0608cfe63c5c7adfa5421834f73eae59120a6e53cac3d9050471fde2"

RDEPENDS:sdbus-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 systemd-libs \
 "
RDEPENDS:sdbus-cpp-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 sdbus-cpp \
 systemd-devel \
 "
RDEPENDS:sdbus-cpp-devel-doc = " \
 "
RDEPENDS:sdbus-cpp-tests = " \
 glibc \
 gmock \
 gtest \
 libgcc \
 libstdc++ \
 sdbus-cpp \
 systemd-libs \
 "
RDEPENDS:sdbus-cpp-tools = " \
 cmake-filesystem \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 sdbus-cpp \
 "
