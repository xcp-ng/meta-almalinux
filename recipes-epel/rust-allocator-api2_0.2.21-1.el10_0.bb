# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-allocator-api2"
PV = "0.2.21"
PR = "1.el10_0"
PACKAGES = " \
 rust-allocator-api2+alloc-devel \
 rust-allocator-api2+default-devel \
 rust-allocator-api2+fresh-rust-devel \
 rust-allocator-api2+nightly-devel \
 rust-allocator-api2+serde-devel \
 rust-allocator-api2+std-devel \
 rust-allocator-api2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-allocator-api2-0.2.21-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58423701f17c5ac63c1a26a7a60901cc0c61a698f801c1f202c796cd6253ac85"

URI_x86_64_v2_rust-allocator-api2+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-allocator-api2+alloc-devel-0.2.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-allocator-api2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-allocator-api2+alloc-devel}"
SRC_URI[x86_64_v2_rust-allocator-api2+alloc-devel.sha256sum] = "0624e21c06445bb88b59b2a7c4e33bf6896061650770f857415862f19fc9e6e4"

URI_x86_64_v2_rust-allocator-api2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-allocator-api2+default-devel-0.2.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-allocator-api2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-allocator-api2+default-devel}"
SRC_URI[x86_64_v2_rust-allocator-api2+default-devel.sha256sum] = "c469932ca449faa67016330db04ee4f7b781eb4f30c1f3b0b12dbef7817d9c7d"

URI_x86_64_v2_rust-allocator-api2+fresh-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-allocator-api2+fresh-rust-devel-0.2.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-allocator-api2+fresh-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-allocator-api2+fresh-rust-devel}"
SRC_URI[x86_64_v2_rust-allocator-api2+fresh-rust-devel.sha256sum] = "73cad61030eb41e9d0005b3c51c05ad5f5a9bdb1efefc144e8bf6e0a8a37c70e"

URI_x86_64_v2_rust-allocator-api2+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-allocator-api2+nightly-devel-0.2.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-allocator-api2+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-allocator-api2+nightly-devel}"
SRC_URI[x86_64_v2_rust-allocator-api2+nightly-devel.sha256sum] = "01324821d3f693ec0b3efd45b775d56c09b627b3b23219f337681d7fc62eb2e2"

URI_x86_64_v2_rust-allocator-api2+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-allocator-api2+serde-devel-0.2.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-allocator-api2+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-allocator-api2+serde-devel}"
SRC_URI[x86_64_v2_rust-allocator-api2+serde-devel.sha256sum] = "32c3a27e6c02b12775a6813654ef52a7c0aa1ba8580c4b2ca5b4d581a8c55cf2"

URI_x86_64_v2_rust-allocator-api2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-allocator-api2+std-devel-0.2.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-allocator-api2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-allocator-api2+std-devel}"
SRC_URI[x86_64_v2_rust-allocator-api2+std-devel.sha256sum] = "912619fdadb8b9acb7b29f9d6de9037f8e8e7545d63c5cf62abb58ab2bbdad21"

URI_x86_64_v2_rust-allocator-api2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-allocator-api2-devel-0.2.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-allocator-api2-devel}"
SRC_URI[x86_64_v2_rust-allocator-api2-devel.sha256sum] = "6886e6c52487ecadeab231a349122df9c4d533f92a84def3f246a5feff693b67"

URI_aarch64_rust-allocator-api2+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-allocator-api2+alloc-devel-0.2.21-1.el10_0.noarch.rpm;name=aarch64_rust-allocator-api2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-allocator-api2+alloc-devel}"
SRC_URI[aarch64_rust-allocator-api2+alloc-devel.sha256sum] = "fe330608e0ab94d98407ccb8059625b131cc91404b971621372fb3e50fc74ac9"

URI_aarch64_rust-allocator-api2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-allocator-api2+default-devel-0.2.21-1.el10_0.noarch.rpm;name=aarch64_rust-allocator-api2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-allocator-api2+default-devel}"
SRC_URI[aarch64_rust-allocator-api2+default-devel.sha256sum] = "df07ec552433c8af09a3129f4a23d125dafce45b00d108bc552a38b3856a52e7"

URI_aarch64_rust-allocator-api2+fresh-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-allocator-api2+fresh-rust-devel-0.2.21-1.el10_0.noarch.rpm;name=aarch64_rust-allocator-api2+fresh-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-allocator-api2+fresh-rust-devel}"
SRC_URI[aarch64_rust-allocator-api2+fresh-rust-devel.sha256sum] = "b50b76486dfeac515fe60e55feb222ff5ce69537b4e086244129488dc52bb858"

URI_aarch64_rust-allocator-api2+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-allocator-api2+nightly-devel-0.2.21-1.el10_0.noarch.rpm;name=aarch64_rust-allocator-api2+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-allocator-api2+nightly-devel}"
SRC_URI[aarch64_rust-allocator-api2+nightly-devel.sha256sum] = "30b83f43c8476b6d2d5e1dafdee5aead7cca2607adb7b52bd65575d5ce05a9a4"

URI_aarch64_rust-allocator-api2+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-allocator-api2+serde-devel-0.2.21-1.el10_0.noarch.rpm;name=aarch64_rust-allocator-api2+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-allocator-api2+serde-devel}"
SRC_URI[aarch64_rust-allocator-api2+serde-devel.sha256sum] = "4f8f2461bf8db33598648b68bbcfe8535f432a2d3ac75318ecfdca8ff184a1ae"

URI_aarch64_rust-allocator-api2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-allocator-api2+std-devel-0.2.21-1.el10_0.noarch.rpm;name=aarch64_rust-allocator-api2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-allocator-api2+std-devel}"
SRC_URI[aarch64_rust-allocator-api2+std-devel.sha256sum] = "bb554fbb7bb02504db6670877a49e865aca72f695046df9b850426a8d2ba310a"

URI_aarch64_rust-allocator-api2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-allocator-api2-devel-0.2.21-1.el10_0.noarch.rpm;name=aarch64_rust-allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-allocator-api2-devel}"
SRC_URI[aarch64_rust-allocator-api2-devel.sha256sum] = "865ee745d990bbe73af95052678663830e1abc6f8822324523bcffb32d444242"

RDEPENDS:rust-allocator-api2+alloc-devel = " \
 cargo \
 rust-allocator-api2-devel \
 "
RDEPENDS:rust-allocator-api2+default-devel = " \
 cargo \
 rust-allocator-api2+std-devel \
 rust-allocator-api2-devel \
 "
RDEPENDS:rust-allocator-api2+fresh-rust-devel = " \
 cargo \
 rust-allocator-api2-devel \
 "
RDEPENDS:rust-allocator-api2+nightly-devel = " \
 cargo \
 rust-allocator-api2-devel \
 "
RDEPENDS:rust-allocator-api2+serde-devel = " \
 cargo \
 rust-allocator-api2-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-allocator-api2+std-devel = " \
 cargo \
 rust-allocator-api2+alloc-devel \
 rust-allocator-api2-devel \
 "
RDEPENDS:rust-allocator-api2-devel = " \
 cargo \
 rust \
 "
