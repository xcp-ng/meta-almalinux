# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-phayes-permbits"
PV = "0"
PR = "16.20210110git39d7c58.el10_0"
PACKAGES = " \
 golang-github-phayes-permbits-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-phayes-permbits-0-16.20210110git39d7c58.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f4b04b3b0d1bbe40687957bbcd49206ce01b29ac798470396a12ee01f380dc4"

URI_aarch64_golang-github-phayes-permbits-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-phayes-permbits-devel-0-16.20210110git39d7c58.el10_0.noarch.rpm;name=aarch64_golang-github-phayes-permbits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-phayes-permbits-devel}"
SRC_URI[aarch64_golang-github-phayes-permbits-devel.sha256sum] = "8f04da8f34f01d3a411943eb98f8e20c341ae3002de460be0488ddc534915d73"

RDEPENDS:golang-github-phayes-permbits-devel = " \
 go-filesystem \
 "
