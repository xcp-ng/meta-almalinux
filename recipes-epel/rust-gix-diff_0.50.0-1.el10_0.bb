# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-diff"
PV = "0.50.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-diff+blob-devel \
 rust-gix-diff+default-devel \
 rust-gix-diff+document-features-devel \
 rust-gix-diff+index-devel \
 rust-gix-diff+serde-devel \
 rust-gix-diff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-diff-0.50.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8101a3080a55e27ae1cf1ef470888447fe445cff69798c7aca86a43fe318343"

URI_x86_64_v2_rust-gix-diff+blob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+blob-devel-0.50.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+blob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+blob-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+blob-devel.sha256sum] = "86b8a36dcea90327d0565fc625de9be6b309fcf6e34c69217cd88d0a38f46689"

URI_x86_64_v2_rust-gix-diff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+default-devel-0.50.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+default-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+default-devel.sha256sum] = "b56c7edd1110b8e1ffe8b82d37a25f9f8a2ba6f8384a395ed844e48e5588732e"

URI_x86_64_v2_rust-gix-diff+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+document-features-devel-0.50.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+document-features-devel.sha256sum] = "4be3dbaee68b36c47fe1a3d0ffb476f7bb48fabe581f14d16d8f3dc57b22e463"

URI_x86_64_v2_rust-gix-diff+index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+index-devel-0.50.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+index-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+index-devel.sha256sum] = "3e8e96fd83f2ada2d56411694a4daa858c53b7c0b66a7bf669b726b2e2b05c2b"

URI_x86_64_v2_rust-gix-diff+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+serde-devel-0.50.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+serde-devel.sha256sum] = "f50c895f7f8ed59aca3e9515853d2ea10f933745aa3ad52b29c673f48eb96e8f"

URI_x86_64_v2_rust-gix-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff-devel-0.50.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff-devel}"
SRC_URI[x86_64_v2_rust-gix-diff-devel.sha256sum] = "7634a10cba7f0a5af73cde67419736bc05868e624fbf083c975d74fee41a4236"

URI_aarch64_rust-gix-diff+blob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+blob-devel-0.50.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-diff+blob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+blob-devel}"
SRC_URI[aarch64_rust-gix-diff+blob-devel.sha256sum] = "a25e49d35c6af22ce539cfae14335807d90d7ed91d2fe08aecd6e54a72d7deeb"

URI_aarch64_rust-gix-diff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+default-devel-0.50.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+default-devel}"
SRC_URI[aarch64_rust-gix-diff+default-devel.sha256sum] = "040d563d0ed8b08d7cea200e79f9880fa31a02bbf734a80adeaab11f074faa73"

URI_aarch64_rust-gix-diff+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+document-features-devel-0.50.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-diff+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+document-features-devel}"
SRC_URI[aarch64_rust-gix-diff+document-features-devel.sha256sum] = "0e39d4b8037232f7cf53919fce81cb03d65e1b79e459652e58b8ff5bdde221c7"

URI_aarch64_rust-gix-diff+index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+index-devel-0.50.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-diff+index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+index-devel}"
SRC_URI[aarch64_rust-gix-diff+index-devel.sha256sum] = "e1a410dc72f1af3629e4bfa9c81aec406c0ca6496346d224d53108472a888a8d"

URI_aarch64_rust-gix-diff+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+serde-devel-0.50.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-diff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+serde-devel}"
SRC_URI[aarch64_rust-gix-diff+serde-devel.sha256sum] = "b700223640f0793cfee47f92e4d26dd4747110f64bfa90218d88eb4fe65155b2"

URI_aarch64_rust-gix-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff-devel-0.50.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff-devel}"
SRC_URI[aarch64_rust-gix-diff-devel.sha256sum] = "93bb81351d37a5f836b80e2ee8ea2a836b23b02000752cb78599df391e606b5c"

RDEPENDS:rust-gix-diff+blob-devel = " \
 cargo \
 rust-gix-command+default-devel \
 rust-gix-diff-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-path+default-devel \
 rust-gix-tempfile+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-traverse+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-imara-diff+default-devel \
 "
RDEPENDS:rust-gix-diff+default-devel = " \
 cargo \
 rust-gix-diff+blob-devel \
 rust-gix-diff+index-devel \
 rust-gix-diff-devel \
 "
RDEPENDS:rust-gix-diff+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-diff-devel \
 "
RDEPENDS:rust-gix-diff+index-devel = " \
 cargo \
 rust-gix-attributes+default-devel \
 rust-gix-diff-devel \
 rust-gix-index+default-devel \
 rust-gix-pathspec+default-devel \
 "
RDEPENDS:rust-gix-diff+serde-devel = " \
 cargo \
 rust-gix-diff-devel \
 rust-gix-hash+serde-devel \
 rust-gix-index+default-devel \
 rust-gix-index+serde-devel \
 rust-gix-object+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-diff-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-thiserror+default-devel \
 "
