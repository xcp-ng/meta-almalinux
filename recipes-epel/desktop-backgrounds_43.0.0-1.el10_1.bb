# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "desktop-backgrounds"
PV = "43.0.0"
PR = "1.el10_1"
PACKAGES = " \
 desktop-backgrounds-basic \
 desktop-backgrounds-budgie \
 desktop-backgrounds-compat \
 desktop-backgrounds-gnome \
 desktop-backgrounds-waves \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/desktop-backgrounds-43.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0b26f87a093ea79f49ae7dbcf24188043fbe927df8a165f34ab0d245aafe08d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-basic-43.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-basic;unpack=0"
SRC_URI[x86_64_v2_desktop-backgrounds-basic.sha256sum] = "a586bdecc57faabf9dfb15049d678e6ed41f2270edb5bded65961b57f38f9786"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-budgie-43.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-budgie;unpack=0"
SRC_URI[x86_64_v2_desktop-backgrounds-budgie.sha256sum] = "45442127cbe987899f647699baffb015daceb8ce92879924e5c7cc776056ef8a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-compat-43.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-compat;unpack=0"
SRC_URI[x86_64_v2_desktop-backgrounds-compat.sha256sum] = "3c91387478d585bf3209e2f16f4bc75cfaf592a37ef9f518163a53fe7c880043"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-gnome-43.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-gnome;unpack=0"
SRC_URI[x86_64_v2_desktop-backgrounds-gnome.sha256sum] = "90dc6cb6f404cf430a58e1ea310a3f592a6e0aa1b8ff67124c41f51fe6c70bc9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-waves-43.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-waves;unpack=0"
SRC_URI[x86_64_v2_desktop-backgrounds-waves.sha256sum] = "d4275f8b0d6fc0d6d347c408551192567cbd6a4b19164e77398a1dfb4d1e8fea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-basic-43.0.0-1.el10_1.noarch.rpm;name=aarch64_desktop-backgrounds-basic;unpack=0"
SRC_URI[aarch64_desktop-backgrounds-basic.sha256sum] = "990c4e3ae5daa8c8c4b53a936bb45289549f9ab4022e74ba53cd22df5dc3706f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-budgie-43.0.0-1.el10_1.noarch.rpm;name=aarch64_desktop-backgrounds-budgie;unpack=0"
SRC_URI[aarch64_desktop-backgrounds-budgie.sha256sum] = "cb8ea34593ffca93f70cec83ecff0ac3e59929464005d52d507168f1f0b4881a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-compat-43.0.0-1.el10_1.noarch.rpm;name=aarch64_desktop-backgrounds-compat;unpack=0"
SRC_URI[aarch64_desktop-backgrounds-compat.sha256sum] = "5bcf2671617ddee612aeecd0b8e9730ee45b7c1ae3f4ef2d8c69f6f484122270"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-gnome-43.0.0-1.el10_1.noarch.rpm;name=aarch64_desktop-backgrounds-gnome;unpack=0"
SRC_URI[aarch64_desktop-backgrounds-gnome.sha256sum] = "0371ab56f72a2ca25bce1257eef94938416c37d588c2bcbfab3e70ea27b396aa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-waves-43.0.0-1.el10_1.noarch.rpm;name=aarch64_desktop-backgrounds-waves;unpack=0"
SRC_URI[aarch64_desktop-backgrounds-waves.sha256sum] = "7dbc3b790226ddcbb5865bc3eb8af2c95fc1b55b839f70f1be7aecb81add914d"

RDEPENDS:desktop-backgrounds-basic = " \
 "
RDEPENDS:desktop-backgrounds-budgie = " \
 f43-backgrounds-budgie \
 gsettings-desktop-schemas \
 "
RDEPENDS:desktop-backgrounds-compat = " \
 f43-backgrounds-base \
 "
RDEPENDS:desktop-backgrounds-gnome = " \
 f43-backgrounds-gnome \
 gsettings-desktop-schemas \
 "
RDEPENDS:desktop-backgrounds-waves = " \
 "
