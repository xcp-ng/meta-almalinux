# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-config"
PV = "0.25.10"
PR = "3.el10_2"
PACKAGES = " \
 rust-tree-sitter-config+default-devel \
 rust-tree-sitter-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-config-0.25.10-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fedd49ea6c6fa4a8d1b6601d8ebd3b1577eebdc35749caeef76561459e2af59e"

URI_x86_64_v2_rust-tree-sitter-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-config+default-devel-0.25.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-config+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-config+default-devel.sha256sum] = "e28e1d04857b65690c88fa01727d0806d2d9c069ff6ed7d763df0b1b630996c1"

URI_x86_64_v2_rust-tree-sitter-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-config-devel-0.25.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-config-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-config-devel.sha256sum] = "6abae0da7174058a3b447bc8d29faddde10ee35039d6a06a04967bf577b4a16d"

URI_aarch64_rust-tree-sitter-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-config+default-devel-0.25.10-3.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-config+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-config+default-devel.sha256sum] = "0c21b687701b560d20040c7f44b1cadfd99f8775ce4f140783f533c576463821"

URI_aarch64_rust-tree-sitter-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-config-devel-0.25.10-3.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-config-devel}"
SRC_URI[aarch64_rust-tree-sitter-config-devel.sha256sum] = "33774238005d3f971f732f826cfc7688087ce5d0dc99612152aa276b1a015742"

RDEPENDS:rust-tree-sitter-config+default-devel = " \
 cargo \
 rust-tree-sitter-config-devel \
 "
RDEPENDS:rust-tree-sitter-config-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-etcetera+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+preserve_order-devel \
 "
