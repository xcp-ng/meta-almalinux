# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rsync"
PV = "3.5.0"
PR = "3.el10_2"
PACKAGES = " \
 rsync \
 rsync-daemon \
 rsync-rrsync \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rsync-3.5.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a09a33f4a692514027ddbf307cbebf1f5a901b76570fcce42c6322255f6ff456"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rsync-3.5.0-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_rsync;unpack=0"
SRC_URI[x86_64_v2_rsync.sha256sum] = "0ef43712db75150af848c2d4b7c0bf5afed44360f9c1e5232140fc0d819ddedf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsync-daemon-3.5.0-3.el10_2.noarch.rpm;name=x86_64_v2_rsync-daemon;unpack=0"
SRC_URI[x86_64_v2_rsync-daemon.sha256sum] = "d9eeb4e538648566b7bc50ebdf47325f2158a1f110be3d5a1451d1dbf7b786e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsync-rrsync-3.5.0-3.el10_2.noarch.rpm;name=x86_64_v2_rsync-rrsync;unpack=0"
SRC_URI[x86_64_v2_rsync-rrsync.sha256sum] = "f379c5d18d7e720110d224d854c2e2796f7af861e7e3c5b78903eaadc9caa299"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rsync-3.5.0-3.el10_2.aarch64.rpm;name=aarch64_rsync;unpack=0"
SRC_URI[aarch64_rsync.sha256sum] = "083a290c8202305d7e47d055fce15fb023be49dd11e0bab9a828988db93b52ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsync-daemon-3.5.0-3.el10_2.noarch.rpm;name=aarch64_rsync-daemon;unpack=0"
SRC_URI[aarch64_rsync-daemon.sha256sum] = "d9eeb4e538648566b7bc50ebdf47325f2158a1f110be3d5a1451d1dbf7b786e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsync-rrsync-3.5.0-3.el10_2.noarch.rpm;name=aarch64_rsync-rrsync;unpack=0"
SRC_URI[aarch64_rsync-rrsync.sha256sum] = "f379c5d18d7e720110d224d854c2e2796f7af861e7e3c5b78903eaadc9caa299"

RDEPENDS:rsync = " \
 bash \
 glibc \
 libacl \
 libzstd \
 lz4-libs \
 openssl-libs \
 popt \
 "
RDEPENDS:rsync-daemon = " \
 bash \
 rsync \
 systemd \
 "
RDEPENDS:rsync-rrsync = " \
 python3 \
 rsync \
 "
