# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcupsfilters"
PE = "1"
PV = "2.0.0"
PR = "10.el10"
PACKAGES = " \
 libcupsfilters \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libcupsfilters-2.0.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b6f09eb62e505d6f01c6639ff08138020a5e623c23562d13dc8d40257f5892f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcupsfilters-2.0.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_libcupsfilters;unpack=0"
SRC_URI[x86_64_v2_libcupsfilters.sha256sum] = "46d6b6bca3c81cc3f68288fcefcfe224b82b46a7de0851630dccf82e794554d9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcupsfilters-2.0.0-10.el10.aarch64.rpm;name=aarch64_libcupsfilters;unpack=0"
SRC_URI[aarch64_libcupsfilters.sha256sum] = "453325996c2f419a39bdc89cc627112f7d6a73f219591401344156618dbae40a"

RDEPENDS:libcupsfilters = " \
 colord \
 cups-filesystem \
 cups-libs \
 dbus-libs \
 fontconfig \
 ghostscript \
 glibc \
 lcms2 \
 libexif \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 poppler-cpp \
 qpdf-libs \
 "
