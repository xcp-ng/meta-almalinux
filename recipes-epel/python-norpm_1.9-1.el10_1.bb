# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-norpm"
PV = "1.9"
PR = "1.el10_1"
PACKAGES = " \
 python3-norpm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-norpm-1.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aaa0df8bdbe6128f8d9162bf6005a594162de4e97d5bccabfbab2b32166bb184"

URI_x86_64_v2_python3-norpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-norpm-1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-norpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-norpm}"
SRC_URI[x86_64_v2_python3-norpm.sha256sum] = "f629dcce6b09f6027327b6a255bf743baa9f2b396beb02b0865e6442cc5a2b56"

URI_aarch64_python3-norpm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-norpm-1.9-1.el10_1.noarch.rpm;name=aarch64_python3-norpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-norpm}"
SRC_URI[aarch64_python3-norpm.sha256sum] = "5d00a567e0bfd2116c0b35a3124c893c79a6ac3663bedc5b36ee9813514a4607"

RDEPENDS:python3-norpm = " \
 python3 \
 python3-lark \
 "
