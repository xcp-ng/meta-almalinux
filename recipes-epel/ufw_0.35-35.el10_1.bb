# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ufw"
PV = "0.35"
PR = "35.el10_1"
PACKAGES = " \
 ufw \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/ufw-0.35-35.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81dc533a0a9442e195ca6a294787a166f095624b0702362187dfe5bb15791116"

URI_x86_64_v2_ufw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ufw-0.35-35.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ufw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ufw}"
SRC_URI[x86_64_v2_ufw.sha256sum] = "ed2c8a93870f314de65b05d5a14bdd6e0724ba87acaec1c43c569bdc05e2f5fc"

URI_aarch64_ufw = "${EPEL_MIRROR}/aarch64/Packages/u/ufw-0.35-35.el10_1.noarch.rpm;name=aarch64_ufw;unpack=0"
SRC_URI:append = " ${URI_aarch64_ufw}"
SRC_URI[aarch64_ufw.sha256sum] = "b0823e3a56287b68e130ee8bb84d50b84094dd4110e02874af238738ebe1da13"

RDEPENDS:ufw = " \
 bash \
 iptables-nft \
 python3 \
 systemd \
 "
