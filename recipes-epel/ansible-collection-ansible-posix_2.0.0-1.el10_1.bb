# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-ansible-posix"
PV = "2.0.0"
PR = "1.el10_1"
PACKAGES = " \
 ansible-collection-ansible-posix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-collection-ansible-posix-2.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9181e6c2e4ef49715b310cd11a8c9a0965dbc20232c61f0899b97d1d502e651"

URI_x86_64_v2_ansible-collection-ansible-posix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-collection-ansible-posix-2.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-collection-ansible-posix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-ansible-posix}"
SRC_URI[x86_64_v2_ansible-collection-ansible-posix.sha256sum] = "5bcfc34b1cea52bdd0861b1170eb937a4f1d58818162a770738dff0a77a6d67e"

URI_aarch64_ansible-collection-ansible-posix = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-collection-ansible-posix-2.0.0-1.el10_1.noarch.rpm;name=aarch64_ansible-collection-ansible-posix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-ansible-posix}"
SRC_URI[aarch64_ansible-collection-ansible-posix.sha256sum] = "c46e4675fbc5c514cc8fa9763250a1e78c694d3bbbf9e48d4c394c6229726c4b"

RDEPENDS:ansible-collection-ansible-posix = " \
 ansible-core \
 "
