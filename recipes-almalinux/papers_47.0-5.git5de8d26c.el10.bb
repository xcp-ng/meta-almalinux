# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "papers"
PV = "47.0"
PR = "5.git5de8d26c.el10"
PACKAGES = " \
 papers \
 papers-devel \
 papers-libs \
 papers-nautilus \
 papers-previewer \
 papers-thumbnailer \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/papers-47.0-5.git5de8d26c.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d65565acf1dc5e2284d7eddf8e1afad2227b08ccdb4bb9807aea0b3f4e1a01ec"

URI_x86_64_v2_papers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-47.0-5.git5de8d26c.el10.x86_64_v2.rpm;name=x86_64_v2_papers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers}"
SRC_URI[x86_64_v2_papers.sha256sum] = "0ec2c462e72bf6112ce8fec34f694402617e90fb05042e5ff530e4267eda40b3"

URI_x86_64_v2_papers-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/papers-devel-47.0-5.git5de8d26c.el10.x86_64_v2.rpm;name=x86_64_v2_papers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-devel}"
SRC_URI[x86_64_v2_papers-devel.sha256sum] = "f579df1d1c0ec2b84e5970a3cc8970f12da059fceeeac477d36cc1cdc84b608c"

URI_x86_64_v2_papers-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-libs-47.0-5.git5de8d26c.el10.x86_64_v2.rpm;name=x86_64_v2_papers-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-libs}"
SRC_URI[x86_64_v2_papers-libs.sha256sum] = "0a77b742f8a0a7aa015794d7f25d66eea28474599c91894d82b5f6130e573cd9"

URI_x86_64_v2_papers-nautilus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-nautilus-47.0-5.git5de8d26c.el10.x86_64_v2.rpm;name=x86_64_v2_papers-nautilus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-nautilus}"
SRC_URI[x86_64_v2_papers-nautilus.sha256sum] = "eecc71f849767c0587f2c6365157202892483dc4e6b8e1f2c4a3d35350fb540b"

URI_x86_64_v2_papers-previewer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-previewer-47.0-5.git5de8d26c.el10.x86_64_v2.rpm;name=x86_64_v2_papers-previewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-previewer}"
SRC_URI[x86_64_v2_papers-previewer.sha256sum] = "3e3723e44cb223ff229395c0612af672fb5604d1aa37d2272e12e9f477b2c669"

URI_x86_64_v2_papers-thumbnailer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-thumbnailer-47.0-5.git5de8d26c.el10.x86_64_v2.rpm;name=x86_64_v2_papers-thumbnailer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-thumbnailer}"
SRC_URI[x86_64_v2_papers-thumbnailer.sha256sum] = "cce20ebb331399646a8ca650a93f4bd0145d7d9661117121e302d14142efa16b"

URI_aarch64_papers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-47.0-5.git5de8d26c.el10.aarch64.rpm;name=aarch64_papers;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers}"
SRC_URI[aarch64_papers.sha256sum] = "5ec48067cbbc3dde2d3335b81febe2cec4d5476c1538a6bb0f645f2bac9020a3"

URI_aarch64_papers-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/papers-devel-47.0-5.git5de8d26c.el10.aarch64.rpm;name=aarch64_papers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-devel}"
SRC_URI[aarch64_papers-devel.sha256sum] = "f8012f423ad2754b22e99c1dc80dc6d99e3a244bfe6dd3cc7303b94a991d8440"

URI_aarch64_papers-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-libs-47.0-5.git5de8d26c.el10.aarch64.rpm;name=aarch64_papers-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-libs}"
SRC_URI[aarch64_papers-libs.sha256sum] = "a303e5d21b4d8fde54b1f1377336ac4c4eb813f97597832f62da83a82b12e17f"

URI_aarch64_papers-nautilus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-nautilus-47.0-5.git5de8d26c.el10.aarch64.rpm;name=aarch64_papers-nautilus;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-nautilus}"
SRC_URI[aarch64_papers-nautilus.sha256sum] = "a3e7a47c72b58d414c867466368fa5297d9e0e3116b364f156a4462289ce4359"

URI_aarch64_papers-previewer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-previewer-47.0-5.git5de8d26c.el10.aarch64.rpm;name=aarch64_papers-previewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-previewer}"
SRC_URI[aarch64_papers-previewer.sha256sum] = "f6dda749e3aab9c5674eb31d93e9b3880d5da7320f6455eed18aef88d5c32d0b"

URI_aarch64_papers-thumbnailer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-thumbnailer-47.0-5.git5de8d26c.el10.aarch64.rpm;name=aarch64_papers-thumbnailer;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-thumbnailer}"
SRC_URI[aarch64_papers-thumbnailer.sha256sum] = "a9ff473b89d44f5c238a7b36b37e2042fd7c34273a0a3760c309496689d40e5f"

RDEPENDS:papers = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 hicolor-icon-theme \
 libadwaita \
 libgcc \
 pango \
 papers-libs \
 papers-previewer \
 papers-thumbnailer \
 "
RDEPENDS:papers-devel = " \
 glib2-devel \
 gtk4-devel \
 libadwaita-devel \
 papers-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:papers-libs = " \
 cairo \
 exempi \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 gtksourceview5 \
 libadwaita \
 libarchive \
 libgcc \
 libspelling \
 libtiff \
 pango \
 poppler-glib \
 "
RDEPENDS:papers-nautilus = " \
 glib2 \
 glibc \
 libgcc \
 nautilus \
 nautilus-extensions \
 papers-libs \
 "
RDEPENDS:papers-previewer = " \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
 libgcc \
 papers-libs \
 "
RDEPENDS:papers-thumbnailer = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libgcc \
 papers-libs \
 "
