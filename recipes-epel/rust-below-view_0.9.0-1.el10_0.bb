# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-view"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-below-view+default-devel \
 rust-below-view-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-view-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "503b08caf7a3b923c5d1a480a6b516c8547777be3b55b5fe3b5fe7ddb874cd52"

URI_x86_64_v2_rust-below-view+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-view+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-view+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-view+default-devel}"
SRC_URI[x86_64_v2_rust-below-view+default-devel.sha256sum] = "f8fd1f55bf9a1a4686c9cb1cb4350b92e97badbd138c8afb5cad46e6ee3fbec9"

URI_x86_64_v2_rust-below-view-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-view-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-view-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-view-devel}"
SRC_URI[x86_64_v2_rust-below-view-devel.sha256sum] = "e332afe417bfcb2e11c445a702b77c5180152ac4d76ad12b551dccefbddcb848"

URI_aarch64_rust-below-view+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-view+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-view+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-view+default-devel}"
SRC_URI[aarch64_rust-below-view+default-devel.sha256sum] = "01df356b3dd0050fe5fde5783a11cce49d5f772c9f6fa6dae39426e242af2509"

URI_aarch64_rust-below-view-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-view-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-view-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-view-devel}"
SRC_URI[aarch64_rust-below-view-devel.sha256sum] = "8ed180aa291cacde946617df29f4266443359a61a89589266707fbba64eddcec"

RDEPENDS:rust-below-view+default-devel = " \
 cargo \
 rust-below-view-devel \
 "
RDEPENDS:rust-below-view-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-below-common+default-devel \
 rust-below-model+default-devel \
 rust-below-render+default-devel \
 rust-below-store+default-devel \
 rust-chrono+clock-devel \
 rust-chrono+serde-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-crossterm+default-devel \
 rust-crossterm+event-stream-devel \
 rust-cursive0.20+crossterm-backend-devel \
 rust-cursive0.20-devel \
 rust-cursive_buffered_backend+default-devel \
 rust-enum-iterator+default-devel \
 rust-fb_procfs+default-devel \
 rust-humantime+default-devel \
 rust-itertools+default-devel \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-slog+default-devel \
 rust-slog+max_level_trace-devel \
 rust-slog+nested-values-devel \
 rust-toml+default-devel \
 "
