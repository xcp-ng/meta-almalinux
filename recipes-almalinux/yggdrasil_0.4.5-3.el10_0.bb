# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yggdrasil"
PV = "0.4.5"
PR = "3.el10_0"
PACKAGES = " \
 yggdrasil \
 yggdrasil-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yggdrasil-0.4.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0447b143f2e115bda75ee118b99e0a3d1d619206f4a4d5425e740ea569705699"

URI_x86_64_v2_yggdrasil = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yggdrasil-0.4.5-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_yggdrasil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yggdrasil}"
SRC_URI[x86_64_v2_yggdrasil.sha256sum] = "4f2193da43e2f356d9ff8c13e9f9df50cba26f2ed1a80c12a4a8882923276a14"

URI_x86_64_v2_yggdrasil-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/yggdrasil-devel-0.4.5-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_yggdrasil-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yggdrasil-devel}"
SRC_URI[x86_64_v2_yggdrasil-devel.sha256sum] = "5da2dea6dbefc5f3f44e38cfba724a9806c165074226cc34ab02addf6ee64021"

URI_aarch64_yggdrasil = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yggdrasil-0.4.5-3.el10_0.aarch64.rpm;name=aarch64_yggdrasil;unpack=0"
SRC_URI:append = " ${URI_aarch64_yggdrasil}"
SRC_URI[aarch64_yggdrasil.sha256sum] = "f71cc315e852df300e731db190a81111becc5ca43d9583224d629904fa6b53ce"

URI_aarch64_yggdrasil-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/yggdrasil-devel-0.4.5-3.el10_0.aarch64.rpm;name=aarch64_yggdrasil-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yggdrasil-devel}"
SRC_URI[aarch64_yggdrasil-devel.sha256sum] = "63d74cc162ad1c274e083ddf6d77dfbb4c0f2481c38528629df7bb1303bbb6e3"

RDEPENDS:yggdrasil = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:yggdrasil-devel = " \
 pkgconf-pkg-config \
 "
