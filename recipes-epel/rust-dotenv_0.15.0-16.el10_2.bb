# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dotenv"
PV = "0.15.0"
PR = "16.el10_2"
PACKAGES = " \
 rust-dotenv+default-devel \
 rust-dotenv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dotenv-0.15.0-16.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4460aaabb52fbb2dd4e8b4e1e622dd78155d9adf08a0f3d6707b4c1b1a74a678"

URI_x86_64_v2_rust-dotenv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dotenv+default-devel-0.15.0-16.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dotenv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dotenv+default-devel}"
SRC_URI[x86_64_v2_rust-dotenv+default-devel.sha256sum] = "3a2f7c14cd245072f5c0da9da11867517f547196cac9f05a3080d42b2fed9865"

URI_x86_64_v2_rust-dotenv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dotenv-devel-0.15.0-16.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dotenv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dotenv-devel}"
SRC_URI[x86_64_v2_rust-dotenv-devel.sha256sum] = "284e2b594dd204d99cd7c117bab9f587f60e8d60dc50c654522217f779b0ba3f"

URI_aarch64_rust-dotenv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dotenv+default-devel-0.15.0-16.el10_2.noarch.rpm;name=aarch64_rust-dotenv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dotenv+default-devel}"
SRC_URI[aarch64_rust-dotenv+default-devel.sha256sum] = "308129f0be0ff475ed09da2adeb543d4cedcaa3ece4a624eefd00022dcb60ba8"

URI_aarch64_rust-dotenv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dotenv-devel-0.15.0-16.el10_2.noarch.rpm;name=aarch64_rust-dotenv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dotenv-devel}"
SRC_URI[aarch64_rust-dotenv-devel.sha256sum] = "b2689558dc4ca9c17aec823ab9f863eac1fc11907919b8949adee9c2e2682e74"

RDEPENDS:rust-dotenv+default-devel = " \
 cargo \
 rust-dotenv-devel \
 "
RDEPENDS:rust-dotenv-devel = " \
 cargo \
 "
