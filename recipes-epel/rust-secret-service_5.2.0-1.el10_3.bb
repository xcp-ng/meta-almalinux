# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-secret-service"
PV = "5.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-secret-service+crypto-openssl-devel \
 rust-secret-service+crypto-rust-devel \
 rust-secret-service+default-devel \
 rust-secret-service+rt-async-io-crypto-openssl-devel \
 rust-secret-service+rt-async-io-crypto-rust-devel \
 rust-secret-service+rt-async-io-devel \
 rust-secret-service+rt-tokio-crypto-openssl-devel \
 rust-secret-service+rt-tokio-crypto-rust-devel \
 rust-secret-service+rt-tokio-devel \
 rust-secret-service-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-secret-service-5.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5c7f8fd727fda42d6d84f425103029a7a221a11116d58a412f9b2a2ecb1eba66"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+crypto-openssl-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+crypto-openssl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-secret-service+crypto-openssl-devel.sha256sum] = "3253bc1efc55f00c26bc6d4633f488e83e5ce8fb226025720b840f7185978ed9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+crypto-rust-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+crypto-rust-devel;unpack=0"
SRC_URI[x86_64_v2_rust-secret-service+crypto-rust-devel.sha256sum] = "ff853058b84b6534054da48e1d42b5fca087de781d626d500c7f2a48233aa97d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+default-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-secret-service+default-devel.sha256sum] = "8325493be983f525915d02827a8464a79b1361b66b2dd32cc6ac0601488e2124"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+rt-async-io-crypto-openssl-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+rt-async-io-crypto-openssl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-secret-service+rt-async-io-crypto-openssl-devel.sha256sum] = "a6c86fe36df8edd9363c1a80fb99e6d0aeb6db3ed2ddc46423d05a2ed628e6b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+rt-async-io-crypto-rust-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+rt-async-io-crypto-rust-devel;unpack=0"
SRC_URI[x86_64_v2_rust-secret-service+rt-async-io-crypto-rust-devel.sha256sum] = "ff420bd72ee84eeb086e73c7bd3f389fafb9e910feb581d56b35d5042844cca2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+rt-async-io-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+rt-async-io-devel;unpack=0"
SRC_URI[x86_64_v2_rust-secret-service+rt-async-io-devel.sha256sum] = "0967d3699c8e87d962f46cb58fd9c71598f86f64a9e8cb1f83f24cb74d743571"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+rt-tokio-crypto-openssl-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+rt-tokio-crypto-openssl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-secret-service+rt-tokio-crypto-openssl-devel.sha256sum] = "429af17c96ebb867c9bef6e38ec687ca5265e7bb4ed6b794fe98ac0dc562c357"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+rt-tokio-crypto-rust-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+rt-tokio-crypto-rust-devel;unpack=0"
SRC_URI[x86_64_v2_rust-secret-service+rt-tokio-crypto-rust-devel.sha256sum] = "ec5bdb540fead62b099cd27d5653c6c16f2ca4fb4a10d428f15e9b429179214a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+rt-tokio-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+rt-tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-secret-service+rt-tokio-devel.sha256sum] = "3921da7de6c972e0d90a9f332662eea29e614f20ce5146020a3a67e4a7e3f438"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service-devel;unpack=0"
SRC_URI[x86_64_v2_rust-secret-service-devel.sha256sum] = "a9db3e70770274cb59e03ef8d202095b0ccaf950053d88cecd43ad3c53b6595c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+crypto-openssl-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-secret-service+crypto-openssl-devel;unpack=0"
SRC_URI[aarch64_rust-secret-service+crypto-openssl-devel.sha256sum] = "7aa55cd378dc16a2f5220179a4ddb4bf86c54006629a27651bd78e6b4495fbf0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+crypto-rust-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-secret-service+crypto-rust-devel;unpack=0"
SRC_URI[aarch64_rust-secret-service+crypto-rust-devel.sha256sum] = "22793d4703442c015a356d6d76e879d0c848157adba8321ea8813af0f4e77681"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+default-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-secret-service+default-devel;unpack=0"
SRC_URI[aarch64_rust-secret-service+default-devel.sha256sum] = "af773f92549d3f2eb9b84a906a87d87679ff5700a4f83a8fae04ee39406a0a2c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+rt-async-io-crypto-openssl-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-secret-service+rt-async-io-crypto-openssl-devel;unpack=0"
SRC_URI[aarch64_rust-secret-service+rt-async-io-crypto-openssl-devel.sha256sum] = "51abbc8e1c071d4ba42cc548585ae57feed09c949d4dbd65165ec84c7dd14126"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+rt-async-io-crypto-rust-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-secret-service+rt-async-io-crypto-rust-devel;unpack=0"
SRC_URI[aarch64_rust-secret-service+rt-async-io-crypto-rust-devel.sha256sum] = "7727c73859af1f96d14ef23b002a22da5f092e286c50ab6a5eb2b368ca183b81"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+rt-async-io-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-secret-service+rt-async-io-devel;unpack=0"
SRC_URI[aarch64_rust-secret-service+rt-async-io-devel.sha256sum] = "4c357c6e3701200fc0a41f08eb3dc0325e0ec23b781808428a1b6c36c5120e57"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+rt-tokio-crypto-openssl-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-secret-service+rt-tokio-crypto-openssl-devel;unpack=0"
SRC_URI[aarch64_rust-secret-service+rt-tokio-crypto-openssl-devel.sha256sum] = "0a13ff93e16321434a5e523697f68cf273fc8365f0cee36b9b00da8d42b01e4a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+rt-tokio-crypto-rust-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-secret-service+rt-tokio-crypto-rust-devel;unpack=0"
SRC_URI[aarch64_rust-secret-service+rt-tokio-crypto-rust-devel.sha256sum] = "690225e60389d7ee359b543d2707a14751d68aab32081cff3b00563e05ab5448"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+rt-tokio-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-secret-service+rt-tokio-devel;unpack=0"
SRC_URI[aarch64_rust-secret-service+rt-tokio-devel.sha256sum] = "d12cf9ed40ba9c9364ccfe6eab6e18415379fc7df5d985b88e90df337763134c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-secret-service-devel;unpack=0"
SRC_URI[aarch64_rust-secret-service-devel.sha256sum] = "e5ae129d792a83f7907499d174d967ffb96f96ca81c93c9ee32e68b17ddb8723"

RDEPENDS:rust-secret-service+crypto-openssl-devel = " \
 cargo \
 rust-openssl+default-devel \
 rust-secret-service-devel \
 "
RDEPENDS:rust-secret-service+crypto-rust-devel = " \
 cargo \
 rust-aes+default-devel \
 rust-cbc+alloc-devel \
 rust-cbc+block-padding-devel \
 rust-cbc+default-devel \
 rust-hkdf+default-devel \
 rust-secret-service-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-secret-service+default-devel = " \
 cargo \
 rust-secret-service-devel \
 "
RDEPENDS:rust-secret-service+rt-async-io-crypto-openssl-devel = " \
 cargo \
 rust-secret-service+crypto-openssl-devel \
 rust-secret-service+rt-async-io-devel \
 rust-secret-service-devel \
 "
RDEPENDS:rust-secret-service+rt-async-io-crypto-rust-devel = " \
 cargo \
 rust-secret-service+crypto-rust-devel \
 rust-secret-service+rt-async-io-devel \
 rust-secret-service-devel \
 "
RDEPENDS:rust-secret-service+rt-async-io-devel = " \
 cargo \
 rust-secret-service-devel \
 rust-zbus+async-io-devel \
 "
RDEPENDS:rust-secret-service+rt-tokio-crypto-openssl-devel = " \
 cargo \
 rust-secret-service+crypto-openssl-devel \
 rust-secret-service+rt-tokio-devel \
 rust-secret-service-devel \
 "
RDEPENDS:rust-secret-service+rt-tokio-crypto-rust-devel = " \
 cargo \
 rust-secret-service+crypto-rust-devel \
 rust-secret-service+rt-tokio-devel \
 rust-secret-service-devel \
 "
RDEPENDS:rust-secret-service+rt-tokio-devel = " \
 cargo \
 rust-secret-service-devel \
 rust-zbus+tokio-devel \
 "
RDEPENDS:rust-secret-service-devel = " \
 cargo \
 rust \
 rust-futures-util+default-devel \
 rust-getrandom+default-devel \
 rust-hybrid-array+default-devel \
 rust-num+default-devel \
 rust-once_cell+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-zbus+blocking-api-devel \
 rust-zbus-devel \
 "
