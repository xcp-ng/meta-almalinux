# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ast"
PE = "1"
PV = "2.0"
PR = "16.el10"
PACKAGES = " \
 hunspell-ast \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ast-2.0-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d10c98c58f6105debcb6192cf9fa83b8be6aabb02a7419792e86571a9b911328"

URI_x86_64_v2_hunspell-ast = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ast-2.0-16.el10.noarch.rpm;name=x86_64_v2_hunspell-ast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-ast}"
SRC_URI[x86_64_v2_hunspell-ast.sha256sum] = "7b8e59ce773095b1c245488d25f11583e893d4ff7b30ddd5db4c360682204d39"

URI_aarch64_hunspell-ast = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ast-2.0-16.el10.noarch.rpm;name=aarch64_hunspell-ast;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-ast}"
SRC_URI[aarch64_hunspell-ast.sha256sum] = "7b8e59ce773095b1c245488d25f11583e893d4ff7b30ddd5db4c360682204d39"

RDEPENDS:hunspell-ast = " \
 hunspell-filesystem \
 "
