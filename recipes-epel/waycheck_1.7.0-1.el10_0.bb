# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "waycheck"
PV = "1.7.0"
PR = "1.el10_0"
PACKAGES = " \
 waycheck \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/waycheck-1.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eee08323bb899bf4de0e01e62200aefbf79e948287d4f420c254d5305c26337d"

URI_x86_64_v2_waycheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/waycheck-1.7.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_waycheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_waycheck}"
SRC_URI[x86_64_v2_waycheck.sha256sum] = "50e820116924a4f8235851a0b7313a351fd5f28b23cfd27a158e5959867d92f1"

URI_aarch64_waycheck = "${EPEL_MIRROR}/aarch64/Packages/w/waycheck-1.7.0-1.el10_0.aarch64.rpm;name=aarch64_waycheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_waycheck}"
SRC_URI[aarch64_waycheck.sha256sum] = "52467163ee432fa12fe1725feefd19514d9f27b47d0bbd0697ac32cbe52ac3d8"

RDEPENDS:waycheck = " \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
