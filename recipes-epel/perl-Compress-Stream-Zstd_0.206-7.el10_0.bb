# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Compress-Stream-Zstd"
PV = "0.206"
PR = "7.el10_0"
PACKAGES = " \
 perl-Compress-Stream-Zstd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Compress-Stream-Zstd-0.206-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7fa01a57c474e426882b18bdd97757cf6cc3bc6361730f25a324df74d3c9aa2"

URI_x86_64_v2_perl-Compress-Stream-Zstd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Compress-Stream-Zstd-0.206-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Compress-Stream-Zstd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Compress-Stream-Zstd}"
SRC_URI[x86_64_v2_perl-Compress-Stream-Zstd.sha256sum] = "ee7f160a852f3718f82c2b8360fc7d883b1cbab13115871feabb059c1a0756e2"

URI_aarch64_perl-Compress-Stream-Zstd = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Compress-Stream-Zstd-0.206-7.el10_0.aarch64.rpm;name=aarch64_perl-Compress-Stream-Zstd;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Compress-Stream-Zstd}"
SRC_URI[aarch64_perl-Compress-Stream-Zstd.sha256sum] = "7c996a7a5652c650f29fbeb5377de65c4e3bd26a29ec03aa60a2047740a6e9d8"

RDEPENDS:perl-Compress-Stream-Zstd = " \
 glibc \
 perl-Compress-Stream-Zstd \
 perl-Exporter \
 perl-libs \
 "
