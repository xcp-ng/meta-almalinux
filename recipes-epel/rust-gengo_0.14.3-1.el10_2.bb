# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gengo"
PV = "0.14.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-gengo+default-devel \
 rust-gengo+directory-devel \
 rust-gengo+git-devel \
 rust-gengo+max-performance-devel \
 rust-gengo+max-performance-safe-devel \
 rust-gengo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gengo-0.14.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e028206086f42f858c0a8ea6e19f7dd6587cd3ce4bf3be808add07785c702263"

URI_x86_64_v2_rust-gengo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo+default-devel-0.14.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo+default-devel}"
SRC_URI[x86_64_v2_rust-gengo+default-devel.sha256sum] = "9537e461a155ecf734442806da51d015211372239582d707590ba08e72a13b31"

URI_x86_64_v2_rust-gengo+directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo+directory-devel-0.14.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo+directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo+directory-devel}"
SRC_URI[x86_64_v2_rust-gengo+directory-devel.sha256sum] = "9cfcbd06828dab1743ffb5a181da37c602d35deac0ce49bd20e4264cd1886f2d"

URI_x86_64_v2_rust-gengo+git-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo+git-devel-0.14.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo+git-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo+git-devel}"
SRC_URI[x86_64_v2_rust-gengo+git-devel.sha256sum] = "e47137cdbfe336bd552a1e029654e23479db2fd4fbf7a3cf80839f0cfd6e54a6"

URI_x86_64_v2_rust-gengo+max-performance-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo+max-performance-devel-0.14.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo+max-performance-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo+max-performance-devel}"
SRC_URI[x86_64_v2_rust-gengo+max-performance-devel.sha256sum] = "217286defb332bc6ac274d8660ccca75d1443ada60701e27dfc33428ee8879de"

URI_x86_64_v2_rust-gengo+max-performance-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo+max-performance-safe-devel-0.14.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo+max-performance-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo+max-performance-safe-devel}"
SRC_URI[x86_64_v2_rust-gengo+max-performance-safe-devel.sha256sum] = "ecf7ec750cb31513cb6ba412471f4f623388e2bea9c1ffb35601ac791bdc8183"

URI_x86_64_v2_rust-gengo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo-devel-0.14.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo-devel}"
SRC_URI[x86_64_v2_rust-gengo-devel.sha256sum] = "af6b3c2fcbb4c0e4ae4ed8e5b50fb4a8d4a4be26ee4d336ff9136282c7e3ff8b"

URI_aarch64_rust-gengo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo+default-devel-0.14.3-1.el10_2.noarch.rpm;name=aarch64_rust-gengo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo+default-devel}"
SRC_URI[aarch64_rust-gengo+default-devel.sha256sum] = "01c64fcc282aa733bf877cd1321c9d853c74d483b4b6190f2ddcfe42ff2def57"

URI_aarch64_rust-gengo+directory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo+directory-devel-0.14.3-1.el10_2.noarch.rpm;name=aarch64_rust-gengo+directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo+directory-devel}"
SRC_URI[aarch64_rust-gengo+directory-devel.sha256sum] = "51f1a8650e97cd5a6fb2517370fdc96fa8e76e20f4179efdccc18ac822ba0f51"

URI_aarch64_rust-gengo+git-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo+git-devel-0.14.3-1.el10_2.noarch.rpm;name=aarch64_rust-gengo+git-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo+git-devel}"
SRC_URI[aarch64_rust-gengo+git-devel.sha256sum] = "40d84d7a0c6ded7949dac2b15d5f6573d0845573b2012b98812b4faae961a4ef"

URI_aarch64_rust-gengo+max-performance-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo+max-performance-devel-0.14.3-1.el10_2.noarch.rpm;name=aarch64_rust-gengo+max-performance-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo+max-performance-devel}"
SRC_URI[aarch64_rust-gengo+max-performance-devel.sha256sum] = "b36f23b257367bf561569e7f210ccf11b35ab1da4e957497d58ee4087c4642c2"

URI_aarch64_rust-gengo+max-performance-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo+max-performance-safe-devel-0.14.3-1.el10_2.noarch.rpm;name=aarch64_rust-gengo+max-performance-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo+max-performance-safe-devel}"
SRC_URI[aarch64_rust-gengo+max-performance-safe-devel.sha256sum] = "aee31a3230d482dfe32c599ce3739e58f38656ce5be89e1e851186e6de7883e4"

URI_aarch64_rust-gengo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo-devel-0.14.3-1.el10_2.noarch.rpm;name=aarch64_rust-gengo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo-devel}"
SRC_URI[aarch64_rust-gengo-devel.sha256sum] = "bae8a1e17183550d007ed3e02ebf7be00ea35931088f563bc60d45196dfc2087"

RDEPENDS:rust-gengo+default-devel = " \
 cargo \
 rust-gengo+directory-devel \
 rust-gengo+git-devel \
 rust-gengo+max-performance-safe-devel \
 rust-gengo-devel \
 "
RDEPENDS:rust-gengo+directory-devel = " \
 cargo \
 rust-gengo-devel \
 rust-ignore+default-devel \
 "
RDEPENDS:rust-gengo+git-devel = " \
 cargo \
 rust-gengo-devel \
 rust-gix+attributes-devel \
 rust-gix+index-devel \
 rust-gix+parallel-devel \
 rust-gix+revision-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gengo+max-performance-devel = " \
 cargo \
 rust-gengo-devel \
 rust-gix+attributes-devel \
 rust-gix+index-devel \
 rust-gix+max-performance-devel \
 rust-gix+parallel-devel \
 rust-gix+revision-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gengo+max-performance-safe-devel = " \
 cargo \
 rust-gengo-devel \
 rust-gix+attributes-devel \
 rust-gix+index-devel \
 rust-gix+max-performance-safe-devel \
 rust-gix+parallel-devel \
 rust-gix+revision-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gengo-devel = " \
 cargo \
 rust \
 rust-gengo-language+default-devel \
 rust-glob+default-devel \
 rust-indexmap+default-devel \
 rust-indexmap+rayon-devel \
 rust-indexmap+serde-devel \
 rust-rayon+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
