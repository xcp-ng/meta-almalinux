# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-annotate-snippets0.9"
PV = "0.9.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-annotate-snippets0.9+color-devel \
 rust-annotate-snippets0.9+default-devel \
 rust-annotate-snippets0.9+yansi-term-devel \
 rust-annotate-snippets0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-annotate-snippets0.9-0.9.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "516ae413eceb5f5d3f9e2409c7d4f6a5d62fd23736faef96ff196628e3dc0b08"

URI_x86_64_v2_rust-annotate-snippets0.9+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.9+color-devel-0.9.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.9+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.9+color-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.9+color-devel.sha256sum] = "7fe7e5236941785dd310cb17aa377483b15cf7862bef4923166062d26e7ac8bd"

URI_x86_64_v2_rust-annotate-snippets0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.9+default-devel-0.9.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.9+default-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.9+default-devel.sha256sum] = "1150c8863832e25550fc2b3216176598b9c3a63904c0633d8916f38ecbf5a509"

URI_x86_64_v2_rust-annotate-snippets0.9+yansi-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.9+yansi-term-devel-0.9.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.9+yansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.9+yansi-term-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.9+yansi-term-devel.sha256sum] = "35b6e8618382c927b91ebd135f29d83d6e2c825d1105f0cab15c660cc8f562a0"

URI_x86_64_v2_rust-annotate-snippets0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.9-devel-0.9.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.9-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.9-devel.sha256sum] = "fc486de8b20d3f3cf0debc03d6a27b48e54c37c28f9af20b89a91eca4d6d1b74"

URI_aarch64_rust-annotate-snippets0.9+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.9+color-devel-0.9.2-2.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets0.9+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.9+color-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.9+color-devel.sha256sum] = "1b991c20b444e8d08fc4cc1a4eedcc17556e08eeb513893be23b3049d08a591d"

URI_aarch64_rust-annotate-snippets0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.9+default-devel-0.9.2-2.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.9+default-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.9+default-devel.sha256sum] = "06498462e176584c6b64c9f760e05a4e15d80a4c3e646614cf4b2d08af1fb886"

URI_aarch64_rust-annotate-snippets0.9+yansi-term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.9+yansi-term-devel-0.9.2-2.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets0.9+yansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.9+yansi-term-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.9+yansi-term-devel.sha256sum] = "4f644c6207edc878e2ddb3fb6a72d8ab4f0d107f37393f075d573918a7a2f29f"

URI_aarch64_rust-annotate-snippets0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.9-devel-0.9.2-2.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.9-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.9-devel.sha256sum] = "ce6cfbb24f9952257dc860c806e32e0f731ac5356d42bdb7437d671d089ce7b1"

RDEPENDS:rust-annotate-snippets0.9+color-devel = " \
 cargo \
 rust-annotate-snippets0.9+yansi-term-devel \
 rust-annotate-snippets0.9-devel \
 "
RDEPENDS:rust-annotate-snippets0.9+default-devel = " \
 cargo \
 rust-annotate-snippets0.9-devel \
 "
RDEPENDS:rust-annotate-snippets0.9+yansi-term-devel = " \
 cargo \
 rust-annotate-snippets0.9-devel \
 rust-yansi-term+default-devel \
 "
RDEPENDS:rust-annotate-snippets0.9-devel = " \
 cargo \
 rust-unicode-width0.1+default-devel \
 "
