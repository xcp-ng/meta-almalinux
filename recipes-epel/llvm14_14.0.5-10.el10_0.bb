# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llvm14"
PV = "14.0.5"
PR = "10.el10_0"
PACKAGES = " \
 llvm14 \
 llvm14-devel \
 llvm14-doc \
 llvm14-libs \
 llvm14-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/llvm14-14.0.5-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f25eee9fd3b07896897655e1d7b7d5d38d2c00a272af2b2dbd3f9f996d5b9b4"

URI_x86_64_v2_llvm14 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm14-14.0.5-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm14;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm14}"
SRC_URI[x86_64_v2_llvm14.sha256sum] = "943a3af4be0ef7471eabd6f9fca7b262c1271f277f4149013bb609a156c97032"

URI_x86_64_v2_llvm14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm14-devel-14.0.5-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm14-devel}"
SRC_URI[x86_64_v2_llvm14-devel.sha256sum] = "326c1cfe1979139fded444e35c71e6fe341dd4d070b8aa7c1ca88b3717e73f5c"

URI_x86_64_v2_llvm14-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm14-doc-14.0.5-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_llvm14-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm14-doc}"
SRC_URI[x86_64_v2_llvm14-doc.sha256sum] = "8c17fbc11edccd91647a8c3ec865954abbc61156194577733b7f60c2bb0abfad"

URI_x86_64_v2_llvm14-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm14-libs-14.0.5-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm14-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm14-libs}"
SRC_URI[x86_64_v2_llvm14-libs.sha256sum] = "30ab98046b328342fad7a37ee084f59e94ea348351895955f831a2bf22f2014f"

URI_x86_64_v2_llvm14-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm14-static-14.0.5-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm14-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm14-static}"
SRC_URI[x86_64_v2_llvm14-static.sha256sum] = "a4fb711da908ea76d4710da1edfe110f6628237e0092c17254f20581e493cdb0"

URI_aarch64_llvm14 = "${EPEL_MIRROR}/aarch64/Packages/l/llvm14-14.0.5-10.el10_0.aarch64.rpm;name=aarch64_llvm14;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm14}"
SRC_URI[aarch64_llvm14.sha256sum] = "23012be9d57039de94e9f04d59d92c71463c6b022939c7f7499880a706d949af"

URI_aarch64_llvm14-devel = "${EPEL_MIRROR}/aarch64/Packages/l/llvm14-devel-14.0.5-10.el10_0.aarch64.rpm;name=aarch64_llvm14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm14-devel}"
SRC_URI[aarch64_llvm14-devel.sha256sum] = "fe69e4cb02d2d172971a3457e5beca23d97a66edd13f6c1705f5aeb1d3ed564e"

URI_aarch64_llvm14-doc = "${EPEL_MIRROR}/aarch64/Packages/l/llvm14-doc-14.0.5-10.el10_0.noarch.rpm;name=aarch64_llvm14-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm14-doc}"
SRC_URI[aarch64_llvm14-doc.sha256sum] = "827f87b4cc1a1868fdccd63f3c92c643515e453fc42e69df9f2cd7cdb9a4a829"

URI_aarch64_llvm14-libs = "${EPEL_MIRROR}/aarch64/Packages/l/llvm14-libs-14.0.5-10.el10_0.aarch64.rpm;name=aarch64_llvm14-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm14-libs}"
SRC_URI[aarch64_llvm14-libs.sha256sum] = "c94983c681ade118c6ec37bfe6495f343d5fd21ce7a392ed90fc9162c1ab266c"

URI_aarch64_llvm14-static = "${EPEL_MIRROR}/aarch64/Packages/l/llvm14-static-14.0.5-10.el10_0.aarch64.rpm;name=aarch64_llvm14-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm14-static}"
SRC_URI[aarch64_llvm14-static.sha256sum] = "26ea84f66082d852e0668ba67b6cc99f12fc95ec8aabda7c5b838f873a0a89a7"

RDEPENDS:llvm14 = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm14-libs \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:llvm14-devel = " \
 alternatives \
 bash \
 libedit-devel \
 llvm14 \
 llvm14-libs \
 llvm14-static \
 "
RDEPENDS:llvm14-doc = " \
 llvm14 \
 "
RDEPENDS:llvm14-libs = " \
 glibc \
 libedit \
 libffi \
 libgcc \
 libstdc++ \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:llvm14-static = " \
 "
