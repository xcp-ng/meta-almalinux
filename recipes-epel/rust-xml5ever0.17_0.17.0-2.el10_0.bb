# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xml5ever0.17"
PV = "0.17.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-xml5ever0.17+default-devel \
 rust-xml5ever0.17-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-xml5ever0.17-0.17.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8321b391ea6b4e7158177d8d0ef7d6d660ba11c1ef079f0e0dcced151112c8f"

URI_x86_64_v2_rust-xml5ever0.17+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xml5ever0.17+default-devel-0.17.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xml5ever0.17+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xml5ever0.17+default-devel}"
SRC_URI[x86_64_v2_rust-xml5ever0.17+default-devel.sha256sum] = "a93775f552d241e00e3f350a86964c66806974e59dc3c4a89f9aab36334a8228"

URI_x86_64_v2_rust-xml5ever0.17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xml5ever0.17-devel-0.17.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xml5ever0.17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xml5ever0.17-devel}"
SRC_URI[x86_64_v2_rust-xml5ever0.17-devel.sha256sum] = "9960c38e2d5ca8eaf645ca1ed2eddad443f7e3e0c53b933a1dd42a9971b90fd4"

URI_aarch64_rust-xml5ever0.17+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xml5ever0.17+default-devel-0.17.0-2.el10_0.noarch.rpm;name=aarch64_rust-xml5ever0.17+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xml5ever0.17+default-devel}"
SRC_URI[aarch64_rust-xml5ever0.17+default-devel.sha256sum] = "f3822211b639b06c02f96c3a5d0897aabeb8ac7aeefafd3673b3249f22010966"

URI_aarch64_rust-xml5ever0.17-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xml5ever0.17-devel-0.17.0-2.el10_0.noarch.rpm;name=aarch64_rust-xml5ever0.17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xml5ever0.17-devel}"
SRC_URI[aarch64_rust-xml5ever0.17-devel.sha256sum] = "16d0c8e3a569d4ae55847a542d64e540d00d33b60d37d35eb959e98f2c91f706"

RDEPENDS:rust-xml5ever0.17+default-devel = " \
 cargo \
 rust-xml5ever0.17-devel \
 "
RDEPENDS:rust-xml5ever0.17-devel = " \
 cargo \
 rust-log+default-devel \
 rust-mac+default-devel \
 rust-markup5ever0.11+default-devel \
 "
