# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper-timeout"
PV = "0.5.2"
PR = "5.el10_3"
PACKAGES = " \
 rust-hyper-timeout+default-devel \
 rust-hyper-timeout-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-timeout-0.5.2-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6981e6ed0591a46115ae67bf17168ea317d96b062c3cb122ed04632c325e3975"

URI_x86_64_v2_rust-hyper-timeout+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-timeout+default-devel-0.5.2-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-timeout+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-timeout+default-devel}"
SRC_URI[x86_64_v2_rust-hyper-timeout+default-devel.sha256sum] = "fe61b9a7eb0387d6a295706e2b6c523724b717055eeac4bc0c0ea41b8f2137ed"

URI_x86_64_v2_rust-hyper-timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-timeout-devel-0.5.2-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-timeout-devel}"
SRC_URI[x86_64_v2_rust-hyper-timeout-devel.sha256sum] = "088068be317a071f9bccf2d31872f98b2681bab2477cfe836e1d0a85bc34aba2"

URI_aarch64_rust-hyper-timeout+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-timeout+default-devel-0.5.2-5.el10_3.noarch.rpm;name=aarch64_rust-hyper-timeout+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-timeout+default-devel}"
SRC_URI[aarch64_rust-hyper-timeout+default-devel.sha256sum] = "33ccd60e5eb7c9980710beaa304cca0803b3d4a31d3421fa890121125b495d07"

URI_aarch64_rust-hyper-timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-timeout-devel-0.5.2-5.el10_3.noarch.rpm;name=aarch64_rust-hyper-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-timeout-devel}"
SRC_URI[aarch64_rust-hyper-timeout-devel.sha256sum] = "608b4363c9289ef1dca1446f75f4edeb929ccd5bfb7a2471c713e1b81bf71102"

RDEPENDS:rust-hyper-timeout+default-devel = " \
 cargo \
 rust-hyper-timeout-devel \
 "
RDEPENDS:rust-hyper-timeout-devel = " \
 cargo \
 rust-hyper+default-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http1-devel \
 rust-pin-project-lite+default-devel \
 rust-tokio+default-devel \
 rust-tower-service+default-devel \
 "
