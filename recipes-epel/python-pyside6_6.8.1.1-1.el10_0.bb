# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyside6"
PV = "6.8.1.1"
PR = "1.el10_0"
PACKAGES = " \
 pyside6-tools \
 python3-pyside6 \
 python3-pyside6-devel \
 python3-shiboken6 \
 python3-shiboken6-devel \
 shiboken6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyside6-6.8.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a42b3d76c73c3133f1e34af79e3db07347b18a11b89edce6f7ec01bf2c2bc0a"

URI_x86_64_v2_pyside6-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pyside6-tools-6.8.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pyside6-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pyside6-tools}"
SRC_URI[x86_64_v2_pyside6-tools.sha256sum] = "30da533ec16529d52922e2df1951ccfbc0d1d6c8a983c2231fe215e20982236a"

URI_x86_64_v2_python3-pyside6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyside6-6.8.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyside6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyside6}"
SRC_URI[x86_64_v2_python3-pyside6.sha256sum] = "5f8b66a140daba6a9836a937b2766182b64eee159d3f34682bbddf51645c7f1d"

URI_x86_64_v2_python3-pyside6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyside6-devel-6.8.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyside6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyside6-devel}"
SRC_URI[x86_64_v2_python3-pyside6-devel.sha256sum] = "3f85728f06c3d36b355a77e883d4cecf0d04b463b82b466f2d53ff8e0b5b7aa9"

URI_x86_64_v2_python3-shiboken6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-shiboken6-6.8.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-shiboken6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-shiboken6}"
SRC_URI[x86_64_v2_python3-shiboken6.sha256sum] = "7de852a4178979d4c15882e8b91207a7b34b5f6faa8cb7b23567ecb216aeaa70"

URI_x86_64_v2_python3-shiboken6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-shiboken6-devel-6.8.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-shiboken6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-shiboken6-devel}"
SRC_URI[x86_64_v2_python3-shiboken6-devel.sha256sum] = "fbe322854803390a8b59a963e160a142b8e6dddc96e9dfbb3fdf0da072ad9ce2"

URI_x86_64_v2_shiboken6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shiboken6-6.8.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_shiboken6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shiboken6}"
SRC_URI[x86_64_v2_shiboken6.sha256sum] = "15bd07e823895b4da159e8f7aca2d806f7c36cd245e3021b7fd2efbe251a5d59"

URI_aarch64_pyside6-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pyside6-tools-6.8.1.1-1.el10_0.aarch64.rpm;name=aarch64_pyside6-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pyside6-tools}"
SRC_URI[aarch64_pyside6-tools.sha256sum] = "af68f6120266ec7d76f6f44a37d7b438522662ea98bcfcb8162f3c6196734c79"

URI_aarch64_python3-pyside6 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyside6-6.8.1.1-1.el10_0.aarch64.rpm;name=aarch64_python3-pyside6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyside6}"
SRC_URI[aarch64_python3-pyside6.sha256sum] = "b98d3012cd1e32236eebaa2e7e78e710409e9faaf407b2cea1ee3318e33bf3d0"

URI_aarch64_python3-pyside6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyside6-devel-6.8.1.1-1.el10_0.aarch64.rpm;name=aarch64_python3-pyside6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyside6-devel}"
SRC_URI[aarch64_python3-pyside6-devel.sha256sum] = "35e37533ce3c9a630983dd4767c1a0005b97c0a3352d3821e51b88b65ff0a555"

URI_aarch64_python3-shiboken6 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-shiboken6-6.8.1.1-1.el10_0.aarch64.rpm;name=aarch64_python3-shiboken6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-shiboken6}"
SRC_URI[aarch64_python3-shiboken6.sha256sum] = "28f542e35f8dab73f2db887fb2228ded65833f670dbfaba422e788e145f2628a"

URI_aarch64_python3-shiboken6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-shiboken6-devel-6.8.1.1-1.el10_0.aarch64.rpm;name=aarch64_python3-shiboken6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-shiboken6-devel}"
SRC_URI[aarch64_python3-shiboken6-devel.sha256sum] = "a1a7f7f5bbd3bbffdfe4241298666f9a6db31d62f8db248629ff5d194f646ca8"

URI_aarch64_shiboken6 = "${EPEL_MIRROR}/aarch64/Packages/s/shiboken6-6.8.1.1-1.el10_0.aarch64.rpm;name=aarch64_shiboken6;unpack=0"
SRC_URI:append = " ${URI_aarch64_shiboken6}"
SRC_URI[aarch64_shiboken6.sha256sum] = "de06115706a20765364f871c47fb156bc512ad3b6663da4db36f5a4eae5f9554"

RDEPENDS:pyside6-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 qt6-assistant \
 qt6-designer \
 qt6-linguist \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:python3-pyside6 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 python3-shiboken6 \
 qt6-qt3d \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtconnectivity \
 qt6-qtdatavis3d \
 qt6-qtdeclarative \
 qt6-qtgraphs \
 qt6-qthttpserver \
 qt6-qtlocation \
 qt6-qtmultimedia \
 qt6-qtnetworkauth \
 qt6-qtpdf \
 qt6-qtpositioning \
 qt6-qtquick3d \
 qt6-qtremoteobjects \
 qt6-qtscxml \
 qt6-qtsensors \
 qt6-qtserialbus \
 qt6-qtserialport \
 qt6-qtspeech \
 qt6-qtsvg \
 qt6-qttools \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-help \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 qt6-qtwebsockets \
 qt6-qtwebview \
 "
RDEPENDS:python3-pyside6-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pyside6-tools \
 python3-pyside6 \
 python3-shiboken6-devel \
 shiboken6 \
 "
RDEPENDS:python3-shiboken6 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 "
RDEPENDS:python3-shiboken6-devel = " \
 clang-libs \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 libxslt \
 pkgconf-pkg-config \
 python3 \
 python3-shiboken6 \
 qt6-qtbase \
 shiboken6 \
 "
RDEPENDS:shiboken6 = " \
 cmake-filesystem \
 "
