# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "root"
PV = "6.40.04"
PR = "1.el10_3"
PACKAGES = " \
 python3-root \
 python3-root+distrdf \
 python3-root+jupyroot \
 root \
 root-cli \
 root-cling \
 root-core \
 root-fftw \
 root-foam \
 root-font-files \
 root-fumili \
 root-gdml \
 root-genetic \
 root-genvector \
 root-geom \
 root-geom-builder \
 root-geom-checker \
 root-geom-painter \
 root-geom-webviewer \
 root-graf \
 root-graf-asimage \
 root-graf-fitsio \
 root-graf-gpad \
 root-graf-gpadv7 \
 root-graf-gviz \
 root-graf-postscript \
 root-graf-primitives \
 root-graf-x11 \
 root-graf3d \
 root-graf3d-csg \
 root-graf3d-eve \
 root-graf3d-eve7 \
 root-graf3d-gl \
 root-graf3d-glad \
 root-graf3d-gviz3d \
 root-graf3d-x3d \
 root-gui \
 root-gui-browsable \
 root-gui-browsable-v7 \
 root-gui-browserv7 \
 root-gui-browserv7-v7 \
 root-gui-builder \
 root-gui-canvaspainter \
 root-gui-fitpanel \
 root-gui-fitpanelv7 \
 root-gui-ged \
 root-gui-html \
 root-gui-qt6webdisplay \
 root-gui-recorder \
 root-gui-treemap \
 root-gui-webdisplay \
 root-gui-webgui6 \
 root-hbook \
 root-hist \
 root-hist-factory \
 root-hist-painter \
 root-histv7 \
 root-histv7util \
 root-icons \
 root-io \
 root-io-dcache \
 root-io-sql \
 root-io-xml \
 root-io-xmlparser \
 root-mathcore \
 root-mathmore \
 root-matrix \
 root-minuit \
 root-minuit2 \
 root-mlp \
 root-montecarlo-eg \
 root-montecarlo-pythia8 \
 root-multiproc \
 root-net \
 root-net-auth \
 root-net-curl \
 root-net-davix \
 root-net-http \
 root-net-httpsniff \
 root-net-rpdutils \
 root-netx \
 root-physics \
 root-quadp \
 root-r \
 root-r-tools \
 root-roofit \
 root-roofit-batchcompute \
 root-roofit-codegen \
 root-roofit-core \
 root-roofit-hs3 \
 root-roofit-more \
 root-roofit-multiprocess \
 root-roofit-zmq \
 root-roostats \
 root-smatrix \
 root-spectrum \
 root-spectrum-painter \
 root-splot \
 root-sql-sqlite \
 root-testsupport \
 root-tmva \
 root-tmva-gui \
 root-tmva-python \
 root-tmva-r \
 root-tmva-sofie \
 root-tmva-sofie-parser \
 root-tmva-sofie-parser-python \
 root-tmva-utils \
 root-tpython \
 root-tree \
 root-tree-dataframe \
 root-tree-ml \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 root-tree-ntuple-utils \
 root-tree-player \
 root-tree-viewer \
 root-tree-webviewer \
 root-tutorial \
 root-unfold \
 root-unuran \
 root-vecops \
 root-xroofit \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/root-6.40.04-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1d6f171069acd99e34287518aa1d6ebb6e9193580095662ad03e86b4ad33576e"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - root-graf-gviz: libcgraph.so.6()(64bit)
# - root-graf-gviz: libgvc.so.6()(64bit)

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-root-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-root;unpack=0"
SRC_URI[x86_64_v2_python3-root.sha256sum] = "99a78e3db872a3a625b9694c0a7750015b00e7a3e940a74927252af201e33019"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-root+distrdf-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-root+distrdf;unpack=0"
SRC_URI[x86_64_v2_python3-root+distrdf.sha256sum] = "4c41204fa408989c7c2119b1571558e84edd1db199e00c83fe775c1c96215f2b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-root+jupyroot-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-root+jupyroot;unpack=0"
SRC_URI[x86_64_v2_python3-root+jupyroot.sha256sum] = "21cf7ba0764b025edca9bd3868c39243e21614bc716ae1f254499d539155eb40"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root;unpack=0"
SRC_URI[x86_64_v2_root.sha256sum] = "98e1af84b43c4dc3d1d898d3149e58df80216ab86b0cbeeab976db8c00cc02a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-cli-6.40.04-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_root-cli;unpack=0"
SRC_URI[x86_64_v2_root-cli.sha256sum] = "975a6bee44b020709756955e2d028564838736aa00d1cbde556feac13d0b60d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-cling-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-cling;unpack=0"
SRC_URI[x86_64_v2_root-cling.sha256sum] = "5360a2018ddf27390f420fa1203b2e98d4f4f11c1f694057f8ddd1010ae2a85e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-core-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-core;unpack=0"
SRC_URI[x86_64_v2_root-core.sha256sum] = "843ef77404c290317b8e0a90dba5cd3cfabe35864e29f2fd9a8e9b0c49ad255c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-fftw-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-fftw;unpack=0"
SRC_URI[x86_64_v2_root-fftw.sha256sum] = "5b2c5d139e1bbe279c96b4b824f014e7b56cceeab8af335c909785ced0d19667"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-foam-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-foam;unpack=0"
SRC_URI[x86_64_v2_root-foam.sha256sum] = "def064a702c4a3ec55cb381969dfa6e15e466c0bd0f0de4923fe6c52af7bbb09"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-font-files-6.40.04-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_root-font-files;unpack=0"
SRC_URI[x86_64_v2_root-font-files.sha256sum] = "531d5a9505b715809654aabcc965436476d7c160171042624e963c0eb4cc1182"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-fumili-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-fumili;unpack=0"
SRC_URI[x86_64_v2_root-fumili.sha256sum] = "19177125c53314fdf811e0edbb94270b81824c66a1edd87fce01e0ac2feb0243"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gdml-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gdml;unpack=0"
SRC_URI[x86_64_v2_root-gdml.sha256sum] = "042695ef32397968dc93e6b4dbc691e02c25c7876f903cc007c8f922405c2358"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-genetic-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-genetic;unpack=0"
SRC_URI[x86_64_v2_root-genetic.sha256sum] = "0340f71dbcdf4f6763de9fc65634776ab4d37a44b55d5bd7693e724251465f6f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-genvector-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-genvector;unpack=0"
SRC_URI[x86_64_v2_root-genvector.sha256sum] = "513c947104e56c59a9ada9edfea6309526597016e5ecd31a123bb840840fae30"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom;unpack=0"
SRC_URI[x86_64_v2_root-geom.sha256sum] = "98cc78f1a8d8a1415be792f209b06b23a368c85027e7c0b178d096b95ffaa739"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-builder-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-builder;unpack=0"
SRC_URI[x86_64_v2_root-geom-builder.sha256sum] = "154f8d02a7faeae469e54c43c5357f35a2a93c8a9aa52b42ef84f9ad8eb92bd3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-checker-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-checker;unpack=0"
SRC_URI[x86_64_v2_root-geom-checker.sha256sum] = "06351db34c8419462b8c6c1018f786b77ee09dc5a4926b3b6787852eb2404968"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-painter-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-painter;unpack=0"
SRC_URI[x86_64_v2_root-geom-painter.sha256sum] = "0bd38b0edc4e57e2c9d67c7884462e84d32b2a0e5a987c8e89b2650a412374af"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-webviewer-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-webviewer;unpack=0"
SRC_URI[x86_64_v2_root-geom-webviewer.sha256sum] = "d49529006006ac48956f19df67debfd11a78a709409a2f67d1948d1825059818"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf;unpack=0"
SRC_URI[x86_64_v2_root-graf.sha256sum] = "dd906dd814762a8db50ad943030a28707d2a0d917e6050eee12328dc8238fdc4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-asimage-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-asimage;unpack=0"
SRC_URI[x86_64_v2_root-graf-asimage.sha256sum] = "5f98edfb7e133d0b38fe7174366d3eaf398855fce71aa4b8c870b467967b9e74"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-fitsio-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-fitsio;unpack=0"
SRC_URI[x86_64_v2_root-graf-fitsio.sha256sum] = "e4595f8ee6c3f2bac8c8aa08b833e2d030cf9c2eabdd3fe781e3cecc78d8f9e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gpad-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gpad;unpack=0"
SRC_URI[x86_64_v2_root-graf-gpad.sha256sum] = "b7d189a01df8b76c87786d8fa3aafcb20dd0bcb62941828d07e05aa01e892d2f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gpadv7-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gpadv7;unpack=0"
SRC_URI[x86_64_v2_root-graf-gpadv7.sha256sum] = "66d5f3017ffcc8ae8315a3458114b9ee3a22b3cac0211539f1f7fa1f1f007887"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gviz-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gviz;unpack=0"
SRC_URI[x86_64_v2_root-graf-gviz.sha256sum] = "0d0f84762e4e274c1844af49cd402369756199003d765b0c53e28b749ba1a1a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-postscript-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-postscript;unpack=0"
SRC_URI[x86_64_v2_root-graf-postscript.sha256sum] = "48f23ddbe29439bf09a11088fc24fade55dcdb061fcb93cd2d01bf7247ba3f8d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-primitives-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-primitives;unpack=0"
SRC_URI[x86_64_v2_root-graf-primitives.sha256sum] = "b8b87ee7fc1985dcd5a656de50426909b85b2cdeaf1bb5ede43ffc2cce57d9b0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-x11-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-x11;unpack=0"
SRC_URI[x86_64_v2_root-graf-x11.sha256sum] = "6f08cebc9a23dd988ec095df408e707ef7afe37e2382ba0a3131ca8b092a5f0d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d;unpack=0"
SRC_URI[x86_64_v2_root-graf3d.sha256sum] = "c00e7e6ab72d996cca6baec4ee6dcfeeef406b4892dc7dc467cd6cdc6a4f0515"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-csg-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-csg;unpack=0"
SRC_URI[x86_64_v2_root-graf3d-csg.sha256sum] = "84ad2e1cb723c3c2dc1587050a0e6e6e79d5230cfa146579b8ce3764b3e6fce5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-eve-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-eve;unpack=0"
SRC_URI[x86_64_v2_root-graf3d-eve.sha256sum] = "e4e27f2061a2310e5d23dd9c71e443ee86f91f72c97e49970b99be0442196ce3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-eve7-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-eve7;unpack=0"
SRC_URI[x86_64_v2_root-graf3d-eve7.sha256sum] = "c5ea9d5a202cbf25ba3cfa288797591325e4ed5e804a89f200e84f208fa8eb19"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-gl-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-gl;unpack=0"
SRC_URI[x86_64_v2_root-graf3d-gl.sha256sum] = "d149601102e2092e5d27cfdaf60cb9ead9511575d69ce4639663572b42e8ed2e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-glad-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-glad;unpack=0"
SRC_URI[x86_64_v2_root-graf3d-glad.sha256sum] = "e6953613cddc4555865b1bad8e16fd14c4119d1146614f74eaf26f29b19dd1a3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-gviz3d-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-gviz3d;unpack=0"
SRC_URI[x86_64_v2_root-graf3d-gviz3d.sha256sum] = "115cc0d1527ba466d4e5c9727b4345e65309f9aa51d924edc68724fcaab4b564"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-x3d-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-x3d;unpack=0"
SRC_URI[x86_64_v2_root-graf3d-x3d.sha256sum] = "b5a3df430f1fb381442839066ad7036d3310eb983b89356a7908d0380a10d3ad"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui;unpack=0"
SRC_URI[x86_64_v2_root-gui.sha256sum] = "779abe823662f756cbe893460fe37a1eb2bbb7c8891d6f2570087e0fe669a1e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browsable-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browsable;unpack=0"
SRC_URI[x86_64_v2_root-gui-browsable.sha256sum] = "95495586b8b50218f824fb9d8483c1ec6ddeae4db2f8ba61c697df5ac64b30bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browsable-v7-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browsable-v7;unpack=0"
SRC_URI[x86_64_v2_root-gui-browsable-v7.sha256sum] = "6457bf86a0d596dc3e899ed16229b2c6fc80f4317a9cd1e2317da66d00ad7c63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browserv7-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browserv7;unpack=0"
SRC_URI[x86_64_v2_root-gui-browserv7.sha256sum] = "22a3bd30e5e72830fbb136af6ee50ba61d2bfc912c887bda2f4c55b49b546b9c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browserv7-v7-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browserv7-v7;unpack=0"
SRC_URI[x86_64_v2_root-gui-browserv7-v7.sha256sum] = "42b0469fdc614f86aa0ee07ba3c2c76278a939938ae58260e8094625387650d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-builder-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-builder;unpack=0"
SRC_URI[x86_64_v2_root-gui-builder.sha256sum] = "2d60a34a1501f5fc7bfa846a04f6b2f49087ac8960f9826f0e7e3fb4c9c660d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-canvaspainter-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-canvaspainter;unpack=0"
SRC_URI[x86_64_v2_root-gui-canvaspainter.sha256sum] = "0c8c29e1f2ef01b6b7204ccb1d40af2c989673e4ca48e96b008c26a1efda451c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-fitpanel-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-fitpanel;unpack=0"
SRC_URI[x86_64_v2_root-gui-fitpanel.sha256sum] = "812c7de9ca512d573c616ae9c221c8e160aace80a84a10b8cbb50803e68e4208"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-fitpanelv7-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-fitpanelv7;unpack=0"
SRC_URI[x86_64_v2_root-gui-fitpanelv7.sha256sum] = "313fb8f437c058032663f8b5b2f19501fbd224944c9ecf819e2e0652dc9027bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-ged-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-ged;unpack=0"
SRC_URI[x86_64_v2_root-gui-ged.sha256sum] = "c80030348d2f53ebe0c92265000bdfc16d07a0f50ccd2a2cd0087b1f5b7cf71f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-html-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-html;unpack=0"
SRC_URI[x86_64_v2_root-gui-html.sha256sum] = "76c21e5fd6f7ca6658a604617287dc5283e74280041712bee5840aa3b29036fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-qt6webdisplay-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-qt6webdisplay;unpack=0"
SRC_URI[x86_64_v2_root-gui-qt6webdisplay.sha256sum] = "f77316893339736de2f2ceb42ab833b035f14de5fd28900e2ead2626ec60cdc7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-recorder-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-recorder;unpack=0"
SRC_URI[x86_64_v2_root-gui-recorder.sha256sum] = "245ad6d05f6e8c0bf170d6bc1629d48874c03f0de0d40462f2d0660b5eb36a02"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-treemap-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-treemap;unpack=0"
SRC_URI[x86_64_v2_root-gui-treemap.sha256sum] = "372923953d2551beab64e1e82bba468bd792ac2c49ed00d327e967662b6e161d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-webdisplay-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-webdisplay;unpack=0"
SRC_URI[x86_64_v2_root-gui-webdisplay.sha256sum] = "1ca2524620461bc47f02a2a1914da78010c64528f22ea26f9656b0f8c5adbf34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-webgui6-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-webgui6;unpack=0"
SRC_URI[x86_64_v2_root-gui-webgui6.sha256sum] = "ee907454880849d838c3d23f445a1aab605761a55844842c25fc32ed525e12b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hbook-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hbook;unpack=0"
SRC_URI[x86_64_v2_root-hbook.sha256sum] = "58e685a0c70740c9eafbfe56a056ae07e9a13bf83cc10175eb67ce7f0b9ab734"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist;unpack=0"
SRC_URI[x86_64_v2_root-hist.sha256sum] = "607421fee286866ea6cd0efec68e60408387f156b649092b70bbfdfb42c4d750"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-factory-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist-factory;unpack=0"
SRC_URI[x86_64_v2_root-hist-factory.sha256sum] = "da38451afb7ea59cf4b183785c95794210b0169b63fd14ee1e5986a1be42bcdb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-painter-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist-painter;unpack=0"
SRC_URI[x86_64_v2_root-hist-painter.sha256sum] = "20331301247c0e452ce14c10d873668ac3871a352252f3c4361c8c89eddc6542"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-histv7-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-histv7;unpack=0"
SRC_URI[x86_64_v2_root-histv7.sha256sum] = "a3802211e201774923a2324337d5ab0979af3746512d6e599d8cc5991f52d175"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-histv7util-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-histv7util;unpack=0"
SRC_URI[x86_64_v2_root-histv7util.sha256sum] = "f1ad7e8845ae25308284189caf2e040a369e6f9f75cebec94e4759590074fdc6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-icons-6.40.04-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_root-icons;unpack=0"
SRC_URI[x86_64_v2_root-icons.sha256sum] = "f4c12831d1db617ca39c50462c0612bcb62a68c4d9fa1c686678330216db5d42"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io;unpack=0"
SRC_URI[x86_64_v2_root-io.sha256sum] = "ab85d699edff4023ae7fb93f5c17b712478e1d71de3a47dfab4bd506ed0cf0a9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-dcache-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-dcache;unpack=0"
SRC_URI[x86_64_v2_root-io-dcache.sha256sum] = "1faa60f6ad81efbe5e7ee36b25cd380558f665ad625ca6fe6177560f12f381a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-sql-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-sql;unpack=0"
SRC_URI[x86_64_v2_root-io-sql.sha256sum] = "fe6f424e00f1df130db19f41dd62cd741494f37e0d9ec0e8bea3d37516d4ed1b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-xml-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-xml;unpack=0"
SRC_URI[x86_64_v2_root-io-xml.sha256sum] = "4990ada1f7af779b935a62eb4089a9159275ac73cb58cd9e72f8d71c46077d75"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-xmlparser-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-xmlparser;unpack=0"
SRC_URI[x86_64_v2_root-io-xmlparser.sha256sum] = "65435b620c470bcf85aa1336b8600c9998d91236addb49ae97a7fc4672300561"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mathcore-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mathcore;unpack=0"
SRC_URI[x86_64_v2_root-mathcore.sha256sum] = "fa4e337a6b5cd4e9fbf973107256f2b387d514639bbfb69254aaf7132494bfd7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mathmore-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mathmore;unpack=0"
SRC_URI[x86_64_v2_root-mathmore.sha256sum] = "e11a27d8506394f0de9a12d9c95360d28a458d31b771337f0a03939cd398b6ae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-matrix-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-matrix;unpack=0"
SRC_URI[x86_64_v2_root-matrix.sha256sum] = "5ffc353ec1dfca42301f8f709c694163b5cfa15736784cbfdb1872b288b34646"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-minuit-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-minuit;unpack=0"
SRC_URI[x86_64_v2_root-minuit.sha256sum] = "ac0484c43bc630326588d5579a7fa173953619ad626c47ab9dcb5c9a199c803e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-minuit2-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-minuit2;unpack=0"
SRC_URI[x86_64_v2_root-minuit2.sha256sum] = "8b22586b0b4492f67a1b3cdd4a505fc8afc4a88c2e3b009ca2dba521100953c3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mlp-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mlp;unpack=0"
SRC_URI[x86_64_v2_root-mlp.sha256sum] = "44a59850c6839caa61a1dae07d4f01b5698058047df621ed82bd607b45fbf1b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-montecarlo-eg-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-montecarlo-eg;unpack=0"
SRC_URI[x86_64_v2_root-montecarlo-eg.sha256sum] = "eab4c980aaad75817db06c2febf046d4c3619c1fee9ba49f58108b2e4f743c17"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-montecarlo-pythia8-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-montecarlo-pythia8;unpack=0"
SRC_URI[x86_64_v2_root-montecarlo-pythia8.sha256sum] = "abd58a5e5336f3c3781a4704899757d9b104e73ac25a1ef1b074336b253c0b51"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-multiproc-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-multiproc;unpack=0"
SRC_URI[x86_64_v2_root-multiproc.sha256sum] = "db30758dfe0d536da1acbae86858d780d5de9b1375e95fc2817e277583194205"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net;unpack=0"
SRC_URI[x86_64_v2_root-net.sha256sum] = "d4eceabdb4d56f02006d3c5b33c4163045949438830446551d68128eb720ea7a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-auth-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-auth;unpack=0"
SRC_URI[x86_64_v2_root-net-auth.sha256sum] = "62c27929e4ddcd9781b5400c8f66de9fd3583cf9270bd53bea4c92c7dbd85f57"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-curl-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-curl;unpack=0"
SRC_URI[x86_64_v2_root-net-curl.sha256sum] = "acb1b84b73c188d614a591e1eb8fce027b23efbb8b413cb1345c0e58fa96a217"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-davix-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-davix;unpack=0"
SRC_URI[x86_64_v2_root-net-davix.sha256sum] = "d3cf97dab883b39c53575839b8de89b595680ed1353c1d81de9438835336f30f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-http-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-http;unpack=0"
SRC_URI[x86_64_v2_root-net-http.sha256sum] = "5aff1cf0fa5221c623598ea079c98dbd5f9158fc7463a40dc09e074059e4925e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-httpsniff-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-httpsniff;unpack=0"
SRC_URI[x86_64_v2_root-net-httpsniff.sha256sum] = "30b70ff74d12211f22304570ba8dcfc948e26f031fe20ba0790ab0cfbe1d7ea3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-rpdutils-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-rpdutils;unpack=0"
SRC_URI[x86_64_v2_root-net-rpdutils.sha256sum] = "7d1f601a0b2bc535164b35b1fa79bfbb34a0b1b6fda59a0b25e2730cd4de0f98"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-netx-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-netx;unpack=0"
SRC_URI[x86_64_v2_root-netx.sha256sum] = "9a398188a84a826f5a8432b80e2d856e76372874e31e3fb40c24dfd983f0bc36"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-physics-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-physics;unpack=0"
SRC_URI[x86_64_v2_root-physics.sha256sum] = "31d2367423505dcb1db22a0033a30c16299df20ad21a644f4bc869b4e25909fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-quadp-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-quadp;unpack=0"
SRC_URI[x86_64_v2_root-quadp.sha256sum] = "da1a537a0cdf4f59d79c5c71c65902524ca1cecf5e25695d8944bdfaeb995d00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-r-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-r;unpack=0"
SRC_URI[x86_64_v2_root-r.sha256sum] = "e1f9a7a4c25818df91892e22634751fe8b55d5852b4b0075d192616a996dfd0f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-r-tools-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-r-tools;unpack=0"
SRC_URI[x86_64_v2_root-r-tools.sha256sum] = "c3e660907e81b91381891634e4572b775911e6a22c13f902fe7d8ff4a59a1ca1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit;unpack=0"
SRC_URI[x86_64_v2_root-roofit.sha256sum] = "4816ce0ef74e5e2a38f01edc94bd2533aeba389b6b27826d580a8f331ee80db0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-batchcompute-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-batchcompute;unpack=0"
SRC_URI[x86_64_v2_root-roofit-batchcompute.sha256sum] = "3ae45e6701c5db3550acf67901ed4c8214f2b597162cf5d2394cc5509a433239"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-codegen-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-codegen;unpack=0"
SRC_URI[x86_64_v2_root-roofit-codegen.sha256sum] = "9ca0145b8dd35b1d8bd1c673b3aa4ab0b7a41b5b2b91d8eac34c6531ba622497"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-core-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-core;unpack=0"
SRC_URI[x86_64_v2_root-roofit-core.sha256sum] = "3f53b7f9d0c5ba2ade5d890295cf5cc0b6e033e8e2f79bfc2e563d645ef67880"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-hs3-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-hs3;unpack=0"
SRC_URI[x86_64_v2_root-roofit-hs3.sha256sum] = "257b1fab3e550f416b1f7e76e42dae14a30cc42fd3a30a72fb5a5a1cdfb1ba1c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-more-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-more;unpack=0"
SRC_URI[x86_64_v2_root-roofit-more.sha256sum] = "1390e82cf86b192c2e8b5fa4f84a17de851b459a11f3b16ff4a4e57cd8732c46"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-multiprocess-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-multiprocess;unpack=0"
SRC_URI[x86_64_v2_root-roofit-multiprocess.sha256sum] = "f885a78c76e3c369277f45cd661d17bcafcee50a81b3dbac46381b65249633a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-zmq-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-zmq;unpack=0"
SRC_URI[x86_64_v2_root-roofit-zmq.sha256sum] = "67f1064ec0ee7639726adb03d4f8b5c94ac8d6c8e25d82ab4d7ce3d25b866d4a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roostats-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roostats;unpack=0"
SRC_URI[x86_64_v2_root-roostats.sha256sum] = "1a1ff5d3f2ca66631499944b70813c29d91f7b8b4d804d71c8243d1647804720"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-smatrix-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-smatrix;unpack=0"
SRC_URI[x86_64_v2_root-smatrix.sha256sum] = "aea67327b8626aea0dedf092344f046cade2693bed4ef05df0d70522b8f9b331"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-spectrum-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-spectrum;unpack=0"
SRC_URI[x86_64_v2_root-spectrum.sha256sum] = "b9d397cf4ce5c9142c923287c7d9cea4f678752d808d8750552539e02c6a386d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-spectrum-painter-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-spectrum-painter;unpack=0"
SRC_URI[x86_64_v2_root-spectrum-painter.sha256sum] = "67271ddb16fcb05529db9682da3573ccaf5fd538b202782291d3eb4a61140410"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-splot-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-splot;unpack=0"
SRC_URI[x86_64_v2_root-splot.sha256sum] = "a9540887af1d09337b05a8cf9a78e576a1cbd79b702abc8ce69e697252b49e0e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-sql-sqlite-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-sql-sqlite;unpack=0"
SRC_URI[x86_64_v2_root-sql-sqlite.sha256sum] = "24244afa44dda2fa48cbab07115660f71ed1824a33266a95ecd39393294abc00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-testsupport-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-testsupport;unpack=0"
SRC_URI[x86_64_v2_root-testsupport.sha256sum] = "06e2bb47c7d4f34bd5e13f4c39bbce34377a85094dd4daa8f6131846c8ecef4d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva;unpack=0"
SRC_URI[x86_64_v2_root-tmva.sha256sum] = "176f9edb751da5cec5f71d584f7b96b282f7a70e3a124bc04e0ec53e51f43eb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-gui-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-gui;unpack=0"
SRC_URI[x86_64_v2_root-tmva-gui.sha256sum] = "148015ac886ee6c2e8c6235340b25638f2c1d24c9b3a81ba068cfc8020ce0ecc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-python-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-python;unpack=0"
SRC_URI[x86_64_v2_root-tmva-python.sha256sum] = "476da925f92e9a7041be0593d9ebb36c3f8fabf6c4e4bf7c9debed2c3e363224"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-r-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-r;unpack=0"
SRC_URI[x86_64_v2_root-tmva-r.sha256sum] = "3f77fe09e6654db5a46f202208a17be48ebb462e471e39993692032ffcf71830"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-sofie-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-sofie;unpack=0"
SRC_URI[x86_64_v2_root-tmva-sofie.sha256sum] = "d91277b2d98e5efd06fff4beb6cef156ede2493d7bd1df30407f90967c2850d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-sofie-parser-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-sofie-parser;unpack=0"
SRC_URI[x86_64_v2_root-tmva-sofie-parser.sha256sum] = "3c97830f1b1a3125b7d7a8b5dff4e6286bc9062ae67f56b13eb076ed119cba3f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-sofie-parser-python-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-sofie-parser-python;unpack=0"
SRC_URI[x86_64_v2_root-tmva-sofie-parser-python.sha256sum] = "e13ed6a5c55ab65f5b37b67f06f3c93de3c6b73e0b4b1ffcf081666946653c60"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-utils-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-utils;unpack=0"
SRC_URI[x86_64_v2_root-tmva-utils.sha256sum] = "6316dd033558bd67483c2817b037387e96b9233301fa2408573a451573223897"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tpython-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tpython;unpack=0"
SRC_URI[x86_64_v2_root-tpython.sha256sum] = "a39e6d1b7fb68532842b29bc273b07dedfde6669bdbd4e3d4b410064c66aad8f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree;unpack=0"
SRC_URI[x86_64_v2_root-tree.sha256sum] = "981571ecf927dcf023d5d9ecedc5184e56381cca4b34db7d04d99cd959eec629"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-dataframe-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-dataframe;unpack=0"
SRC_URI[x86_64_v2_root-tree-dataframe.sha256sum] = "af461b88608fe069d633e6b465b2f416b39cf78da749a0624a85afd942bf42ee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ml-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ml;unpack=0"
SRC_URI[x86_64_v2_root-tree-ml.sha256sum] = "1c1d803b0479df89a1d103df425e92775c2d14bd5697c4fc12005115dabe1336"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple;unpack=0"
SRC_URI[x86_64_v2_root-tree-ntuple.sha256sum] = "bc48488472d43fe277726147d9118f300d0bef7cba67441f1664d0f3fecd8e68"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-browse-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple-browse;unpack=0"
SRC_URI[x86_64_v2_root-tree-ntuple-browse.sha256sum] = "482da221898e624e620f6da32bb92cdc80a5b19e9d704e36bbf67531b6d9118b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-utils-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple-utils;unpack=0"
SRC_URI[x86_64_v2_root-tree-ntuple-utils.sha256sum] = "e3170ddc8501b6fa09e6e19b0d48d9ce2771deaa67ad58c885f58b302c396d3f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-player-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-player;unpack=0"
SRC_URI[x86_64_v2_root-tree-player.sha256sum] = "e959a335f8bd1adc41d44d7a706a458f8a651c5d894b61b88b9ed44f5fbce774"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-viewer-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-viewer;unpack=0"
SRC_URI[x86_64_v2_root-tree-viewer.sha256sum] = "4cded25d9765e28365aa390d0cd054d36eba3cbc288a14a50b89626fecc806a4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-webviewer-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-webviewer;unpack=0"
SRC_URI[x86_64_v2_root-tree-webviewer.sha256sum] = "cd3e805f5e346c2cdf505a37b9b4f04e953a83693d78945942005858d587c4f5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tutorial-6.40.04-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_root-tutorial;unpack=0"
SRC_URI[x86_64_v2_root-tutorial.sha256sum] = "2bc2a662adecb13840a6493617eb39299b8d6627a11f09e23568e444690c19b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-unfold-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-unfold;unpack=0"
SRC_URI[x86_64_v2_root-unfold.sha256sum] = "7434cd19f90239566098307bdb4fd36d2b78814d6895385f6b3efd6a5d161646"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-unuran-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-unuran;unpack=0"
SRC_URI[x86_64_v2_root-unuran.sha256sum] = "106d7bd02757695d264698ed336eaf13e0ed0e66af29e4cd6480085f2ce832ad"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-vecops-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-vecops;unpack=0"
SRC_URI[x86_64_v2_root-vecops.sha256sum] = "f5be50914751b2ce27040b224391072ea9157df9049eaf431ab17340ed722491"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-xroofit-6.40.04-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-xroofit;unpack=0"
SRC_URI[x86_64_v2_root-xroofit.sha256sum] = "fe2033b9a6628746cc3adde00467f67f5dddd9063916278ab6c41cd5ff932b70"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-root-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_python3-root;unpack=0"
SRC_URI[aarch64_python3-root.sha256sum] = "fec2fe7b46820f90224046c9d592107d1279ec1daff3b40b4cfb77a70e041a01"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-root+distrdf-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_python3-root+distrdf;unpack=0"
SRC_URI[aarch64_python3-root+distrdf.sha256sum] = "7942a53254f0afcc86c633f0c719b7cda7b932b1e9a9efbed3493928f9501637"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-root+jupyroot-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_python3-root+jupyroot;unpack=0"
SRC_URI[aarch64_python3-root+jupyroot.sha256sum] = "5ef1e8bfcaa86a0c63e25fcd205ae55b97e9ede62b6beb0bdf296cf714f0689f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root;unpack=0"
SRC_URI[aarch64_root.sha256sum] = "98f03a7864216265e0e9689470299127c68d9c99da43a197c6dac90527bafb49"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-cli-6.40.04-1.el10_3.noarch.rpm;name=aarch64_root-cli;unpack=0"
SRC_URI[aarch64_root-cli.sha256sum] = "a6aa4f1d525d72552d14f97a07a601464128d8ccdcedbdbf80c7835609627182"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-cling-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-cling;unpack=0"
SRC_URI[aarch64_root-cling.sha256sum] = "f449b62c3ff6da7f3532c6896c8d5b4cd902e6b09eaca61fea4f5e300bf7778a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-core-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-core;unpack=0"
SRC_URI[aarch64_root-core.sha256sum] = "42710d69b06a7775bebe94cfbcb9917edcc3d1cffa3a2120498c5e3b51151060"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-fftw-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-fftw;unpack=0"
SRC_URI[aarch64_root-fftw.sha256sum] = "46f33362fb057f3cca6b18d77b5f78e9cbe3dfb5c6d1b8f7170b03f995ac385a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-foam-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-foam;unpack=0"
SRC_URI[aarch64_root-foam.sha256sum] = "41c7f2f3e06a4f7ef3df551c51695100fe9f14b3ad575b88d52e887c0ead6c7b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-font-files-6.40.04-1.el10_3.noarch.rpm;name=aarch64_root-font-files;unpack=0"
SRC_URI[aarch64_root-font-files.sha256sum] = "1856162fa12685479dafa99b657e052ca00a82f410f87b02df8d0a80ba5c295a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-fumili-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-fumili;unpack=0"
SRC_URI[aarch64_root-fumili.sha256sum] = "e5393c984ab5309f3c51f3513d1538683d4f955fc24a718276aa87c1cd287284"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gdml-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gdml;unpack=0"
SRC_URI[aarch64_root-gdml.sha256sum] = "311297f711cf5b7ec7cc8cc0b063debb8a0e16b22d97b01c38e625e4e19a32bd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-genetic-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-genetic;unpack=0"
SRC_URI[aarch64_root-genetic.sha256sum] = "5b7626316f11eb096706dec4fad927715e18804f7f122e583e9c625fc20cb463"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-genvector-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-genvector;unpack=0"
SRC_URI[aarch64_root-genvector.sha256sum] = "e33c2872ff4a6670975b940e671166ff0c0b131dc188937094f7b0b9f2e01f14"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-geom-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-geom;unpack=0"
SRC_URI[aarch64_root-geom.sha256sum] = "a88cb58a073bb39150d469172df68b22bdc103a17ead6788e6535724c448afb0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-geom-builder-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-geom-builder;unpack=0"
SRC_URI[aarch64_root-geom-builder.sha256sum] = "fed08280c3a099f94616af025bd8eacbb34c6d9745b12b6c9c2fd8e617e016ab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-geom-checker-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-geom-checker;unpack=0"
SRC_URI[aarch64_root-geom-checker.sha256sum] = "4929824201b7f363636c149b8efffa59980363c8ee6e8d44e5e8c67701a4a829"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-geom-painter-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-geom-painter;unpack=0"
SRC_URI[aarch64_root-geom-painter.sha256sum] = "2d88e33324c88b9fa4d39944d1e33fd01f8c189741df3854ebf8bf5870cdab3b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-geom-webviewer-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-geom-webviewer;unpack=0"
SRC_URI[aarch64_root-geom-webviewer.sha256sum] = "52ea2004d6de23513d45fbd204b7470be6a1f2de01bf7ff63fb07527070e4044"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf;unpack=0"
SRC_URI[aarch64_root-graf.sha256sum] = "f48ecd421b348c5a9cb775345c1c0c6dae492419d35c87c96b581ff15f146241"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-asimage-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf-asimage;unpack=0"
SRC_URI[aarch64_root-graf-asimage.sha256sum] = "22da9be54104dba485bb657db36bb6f3f2983899e3d5070321fe75121f19d38c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-fitsio-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf-fitsio;unpack=0"
SRC_URI[aarch64_root-graf-fitsio.sha256sum] = "395641aa8e97d060c13d84c71d4f69dbffa67eb629b242f4f589b98b780b214c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gpad-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf-gpad;unpack=0"
SRC_URI[aarch64_root-graf-gpad.sha256sum] = "b6feedb34ca494e3b2beb84c804c9a6cb3b8be3caa1bbce9acbf4c2490bf081f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gpadv7-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf-gpadv7;unpack=0"
SRC_URI[aarch64_root-graf-gpadv7.sha256sum] = "8605d4610d384ec87544d68d931fc8c1d3d23ac6fce0404dc9502cb94f4d6b0f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gviz-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf-gviz;unpack=0"
SRC_URI[aarch64_root-graf-gviz.sha256sum] = "b2ee7dc87aca4acdda949434b8a19dbecf8d8d2f12e94dc89bb4348f279f993a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-postscript-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf-postscript;unpack=0"
SRC_URI[aarch64_root-graf-postscript.sha256sum] = "141c1f2a3668a71284e5d6fc4fd4693c9e8115ac979111cb1e55c95b2d804f04"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-primitives-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf-primitives;unpack=0"
SRC_URI[aarch64_root-graf-primitives.sha256sum] = "6b9a58b3d67ebc45f0f78b9c07947db69a5e65925025d9d0fefc29cffd0eb51c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-x11-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf-x11;unpack=0"
SRC_URI[aarch64_root-graf-x11.sha256sum] = "3673da3fcf28bca1e7416faad356044090cb6db9ab74c60bcd582c3fbbf8af52"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d;unpack=0"
SRC_URI[aarch64_root-graf3d.sha256sum] = "6fefa00ed7be2aca9b03df3affa436d551b541b21eaf901f62c89b04cc3537f3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-csg-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d-csg;unpack=0"
SRC_URI[aarch64_root-graf3d-csg.sha256sum] = "11b2a198a92a66474332ed6100ee0d7230f459821e5c53f83dde811b371eca1b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-eve-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d-eve;unpack=0"
SRC_URI[aarch64_root-graf3d-eve.sha256sum] = "d39bf68f54d77599d6664214d758bb6835e2adf024a5975c573bfcaba4c020cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-eve7-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d-eve7;unpack=0"
SRC_URI[aarch64_root-graf3d-eve7.sha256sum] = "90b25dcbf07b62c6b10cd58fbdaf8007f5e74fd8672bcf486ad0698b3d60c556"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-gl-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d-gl;unpack=0"
SRC_URI[aarch64_root-graf3d-gl.sha256sum] = "fb6f35534af52d9a2dcac5b2c1fcc6526c51e02b4778349680e937f8b03c5006"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-glad-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d-glad;unpack=0"
SRC_URI[aarch64_root-graf3d-glad.sha256sum] = "7158fa1b59bbe3e0dc499a5c35b45ccdcf9821841187972ccad7ca193fa8f07f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-gviz3d-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d-gviz3d;unpack=0"
SRC_URI[aarch64_root-graf3d-gviz3d.sha256sum] = "9039605af9ce09f9bbd48b16dfabbe6a84ab52e5b58c35c85535bdb762e75fd8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-x3d-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d-x3d;unpack=0"
SRC_URI[aarch64_root-graf3d-x3d.sha256sum] = "0b002695e22c67a6909436b4b70f9cca9ae98f49f2d4014b6c42c38d149eb855"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui;unpack=0"
SRC_URI[aarch64_root-gui.sha256sum] = "89dfb850dc389e33a37d47745402a28ec3f8bcb8518f4b118b33d6d1ce3380e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browsable-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-browsable;unpack=0"
SRC_URI[aarch64_root-gui-browsable.sha256sum] = "0ef07fcee4bd622fa6d43ff4c21300fe0cd94db35acf3eed7f22f72f9fd7aa6f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browsable-v7-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-browsable-v7;unpack=0"
SRC_URI[aarch64_root-gui-browsable-v7.sha256sum] = "0a04373102e7f3133383eb0b829c529ba503df1dbcf0d2f387d692f46c7d3317"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browserv7-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-browserv7;unpack=0"
SRC_URI[aarch64_root-gui-browserv7.sha256sum] = "2d377b6d3bd1c4481d215d43b4f722e5480646dc015a1f9fc7b07c7d0291a144"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browserv7-v7-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-browserv7-v7;unpack=0"
SRC_URI[aarch64_root-gui-browserv7-v7.sha256sum] = "3f7881a44809456af57746da099f5f3c4d8d828e3d5891cb2274b91a0ede2cb7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-builder-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-builder;unpack=0"
SRC_URI[aarch64_root-gui-builder.sha256sum] = "a50f7bd95e0ff6b149c35bb5bf8e7f3e803b6e84b81f5f204dbaf7bcbee02649"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-canvaspainter-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-canvaspainter;unpack=0"
SRC_URI[aarch64_root-gui-canvaspainter.sha256sum] = "496cfe9d184ac0dde30328b8f642de28add3323f46d5209a1f83d9d06e9b7e41"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-fitpanel-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-fitpanel;unpack=0"
SRC_URI[aarch64_root-gui-fitpanel.sha256sum] = "a8160c2beda2237c8dbd1db7a7a11b9b077c51eb52afbce2fe930cda62dba758"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-fitpanelv7-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-fitpanelv7;unpack=0"
SRC_URI[aarch64_root-gui-fitpanelv7.sha256sum] = "135631ea0db1fb10def735291e1bfd78e2dcf249435cff2786af0a2f947ce6db"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-ged-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-ged;unpack=0"
SRC_URI[aarch64_root-gui-ged.sha256sum] = "1a18158fd976e444efbaca6a9e6d30877e12da65f7c047eb6ee71876b4cc2c14"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-html-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-html;unpack=0"
SRC_URI[aarch64_root-gui-html.sha256sum] = "191eaf529a377dc5a1d836079d88b4a5adcf8dec65c52fc0d6783b62553439b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-qt6webdisplay-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-qt6webdisplay;unpack=0"
SRC_URI[aarch64_root-gui-qt6webdisplay.sha256sum] = "852bd369b853727d3b81d9a0d58f88917a29fc025150464aa54dcdb0ffbec922"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-recorder-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-recorder;unpack=0"
SRC_URI[aarch64_root-gui-recorder.sha256sum] = "a26566d107365dbe36dedc9041a33ecc1e805396b113da1dd886a210e291cde1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-treemap-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-treemap;unpack=0"
SRC_URI[aarch64_root-gui-treemap.sha256sum] = "4f2bb13025bbc2a29b0ad996807dd5004ad548d02d79ab4751e4277804f07d7e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-webdisplay-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-webdisplay;unpack=0"
SRC_URI[aarch64_root-gui-webdisplay.sha256sum] = "345d2da913f91d2e723274688500889d4038c6cb2eb62edb3ec516f2fc266020"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-webgui6-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-gui-webgui6;unpack=0"
SRC_URI[aarch64_root-gui-webgui6.sha256sum] = "f5bba0beeb8a5a489d332db22bf01553f55a71c7fca3dbbfcd31f625dd663fc5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-hbook-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-hbook;unpack=0"
SRC_URI[aarch64_root-hbook.sha256sum] = "d31f5479144b6d2bb9d5bef07da85c1caf720e157cd48b88ccd15ba8f3b50817"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-hist-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-hist;unpack=0"
SRC_URI[aarch64_root-hist.sha256sum] = "b65b8cf0fdd69165fe97d272afaa3efe4dd4be10ff621681d3ef3396fedecf21"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-hist-factory-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-hist-factory;unpack=0"
SRC_URI[aarch64_root-hist-factory.sha256sum] = "0baff8edadc30be7d0dc3f6c8fa06420a129309c49ef39269b7d2fcb0e8b882c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-hist-painter-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-hist-painter;unpack=0"
SRC_URI[aarch64_root-hist-painter.sha256sum] = "5390e5ab899b163bc2c6db8a42e9316b776fb5e734120a46b169e0894aa60d87"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-histv7-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-histv7;unpack=0"
SRC_URI[aarch64_root-histv7.sha256sum] = "bab53f4e8a396e4f1591d13a3fa4210df3257e23e95461f88d08697a432668e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-histv7util-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-histv7util;unpack=0"
SRC_URI[aarch64_root-histv7util.sha256sum] = "9c1c37a37ffa7cdbbfe88357624fcd0fc770efe26b0b15d9d9ab88cf80d4a401"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-icons-6.40.04-1.el10_3.noarch.rpm;name=aarch64_root-icons;unpack=0"
SRC_URI[aarch64_root-icons.sha256sum] = "181edbc10d5b17c4541961a258d2a0548c741777dadc0ef1c9b7f0947da30f05"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-io-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-io;unpack=0"
SRC_URI[aarch64_root-io.sha256sum] = "38b6b8ae08b72e948aef574211045eb38eee8ea4518742ddee5252cbd625c23f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-io-dcache-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-io-dcache;unpack=0"
SRC_URI[aarch64_root-io-dcache.sha256sum] = "4c36d99c1ad3377d622cb1fd21bc6c9eea685a02d5042465d641b0a541e4d5c5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-io-sql-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-io-sql;unpack=0"
SRC_URI[aarch64_root-io-sql.sha256sum] = "5798c37b13f36249b8307cb0f22e0b292cb2505166946e9528555ec1622b1c32"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-io-xml-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-io-xml;unpack=0"
SRC_URI[aarch64_root-io-xml.sha256sum] = "ce5b53ef7fabbd44c3752c5f13f3e6fdd2804700c52e62ac0bd66ef97ff48594"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-io-xmlparser-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-io-xmlparser;unpack=0"
SRC_URI[aarch64_root-io-xmlparser.sha256sum] = "3dac0f5d29335cace6c1c88a58b37c1758c03e8003471fbebee3de4f8f365a13"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-mathcore-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-mathcore;unpack=0"
SRC_URI[aarch64_root-mathcore.sha256sum] = "9ad10ec6d31777201c78234987594bc25f57d8c66a31a003976d039743c6e5ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-mathmore-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-mathmore;unpack=0"
SRC_URI[aarch64_root-mathmore.sha256sum] = "caedfe955461c85dd2e72c2d4343660c54d50a9ce285156a3da408cf9debc097"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-matrix-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-matrix;unpack=0"
SRC_URI[aarch64_root-matrix.sha256sum] = "0809469d78bb23162792eff56c2665db0a61d45fb7d1f9c7d31ce47c9c28a83d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-minuit-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-minuit;unpack=0"
SRC_URI[aarch64_root-minuit.sha256sum] = "5e369bb8394cf17b64f1c5c54aab8420337da4fa6d48ddc9758e34096c21760b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-minuit2-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-minuit2;unpack=0"
SRC_URI[aarch64_root-minuit2.sha256sum] = "e48fa333caa272c8979cef1dc45a80f54911635fa067f7fa3cd7a69b0b33b5e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-mlp-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-mlp;unpack=0"
SRC_URI[aarch64_root-mlp.sha256sum] = "d60f6fc79f4b78b75a70d3396206143650c04a435d64a790be29997e06f49b1d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-montecarlo-eg-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-montecarlo-eg;unpack=0"
SRC_URI[aarch64_root-montecarlo-eg.sha256sum] = "e3a9403155ff11c1011c7366521442f73f31697615ebdb96b28c11a58be02be1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-montecarlo-pythia8-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-montecarlo-pythia8;unpack=0"
SRC_URI[aarch64_root-montecarlo-pythia8.sha256sum] = "0c2c4bf0866cf02e28dc73645851e7f18a8e40fe32b17b634b92b1ccb4403d45"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-multiproc-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-multiproc;unpack=0"
SRC_URI[aarch64_root-multiproc.sha256sum] = "7ce26bc4e9163c9e68663134f409075165efb01e0c91c861679a7d753b6dc840"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-net-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-net;unpack=0"
SRC_URI[aarch64_root-net.sha256sum] = "dd320c615a6a29c1899dd6c82bd27a54f4c7c35e11901bfd12177ff0a93bb837"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-net-auth-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-net-auth;unpack=0"
SRC_URI[aarch64_root-net-auth.sha256sum] = "760b83bfc3e8a070d82a553f5faa88d5cb21e4904b89a5cc0062e21aabbfde4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-net-curl-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-net-curl;unpack=0"
SRC_URI[aarch64_root-net-curl.sha256sum] = "0db70163366546b32d5835a0235104de41d0dd8280b25fb517a604d51b250286"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-net-davix-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-net-davix;unpack=0"
SRC_URI[aarch64_root-net-davix.sha256sum] = "d53d2204bae2e57eca4b6a0d3740d34dc771a96e6b875697e0f5ae04542ed34f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-net-http-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-net-http;unpack=0"
SRC_URI[aarch64_root-net-http.sha256sum] = "79e3872d19daaa9c8e6128b2a4631f1825b10d1a3d4c208b42016efc43393602"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-net-httpsniff-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-net-httpsniff;unpack=0"
SRC_URI[aarch64_root-net-httpsniff.sha256sum] = "5930b10c0bd8b8228374c2442b260815592b202c0877318ca508e568085244ec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-net-rpdutils-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-net-rpdutils;unpack=0"
SRC_URI[aarch64_root-net-rpdutils.sha256sum] = "b83743311faf26d9748fbec41b5463409d007dc9d32fd651e0a28b8b0f242e5c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-netx-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-netx;unpack=0"
SRC_URI[aarch64_root-netx.sha256sum] = "119238d2e68a88b75a5d99034da7ea4372dca74b136bbf09c445012e769136a5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-physics-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-physics;unpack=0"
SRC_URI[aarch64_root-physics.sha256sum] = "e06fc013d6a6a34ce2db96100f20becf85ec2b103181f755fb825224241aa751"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-quadp-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-quadp;unpack=0"
SRC_URI[aarch64_root-quadp.sha256sum] = "d01cc8982fa872708b64f877fc56ca3321699d443c950d8077bb715e4080d991"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-r-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-r;unpack=0"
SRC_URI[aarch64_root-r.sha256sum] = "52b88d430a26fedb76cfd862f8dabb1ee3ab7681c0a6888ccf0306b543c938f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-r-tools-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-r-tools;unpack=0"
SRC_URI[aarch64_root-r-tools.sha256sum] = "8d400a8c9d6308c1256e177d82c3a0a03e195385edf4730f45289e2fe5487a69"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-roofit;unpack=0"
SRC_URI[aarch64_root-roofit.sha256sum] = "a80cb4c9d313f166318bb242c1f9e255f3da7c4f209d4367696d7e7ce94d9cc5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-batchcompute-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-batchcompute;unpack=0"
SRC_URI[aarch64_root-roofit-batchcompute.sha256sum] = "0a21aa0900d6ecb5ed6d6db5bf923b7cde856b6a2cf5b32e1a25844081d74f1c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-codegen-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-codegen;unpack=0"
SRC_URI[aarch64_root-roofit-codegen.sha256sum] = "b587a03874d683754b02f8c5677be2b76900f0d0aa109bba00b95bf304ec86f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-core-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-core;unpack=0"
SRC_URI[aarch64_root-roofit-core.sha256sum] = "6cbe030585115b1d5273cb750744f00ebe56e112e5a9d04d9fec05fe3299d1ce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-hs3-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-hs3;unpack=0"
SRC_URI[aarch64_root-roofit-hs3.sha256sum] = "44acf27da740b3bebe353d7019b12337b19762843d3a2e0e9f8debccf7d181d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-more-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-more;unpack=0"
SRC_URI[aarch64_root-roofit-more.sha256sum] = "d737d72cdea508630cd569c71c02b51aa4a323d310d55de0fcd98b8a40d14be9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-multiprocess-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-multiprocess;unpack=0"
SRC_URI[aarch64_root-roofit-multiprocess.sha256sum] = "dfb6042af73dc2648df02f7b56e3fa5703c46366afd289bd889658f5580e767a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-zmq-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-zmq;unpack=0"
SRC_URI[aarch64_root-roofit-zmq.sha256sum] = "75b1da09b76c4852d45022b5c7a40515bb798cae573c42455add5368f053fbfc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roostats-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-roostats;unpack=0"
SRC_URI[aarch64_root-roostats.sha256sum] = "6464ea57d3101f1f4dd22f587386a6fa72f808e3e91cb2f8779e4336c46de44b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-smatrix-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-smatrix;unpack=0"
SRC_URI[aarch64_root-smatrix.sha256sum] = "24e4a755a4c5faaf0d8c77ea94884fde402f85c79355e9ec3ad917f4882b61f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-spectrum-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-spectrum;unpack=0"
SRC_URI[aarch64_root-spectrum.sha256sum] = "5416a1e2430c548ccce63aa2bd287f181883b09019f0bb5b17a8e3d0674671af"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-spectrum-painter-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-spectrum-painter;unpack=0"
SRC_URI[aarch64_root-spectrum-painter.sha256sum] = "187971722e9a7703f6de6a19a00bf243d60b690191b8c6528f9489700cf27f41"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-splot-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-splot;unpack=0"
SRC_URI[aarch64_root-splot.sha256sum] = "1c9e394623781ad7f860d231ede96666a55f459fb3d5bd5f64ff08dd9dda780f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-sql-sqlite-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-sql-sqlite;unpack=0"
SRC_URI[aarch64_root-sql-sqlite.sha256sum] = "20a66beffff0b7c750b9d92357f9e86a65218ef8540bfdb322bb59c04e143cf5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-testsupport-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-testsupport;unpack=0"
SRC_URI[aarch64_root-testsupport.sha256sum] = "8bd7ca9ab1d209d8fbd8fbbf1160027b5d37a34febd934141b79a92dd0adf427"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tmva;unpack=0"
SRC_URI[aarch64_root-tmva.sha256sum] = "5f25b94b5bed2c3984db894545711878a5add11ff46a1c0e0cf6b6e25240872c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-gui-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tmva-gui;unpack=0"
SRC_URI[aarch64_root-tmva-gui.sha256sum] = "dc0d8e70403927753ad6ab5a22d1e6b66af6d4723f6c1ea61d848eb900af7dc2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-python-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tmva-python;unpack=0"
SRC_URI[aarch64_root-tmva-python.sha256sum] = "82db6a8a2ded13aeebe49ef1eb399ffe0fcdfa77f0e1eedce05cf987020d6c1e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-r-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tmva-r;unpack=0"
SRC_URI[aarch64_root-tmva-r.sha256sum] = "0df867b4470906d67ccb0c1302df3f6c2c35751f58ed9708f1ad7b1f098704cb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-sofie-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tmva-sofie;unpack=0"
SRC_URI[aarch64_root-tmva-sofie.sha256sum] = "2c6f709f9c0ae2e6ebbc9535f3dd2213ac3f4a9e574551ab30c3dbbb9948b6bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-sofie-parser-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tmva-sofie-parser;unpack=0"
SRC_URI[aarch64_root-tmva-sofie-parser.sha256sum] = "ac5e89af43eb2608375850d861f79b3ac3ddf66e4180377144233bbb244389eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-sofie-parser-python-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tmva-sofie-parser-python;unpack=0"
SRC_URI[aarch64_root-tmva-sofie-parser-python.sha256sum] = "f063545e76906c0c10452b07e57aabca5c0406a42e4074a57676c6db10201c3d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-utils-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tmva-utils;unpack=0"
SRC_URI[aarch64_root-tmva-utils.sha256sum] = "7655cfe81c4c2911eecadc328531b81700de4682dcaf855a349c0bc8e1a53eaa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tpython-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tpython;unpack=0"
SRC_URI[aarch64_root-tpython.sha256sum] = "24f91bfaa08e0684e3d4ee3ff2c6006a8dedb7017ad907b10f85b8a2b5ab2539"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tree;unpack=0"
SRC_URI[aarch64_root-tree.sha256sum] = "9df3fcf46c98bcfad20c239ff4ac9ff11942b866ab7cd118ccfe383de47b1ad0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-dataframe-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tree-dataframe;unpack=0"
SRC_URI[aarch64_root-tree-dataframe.sha256sum] = "a9ec5815daadcaa92acb6339d42874f6977618c86ef64ea95ae2c63dd1ccb6c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ml-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tree-ml;unpack=0"
SRC_URI[aarch64_root-tree-ml.sha256sum] = "7cde1823c3ea399b9ff413ccf2671b08975c4b517b0b6c6f9488c49b8954b2a6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tree-ntuple;unpack=0"
SRC_URI[aarch64_root-tree-ntuple.sha256sum] = "31a38ef75840f2e4936d06f5cb015d7b27aaeff54ee3d6cf33904075a34d934c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-browse-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tree-ntuple-browse;unpack=0"
SRC_URI[aarch64_root-tree-ntuple-browse.sha256sum] = "ec34594854da8b45af287d08c0cbcbaa1028d1675320805276f4c86b8a3fc5cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-utils-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tree-ntuple-utils;unpack=0"
SRC_URI[aarch64_root-tree-ntuple-utils.sha256sum] = "49e9f3b896a02af2caa037e3255706d475b7db28000253414d3672cb8bceda8f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-player-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tree-player;unpack=0"
SRC_URI[aarch64_root-tree-player.sha256sum] = "c091345a36ae45c1edc0426d4bcfe76f3ef414502e590a6710f01c4f26f1c057"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-viewer-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tree-viewer;unpack=0"
SRC_URI[aarch64_root-tree-viewer.sha256sum] = "01205459ba334fcf4fa45e2ebe67f5bd24a41d8f7d3894b0a7c014b54144c9a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-webviewer-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-tree-webviewer;unpack=0"
SRC_URI[aarch64_root-tree-webviewer.sha256sum] = "774731e3568ef6b0004226cc7d12ac9cfcfa7a09ff83ecefb73a982ffe9f9920"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tutorial-6.40.04-1.el10_3.noarch.rpm;name=aarch64_root-tutorial;unpack=0"
SRC_URI[aarch64_root-tutorial.sha256sum] = "dc9bfe5c8d1dddec8b48c16f4f893038a21eb9299c0c67ad3e2485f21c433b0b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-unfold-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-unfold;unpack=0"
SRC_URI[aarch64_root-unfold.sha256sum] = "5850a3c9d20c20799b1ee10a2dfc8173081dbde967c48e2cf8617265b64dd563"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-unuran-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-unuran;unpack=0"
SRC_URI[aarch64_root-unuran.sha256sum] = "ff28aef04301cbe2edb9ace323ce262291f3c861587914c1cf597966782b6a45"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-vecops-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-vecops;unpack=0"
SRC_URI[aarch64_root-vecops.sha256sum] = "2f3c81679d8b7c7152379b60b337cc174b17184caab8891c6632eb1c02f2ac28"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-xroofit-6.40.04-1.el10_3.aarch64.rpm;name=aarch64_root-xroofit;unpack=0"
SRC_URI[aarch64_root-xroofit.sha256sum] = "53377fd2a46590b93ac6eebc6fe00b25aa77b416e2824dff6d37c99a7b0f9035"

RDEPENDS:python3-root = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 root-core \
 root-io \
 root-tree \
 "
RDEPENDS:python3-root+distrdf = " \
 python3 \
 python3-root \
 root-tree-dataframe \
 "
RDEPENDS:python3-root+jupyroot = " \
 bash \
 js-jsroot \
 python-jupyter-filesystem \
 python3 \
 python3-ipython \
 python3-metakernel \
 python3-notebook \
 python3-root \
 root-core \
 "
RDEPENDS:root = " \
 bash \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-mathcore \
 root-multiproc \
 root-net \
 root-tree \
 root-tree-ntuple \
 root-tree-player \
 "
RDEPENDS:root-cli = " \
 python3 \
 python3-root \
 "
RDEPENDS:root-cling = " \
 gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 python3 \
 redhat-rpm-config \
 root-core \
 root-io \
 zlib-ng-compat \
 "
RDEPENDS:root-core = " \
 bash \
 glibc \
 gnu-free-mono-fonts \
 gnu-free-sans-fonts \
 gnu-free-serif-fonts \
 google-droid-sans-fonts \
 json-devel \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 pcre2 \
 root-cling \
 root-font-files \
 root-graf \
 root-graf-asimage \
 root-graf-gpad \
 root-graf-postscript \
 root-graf3d \
 root-hist \
 root-icons \
 root-io \
 root-mathcore \
 root-matrix \
 root-multiproc \
 root-net \
 root-physics \
 root-tree \
 root-tree-dataframe \
 root-tree-ntuple \
 root-tree-ntuple-utils \
 root-tree-player \
 root-vecops \
 tbb \
 urw-base35-d050000l-fonts \
 urw-base35-standard-symbols-ps-fonts \
 urw-base35-z003-fonts \
 xorg-x11-fonts-ISO8859-1-75dpi \
 xxhash-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:root-fftw = " \
 fftw-libs-double \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-foam = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-font-files = " \
 root-core \
 "
RDEPENDS:root-fumili = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-gdml = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-hist \
 root-io-xml \
 "
RDEPENDS:root-genetic = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-tmva \
 "
RDEPENDS:root-genvector = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-geom = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-geom-builder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-gui \
 root-gui-ged \
 "
RDEPENDS:root-geom-checker = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 "
RDEPENDS:root-geom-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 "
RDEPENDS:root-geom-webviewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-painter \
 root-graf3d-csg \
 root-gui-webdisplay \
 root-io \
 "
RDEPENDS:root-graf = " \
 fontconfig \
 freetype \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-asimage = " \
 fontconfig \
 freetype \
 giflib \
 glibc \
 libX11 \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf-postscript \
 root-gui \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-fitsio = " \
 cfitsio \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-matrix \
 "
RDEPENDS:root-graf-gpad = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-postscript \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-gpadv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-graf-gviz:x86_64_v2 = " \
 glibc \
 graphviz \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-hist \
"
RDEPENDS:root-graf-gviz:aarch64 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-hist \
"
RDEPENDS:root-graf-postscript = " \
 fontconfig \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 zlib-ng-compat \
 "
RDEPENDS:root-graf-primitives = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 "
RDEPENDS:root-graf-x11 = " \
 freetype \
 glibc \
 libX11 \
 libXext \
 libXft \
 libXpm \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 "
RDEPENDS:root-graf3d = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-graf3d-csg = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-graf3d-eve = " \
 glibc \
 libgcc \
 libstdc++ \
 mesa-libGLU \
 root-core \
 root-geom \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-gl \
 root-graf3d-glad \
 root-gui \
 root-gui-ged \
 root-hist \
 root-io \
 root-mathcore \
 root-montecarlo-eg \
 root-physics \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-graf3d-eve7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-webviewer \
 root-graf \
 root-graf3d \
 root-graf3d-csg \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-mathcore \
 root-montecarlo-eg \
 root-net-http \
 root-physics \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-graf3d-gl = " \
 fontconfig \
 ftgl \
 gl2ps \
 glibc \
 libX11 \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 mesa-libGLU \
 root-core \
 root-graf \
 root-graf-asimage \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-csg \
 root-graf3d-glad \
 root-gui \
 root-gui-ged \
 root-hist \
 root-mathcore \
 root-tree \
 "
RDEPENDS:root-graf3d-glad = " \
 glibc \
 libX11 \
 root-core \
 "
RDEPENDS:root-graf3d-gviz3d = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-gl \
 root-gui \
 root-gui-ged \
 "
RDEPENDS:root-graf3d-x3d = " \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 root-core \
 root-graf3d \
 root-gui \
 "
RDEPENDS:root-gui = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf-x11 \
 root-gui-ged \
 root-io \
 root-mathcore \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browsable = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-gui-treemap \
 root-hist \
 root-io \
 root-tree \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browsable-v7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-browsable \
 root-gui-treemap \
 root-hist \
 root-tree \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browserv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-webviewer \
 root-graf-gpad \
 root-gui-browsable \
 root-gui-webdisplay \
 root-gui-webgui6 \
 root-io \
 root-tree \
 root-tree-webviewer \
 "
RDEPENDS:root-gui-browserv7-v7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-browsable \
 root-gui-browserv7 \
 "
RDEPENDS:root-gui-builder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-gui \
 root-mathcore \
 "
RDEPENDS:root-gui-canvaspainter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-webdisplay \
 root-io \
 "
RDEPENDS:root-gui-fitpanel = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-mathcore \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-gui-fitpanelv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-graf-gpadv7 \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-gui-ged = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-gui-html = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-gui \
 root-net \
 "
RDEPENDS:root-gui-qt6webdisplay = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 root-core \
 root-gui-webdisplay \
 root-net-http \
 "
RDEPENDS:root-gui-recorder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-gui \
 root-io \
 root-tree \
 "
RDEPENDS:root-gui-treemap = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 "
RDEPENDS:root-gui-webdisplay = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-mathcore \
 root-net \
 root-net-http \
 "
RDEPENDS:root-gui-webgui6 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-net-http \
 "
RDEPENDS:root-hbook = " \
 glibc \
 libgcc \
 libgfortran \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-tree \
 "
RDEPENDS:root-hist = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist-painter \
 root-io \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-hist-factory = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-io-xmlparser \
 root-roofit \
 root-roofit-core \
 root-roostats \
 "
RDEPENDS:root-hist-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-histv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-histv7util = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 "
RDEPENDS:root-icons = " \
 root-core \
 "
RDEPENDS:root-io = " \
 glibc \
 libgcc \
 libstdc++ \
 liburing \
 liburing-devel \
 root-core \
 "
RDEPENDS:root-io-dcache = " \
 dcap-libs \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-io-sql = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-io-xml = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-io-xmlparser = " \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 root-core \
 "
RDEPENDS:root-mathcore = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathmore \
 root-minuit2 \
 "
RDEPENDS:root-mathmore = " \
 glibc \
 gsl \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 "
RDEPENDS:root-matrix = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 "
RDEPENDS:root-minuit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-minuit2 = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-mlp = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 root-matrix \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-montecarlo-eg = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-mathcore \
 "
RDEPENDS:root-montecarlo-pythia8 = " \
 glibc \
 libgcc \
 libstdc++ \
 pythia8 \
 root-core \
 root-montecarlo-eg \
 "
RDEPENDS:root-multiproc = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-net = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 root-core \
 root-io \
 "
RDEPENDS:root-net-auth = " \
 glibc \
 libgcc \
 libstdc++ \
 libxcrypt \
 root-core \
 root-net \
 "
RDEPENDS:root-net-curl = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:root-net-davix = " \
 davix-libs \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-net-http = " \
 bash \
 civetweb \
 fcgi \
 glibc \
 js-jsroot \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-net-httpsniff = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-io-xml \
 root-net-http \
 root-tree \
 "
RDEPENDS:root-net-rpdutils = " \
 glibc \
 libgcc \
 libstdc++ \
 libxcrypt \
 root-core \
 root-net \
 "
RDEPENDS:root-netx = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:root-physics = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-quadp = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-matrix \
 "
RDEPENDS:root-r = " \
 R-RInside \
 R-Rcpp \
 R-core \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 readline \
 root-core \
 root-matrix \
 "
RDEPENDS:root-r-tools = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-matrix \
 root-r \
 "
RDEPENDS:root-roofit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-roofit-batchcompute \
 root-roofit-core \
 root-tree \
 "
RDEPENDS:root-roofit-batchcompute = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-roofit-codegen = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist-factory \
 root-roofit \
 root-roofit-core \
 "
RDEPENDS:root-roofit-core = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-foam \
 root-graf \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-minuit2 \
 root-roofit-batchcompute \
 root-roofit-multiprocess \
 root-roofit-zmq \
 root-tree \
 zeromq \
 "
RDEPENDS:root-roofit-hs3 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-hist-factory \
 root-matrix \
 root-roofit \
 root-roofit-core \
 "
RDEPENDS:root-roofit-more = " \
 glibc \
 gsl \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-mathmore \
 root-roofit-core \
 "
RDEPENDS:root-roofit-multiprocess = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-roofit-zmq \
 zeromq \
 "
RDEPENDS:root-roofit-zmq = " \
 glibc \
 libgcc \
 libstdc++ \
 zeromq \
 "
RDEPENDS:root-roostats = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-minuit \
 root-roofit \
 root-roofit-core \
 root-tree \
 "
RDEPENDS:root-smatrix = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-spectrum = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 "
RDEPENDS:root-spectrum-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-hist \
 "
RDEPENDS:root-splot = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-matrix \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-sql-sqlite = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-net \
 sqlite-libs \
 "
RDEPENDS:root-testsupport = " \
 root-core \
 "
RDEPENDS:root-tmva = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-io-xml \
 root-mathcore \
 root-matrix \
 root-minuit \
 root-mlp \
 root-multiproc \
 root-net \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-tmva-gui = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-io \
 root-io-xml \
 root-matrix \
 root-tmva \
 root-tree \
 root-tree-viewer \
 "
RDEPENDS:root-tmva-python = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 python3-numpy \
 root-core \
 root-tmva \
 root-tree \
 "
RDEPENDS:root-tmva-r = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-matrix \
 root-r \
 root-tmva \
 "
RDEPENDS:root-tmva-sofie = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-tmva-sofie-parser = " \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 root-core \
 root-tmva-sofie \
 "
RDEPENDS:root-tmva-sofie-parser-python = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 python3-numpy \
 root-core \
 root-tmva-sofie \
 "
RDEPENDS:root-tmva-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-tpython = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 python3-root \
 root-core \
 "
RDEPENDS:root-tree = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-tree-dataframe = " \
 glibc \
 libarrow \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 root-tree-ntuple \
 root-tree-player \
 root-vecops \
 sqlite-libs \
 "
RDEPENDS:root-tree-ml = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-vecops \
 "
RDEPENDS:root-tree-ntuple = " \
 glibc \
 libgcc \
 libstdc++ \
 libuuid \
 root-core \
 root-io \
 xxhash-libs \
 "
RDEPENDS:root-tree-ntuple-browse = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui-treemap \
 root-hist \
 root-io \
 root-tree-ntuple \
 root-tree-ntuple-utils \
 "
RDEPENDS:root-tree-ntuple-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-tree \
 root-tree-ntuple \
 "
RDEPENDS:root-tree-player = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 root-io \
 root-mathcore \
 root-multiproc \
 root-net \
 root-tree \
 "
RDEPENDS:root-tree-viewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-gui-ged \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-tree-webviewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-tree \
 "
RDEPENDS:root-tutorial = " \
 root \
 "
RDEPENDS:root-unfold = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io-xmlparser \
 root-matrix \
 "
RDEPENDS:root-unuran = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 unuran \
 "
RDEPENDS:root-vecops = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-xroofit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-gui-fitpanel \
 root-gui-ged \
 root-hist \
 root-hist-factory \
 root-io \
 root-mathcore \
 root-matrix \
 root-roofit \
 root-roofit-core \
 root-roofit-hs3 \
 root-roostats \
 root-tree \
 "
