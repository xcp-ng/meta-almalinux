# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-generic-array"
PV = "0.14.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-generic-array+default-devel \
 rust-generic-array+more_lengths-devel \
 rust-generic-array+serde-devel \
 rust-generic-array+zeroize-devel \
 rust-generic-array-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-generic-array-0.14.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dacb6164fa34c0ebb2f1c626c05727672c670b79d0f85dbf198203c56ed9fb2"

URI_x86_64_v2_rust-generic-array+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array+default-devel-0.14.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-generic-array+default-devel}"
SRC_URI[x86_64_v2_rust-generic-array+default-devel.sha256sum] = "da8e689f45e87cc537966fcbbed13ad0c6df38ef8b6f342089921356d6e417b5"

URI_x86_64_v2_rust-generic-array+more_lengths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array+more_lengths-devel-0.14.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array+more_lengths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-generic-array+more_lengths-devel}"
SRC_URI[x86_64_v2_rust-generic-array+more_lengths-devel.sha256sum] = "3277732d888fd013c8c6d8b8b0d5db75ed28dc2f63ee4ef85667a860486187b2"

URI_x86_64_v2_rust-generic-array+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array+serde-devel-0.14.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-generic-array+serde-devel}"
SRC_URI[x86_64_v2_rust-generic-array+serde-devel.sha256sum] = "9bb8bc31c30ef8e5f6eb9d4cab646bb9b8da4811c2edd406e11ef02b74d4921c"

URI_x86_64_v2_rust-generic-array+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array+zeroize-devel-0.14.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-generic-array+zeroize-devel}"
SRC_URI[x86_64_v2_rust-generic-array+zeroize-devel.sha256sum] = "200a08891485c5f1de174b7f03fda39bd533b4dab01a4e9c02d018d316763729"

URI_x86_64_v2_rust-generic-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array-devel-0.14.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-generic-array-devel}"
SRC_URI[x86_64_v2_rust-generic-array-devel.sha256sum] = "a4fbb6e799dd0d226a0a17e2172eda8dc30e09724d56bfdd715a7d7c038571ff"

URI_aarch64_rust-generic-array+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array+default-devel-0.14.9-1.el10_1.noarch.rpm;name=aarch64_rust-generic-array+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-generic-array+default-devel}"
SRC_URI[aarch64_rust-generic-array+default-devel.sha256sum] = "5765a7df70592a6447a3423e1b7338420067bed4fb793f24b2ecd3630c40c04f"

URI_aarch64_rust-generic-array+more_lengths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array+more_lengths-devel-0.14.9-1.el10_1.noarch.rpm;name=aarch64_rust-generic-array+more_lengths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-generic-array+more_lengths-devel}"
SRC_URI[aarch64_rust-generic-array+more_lengths-devel.sha256sum] = "80b2ba59c6336a16de1d99dca5081af690179fa5f9f5faf7017c0109d5ca21d7"

URI_aarch64_rust-generic-array+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array+serde-devel-0.14.9-1.el10_1.noarch.rpm;name=aarch64_rust-generic-array+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-generic-array+serde-devel}"
SRC_URI[aarch64_rust-generic-array+serde-devel.sha256sum] = "5cfe719e7faa07e8a813f7b44968cadd9e8aa3582f5290adfdf3055f011f205d"

URI_aarch64_rust-generic-array+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array+zeroize-devel-0.14.9-1.el10_1.noarch.rpm;name=aarch64_rust-generic-array+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-generic-array+zeroize-devel}"
SRC_URI[aarch64_rust-generic-array+zeroize-devel.sha256sum] = "cc95cbd7f5ae5bf6cf1680bd23d64226fc1452550c4ab6c0ff059e7dd988a610"

URI_aarch64_rust-generic-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array-devel-0.14.9-1.el10_1.noarch.rpm;name=aarch64_rust-generic-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-generic-array-devel}"
SRC_URI[aarch64_rust-generic-array-devel.sha256sum] = "012db90211c6dbc3838640ccf4f25e18f4631ab0b4d4718d614f3e7867e2f2b5"

RDEPENDS:rust-generic-array+default-devel = " \
 cargo \
 rust-generic-array-devel \
 "
RDEPENDS:rust-generic-array+more_lengths-devel = " \
 cargo \
 rust-generic-array-devel \
 "
RDEPENDS:rust-generic-array+serde-devel = " \
 cargo \
 rust-generic-array-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-generic-array+zeroize-devel = " \
 cargo \
 rust-generic-array-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-generic-array-devel = " \
 cargo \
 rust-typenum+default-devel \
 rust-version_check+default-devel \
 "
