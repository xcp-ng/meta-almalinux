# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwindowsystem"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kwindowsystem \
 kf6-kwindowsystem-devel \
 kf6-kwindowsystem-doc \
 kf6-kwindowsystem-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kwindowsystem-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a846084c9c2e39abd91775cae2abc7031812d57cda8b19c9cf1b906956b3014e"

URI_x86_64_v2_kf6-kwindowsystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwindowsystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem}"
SRC_URI[x86_64_v2_kf6-kwindowsystem.sha256sum] = "bcfa71de4b13947ecfc8c37747660f0a934591105216efae8deab7821d74d4f0"

URI_x86_64_v2_kf6-kwindowsystem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwindowsystem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem-devel}"
SRC_URI[x86_64_v2_kf6-kwindowsystem-devel.sha256sum] = "dfc5f579fd6e66a6fe975106559d5c312938c57e5f444182974faa3daee24692"

URI_x86_64_v2_kf6-kwindowsystem-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwindowsystem-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem-doc}"
SRC_URI[x86_64_v2_kf6-kwindowsystem-doc.sha256sum] = "cd6ebd518c4c89ed22217cb70fd65cf71190f06b1dcc47723787ba86c01003b7"

URI_x86_64_v2_kf6-kwindowsystem-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwindowsystem-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem-html}"
SRC_URI[x86_64_v2_kf6-kwindowsystem-html.sha256sum] = "a6e301ec6e54beda9e936ccff35618ab92dbfcb0289a8eed2f076843d1871a33"

URI_aarch64_kf6-kwindowsystem = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kwindowsystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem}"
SRC_URI[aarch64_kf6-kwindowsystem.sha256sum] = "d943159f36df15afde68e5d5ab20f551f017199e8c6a377563f8d5688831491a"

URI_aarch64_kf6-kwindowsystem-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kwindowsystem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem-devel}"
SRC_URI[aarch64_kf6-kwindowsystem-devel.sha256sum] = "4622ef3e13a82c8836baf8bdfe13ca86247b7249bd4e82fdcd0d1933d4be44a0"

URI_aarch64_kf6-kwindowsystem-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kwindowsystem-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem-doc}"
SRC_URI[aarch64_kf6-kwindowsystem-doc.sha256sum] = "7308193d484fc13475fa23eca089f7ff159b48bcbf49a9faa2b6ed292792ad9b"

URI_aarch64_kf6-kwindowsystem-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kwindowsystem-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem-html}"
SRC_URI[aarch64_kf6-kwindowsystem-html.sha256sum] = "03a2c763ebde0fbc7db4d60b2e0dbb5c4a47871c2b2a3c22a0be0f2c11cc8ec3"

RDEPENDS:kf6-kwindowsystem = " \
 glibc \
 kf6-filesystem \
 libX11 \
 libXfixes \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xcb-util-keysyms \
 "
RDEPENDS:kf6-kwindowsystem-devel = " \
 cmake-filesystem \
 kf6-kwindowsystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kwindowsystem-doc = " \
 "
RDEPENDS:kf6-kwindowsystem-html = " \
 "
