# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jpegxl"
PE = "1"
PV = "0.10.4"
PR = "1.el10_0"
PACKAGES = " \
 jpegxl-doc \
 jxl-pixbuf-loader \
 libjxl \
 libjxl-devel \
 libjxl-devtools \
 libjxl-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jpegxl-0.10.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29873eeee39d944b229649650a9909c2f7b3014cb9d6d8249cbd9dee6d1bc6fc"

URI_x86_64_v2_jpegxl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jpegxl-doc-0.10.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_jpegxl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jpegxl-doc}"
SRC_URI[x86_64_v2_jpegxl-doc.sha256sum] = "2f66a889613b56dc5bd1df0bafbdd9c4136933de88d49f71944f4841f5cfb0c6"

URI_x86_64_v2_jxl-pixbuf-loader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jxl-pixbuf-loader-0.10.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jxl-pixbuf-loader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jxl-pixbuf-loader}"
SRC_URI[x86_64_v2_jxl-pixbuf-loader.sha256sum] = "1ff07ca62c731ac1bfc33d3d2fd08988f67c065c7a3d29532d17fca6d08ca877"

URI_x86_64_v2_libjxl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjxl-0.10.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjxl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjxl}"
SRC_URI[x86_64_v2_libjxl.sha256sum] = "f5dfb622c0f43fe39a41216e5ac63e2ef9f80f226e510d0ad733c9dc092b6bd8"

URI_x86_64_v2_libjxl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjxl-devel-0.10.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjxl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjxl-devel}"
SRC_URI[x86_64_v2_libjxl-devel.sha256sum] = "bdd523fefe0c5ef213478439260429e7c16e841c5062c6e689aa3eeee5b03532"

URI_x86_64_v2_libjxl-devtools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjxl-devtools-0.10.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjxl-devtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjxl-devtools}"
SRC_URI[x86_64_v2_libjxl-devtools.sha256sum] = "c50c932ef0eef35052f4234f17069a0fab02e21c9a601e88744c2d805ac8c7fe"

URI_x86_64_v2_libjxl-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjxl-utils-0.10.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjxl-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjxl-utils}"
SRC_URI[x86_64_v2_libjxl-utils.sha256sum] = "f3bf5a8a4a6e590844d30ba4e4584d72e9cf60c19ca0d6c625fa023071d4a177"

URI_aarch64_jpegxl-doc = "${EPEL_MIRROR}/aarch64/Packages/j/jpegxl-doc-0.10.4-1.el10_0.noarch.rpm;name=aarch64_jpegxl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jpegxl-doc}"
SRC_URI[aarch64_jpegxl-doc.sha256sum] = "bcae2451cd3274828ee757cfe304424c85836619eeb43f872b1fc3cb45c1c454"

URI_aarch64_jxl-pixbuf-loader = "${EPEL_MIRROR}/aarch64/Packages/j/jxl-pixbuf-loader-0.10.4-1.el10_0.aarch64.rpm;name=aarch64_jxl-pixbuf-loader;unpack=0"
SRC_URI:append = " ${URI_aarch64_jxl-pixbuf-loader}"
SRC_URI[aarch64_jxl-pixbuf-loader.sha256sum] = "a3bf564f2227f44872e5ca61e507744ef253f469c87460795eae0534860609d3"

URI_aarch64_libjxl = "${EPEL_MIRROR}/aarch64/Packages/l/libjxl-0.10.4-1.el10_0.aarch64.rpm;name=aarch64_libjxl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjxl}"
SRC_URI[aarch64_libjxl.sha256sum] = "d2de19cee97f51188cf8f0d716279a3caea1c7082b5db5cd3b0a167e8c5e7e43"

URI_aarch64_libjxl-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libjxl-devel-0.10.4-1.el10_0.aarch64.rpm;name=aarch64_libjxl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjxl-devel}"
SRC_URI[aarch64_libjxl-devel.sha256sum] = "05f33aeaf5f76ccc26b0c4b4808f25005513ead263ff01a7eb2f0c454a81405f"

URI_aarch64_libjxl-devtools = "${EPEL_MIRROR}/aarch64/Packages/l/libjxl-devtools-0.10.4-1.el10_0.aarch64.rpm;name=aarch64_libjxl-devtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjxl-devtools}"
SRC_URI[aarch64_libjxl-devtools.sha256sum] = "a53c9c94ef510b6fa849cd9bfea1431c2d419a184b5186ecadfa19fd2c6749e2"

URI_aarch64_libjxl-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libjxl-utils-0.10.4-1.el10_0.aarch64.rpm;name=aarch64_libjxl-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjxl-utils}"
SRC_URI[aarch64_libjxl-utils.sha256sum] = "28cb47ee5776d34bae3fc91af694d8d0f9e96aad8a457cd8a7794ba342de07fb"

RDEPENDS:jpegxl-doc = " \
 "
RDEPENDS:jxl-pixbuf-loader = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libjxl \
 "
RDEPENDS:libjxl = " \
 giflib \
 glibc \
 highway \
 libbrotli \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 openexr-libs \
 shared-mime-info \
 "
RDEPENDS:libjxl-devel = " \
 brotli-devel \
 highway-devel \
 libjxl \
 libjxl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libjxl-devtools = " \
 giflib \
 glibc \
 highway \
 libbrotli \
 libgcc \
 libjpeg-turbo \
 libjxl \
 libpng \
 libstdc++ \
 openexr-libs \
 "
RDEPENDS:libjxl-utils = " \
 giflib \
 glibc \
 highway \
 libbrotli \
 libgcc \
 libjpeg-turbo \
 libjxl \
 libpng \
 libstdc++ \
 openexr-libs \
 "
