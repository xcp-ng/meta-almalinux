# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "signon-plugin-oauth2"
PV = "0.25^20231216.fab6988"
PR = "4.el10_0"
PACKAGES = " \
 signon-plugin-oauth2 \
 signon-plugin-oauth2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/signon-plugin-oauth2-0.25^20231216.fab6988-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "564e3b97c30df19b5ed7646d7bc88586bee9f3a7a88aa1b99353b2cf8277b295"

URI_x86_64_v2_signon-plugin-oauth2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-plugin-oauth2-0.25^20231216.fab6988-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signon-plugin-oauth2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signon-plugin-oauth2}"
SRC_URI[x86_64_v2_signon-plugin-oauth2.sha256sum] = "95a831258dc3267097810cf9e6d5ee733008b3b2f6b4a2f3b0feadb7592a22ef"

URI_x86_64_v2_signon-plugin-oauth2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-plugin-oauth2-devel-0.25^20231216.fab6988-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signon-plugin-oauth2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signon-plugin-oauth2-devel}"
SRC_URI[x86_64_v2_signon-plugin-oauth2-devel.sha256sum] = "da7cf2d2907864897e821e217727dd38a3b9466bbd6efea0fd7d77506ae296d9"

URI_aarch64_signon-plugin-oauth2 = "${EPEL_MIRROR}/aarch64/Packages/s/signon-plugin-oauth2-0.25^20231216.fab6988-4.el10_0.aarch64.rpm;name=aarch64_signon-plugin-oauth2;unpack=0"
SRC_URI:append = " ${URI_aarch64_signon-plugin-oauth2}"
SRC_URI[aarch64_signon-plugin-oauth2.sha256sum] = "c853b5f631e9625e599c3c9bc9201078ff920c41c2a0345dc2ba1516a9a54ba9"

URI_aarch64_signon-plugin-oauth2-devel = "${EPEL_MIRROR}/aarch64/Packages/s/signon-plugin-oauth2-devel-0.25^20231216.fab6988-4.el10_0.aarch64.rpm;name=aarch64_signon-plugin-oauth2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_signon-plugin-oauth2-devel}"
SRC_URI[aarch64_signon-plugin-oauth2-devel.sha256sum] = "5a153b7e340739c8c164753c3d5f7064d606c90b394bd69df2c6d0d00c4ef4a0"

RDEPENDS:signon-plugin-oauth2 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 signon \
 "
RDEPENDS:signon-plugin-oauth2-devel = " \
 pkgconf-pkg-config \
 signon-devel \
 signon-plugin-oauth2 \
 "
