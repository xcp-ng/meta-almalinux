# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-sdk"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-sdk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-sdk-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f4dc7f8dccef11359bd941b39d982eee54c89342c40b9982c5f9a1785b3b0cb"

URI_x86_64_v2_plasma-sdk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-sdk-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-sdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-sdk}"
SRC_URI[x86_64_v2_plasma-sdk.sha256sum] = "1f145c6908356c4a56bfe0bd08de159f84f91d1f0a92f0d9c11c4446c2c43af4"

URI_aarch64_plasma-sdk = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-sdk-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-sdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-sdk}"
SRC_URI[aarch64_plasma-sdk.sha256sum] = "1fe6e86da1daad82772b4d425c87bb993b464741000e0ddea9f7b44ca77c55e0"

RDEPENDS:plasma-sdk = " \
 glibc \
 hicolor-icon-theme \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kpackage \
 kf6-ksvg \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 libplasma \
 libstdc++ \
 plasma5support \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
