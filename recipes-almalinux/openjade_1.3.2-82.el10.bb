# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openjade"
PV = "1.3.2"
PR = "82.el10"
PACKAGES = " \
 openjade \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/openjade-1.3.2-82.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52600c10fe1e1d525c9e0b0671bf767ddf722809d620e3fe4f7474059b8e7673"

URI_x86_64_v2_openjade = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openjade-1.3.2-82.el10.x86_64_v2.rpm;name=x86_64_v2_openjade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openjade}"
SRC_URI[x86_64_v2_openjade.sha256sum] = "bd6f94f73cd6a853e760a89fb2e750e97d0603c1abf6bc4e14d650223c989e8c"

URI_aarch64_openjade = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openjade-1.3.2-82.el10.aarch64.rpm;name=aarch64_openjade;unpack=0"
SRC_URI:append = " ${URI_aarch64_openjade}"
SRC_URI[aarch64_openjade.sha256sum] = "0a79e89c1cce9bebf462ad4ad076b409975fe356ad9338b0da0990a8eee7b650"

RDEPENDS:openjade = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 opensp \
 sgml-common \
 "
