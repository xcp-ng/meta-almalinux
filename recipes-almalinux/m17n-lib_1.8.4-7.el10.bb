# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "m17n-lib"
PV = "1.8.4"
PR = "7.el10"
PACKAGES = " \
 m17n-lib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/m17n-lib-1.8.4-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21ba4d9e07ec883c9081b2e8fcf47d3092cc78b6e603b417b6fdb4a32f3f0c19"

URI_x86_64_v2_m17n-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/m17n-lib-1.8.4-7.el10.x86_64_v2.rpm;name=x86_64_v2_m17n-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_m17n-lib}"
SRC_URI[x86_64_v2_m17n-lib.sha256sum] = "f2ad468edcb77315a7a0ed8f04c694af09c19fa4c65260432528cdad396c76a1"

URI_aarch64_m17n-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/m17n-lib-1.8.4-7.el10.aarch64.rpm;name=aarch64_m17n-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_m17n-lib}"
SRC_URI[aarch64_m17n-lib.sha256sum] = "a55746470f0e9e2c7e153fc8ae0c070874baab953a1ba1ca59d8818e6a14f4f9"

RDEPENDS:m17n-lib = " \
 glibc \
 libthai \
 libxml2 \
 m17n-db \
 xz-libs \
 zlib-ng-compat \
 "
