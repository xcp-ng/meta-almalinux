# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kimap"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kimap \
 kimap-devel \
 kimap-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kimap-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "193e4523c57b7a59eb143bfe6fe4e2209eda02fb4d29d422b0b5ae04f2443c58"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimap;unpack=0"
SRC_URI[x86_64_v2_kimap.sha256sum] = "4258faf7655fec740b8fb9ae3e82f907e7b9508f91f9adb4deeb59f8db38cce8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimap-devel;unpack=0"
SRC_URI[x86_64_v2_kimap-devel.sha256sum] = "91e329fb28bbdec3a18c59f343a6815670be516aeda09e42df3738efb90464c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kimap-doc;unpack=0"
SRC_URI[x86_64_v2_kimap-doc.sha256sum] = "4f4cc31cb824b4ad0d7dea6a88226baf65d459082992c8dcba166004402a56f2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kimap-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kimap;unpack=0"
SRC_URI[aarch64_kimap.sha256sum] = "72c8d5eb6fb0ebebb70c0608f3af6478da9b282c717dc3cd8559e638167d81a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kimap-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kimap-devel;unpack=0"
SRC_URI[aarch64_kimap-devel.sha256sum] = "e5a68496da0eb28d52930a3d0a4a87d91d68d43585a2868af98f7c92acb7060a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kimap-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kimap-doc;unpack=0"
SRC_URI[aarch64_kimap-doc.sha256sum] = "30e161450d66a8ea23359d2652bc96aefa49e2cc98555040c4040037d376ea9c"

RDEPENDS:kimap = " \
 cyrus-sasl-lib \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kimap-devel = " \
 boost-devel \
 cmake-filesystem \
 cyrus-sasl-devel \
 kf6-kcoreaddons-devel \
 kimap \
 "
RDEPENDS:kimap-doc = " \
 "
