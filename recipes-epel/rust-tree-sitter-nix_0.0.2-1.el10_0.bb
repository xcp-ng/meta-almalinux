# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-nix"
PV = "0.0.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-nix+default-devel \
 rust-tree-sitter-nix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-nix-0.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80367025f2d345b1877be2d38ecd72a499e68a8882c652ed12facafbd6867be0"

URI_x86_64_v2_rust-tree-sitter-nix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-nix+default-devel-0.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-nix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-nix+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-nix+default-devel.sha256sum] = "57d6b3cc2afc1f871b8980fc37d3c6ab09dc7c41d694f81137350c16f4922e6a"

URI_x86_64_v2_rust-tree-sitter-nix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-nix-devel-0.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-nix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-nix-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-nix-devel.sha256sum] = "27d60c8b6958c3a258558cf75e1988c38223888a36794c9ef42437309b6cbc5d"

URI_aarch64_rust-tree-sitter-nix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-nix+default-devel-0.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-nix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-nix+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-nix+default-devel.sha256sum] = "da29be63180286da424a3919e19b76f447f6eef0013264d8bd15cc3709c87ad1"

URI_aarch64_rust-tree-sitter-nix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-nix-devel-0.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-nix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-nix-devel}"
SRC_URI[aarch64_rust-tree-sitter-nix-devel.sha256sum] = "27ffb98070cd508782bfb548325968ff3949badd5a75f44b83a20b546730c594"

RDEPENDS:rust-tree-sitter-nix+default-devel = " \
 cargo \
 rust-tree-sitter-nix-devel \
 "
RDEPENDS:rust-tree-sitter-nix-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
