# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "exfatprogs"
PV = "1.2.8"
PR = "1.el10"
PACKAGES = " \
 exfatprogs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/exfatprogs-1.2.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b04f914f2e0e5b66dd2bd554c9e9f212f829133d4a2a8069ee739e92622a430"

URI_x86_64_v2_exfatprogs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/exfatprogs-1.2.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_exfatprogs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_exfatprogs}"
SRC_URI[x86_64_v2_exfatprogs.sha256sum] = "7d5e81b95d62934c877a5dd3180f8c2888eb890709b98e49cd6e2572b705d69d"

URI_aarch64_exfatprogs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/exfatprogs-1.2.8-1.el10.aarch64.rpm;name=aarch64_exfatprogs;unpack=0"
SRC_URI:append = " ${URI_aarch64_exfatprogs}"
SRC_URI[aarch64_exfatprogs.sha256sum] = "0ec924ab6fdafdc89e00b16e7c61c2272f884a2bd9ff45d17a0cf903568f62f8"

RDEPENDS:exfatprogs = " \
 glibc \
 "
