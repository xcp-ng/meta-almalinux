# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spirv-llvm15.0-translator"
PV = "15.0.0"
PR = "14.el10_0"
PACKAGES = " \
 spirv-llvm15.0-translator \
 spirv-llvm15.0-translator-devel \
 spirv-llvm15.0-translator-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spirv-llvm15.0-translator-15.0.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3a658feebcd342926fc163c0c3745d56b6143e71f3cd4096c9cfc67eb5fde00"

URI_x86_64_v2_spirv-llvm15.0-translator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spirv-llvm15.0-translator-15.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spirv-llvm15.0-translator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spirv-llvm15.0-translator}"
SRC_URI[x86_64_v2_spirv-llvm15.0-translator.sha256sum] = "a53309d4f3e86a275e8552557fb5e0d3de3e7211a6938fc2feb5a44f8d891f4f"

URI_x86_64_v2_spirv-llvm15.0-translator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spirv-llvm15.0-translator-devel-15.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spirv-llvm15.0-translator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spirv-llvm15.0-translator-devel}"
SRC_URI[x86_64_v2_spirv-llvm15.0-translator-devel.sha256sum] = "5a978f8b25622a8cc125f02cb5aad58cafce9aaecb4e881a61a63a81185bd93d"

URI_x86_64_v2_spirv-llvm15.0-translator-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spirv-llvm15.0-translator-tools-15.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spirv-llvm15.0-translator-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spirv-llvm15.0-translator-tools}"
SRC_URI[x86_64_v2_spirv-llvm15.0-translator-tools.sha256sum] = "078a12e2bd88fab1537711c8059f6dfecb6b3a1ce3bcc3bce9ab8d91e7aac90d"

URI_aarch64_spirv-llvm15.0-translator = "${EPEL_MIRROR}/aarch64/Packages/s/spirv-llvm15.0-translator-15.0.0-14.el10_0.aarch64.rpm;name=aarch64_spirv-llvm15.0-translator;unpack=0"
SRC_URI:append = " ${URI_aarch64_spirv-llvm15.0-translator}"
SRC_URI[aarch64_spirv-llvm15.0-translator.sha256sum] = "01810a02da0a78516d702cdc85e6406011090eafc90c05590900e4b115cc98bd"

URI_aarch64_spirv-llvm15.0-translator-devel = "${EPEL_MIRROR}/aarch64/Packages/s/spirv-llvm15.0-translator-devel-15.0.0-14.el10_0.aarch64.rpm;name=aarch64_spirv-llvm15.0-translator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_spirv-llvm15.0-translator-devel}"
SRC_URI[aarch64_spirv-llvm15.0-translator-devel.sha256sum] = "af1dde6dab45fb12a89ec1585680c514452e48cf5cba971e18c6ad7c2a9c845d"

URI_aarch64_spirv-llvm15.0-translator-tools = "${EPEL_MIRROR}/aarch64/Packages/s/spirv-llvm15.0-translator-tools-15.0.0-14.el10_0.aarch64.rpm;name=aarch64_spirv-llvm15.0-translator-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_spirv-llvm15.0-translator-tools}"
SRC_URI[aarch64_spirv-llvm15.0-translator-tools.sha256sum] = "a8b56c5fcc540fdcf594fbf2176f9c525e6709371bb7fc9e501143e7b69567dd"

RDEPENDS:spirv-llvm15.0-translator = " \
 glibc \
 libstdc++ \
 llvm15-libs \
 "
RDEPENDS:spirv-llvm15.0-translator-devel = " \
 pkgconf-pkg-config \
 spirv-llvm15.0-translator \
 "
RDEPENDS:spirv-llvm15.0-translator-tools = " \
 glibc \
 libstdc++ \
 llvm15-libs \
 spirv-llvm15.0-translator \
 spirv-tools-libs \
 "
