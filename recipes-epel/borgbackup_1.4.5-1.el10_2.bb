# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "borgbackup"
PV = "1.4.5"
PR = "1.el10_2"
PACKAGES = " \
 borgbackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/borgbackup-1.4.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c67e93e2634913c8326be98875b770c67b901f30d140e5744a37bc64bbc0391"

URI_x86_64_v2_borgbackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/borgbackup-1.4.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_borgbackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_borgbackup}"
SRC_URI[x86_64_v2_borgbackup.sha256sum] = "300076d44136bbc83d4e05e503cdb63b5613abe689b57173feb4e47995294b86"

URI_aarch64_borgbackup = "${EPEL_MIRROR}/aarch64/Packages/b/borgbackup-1.4.5-1.el10_2.aarch64.rpm;name=aarch64_borgbackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_borgbackup}"
SRC_URI[aarch64_borgbackup.sha256sum] = "d6829d1b530c8a9d56bd15fa513323d0f6c09e0477c5f2584b83b7374b44dd92"

RDEPENDS:borgbackup = " \
 fuse \
 glibc \
 libacl \
 libzstd \
 lz4-libs \
 openssl-libs \
 python3 \
 python3-llfuse \
 python3-msgpack \
 python3-packaging \
 xxhash-libs \
 "
