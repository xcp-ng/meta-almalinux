# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Eval-Closure"
PV = "0.14"
PR = "20.el10_0"
PACKAGES = " \
 perl-Eval-Closure \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Eval-Closure-0.14-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45ffb456480c395a3ccbcead1980b2268e0b4599c595afd5b27fd5841008c9b6"

URI_x86_64_v2_perl-Eval-Closure = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Eval-Closure-0.14-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Eval-Closure;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Eval-Closure}"
SRC_URI[x86_64_v2_perl-Eval-Closure.sha256sum] = "956512ce6332c76170bae941a6fb2ed008d884c81bfe4e92b91c72c0a77e7d83"

URI_aarch64_perl-Eval-Closure = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Eval-Closure-0.14-20.el10_0.noarch.rpm;name=aarch64_perl-Eval-Closure;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Eval-Closure}"
SRC_URI[aarch64_perl-Eval-Closure.sha256sum] = "7efb79a59159b2b3079e6d970da043bbe83596d866ca7bd23bbe538089c88427"

RDEPENDS:perl-Eval-Closure = " \
 perl-Carp \
 perl-Devel-LexAlias \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-libs \
 perl-overload \
 perltidy \
 "
