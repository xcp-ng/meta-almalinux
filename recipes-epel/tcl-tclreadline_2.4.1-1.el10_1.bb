# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tcl-tclreadline"
PV = "2.4.1"
PR = "1.el10_1"
PACKAGES = " \
 tcl-tclreadline \
 tcl-tclreadline-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tcl-tclreadline-2.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c72fda1d58d93c31919e2808951992d993306ff6f1474d06e54779fdea30bf9b"

URI_x86_64_v2_tcl-tclreadline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcl-tclreadline-2.4.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcl-tclreadline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tcl-tclreadline}"
SRC_URI[x86_64_v2_tcl-tclreadline.sha256sum] = "084325f9c342de81f4822c1b2e8b221b6ccd7241d5a2ad28deade52ed0254756"

URI_x86_64_v2_tcl-tclreadline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcl-tclreadline-devel-2.4.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcl-tclreadline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tcl-tclreadline-devel}"
SRC_URI[x86_64_v2_tcl-tclreadline-devel.sha256sum] = "bc884fd23091be471a69268b842b84a99a982249f5aede2c9d313a32c77508d4"

URI_aarch64_tcl-tclreadline = "${EPEL_MIRROR}/aarch64/Packages/t/tcl-tclreadline-2.4.1-1.el10_1.aarch64.rpm;name=aarch64_tcl-tclreadline;unpack=0"
SRC_URI:append = " ${URI_aarch64_tcl-tclreadline}"
SRC_URI[aarch64_tcl-tclreadline.sha256sum] = "0117a118eecb2a9c010bf02f0c508f029d895e3f6f965219f8953275550f7278"

URI_aarch64_tcl-tclreadline-devel = "${EPEL_MIRROR}/aarch64/Packages/t/tcl-tclreadline-devel-2.4.1-1.el10_1.aarch64.rpm;name=aarch64_tcl-tclreadline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tcl-tclreadline-devel}"
SRC_URI[aarch64_tcl-tclreadline-devel.sha256sum] = "5b80861fa3548af169f1032e3fccb7a124a68f5e1a44228a5f59b22b3588009a"

RDEPENDS:tcl-tclreadline = " \
 glibc \
 readline \
 tcl \
 "
RDEPENDS:tcl-tclreadline-devel = " \
 tcl-tclreadline \
 "
