# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-schemars_derive"
PV = "0.8.22"
PR = "1.el10_0"
PACKAGES = " \
 rust-schemars_derive+default-devel \
 rust-schemars_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-schemars_derive-0.8.22-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9080297c5b180585cb03b0be963a2b80d705e62ad81fa368894075062b144cd5"

URI_x86_64_v2_rust-schemars_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars_derive+default-devel-0.8.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars_derive+default-devel}"
SRC_URI[x86_64_v2_rust-schemars_derive+default-devel.sha256sum] = "d7c2110a2844cdb26b6a32a7316e465985d0db892d3e4aa2e8420563700f32a1"

URI_x86_64_v2_rust-schemars_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars_derive-devel-0.8.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars_derive-devel}"
SRC_URI[x86_64_v2_rust-schemars_derive-devel.sha256sum] = "544bd2c822338ec7d481d1837b1bed3158d9044fe7b77ed2646f8e32cd592e4d"

URI_aarch64_rust-schemars_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars_derive+default-devel-0.8.22-1.el10_0.noarch.rpm;name=aarch64_rust-schemars_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars_derive+default-devel}"
SRC_URI[aarch64_rust-schemars_derive+default-devel.sha256sum] = "a94c57c3d2855f818cf60a993f7d5674480395cc2a8f096e92d8947f90cf1755"

URI_aarch64_rust-schemars_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars_derive-devel-0.8.22-1.el10_0.noarch.rpm;name=aarch64_rust-schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars_derive-devel}"
SRC_URI[aarch64_rust-schemars_derive-devel.sha256sum] = "c6e69daf5b9be7e6ca5bab0f1d9db3e2f2d9e8d1a3a45837d157f330700e75d7"

RDEPENDS:rust-schemars_derive+default-devel = " \
 cargo \
 rust-schemars_derive-devel \
 "
RDEPENDS:rust-schemars_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-serde_derive_internals+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 "
