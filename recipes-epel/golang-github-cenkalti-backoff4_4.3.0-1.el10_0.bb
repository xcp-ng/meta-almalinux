# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-cenkalti-backoff4"
PV = "4.3.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-cenkalti-backoff4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-cenkalti-backoff4-4.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e579cd2756dde8f9828f2e11f53a9dc1198a45e200aa4e85ae446c134d7f7ed9"

URI_x86_64_v2_golang-github-cenkalti-backoff4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-cenkalti-backoff4-devel-4.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-cenkalti-backoff4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-cenkalti-backoff4-devel}"
SRC_URI[x86_64_v2_golang-github-cenkalti-backoff4-devel.sha256sum] = "564d509f3114395cf78016997caa1cdb4f471e66d547d578dda1451037f6d56b"

URI_aarch64_golang-github-cenkalti-backoff4-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-cenkalti-backoff4-devel-4.3.0-1.el10_0.noarch.rpm;name=aarch64_golang-github-cenkalti-backoff4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-cenkalti-backoff4-devel}"
SRC_URI[aarch64_golang-github-cenkalti-backoff4-devel.sha256sum] = "38cf94358aa082dae014a8ffda8640e7f31b6678d8cd5f56d9b136cfad3b3ea2"

RDEPENDS:golang-github-cenkalti-backoff4-devel = " \
 go-filesystem \
 "
