# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-metadata"
PV = "0.2.5"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-metadata \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-metadata-0.2.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "516869e001db9485f348a7a5743e0ff59074103e3e90882b884fa761fadf281f"

URI_x86_64_v2_python3-colcon-metadata = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-metadata-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-metadata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-metadata}"
SRC_URI[x86_64_v2_python3-colcon-metadata.sha256sum] = "0ea27f1f93a9a5f40a562a97b84140c1a802719aeaf0c9e98540ab106d4c60fb"

URI_aarch64_python3-colcon-metadata = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-metadata-0.2.5-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-metadata;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-metadata}"
SRC_URI[aarch64_python3-colcon-metadata.sha256sum] = "9e4c9834a6287748eca45f52d3a439f682a5dffa54cbe6975b10a7e83e4885cc"

RDEPENDS:python3-colcon-metadata = " \
 python3 \
 python3-colcon-core \
 python3-pyyaml \
 "
