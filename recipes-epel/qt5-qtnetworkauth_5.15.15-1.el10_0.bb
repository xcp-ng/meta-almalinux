# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtnetworkauth"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtnetworkauth \
 qt5-qtnetworkauth-devel \
 qt5-qtnetworkauth-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtnetworkauth-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8dd3c6877b04a3b2d373a35e5c1a22e9bc9930c87f8bab034ae10e2b958f198"

URI_x86_64_v2_qt5-qtnetworkauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtnetworkauth-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtnetworkauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtnetworkauth}"
SRC_URI[x86_64_v2_qt5-qtnetworkauth.sha256sum] = "f3f677570df582f1dd952f8e4350c1ac2bcf0e6aa52165996bca9a39e8f0d97c"

URI_x86_64_v2_qt5-qtnetworkauth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtnetworkauth-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtnetworkauth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtnetworkauth-devel}"
SRC_URI[x86_64_v2_qt5-qtnetworkauth-devel.sha256sum] = "dcf4a6ac3bbe6fce3b75890dc317371d8934af08f82eb09f92f215c7b640d792"

URI_x86_64_v2_qt5-qtnetworkauth-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtnetworkauth-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtnetworkauth-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtnetworkauth-examples}"
SRC_URI[x86_64_v2_qt5-qtnetworkauth-examples.sha256sum] = "904c1d93e39fd9a08d7a431db1638045b549a74caec2fd19910a966c67077eae"

URI_aarch64_qt5-qtnetworkauth = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtnetworkauth-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtnetworkauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtnetworkauth}"
SRC_URI[aarch64_qt5-qtnetworkauth.sha256sum] = "d089d4c36706182f3a675a5d13560941904bde1733fa6c31485f22a2a33f4bf4"

URI_aarch64_qt5-qtnetworkauth-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtnetworkauth-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtnetworkauth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtnetworkauth-devel}"
SRC_URI[aarch64_qt5-qtnetworkauth-devel.sha256sum] = "2f915d5da00cb4761c81eceacc65759c69b73fb31cbaff372bc4faa51eedbd8a"

URI_aarch64_qt5-qtnetworkauth-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtnetworkauth-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtnetworkauth-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtnetworkauth-examples}"
SRC_URI[aarch64_qt5-qtnetworkauth-examples.sha256sum] = "eaad4c32b3e2fbec6bc2f3f066554476eeddb14840e397d2bda491819db2a4eb"

RDEPENDS:qt5-qtnetworkauth = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtnetworkauth-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtnetworkauth \
 "
RDEPENDS:qt5-qtnetworkauth-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtnetworkauth \
 "
