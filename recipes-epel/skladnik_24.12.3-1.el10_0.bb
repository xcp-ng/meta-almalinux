# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skladnik"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 skladnik \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/skladnik-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69e8c75423dc48127273c3f41c6984d1053a8504ad5bfffcd32baa4e4b97bef3"

URI_x86_64_v2_skladnik = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/skladnik-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_skladnik;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skladnik}"
SRC_URI[x86_64_v2_skladnik.sha256sum] = "038216039ab443f0a13180fe21a62a229e779921b5e6cdadbeee9c6fc07969a2"

URI_aarch64_skladnik = "${EPEL_MIRROR}/aarch64/Packages/s/skladnik-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_skladnik;unpack=0"
SRC_URI:append = " ${URI_aarch64_skladnik}"
SRC_URI[aarch64_skladnik.sha256sum] = "8f94e1bc3fa493c8c0e377b6ab04bbba6d04409e5622e8ab7cde6afd80e926ec"

RDEPENDS:skladnik = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
