# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gass-transfer"
PV = "9.5"
PR = "1.el10_2"
PACKAGES = " \
 globus-gass-transfer \
 globus-gass-transfer-devel \
 globus-gass-transfer-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gass-transfer-9.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e23a4b056fb764a837d3653deb62ab31d689e6f2e1cc656db28858bb05747f5c"

URI_x86_64_v2_globus-gass-transfer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-transfer-9.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gass-transfer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-transfer}"
SRC_URI[x86_64_v2_globus-gass-transfer.sha256sum] = "5b5b4fc46d597e53ca992b091098d29a5e0f2033d089982f2952009bd9024d50"

URI_x86_64_v2_globus-gass-transfer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-transfer-devel-9.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gass-transfer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-transfer-devel}"
SRC_URI[x86_64_v2_globus-gass-transfer-devel.sha256sum] = "48ed331a1ba412453696620b4d44e1b7b9a67b31a301c76c7f301332e839443b"

URI_x86_64_v2_globus-gass-transfer-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-transfer-doc-9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gass-transfer-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-transfer-doc}"
SRC_URI[x86_64_v2_globus-gass-transfer-doc.sha256sum] = "f3c606009aeee5c77b3efe2035a67331190e968662d0c9f22540e1cdb0eae92d"

URI_aarch64_globus-gass-transfer = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-transfer-9.5-1.el10_2.aarch64.rpm;name=aarch64_globus-gass-transfer;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-transfer}"
SRC_URI[aarch64_globus-gass-transfer.sha256sum] = "5aca8fd94447e2bae1b5cf5c49a1055e517e401989aacde7d0efbe9179f46223"

URI_aarch64_globus-gass-transfer-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-transfer-devel-9.5-1.el10_2.aarch64.rpm;name=aarch64_globus-gass-transfer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-transfer-devel}"
SRC_URI[aarch64_globus-gass-transfer-devel.sha256sum] = "3255d913c4c7df07f7efd4c9793918dfcc3563bec16dc1554b164ba9cdfdd14d"

URI_aarch64_globus-gass-transfer-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-transfer-doc-9.5-1.el10_2.noarch.rpm;name=aarch64_globus-gass-transfer-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-transfer-doc}"
SRC_URI[aarch64_globus-gass-transfer-doc.sha256sum] = "2a9613dd01b82faac25101407cc3edb7d86e0ff920cc55bac9a9c35acd68c02d"

RDEPENDS:globus-gass-transfer = " \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-io \
 "
RDEPENDS:globus-gass-transfer-devel = " \
 globus-common-devel \
 globus-gass-transfer \
 globus-gss-assist-devel \
 globus-gssapi-gsi-devel \
 globus-io-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gass-transfer-doc = " \
 "
