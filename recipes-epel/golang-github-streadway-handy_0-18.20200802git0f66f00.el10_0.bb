# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-streadway-handy"
PV = "0"
PR = "18.20200802git0f66f00.el10_0"
PACKAGES = " \
 golang-github-streadway-handy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-streadway-handy-0-18.20200802git0f66f00.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22d36868ff15db6bc6d8f1f23e85723c06352c56b1c3a3a63b4b867be19c2ce0"

URI_aarch64_golang-github-streadway-handy-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-streadway-handy-devel-0-18.20200802git0f66f00.el10_0.noarch.rpm;name=aarch64_golang-github-streadway-handy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-streadway-handy-devel}"
SRC_URI[aarch64_golang-github-streadway-handy-devel.sha256sum] = "231460876a512290aacdd369eeb1ac865296eaf6ca9b04e9678f0b775b868332"

RDEPENDS:golang-github-streadway-handy-devel = " \
 go-filesystem \
 "
