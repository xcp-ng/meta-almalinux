# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num_cpus"
PV = "1.17.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-num_cpus+default-devel \
 rust-num_cpus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num_cpus-1.17.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed2c38c53ac2763c78883de5fc05d0721088d0a092ca1669d6ff08f6b99ece84"

URI_x86_64_v2_rust-num_cpus+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_cpus+default-devel-1.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_cpus+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_cpus+default-devel}"
SRC_URI[x86_64_v2_rust-num_cpus+default-devel.sha256sum] = "e7792e5d47948a074bd7fc6e97148c69900b79e35e8fc6d7c54e199b7cb9b907"

URI_x86_64_v2_rust-num_cpus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_cpus-devel-1.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_cpus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_cpus-devel}"
SRC_URI[x86_64_v2_rust-num_cpus-devel.sha256sum] = "fe852df5ffe4d66e50c98c405ee5cff619f960d0b5b8d200e56addf983d4de4c"

URI_aarch64_rust-num_cpus+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_cpus+default-devel-1.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-num_cpus+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_cpus+default-devel}"
SRC_URI[aarch64_rust-num_cpus+default-devel.sha256sum] = "cb5bffaa2a6b47efc006ef1b39c1c656d1e56181c6d85ed0144ed6ff2ace8b74"

URI_aarch64_rust-num_cpus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_cpus-devel-1.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-num_cpus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_cpus-devel}"
SRC_URI[aarch64_rust-num_cpus-devel.sha256sum] = "b4af4dc4e0362435e0d5c434a63f56be085b79149bc4d9c507ab15b9f2323e7c"

RDEPENDS:rust-num_cpus+default-devel = " \
 cargo \
 rust-num_cpus-devel \
 "
RDEPENDS:rust-num_cpus-devel = " \
 cargo \
 rust-libc+default-devel \
 "
