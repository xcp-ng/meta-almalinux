# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gn"
PV = "2509^20260808.64cfb8344ec3"
PR = "1.el10_2"
PACKAGES = " \
 gn \
 gn-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gn-2509^20260808.64cfb8344ec3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dba35631f5caeea2a00d1371da7686cc8fa0901032fb2d86c416709f2fd24ba9"

URI_x86_64_v2_gn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gn-2509^20260808.64cfb8344ec3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gn}"
SRC_URI[x86_64_v2_gn.sha256sum] = "2eba2f380e60042e3a68d5e5e324464171590f3389291a1032a19b64eb9e240f"

URI_x86_64_v2_gn-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gn-doc-2509^20260808.64cfb8344ec3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gn-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gn-doc}"
SRC_URI[x86_64_v2_gn-doc.sha256sum] = "19cc1fbe8160f6965cd3deb358346a0c3821881c475a02746df1261e59262df7"

URI_aarch64_gn = "${EPEL_MIRROR}/aarch64/Packages/g/gn-2509^20260808.64cfb8344ec3-1.el10_2.aarch64.rpm;name=aarch64_gn;unpack=0"
SRC_URI:append = " ${URI_aarch64_gn}"
SRC_URI[aarch64_gn.sha256sum] = "c6b971d4ff6cea87f6c4c96c268d89735690f4246fbcd58f912a9d1e63ccff97"

URI_aarch64_gn-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gn-doc-2509^20260808.64cfb8344ec3-1.el10_2.noarch.rpm;name=aarch64_gn-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gn-doc}"
SRC_URI[aarch64_gn-doc.sha256sum] = "d8a9aae1ad384f87eeb2b06c7dc1c5589971dc4411532e6c365a65152567b629"

RDEPENDS:gn = " \
 emacs-filesystem \
 glibc \
 libstdc++ \
 python3 \
 vim-filesystem \
 "
RDEPENDS:gn-doc = " \
 "
