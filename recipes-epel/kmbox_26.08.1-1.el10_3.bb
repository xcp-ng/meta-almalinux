# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmbox"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kmbox \
 kmbox-devel \
 kmbox-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmbox-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c946cb3ea2597cfe65926d592f85539b4ce9308cde41fcbfaa16d9ce25c8e57d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmbox;unpack=0"
SRC_URI[x86_64_v2_kmbox.sha256sum] = "8e50751bb20d332975bfc04c768220cf128a068deb4bfadfcf080f710336797b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmbox-devel;unpack=0"
SRC_URI[x86_64_v2_kmbox-devel.sha256sum] = "8562d2ef5fec2acaad32b65e390441e9dbb5ecb3d43f346fca1c7ba2e1b3de1e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kmbox-doc;unpack=0"
SRC_URI[x86_64_v2_kmbox-doc.sha256sum] = "8de3db450645c10385b709ebee171510f3ae6051db35436efcb14d4ea8784c0d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmbox-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kmbox;unpack=0"
SRC_URI[aarch64_kmbox.sha256sum] = "100cd51d66d9c364487829d5633b2933d3e76bc17e1e65f1a98aaabcbdda2b54"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmbox-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kmbox-devel;unpack=0"
SRC_URI[aarch64_kmbox-devel.sha256sum] = "3540c01490434d34970401f668094c54e6f232af95f49a1db2928c8fb624872d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmbox-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kmbox-doc;unpack=0"
SRC_URI[aarch64_kmbox-doc.sha256sum] = "bf42bdc67bba87deb81bf907c1907a2a00e821c618197e470e2c56aa6ecb0fe4"

RDEPENDS:kmbox = " \
 glibc \
 kf6-kmime \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kmbox-devel = " \
 cmake-filesystem \
 kf6-kmime-devel \
 kmbox \
 "
RDEPENDS:kmbox-doc = " \
 "
