# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtserialport"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtserialport \
 qt6-qtserialport-devel \
 qt6-qtserialport-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtserialport-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e206e4877be6585691608c04b2d10dd27d0abb96f2bf713521ff8582db1a4072"

URI_x86_64_v2_qt6-qtserialport = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtserialport-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialport}"
SRC_URI[x86_64_v2_qt6-qtserialport.sha256sum] = "ed986cb3b701a8a33c23a752cad60aa68216434913bd59f1cdb70ab5d5130db8"

URI_x86_64_v2_qt6-qtserialport-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtserialport-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialport-devel}"
SRC_URI[x86_64_v2_qt6-qtserialport-devel.sha256sum] = "bdd11dbc4da52c7bff1a17582c35878064a81195f050f127f425f0d615418b4c"

URI_x86_64_v2_qt6-qtserialport-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtserialport-examples-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialport-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialport-examples}"
SRC_URI[x86_64_v2_qt6-qtserialport-examples.sha256sum] = "88077907e5f01ccbab6a565ac7a4d3295648a9fdb049fee024e5aa05c744a16a"

URI_aarch64_qt6-qtserialport = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtserialport-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtserialport;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialport}"
SRC_URI[aarch64_qt6-qtserialport.sha256sum] = "290b3bc19bcb8e409b00abd908933eb1034e62effcb452c2031b9bbb79dbfb30"

URI_aarch64_qt6-qtserialport-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtserialport-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtserialport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialport-devel}"
SRC_URI[aarch64_qt6-qtserialport-devel.sha256sum] = "2e96884981c182e2d841d31cb7a37af42113114e4c883ac2728c5ac7dfce9ac0"

URI_aarch64_qt6-qtserialport-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtserialport-examples-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtserialport-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialport-examples}"
SRC_URI[aarch64_qt6-qtserialport-examples.sha256sum] = "84989367a547dd520a16c1f90b36ccd3484556ddc814cc1e64767367c206bcd7"

RDEPENDS:qt6-qtserialport = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 systemd-libs \
 "
RDEPENDS:qt6-qtserialport-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtserialport \
 "
RDEPENDS:qt6-qtserialport-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtserialport \
 "
