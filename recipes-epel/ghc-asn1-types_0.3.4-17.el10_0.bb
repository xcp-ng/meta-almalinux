# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-asn1-types"
PV = "0.3.4"
PR = "17.el10_0"
PACKAGES = " \
 ghc-asn1-types \
 ghc-asn1-types-devel \
 ghc-asn1-types-doc \
 ghc-asn1-types-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-asn1-types-0.3.4-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dda106f7c4eb7230a7073d77a4ce3895d07aa01d3edfd98f5041fc91fe4afdf4"

URI_x86_64_v2_ghc-asn1-types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-asn1-types-0.3.4-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-asn1-types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-asn1-types}"
SRC_URI[x86_64_v2_ghc-asn1-types.sha256sum] = "b40101f1bee1294b341061a80836d0bcbe6d1f031c42f714c93589f660f8a36f"

URI_x86_64_v2_ghc-asn1-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-asn1-types-devel-0.3.4-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-asn1-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-asn1-types-devel}"
SRC_URI[x86_64_v2_ghc-asn1-types-devel.sha256sum] = "f82d44578a128cfe21c183ad99792f4f42eb3a0746d51fd395fcc8766a59e215"

URI_x86_64_v2_ghc-asn1-types-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-asn1-types-doc-0.3.4-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-asn1-types-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-asn1-types-doc}"
SRC_URI[x86_64_v2_ghc-asn1-types-doc.sha256sum] = "9f94a95164e7eb2b6c6601e34146614f852e1116a6d17418f9faf63720d4ff0c"

URI_x86_64_v2_ghc-asn1-types-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-asn1-types-prof-0.3.4-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-asn1-types-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-asn1-types-prof}"
SRC_URI[x86_64_v2_ghc-asn1-types-prof.sha256sum] = "c2053db687cd9621ae43c316e9285d2f48d3305f213da35aee2c37c70a45f21d"

URI_aarch64_ghc-asn1-types = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-asn1-types-0.3.4-17.el10_0.aarch64.rpm;name=aarch64_ghc-asn1-types;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-asn1-types}"
SRC_URI[aarch64_ghc-asn1-types.sha256sum] = "4b0a53f9d0bda57b0ff6edec8041202e228a82d3b8468108e79d1b74b8541c63"

URI_aarch64_ghc-asn1-types-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-asn1-types-devel-0.3.4-17.el10_0.aarch64.rpm;name=aarch64_ghc-asn1-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-asn1-types-devel}"
SRC_URI[aarch64_ghc-asn1-types-devel.sha256sum] = "c1ffe873fb7d693b44b4875581126d3f7438655616e7d25a8888081843492063"

URI_aarch64_ghc-asn1-types-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-asn1-types-doc-0.3.4-17.el10_0.noarch.rpm;name=aarch64_ghc-asn1-types-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-asn1-types-doc}"
SRC_URI[aarch64_ghc-asn1-types-doc.sha256sum] = "d0d35c89f95784a597dce8f00071d7303c0731e9905c2ac47dbd01c1c9ba9e64"

URI_aarch64_ghc-asn1-types-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-asn1-types-prof-0.3.4-17.el10_0.aarch64.rpm;name=aarch64_ghc-asn1-types-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-asn1-types-prof}"
SRC_URI[aarch64_ghc-asn1-types-prof.sha256sum] = "052389dda74dbaa4da73098378badd2a30dd006202e33946ea88ab41e7220ada"

RDEPENDS:ghc-asn1-types = " \
 ghc-array \
 ghc-base \
 ghc-basement \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hourglass \
 ghc-memory \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-asn1-types-devel = " \
 ghc-asn1-types \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-hourglass-devel \
 ghc-memory-devel \
 "
RDEPENDS:ghc-asn1-types-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-asn1-types-prof = " \
 ghc-asn1-types-devel \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-hourglass-prof \
 ghc-memory-prof \
 "
