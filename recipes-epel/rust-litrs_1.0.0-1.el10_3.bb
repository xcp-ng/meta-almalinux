# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-litrs"
PV = "1.0.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-litrs+check_suffix-devel \
 rust-litrs+default-devel \
 rust-litrs+proc-macro2-devel \
 rust-litrs+unicode-xid-devel \
 rust-litrs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-litrs-1.0.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f48dc7d666cb74f513d384168a943981747e132d833277859c5b97a4e8b9caf1"

URI_x86_64_v2_rust-litrs+check_suffix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs+check_suffix-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs+check_suffix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs+check_suffix-devel}"
SRC_URI[x86_64_v2_rust-litrs+check_suffix-devel.sha256sum] = "603479354806fbca883039956f8c193cbfd358a4fd2c979a986cfd1394a53940"

URI_x86_64_v2_rust-litrs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs+default-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs+default-devel}"
SRC_URI[x86_64_v2_rust-litrs+default-devel.sha256sum] = "c6ba3680086520800c7330e765804650cc331f58c9b964558b47351564027a6e"

URI_x86_64_v2_rust-litrs+proc-macro2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs+proc-macro2-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs+proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs+proc-macro2-devel}"
SRC_URI[x86_64_v2_rust-litrs+proc-macro2-devel.sha256sum] = "1d5a5b2d65cca84b0fc5532ad8d858da9fbf2e947c779fa6505f4b135be609ee"

URI_x86_64_v2_rust-litrs+unicode-xid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs+unicode-xid-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs+unicode-xid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs+unicode-xid-devel}"
SRC_URI[x86_64_v2_rust-litrs+unicode-xid-devel.sha256sum] = "ed2dad2577a26cbb2ebd7a9bf06a06349e5de1234e2d52ceb87766336cef8971"

URI_x86_64_v2_rust-litrs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs-devel}"
SRC_URI[x86_64_v2_rust-litrs-devel.sha256sum] = "298898e0c1417fd6a5955e2f10d8a545a70d4fc4394d44a7479bbfe9cedbc24d"

URI_aarch64_rust-litrs+check_suffix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs+check_suffix-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-litrs+check_suffix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs+check_suffix-devel}"
SRC_URI[aarch64_rust-litrs+check_suffix-devel.sha256sum] = "7fcb3d208450ecad2df3e9f1b52481ad7f69ab1b00738b9f9f851fe75271c379"

URI_aarch64_rust-litrs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs+default-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-litrs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs+default-devel}"
SRC_URI[aarch64_rust-litrs+default-devel.sha256sum] = "06b94dc09292d3dd203dc7356f0d3b5591d57eae57306ef8e73da61c51ad4518"

URI_aarch64_rust-litrs+proc-macro2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs+proc-macro2-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-litrs+proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs+proc-macro2-devel}"
SRC_URI[aarch64_rust-litrs+proc-macro2-devel.sha256sum] = "787bbb4b2a2aa6bf76d5db0f7e482a5d8ed0e2278ed9be5532704dd1ff61b613"

URI_aarch64_rust-litrs+unicode-xid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs+unicode-xid-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-litrs+unicode-xid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs+unicode-xid-devel}"
SRC_URI[aarch64_rust-litrs+unicode-xid-devel.sha256sum] = "d6bb825216cfbf069f41a25524734c762b6c2da0f96cbf521c20f5e1a1702c90"

URI_aarch64_rust-litrs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-litrs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs-devel}"
SRC_URI[aarch64_rust-litrs-devel.sha256sum] = "4100b17afdd93d2990cced239eef29ab43331fea2a9e640da56418e633755aa4"

RDEPENDS:rust-litrs+check_suffix-devel = " \
 cargo \
 rust-litrs+unicode-xid-devel \
 rust-litrs-devel \
 "
RDEPENDS:rust-litrs+default-devel = " \
 cargo \
 rust-litrs-devel \
 "
RDEPENDS:rust-litrs+proc-macro2-devel = " \
 cargo \
 rust-litrs-devel \
 rust-proc-macro2+default-devel \
 "
RDEPENDS:rust-litrs+unicode-xid-devel = " \
 cargo \
 rust-litrs-devel \
 rust-unicode-xid+default-devel \
 "
RDEPENDS:rust-litrs-devel = " \
 cargo \
 rust \
 "
