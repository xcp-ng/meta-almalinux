# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-jmespath"
PV = "0.4.0"
PR = "14.el10_0"
PACKAGES = " \
 golang-github-jmespath \
 golang-github-jmespath-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-jmespath-0.4.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f791ad8b0d52fc191c77231db7f512e3faa58f7633a65a8e038b6122fb8b8cb"

URI_x86_64_v2_golang-github-jmespath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-jmespath-0.4.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-jmespath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-jmespath}"
SRC_URI[x86_64_v2_golang-github-jmespath.sha256sum] = "8e331e08cfe017f58b9d6248ad75ac2bb6c84207004620b4223d9b8c904a8ef4"

URI_x86_64_v2_golang-github-jmespath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-jmespath-devel-0.4.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-jmespath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-jmespath-devel}"
SRC_URI[x86_64_v2_golang-github-jmespath-devel.sha256sum] = "efd308f7e2c9d175c6fb875eae9e8cd1abd86a5f5e7770bfeb2a57857a4c1f08"

URI_aarch64_golang-github-jmespath = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jmespath-0.4.0-14.el10_0.aarch64.rpm;name=aarch64_golang-github-jmespath;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-jmespath}"
SRC_URI[aarch64_golang-github-jmespath.sha256sum] = "adc0b450359ff6ec90be283cc144a063f6df61a93ce8f60e537621f795bdd2d2"

URI_aarch64_golang-github-jmespath-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jmespath-devel-0.4.0-14.el10_0.noarch.rpm;name=aarch64_golang-github-jmespath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-jmespath-devel}"
SRC_URI[aarch64_golang-github-jmespath-devel.sha256sum] = "be538a54a6c6a095353e0998cfd4252a59f53e0b63b1d2f190ac1da3f68e21b3"

RDEPENDS:golang-github-jmespath = " \
 glibc \
 "
RDEPENDS:golang-github-jmespath-devel = " \
 go-filesystem \
 golang-github-davecgh-spew-devel \
 golang-github-pmezard-difflib-devel \
 golang-github-stretchr-objx-devel \
 golang-gopkg-yaml-2-devel \
 "
