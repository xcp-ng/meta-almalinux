# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "createrepo-agent"
PV = "0.6.0"
PR = "1.el10_3"
PACKAGES = " \
 createrepo-agent \
 python3-createrepo-agent \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/createrepo-agent-0.6.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4908ee65f17ecfb9be2fe0770279c59179208917a6448451406a53d87558da7b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/createrepo-agent-0.6.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_createrepo-agent;unpack=0"
SRC_URI[x86_64_v2_createrepo-agent.sha256sum] = "dff293dd17cfaf497c3e46941e5212ca968a2b4f9d16ec05fda2a6ff67d28dab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-createrepo-agent-0.6.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-createrepo-agent;unpack=0"
SRC_URI[x86_64_v2_python3-createrepo-agent.sha256sum] = "bc68284674c93472f65f6dd125f962d13588ab2ca41312dda985be89216e986b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/createrepo-agent-0.6.0-1.el10_3.aarch64.rpm;name=aarch64_createrepo-agent;unpack=0"
SRC_URI[aarch64_createrepo-agent.sha256sum] = "57ef98e4ce370fdd70698b3f0ec3eb080a313f2b13b1c4e9606d85c349349ed2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-createrepo-agent-0.6.0-1.el10_3.aarch64.rpm;name=aarch64_python3-createrepo-agent;unpack=0"
SRC_URI[aarch64_python3-createrepo-agent.sha256sum] = "01fc976a9fc521563b8c019ca239ad2de0fd6868c2edd7a13635540822f3e5de"

RDEPENDS:createrepo-agent = " \
 createrepo_c-libs \
 glib2 \
 glibc \
 gpgme2 \
 libassuan \
 libgpg-error \
 "
RDEPENDS:python3-createrepo-agent = " \
 createrepo-agent \
 createrepo_c-libs \
 glib2 \
 glibc \
 gpgme2 \
 libassuan \
 libgpg-error \
 python3 \
 "
