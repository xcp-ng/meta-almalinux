# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mysql-mmm"
PV = "2.2.1"
PR = "39.el10_1"
PACKAGES = " \
 mysql-mmm \
 mysql-mmm-agent \
 mysql-mmm-monitor \
 mysql-mmm-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mysql-mmm-2.2.1-39.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef286006295d3296522aede1bdde285b3fbe8051bc3f01790e9e0db57a08652f"

URI_x86_64_v2_mysql-mmm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mysql-mmm-2.2.1-39.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mysql-mmm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql-mmm}"
SRC_URI[x86_64_v2_mysql-mmm.sha256sum] = "5fe688ce60be0be968e305a3948809d267c47b74c3be27caa2b25e15a3987d9f"

URI_x86_64_v2_mysql-mmm-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mysql-mmm-agent-2.2.1-39.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mysql-mmm-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql-mmm-agent}"
SRC_URI[x86_64_v2_mysql-mmm-agent.sha256sum] = "212813be5e02a2b280fb821d5027a24dfc5ecc330e4f501742f0e082122b1081"

URI_x86_64_v2_mysql-mmm-monitor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mysql-mmm-monitor-2.2.1-39.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mysql-mmm-monitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql-mmm-monitor}"
SRC_URI[x86_64_v2_mysql-mmm-monitor.sha256sum] = "abae38653ab0c7f548345c46cb546ca48e34e5dae391a4b5b0af40728c7055bb"

URI_x86_64_v2_mysql-mmm-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mysql-mmm-tools-2.2.1-39.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mysql-mmm-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql-mmm-tools}"
SRC_URI[x86_64_v2_mysql-mmm-tools.sha256sum] = "1621de2762961008f91c027d9b298738ac6b7f09aa7ba386a7884092e6e0275e"

URI_aarch64_mysql-mmm = "${EPEL_MIRROR}/aarch64/Packages/m/mysql-mmm-2.2.1-39.el10_1.noarch.rpm;name=aarch64_mysql-mmm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql-mmm}"
SRC_URI[aarch64_mysql-mmm.sha256sum] = "41218051fe6d99d1e52bbbf3bf3cfd62c302177a6da4f3141ad7972235baf86b"

URI_aarch64_mysql-mmm-agent = "${EPEL_MIRROR}/aarch64/Packages/m/mysql-mmm-agent-2.2.1-39.el10_1.noarch.rpm;name=aarch64_mysql-mmm-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql-mmm-agent}"
SRC_URI[aarch64_mysql-mmm-agent.sha256sum] = "d81f91e0959281e2d3babff7de1f2bd619e2becddfbaf861a0a3102d57a13427"

URI_aarch64_mysql-mmm-monitor = "${EPEL_MIRROR}/aarch64/Packages/m/mysql-mmm-monitor-2.2.1-39.el10_1.noarch.rpm;name=aarch64_mysql-mmm-monitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql-mmm-monitor}"
SRC_URI[aarch64_mysql-mmm-monitor.sha256sum] = "76af98ca321203a807cbbc227b4d5aeb9cce18f03c57d8d2460c4cbdcfec3abf"

URI_aarch64_mysql-mmm-tools = "${EPEL_MIRROR}/aarch64/Packages/m/mysql-mmm-tools-2.2.1-39.el10_1.noarch.rpm;name=aarch64_mysql-mmm-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql-mmm-tools}"
SRC_URI[aarch64_mysql-mmm-tools.sha256sum] = "89dc77c9fb8252d722887aed4d1958fd2dec6d2b943168826d2ea45a682c5983"

RDEPENDS:mysql-mmm = " \
 perl-Class-Struct \
 perl-English \
 perl-Errno \
 perl-Exporter \
 perl-File-stat \
 perl-IO \
 perl-Log-Log4perl \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:mysql-mmm-agent = " \
 bash \
 iproute \
 mysql-mmm \
 mysql-mmm-agent \
 perl-Algorithm-Diff \
 perl-Class-Struct \
 perl-DBD-MySQL \
 perl-DBI \
 perl-English \
 perl-Errno \
 perl-File-Basename \
 perl-Log-Log4perl \
 perl-Net-ARP \
 perl-Proc-Daemon \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 systemd \
 "
RDEPENDS:mysql-mmm-monitor = " \
 bash \
 mysql-mmm \
 mysql-mmm-monitor \
 perl-Algorithm-Diff \
 perl-Class-Singleton \
 perl-Class-Struct \
 perl-DBD-MySQL \
 perl-DBI \
 perl-Data-Dumper \
 perl-English \
 perl-Errno \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Temp \
 perl-IO \
 perl-IPC-Open3 \
 perl-Log-Log4perl \
 perl-Net-Ping \
 perl-POSIX \
 perl-Proc-Daemon \
 perl-Scalar-List-Utils \
 perl-Thread-Queue \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 systemd \
 "
RDEPENDS:mysql-mmm-tools = " \
 mysql-mmm \
 mysql-mmm-tools \
 perl-DBI \
 perl-Data-Dumper \
 perl-English \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-Log-Log4perl \
 perl-Path-Class \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
