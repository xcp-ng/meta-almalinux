# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cool_asserts"
PV = "2.0.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-cool_asserts+default-devel \
 rust-cool_asserts-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cool_asserts-2.0.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "653bef8ad0f00e665e474741d692ace3dc4fce450f33d14ede3a082a5a5ed76b"

URI_x86_64_v2_rust-cool_asserts+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cool_asserts+default-devel-2.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cool_asserts+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cool_asserts+default-devel}"
SRC_URI[x86_64_v2_rust-cool_asserts+default-devel.sha256sum] = "7f93df9222f60fd610517a10923840863d4e4cd79a791f5cdc17f7ccecc70664"

URI_x86_64_v2_rust-cool_asserts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cool_asserts-devel-2.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cool_asserts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cool_asserts-devel}"
SRC_URI[x86_64_v2_rust-cool_asserts-devel.sha256sum] = "ce8cc0f6a58756eee77ac2d3ca6e4ff764868acc8e608340932315a0ccf50736"

URI_aarch64_rust-cool_asserts+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cool_asserts+default-devel-2.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-cool_asserts+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cool_asserts+default-devel}"
SRC_URI[aarch64_rust-cool_asserts+default-devel.sha256sum] = "fdeb8063fa160ebf56262276e33f4250c3721365852db0d99bb165bc9200b4c4"

URI_aarch64_rust-cool_asserts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cool_asserts-devel-2.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-cool_asserts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cool_asserts-devel}"
SRC_URI[aarch64_rust-cool_asserts-devel.sha256sum] = "6812f6f8137848d757f7016c621f14e9feb520a5e4d0578e2b87415c48307d24"

RDEPENDS:rust-cool_asserts+default-devel = " \
 cargo \
 rust-cool_asserts-devel \
 "
RDEPENDS:rust-cool_asserts-devel = " \
 cargo \
 rust-indent_write-devel \
 "
