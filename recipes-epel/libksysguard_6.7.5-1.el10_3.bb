# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksysguard"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 libksysguard \
 libksysguard-common \
 libksysguard-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libksysguard-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fc1fdfb05b57edced84cd45b372eec153b5534050c0fe363f51abe06f84efa50"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard;unpack=0"
SRC_URI[x86_64_v2_libksysguard.sha256sum] = "e410fdb3aad567e6b485ed786d8a8d309fb5a5f95d0f4acecd9918e2ba28f83f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-common-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard-common;unpack=0"
SRC_URI[x86_64_v2_libksysguard-common.sha256sum] = "deb09b9f6dd8e2366c19df42762543825b6d3924b51cfe4a0986d9ba6d9be6b8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard-devel;unpack=0"
SRC_URI[x86_64_v2_libksysguard-devel.sha256sum] = "a7e482231b5f5a89f4502c5e346c9b3f497491b3eb6446d4cef89e0b763e9b9d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_libksysguard;unpack=0"
SRC_URI[aarch64_libksysguard.sha256sum] = "e17fa3da3e540cbdb9f442ff6ed8a4e40dcf6cccd11dc7a825863093f7ee9b42"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-common-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_libksysguard-common;unpack=0"
SRC_URI[aarch64_libksysguard-common.sha256sum] = "4359084f5469c86e70922e092d74305d4690931fbc440f6aad8185108b0dc3dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_libksysguard-devel;unpack=0"
SRC_URI[aarch64_libksysguard-devel.sha256sum] = "5151e31a466c88978ec8f5afd5eabe6e6123a57039b613e2204d12e31318a5e7"

RDEPENDS:libksysguard = " \
 glibc \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kservice \
 kf6-solid \
 libdrm \
 libgcc \
 libksysguard-common \
 libnl3 \
 libpcap \
 libstdc++ \
 lm_sensors-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:libksysguard-common = " \
 glibc \
 kf6-kauth \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libksysguard-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-ki18n-devel \
 kf6-kiconthemes-devel \
 libksysguard \
 qt6-qtbase-devel \
 "
