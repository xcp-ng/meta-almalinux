# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalarm"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kalarm \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kalarm-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5c1d916755e4a32bc61b9e2ef0d66a6cfdcd0d611bb86b2a600c09d61ceb6ba7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalarm-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalarm;unpack=0"
SRC_URI[x86_64_v2_kalarm.sha256sum] = "0ea8754faaf78bfcb1e3de6f9b1303ebded12e97e39cae659d259b0346123b47"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kalarm-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kalarm;unpack=0"
SRC_URI[aarch64_kalarm.sha256sum] = "d690a0e21da90a4e745c9fd925b607c4d90e39fd6ae6938e0c1a283870ff8277"

RDEPENDS:kalarm = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 glibc \
 kcalutils \
 kf6-kauth \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kmime \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 libgcc \
 libstdc++ \
 mpv-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 vlc-libs \
 "
