# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gvfs"
PV = "1.54.4"
PR = "4.el10_2.1"
PACKAGES = " \
 gvfs \
 gvfs-client \
 gvfs-fuse \
 gvfs-goa \
 gvfs-gphoto2 \
 gvfs-mtp \
 gvfs-smb \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gvfs-1.54.4-4.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ead71cd7b8f7b854351ee3796fb2cffecba1e65fa60f6fadbfe5a4cb2b3c9449"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-1.54.4-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_gvfs;unpack=0"
SRC_URI[x86_64_v2_gvfs.sha256sum] = "2aec7f6288c4b0d1c46b20cbb318a4d03f7f8742264a3a9449e6282432d42a1c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-client-1.54.4-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_gvfs-client;unpack=0"
SRC_URI[x86_64_v2_gvfs-client.sha256sum] = "4f84961f68ba65c1291942c7fa07812ec49633ffff32a2fc589832a13fa35d41"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-fuse-1.54.4-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_gvfs-fuse;unpack=0"
SRC_URI[x86_64_v2_gvfs-fuse.sha256sum] = "38319b6b54ddb9b44218026e437269673da6d136ec3dff24f5960bf2b9fda272"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-goa-1.54.4-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_gvfs-goa;unpack=0"
SRC_URI[x86_64_v2_gvfs-goa.sha256sum] = "c41bde4c5b43895303f8fe798203ebb4bdcdf2758a0c7822fd6da7aaab71b8aa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-gphoto2-1.54.4-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_gvfs-gphoto2;unpack=0"
SRC_URI[x86_64_v2_gvfs-gphoto2.sha256sum] = "10caa8186accad1c40aa1c4d598612debd48ff537b3125c4bd05961a612d3717"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-mtp-1.54.4-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_gvfs-mtp;unpack=0"
SRC_URI[x86_64_v2_gvfs-mtp.sha256sum] = "b80c65af52be7e58e2cdfe374dfdf3c27247cfa28fa88498d15d5059ad0a7aa8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-smb-1.54.4-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_gvfs-smb;unpack=0"
SRC_URI[x86_64_v2_gvfs-smb.sha256sum] = "226f5a5d46cd79ad483ffe63a440492bd4b2dbcd91703ec7dee1df62ba489fc2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-1.54.4-4.el10_2.1.aarch64.rpm;name=aarch64_gvfs;unpack=0"
SRC_URI[aarch64_gvfs.sha256sum] = "2cff29f8902378fdf7427927dc0fc8695bd371858451da48ede962fe0ca00f06"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-client-1.54.4-4.el10_2.1.aarch64.rpm;name=aarch64_gvfs-client;unpack=0"
SRC_URI[aarch64_gvfs-client.sha256sum] = "29f50584004ddc0d57e396ca20a18c3ecd7c05b520f7a21cc1e94a52ecdff04f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-fuse-1.54.4-4.el10_2.1.aarch64.rpm;name=aarch64_gvfs-fuse;unpack=0"
SRC_URI[aarch64_gvfs-fuse.sha256sum] = "c5201ef6a43fae189a432b50507226ab190ab3996dabb3c1abefb1be298fe920"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-goa-1.54.4-4.el10_2.1.aarch64.rpm;name=aarch64_gvfs-goa;unpack=0"
SRC_URI[aarch64_gvfs-goa.sha256sum] = "a145be318c2cdd62f38a7a3517cd2ce05bf050713031ce39a05e9331ace2ffd5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-gphoto2-1.54.4-4.el10_2.1.aarch64.rpm;name=aarch64_gvfs-gphoto2;unpack=0"
SRC_URI[aarch64_gvfs-gphoto2.sha256sum] = "dc70d730b49332d090b8ccf681835b7ecc7e7041a1356bd328dee861d6580945"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-mtp-1.54.4-4.el10_2.1.aarch64.rpm;name=aarch64_gvfs-mtp;unpack=0"
SRC_URI[aarch64_gvfs-mtp.sha256sum] = "25f083d00c48be4dd5444af45bb40d2df701b9531c0fc577b82f9992393805f5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-smb-1.54.4-4.el10_2.1.aarch64.rpm;name=aarch64_gvfs-smb;unpack=0"
SRC_URI[aarch64_gvfs-smb.sha256sum] = "ae50f0f79c44feca31d089cb9da77f50e74d78306eba5a420bf96720a3518967"

RDEPENDS:gvfs = " \
 avahi-glib \
 avahi-libs \
 bash \
 gcr-libs \
 glib2 \
 glibc \
 gsettings-desktop-schemas \
 gvfs-client \
 libgcc \
 libgudev \
 libsecret \
 libsoup3 \
 libudisks2 \
 libxml2 \
 polkit \
 polkit-libs \
 systemd-libs \
 udisks2 \
 wsdd \
 "
RDEPENDS:gvfs-client = " \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:gvfs-fuse = " \
 fuse3 \
 fuse3-libs \
 glib2 \
 glibc \
 gvfs \
 gvfs-client \
 "
RDEPENDS:gvfs-goa = " \
 bash \
 glib2 \
 glibc \
 gnome-online-accounts \
 gvfs \
 gvfs-client \
 "
RDEPENDS:gvfs-gphoto2 = " \
 bash \
 glib2 \
 glibc \
 gvfs \
 gvfs-client \
 libgphoto2 \
 libgudev \
 "
RDEPENDS:gvfs-mtp = " \
 bash \
 glib2 \
 glibc \
 gvfs \
 gvfs-client \
 libgudev \
 libmtp \
 libusb1 \
 "
RDEPENDS:gvfs-smb = " \
 bash \
 glib2 \
 glibc \
 gvfs \
 gvfs-client \
 libgcc \
 libsmbclient \
 "
