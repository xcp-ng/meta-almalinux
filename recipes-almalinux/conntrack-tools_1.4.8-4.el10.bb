# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "conntrack-tools"
PV = "1.4.8"
PR = "4.el10"
PACKAGES = " \
 conntrack-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/conntrack-tools-1.4.8-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68772bc31e6f3d6383e4ad25416f0425866f020ca10f4531cabd21baabfd4c75"

URI_x86_64_v2_conntrack-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/conntrack-tools-1.4.8-4.el10.x86_64_v2.rpm;name=x86_64_v2_conntrack-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_conntrack-tools}"
SRC_URI[x86_64_v2_conntrack-tools.sha256sum] = "64924a6cd627eddae374c7704a290b5912b092fd84a2ac0d0db0dbc552c1c41f"

URI_aarch64_conntrack-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/conntrack-tools-1.4.8-4.el10.aarch64.rpm;name=aarch64_conntrack-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_conntrack-tools}"
SRC_URI[aarch64_conntrack-tools.sha256sum] = "78cdcb6296e7e87ac9dcdb141d3342e676cb4e88b7726393e339ac906a1f8581"

RDEPENDS:conntrack-tools = " \
 bash \
 glibc \
 libmnl \
 libnetfilter_conntrack \
 libnetfilter_cthelper \
 libnetfilter_cttimeout \
 libnetfilter_queue \
 libnfnetlink \
 systemd \
 systemd-libs \
 "
