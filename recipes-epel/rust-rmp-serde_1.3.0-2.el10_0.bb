# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rmp-serde"
PV = "1.3.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-rmp-serde+default-devel \
 rust-rmp-serde-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rmp-serde-1.3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50928b68263e998b7cd4c388c9f53598fcfa77eebd2d65c63702435c204deb4e"

URI_x86_64_v2_rust-rmp-serde+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp-serde+default-devel-1.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp-serde+default-devel}"
SRC_URI[x86_64_v2_rust-rmp-serde+default-devel.sha256sum] = "38caebbdaa577ee163f847c00715d356c08b687bb5604c253bb65561d455ab3d"

URI_x86_64_v2_rust-rmp-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp-serde-devel-1.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp-serde-devel}"
SRC_URI[x86_64_v2_rust-rmp-serde-devel.sha256sum] = "5441d1ab8b8bf8440e5d8c51036d827746dd268c10e3089a27465f46ecfd4881"

URI_aarch64_rust-rmp-serde+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp-serde+default-devel-1.3.0-2.el10_0.noarch.rpm;name=aarch64_rust-rmp-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp-serde+default-devel}"
SRC_URI[aarch64_rust-rmp-serde+default-devel.sha256sum] = "dd4dbb6c6ed0d1af8ec1410d27ef7f4b7567dc73735dbd78ee9e147270bcf985"

URI_aarch64_rust-rmp-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp-serde-devel-1.3.0-2.el10_0.noarch.rpm;name=aarch64_rust-rmp-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp-serde-devel}"
SRC_URI[aarch64_rust-rmp-serde-devel.sha256sum] = "26fddd9d3fab3d39a30189d445afc31166b5a5d8b846d4d7d2ab25768c230b5b"

RDEPENDS:rust-rmp-serde+default-devel = " \
 cargo \
 rust-rmp-serde-devel \
 "
RDEPENDS:rust-rmp-serde-devel = " \
 cargo \
 rust-byteorder+default-devel \
 rust-rmp+default-devel \
 rust-serde+default-devel \
 "
