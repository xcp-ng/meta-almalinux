# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-moxcms"
PV = "0.8.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-moxcms+any_to_any-devel \
 rust-moxcms+avx-devel \
 rust-moxcms+avx512-devel \
 rust-moxcms+avx512_shaper_fixed_point_paths-devel \
 rust-moxcms+avx512_shaper_optimized_paths-devel \
 rust-moxcms+avx_luts-devel \
 rust-moxcms+avx_shaper_fixed_point_paths-devel \
 rust-moxcms+avx_shaper_optimized_paths-devel \
 rust-moxcms+avx_shaper_paths-devel \
 rust-moxcms+default-devel \
 rust-moxcms+extended_range-devel \
 rust-moxcms+in_place-devel \
 rust-moxcms+lut-devel \
 rust-moxcms+neon-devel \
 rust-moxcms+neon_luts-devel \
 rust-moxcms+neon_shaper_fixed_point_paths-devel \
 rust-moxcms+neon_shaper_optimized_paths-devel \
 rust-moxcms+neon_shaper_paths-devel \
 rust-moxcms+options-devel \
 rust-moxcms+sse-devel \
 rust-moxcms+sse_luts-devel \
 rust-moxcms+sse_shaper_fixed_point_paths-devel \
 rust-moxcms+sse_shaper_optimized_paths-devel \
 rust-moxcms+sse_shaper_paths-devel \
 rust-moxcms-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-moxcms-0.8.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4e3f048da020b9786b124c447df987ff1d0e9899d2347905d68853e8aa3af5a"

URI_x86_64_v2_rust-moxcms+any_to_any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+any_to_any-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+any_to_any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+any_to_any-devel}"
SRC_URI[x86_64_v2_rust-moxcms+any_to_any-devel.sha256sum] = "89b36c1fff3ef36776af3c66949d5005100df374773736bd55d68749f8acaaaf"

URI_x86_64_v2_rust-moxcms+avx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+avx-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+avx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+avx-devel}"
SRC_URI[x86_64_v2_rust-moxcms+avx-devel.sha256sum] = "621bfd4ee5e836313d01772fb8839e714c9e341f8109c32899843a7a3a1b7fa2"

URI_x86_64_v2_rust-moxcms+avx512-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+avx512-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+avx512-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+avx512-devel}"
SRC_URI[x86_64_v2_rust-moxcms+avx512-devel.sha256sum] = "cc08e0e5ee541a92bbf53fb52c4ac50041bc62b69bc7c8b7b9786fa5cb6fed0e"

URI_x86_64_v2_rust-moxcms+avx512_shaper_fixed_point_paths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+avx512_shaper_fixed_point_paths-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+avx512_shaper_fixed_point_paths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+avx512_shaper_fixed_point_paths-devel}"
SRC_URI[x86_64_v2_rust-moxcms+avx512_shaper_fixed_point_paths-devel.sha256sum] = "010c2e06c131545021e3f8f8b52b1135c76ef427487cef3f6dd18821574a036c"

URI_x86_64_v2_rust-moxcms+avx512_shaper_optimized_paths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+avx512_shaper_optimized_paths-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+avx512_shaper_optimized_paths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+avx512_shaper_optimized_paths-devel}"
SRC_URI[x86_64_v2_rust-moxcms+avx512_shaper_optimized_paths-devel.sha256sum] = "57162a4342e38becfc261d40d710fa812bbfa64c05011a880f5a13e0fc73eb99"

URI_x86_64_v2_rust-moxcms+avx_luts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+avx_luts-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+avx_luts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+avx_luts-devel}"
SRC_URI[x86_64_v2_rust-moxcms+avx_luts-devel.sha256sum] = "f815e1c7b1d675232626f0e04881cbf43b8e63fafd2c76c317fb2e1a906da087"

URI_x86_64_v2_rust-moxcms+avx_shaper_fixed_point_paths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+avx_shaper_fixed_point_paths-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+avx_shaper_fixed_point_paths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+avx_shaper_fixed_point_paths-devel}"
SRC_URI[x86_64_v2_rust-moxcms+avx_shaper_fixed_point_paths-devel.sha256sum] = "3bebbf1692ce9e4e6db99bc63795dc811e30a1e2bfeb254e642916b6ece3bfc2"

URI_x86_64_v2_rust-moxcms+avx_shaper_optimized_paths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+avx_shaper_optimized_paths-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+avx_shaper_optimized_paths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+avx_shaper_optimized_paths-devel}"
SRC_URI[x86_64_v2_rust-moxcms+avx_shaper_optimized_paths-devel.sha256sum] = "68f891b16925e42aa66345c7e824f7766d6ca9359199e6b510a9aa0f4b568551"

URI_x86_64_v2_rust-moxcms+avx_shaper_paths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+avx_shaper_paths-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+avx_shaper_paths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+avx_shaper_paths-devel}"
SRC_URI[x86_64_v2_rust-moxcms+avx_shaper_paths-devel.sha256sum] = "f2f5263d2b4cbd52a633031bdfb9e1733040b452c29888693f1724c7b9164320"

URI_x86_64_v2_rust-moxcms+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+default-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+default-devel}"
SRC_URI[x86_64_v2_rust-moxcms+default-devel.sha256sum] = "33bb1e6871149bce905e3793b99ea85d8c1eeb267707d067aae0f31ed7ee92bb"

URI_x86_64_v2_rust-moxcms+extended_range-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+extended_range-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+extended_range-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+extended_range-devel}"
SRC_URI[x86_64_v2_rust-moxcms+extended_range-devel.sha256sum] = "7c52fe8303e0aa2ece1b99266848f2449bd72cf4b18fbe8019c02c9009783e97"

URI_x86_64_v2_rust-moxcms+in_place-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+in_place-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+in_place-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+in_place-devel}"
SRC_URI[x86_64_v2_rust-moxcms+in_place-devel.sha256sum] = "3e9bf3e371ed62b8f9105b02884ba9fcdba048b82ad3a20f144bb0d9f4d2faab"

URI_x86_64_v2_rust-moxcms+lut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+lut-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+lut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+lut-devel}"
SRC_URI[x86_64_v2_rust-moxcms+lut-devel.sha256sum] = "46c87c8345932c01c56cce74aea2ef6c00f110ebbc2040ddbb9607749dba0fb6"

URI_x86_64_v2_rust-moxcms+neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+neon-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+neon-devel}"
SRC_URI[x86_64_v2_rust-moxcms+neon-devel.sha256sum] = "6bd90160fbbb930ceafc0d99b0954496dc7e424bf5d6604a7fd7c8896bf181f5"

URI_x86_64_v2_rust-moxcms+neon_luts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+neon_luts-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+neon_luts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+neon_luts-devel}"
SRC_URI[x86_64_v2_rust-moxcms+neon_luts-devel.sha256sum] = "f41e4dc41519cc12d5ae1814a2461850fe78a592a6a95f5452b20fac21c5124a"

URI_x86_64_v2_rust-moxcms+neon_shaper_fixed_point_paths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+neon_shaper_fixed_point_paths-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+neon_shaper_fixed_point_paths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+neon_shaper_fixed_point_paths-devel}"
SRC_URI[x86_64_v2_rust-moxcms+neon_shaper_fixed_point_paths-devel.sha256sum] = "4cb502d3248a419574c47e9afcf2c0ce64d16f340cd17f16adbe0ba8a72dbc7c"

URI_x86_64_v2_rust-moxcms+neon_shaper_optimized_paths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+neon_shaper_optimized_paths-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+neon_shaper_optimized_paths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+neon_shaper_optimized_paths-devel}"
SRC_URI[x86_64_v2_rust-moxcms+neon_shaper_optimized_paths-devel.sha256sum] = "2da5b28c238737733d99a18e5927c6b110fe8a7e7afebcfbbf58b70abca786f6"

URI_x86_64_v2_rust-moxcms+neon_shaper_paths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+neon_shaper_paths-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+neon_shaper_paths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+neon_shaper_paths-devel}"
SRC_URI[x86_64_v2_rust-moxcms+neon_shaper_paths-devel.sha256sum] = "1bd9f3c99c47b67488f7723432f34c99d8b2dd03b669bbe0c088d2e00cc9585f"

URI_x86_64_v2_rust-moxcms+options-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+options-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+options-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+options-devel}"
SRC_URI[x86_64_v2_rust-moxcms+options-devel.sha256sum] = "bbb1a680c66dadaadb35f4a4b9592f7f16bb4c88ae8309c0520ef0b140a06881"

URI_x86_64_v2_rust-moxcms+sse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+sse-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+sse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+sse-devel}"
SRC_URI[x86_64_v2_rust-moxcms+sse-devel.sha256sum] = "9aa257f6c47019bb27d2aa7708ff6630dc71d3380587e5756433df90dd017741"

URI_x86_64_v2_rust-moxcms+sse_luts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+sse_luts-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+sse_luts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+sse_luts-devel}"
SRC_URI[x86_64_v2_rust-moxcms+sse_luts-devel.sha256sum] = "6a9726e5ad990467f3fa91db1280be7e9cfaf80393152c5e51b313d7c08f1864"

URI_x86_64_v2_rust-moxcms+sse_shaper_fixed_point_paths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+sse_shaper_fixed_point_paths-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+sse_shaper_fixed_point_paths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+sse_shaper_fixed_point_paths-devel}"
SRC_URI[x86_64_v2_rust-moxcms+sse_shaper_fixed_point_paths-devel.sha256sum] = "f1b589aec67309a16490e94e27d8b185a1428fdec0b147c097597cab67ed0b7f"

URI_x86_64_v2_rust-moxcms+sse_shaper_optimized_paths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+sse_shaper_optimized_paths-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+sse_shaper_optimized_paths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+sse_shaper_optimized_paths-devel}"
SRC_URI[x86_64_v2_rust-moxcms+sse_shaper_optimized_paths-devel.sha256sum] = "efa3d2ad2cb0548b6c4f0cead5a92e8e9bdbb1ce06cae6c7f24340891a7bc528"

URI_x86_64_v2_rust-moxcms+sse_shaper_paths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+sse_shaper_paths-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+sse_shaper_paths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+sse_shaper_paths-devel}"
SRC_URI[x86_64_v2_rust-moxcms+sse_shaper_paths-devel.sha256sum] = "1d221e5ce4c406e7a88a46f76338ce17d0001d3788051ab5b6ebc78fa3009f23"

URI_x86_64_v2_rust-moxcms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms-devel}"
SRC_URI[x86_64_v2_rust-moxcms-devel.sha256sum] = "4cacc07dadd2d33945d1fa7c595fa66449ffcf093eb68bc9f0e83241c327b10b"

URI_aarch64_rust-moxcms+any_to_any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+any_to_any-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+any_to_any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+any_to_any-devel}"
SRC_URI[aarch64_rust-moxcms+any_to_any-devel.sha256sum] = "31dd063e27cb493ea3abbd4d10c906a47e75782e454773aa0bb6784270e88268"

URI_aarch64_rust-moxcms+avx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+avx-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+avx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+avx-devel}"
SRC_URI[aarch64_rust-moxcms+avx-devel.sha256sum] = "b5447c57f576cfddd953247768c7506d0610fe91de920b5f1cdca28dc76ad025"

URI_aarch64_rust-moxcms+avx512-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+avx512-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+avx512-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+avx512-devel}"
SRC_URI[aarch64_rust-moxcms+avx512-devel.sha256sum] = "63946d884ae449c75810cb4b2266b66d32a89eaf2b2f11cd4b13a1db3b091920"

URI_aarch64_rust-moxcms+avx512_shaper_fixed_point_paths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+avx512_shaper_fixed_point_paths-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+avx512_shaper_fixed_point_paths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+avx512_shaper_fixed_point_paths-devel}"
SRC_URI[aarch64_rust-moxcms+avx512_shaper_fixed_point_paths-devel.sha256sum] = "9974c2500bfd160225183235afa5c61e430cd1c7cd071885c76440c6c193529f"

URI_aarch64_rust-moxcms+avx512_shaper_optimized_paths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+avx512_shaper_optimized_paths-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+avx512_shaper_optimized_paths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+avx512_shaper_optimized_paths-devel}"
SRC_URI[aarch64_rust-moxcms+avx512_shaper_optimized_paths-devel.sha256sum] = "0c1dc2e99345329689c3d19a6b4322883fed835b29e7a36df84a64cdb71ee855"

URI_aarch64_rust-moxcms+avx_luts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+avx_luts-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+avx_luts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+avx_luts-devel}"
SRC_URI[aarch64_rust-moxcms+avx_luts-devel.sha256sum] = "a9d5f3855fb55cded7cc166dc1542d5e424bde608fe461ec31f35815f3eb92a5"

URI_aarch64_rust-moxcms+avx_shaper_fixed_point_paths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+avx_shaper_fixed_point_paths-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+avx_shaper_fixed_point_paths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+avx_shaper_fixed_point_paths-devel}"
SRC_URI[aarch64_rust-moxcms+avx_shaper_fixed_point_paths-devel.sha256sum] = "b225a2503fc2a7b5b43ecc5468900252172b904e97e6d3a43d1f5a9955dcdcdb"

URI_aarch64_rust-moxcms+avx_shaper_optimized_paths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+avx_shaper_optimized_paths-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+avx_shaper_optimized_paths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+avx_shaper_optimized_paths-devel}"
SRC_URI[aarch64_rust-moxcms+avx_shaper_optimized_paths-devel.sha256sum] = "5bb77e85c078d4e2019fd8dcc593499ce42876d730c8d9d08c01b337d5c24f99"

URI_aarch64_rust-moxcms+avx_shaper_paths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+avx_shaper_paths-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+avx_shaper_paths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+avx_shaper_paths-devel}"
SRC_URI[aarch64_rust-moxcms+avx_shaper_paths-devel.sha256sum] = "617ae119b6584ca4d1698756bc9aa9e9ed17f08c66c7f08a6700c684376a70e8"

URI_aarch64_rust-moxcms+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+default-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+default-devel}"
SRC_URI[aarch64_rust-moxcms+default-devel.sha256sum] = "65b424198fb63bbb6f31ef80f362d015dcb1f8442ec5251a1dca42c50d902776"

URI_aarch64_rust-moxcms+extended_range-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+extended_range-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+extended_range-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+extended_range-devel}"
SRC_URI[aarch64_rust-moxcms+extended_range-devel.sha256sum] = "7b103d5b4e1c1fa362e466929e1c70cbabd07b3d5835f44c59d123bf7e506a1b"

URI_aarch64_rust-moxcms+in_place-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+in_place-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+in_place-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+in_place-devel}"
SRC_URI[aarch64_rust-moxcms+in_place-devel.sha256sum] = "c08bae5ba7f58f98cf806b74f260a6da68b92649ac68df5d7562195203fb0167"

URI_aarch64_rust-moxcms+lut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+lut-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+lut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+lut-devel}"
SRC_URI[aarch64_rust-moxcms+lut-devel.sha256sum] = "4a248f52d88f5a087fc616b2ae7117d440380db4783792e80cf179d33892f7e0"

URI_aarch64_rust-moxcms+neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+neon-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+neon-devel}"
SRC_URI[aarch64_rust-moxcms+neon-devel.sha256sum] = "0f4e6c689c0af9fde060ec4d95189ac14b342c9d4f68ab2708e0418e49f1431d"

URI_aarch64_rust-moxcms+neon_luts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+neon_luts-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+neon_luts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+neon_luts-devel}"
SRC_URI[aarch64_rust-moxcms+neon_luts-devel.sha256sum] = "c6712158b0b4b143b3466b3c0b35ff4bad5085129bb0ba9257e124fe33dc6436"

URI_aarch64_rust-moxcms+neon_shaper_fixed_point_paths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+neon_shaper_fixed_point_paths-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+neon_shaper_fixed_point_paths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+neon_shaper_fixed_point_paths-devel}"
SRC_URI[aarch64_rust-moxcms+neon_shaper_fixed_point_paths-devel.sha256sum] = "6d4aa81c503fd9cc7440f92ffb1bd016ea93f2e8ed0405321aef55aee475c937"

URI_aarch64_rust-moxcms+neon_shaper_optimized_paths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+neon_shaper_optimized_paths-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+neon_shaper_optimized_paths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+neon_shaper_optimized_paths-devel}"
SRC_URI[aarch64_rust-moxcms+neon_shaper_optimized_paths-devel.sha256sum] = "6f698341d60057e977c29422fb09f460a106c22d56f90b57d0d5c0569f3ba351"

URI_aarch64_rust-moxcms+neon_shaper_paths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+neon_shaper_paths-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+neon_shaper_paths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+neon_shaper_paths-devel}"
SRC_URI[aarch64_rust-moxcms+neon_shaper_paths-devel.sha256sum] = "7f8ffa1da2bb78a403688de4395afb0f897102f929b31aa0910b3c1bf62ddccf"

URI_aarch64_rust-moxcms+options-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+options-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+options-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+options-devel}"
SRC_URI[aarch64_rust-moxcms+options-devel.sha256sum] = "af6a8ff727436abae5ca97b8699fd1a79ab07f7020d8d0565bc54f24b2fa7ad4"

URI_aarch64_rust-moxcms+sse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+sse-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+sse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+sse-devel}"
SRC_URI[aarch64_rust-moxcms+sse-devel.sha256sum] = "e3bc3457bd67ddcb11938bb729b227ef6b83b536129e8d5de06da09175854413"

URI_aarch64_rust-moxcms+sse_luts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+sse_luts-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+sse_luts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+sse_luts-devel}"
SRC_URI[aarch64_rust-moxcms+sse_luts-devel.sha256sum] = "9383ae77440a4668b6ec37b0b5773bcdd9f4635239e0290b26289b3a672d547d"

URI_aarch64_rust-moxcms+sse_shaper_fixed_point_paths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+sse_shaper_fixed_point_paths-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+sse_shaper_fixed_point_paths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+sse_shaper_fixed_point_paths-devel}"
SRC_URI[aarch64_rust-moxcms+sse_shaper_fixed_point_paths-devel.sha256sum] = "dc9c30e3fff9d34ad0309c37f220e844a5856f7b6d41348049508778ab57eba3"

URI_aarch64_rust-moxcms+sse_shaper_optimized_paths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+sse_shaper_optimized_paths-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+sse_shaper_optimized_paths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+sse_shaper_optimized_paths-devel}"
SRC_URI[aarch64_rust-moxcms+sse_shaper_optimized_paths-devel.sha256sum] = "87da432afa2681fdee9f002215f9e5544e7b407abdc1db42c9b5f259df384546"

URI_aarch64_rust-moxcms+sse_shaper_paths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+sse_shaper_paths-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms+sse_shaper_paths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+sse_shaper_paths-devel}"
SRC_URI[aarch64_rust-moxcms+sse_shaper_paths-devel.sha256sum] = "f13442069fdbb58a97bbf844d8016aad9def8b00e6876483abd2b813fc022a69"

URI_aarch64_rust-moxcms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-moxcms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms-devel}"
SRC_URI[aarch64_rust-moxcms-devel.sha256sum] = "79160f537062df03ac260131ba3b6be450b56c788f1ac731e7f0d21289bd53c1"

RDEPENDS:rust-moxcms+any_to_any-devel = " \
 cargo \
 rust-moxcms+lut-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+avx-devel = " \
 cargo \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+avx512-devel = " \
 cargo \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+avx512_shaper_fixed_point_paths-devel = " \
 cargo \
 rust-moxcms+avx512-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+avx512_shaper_optimized_paths-devel = " \
 cargo \
 rust-moxcms+avx512-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+avx_luts-devel = " \
 cargo \
 rust-moxcms+avx-devel \
 rust-moxcms+lut-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+avx_shaper_fixed_point_paths-devel = " \
 cargo \
 rust-moxcms+avx-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+avx_shaper_optimized_paths-devel = " \
 cargo \
 rust-moxcms+avx-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+avx_shaper_paths-devel = " \
 cargo \
 rust-moxcms+avx-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+default-devel = " \
 cargo \
 rust-moxcms+avx_luts-devel \
 rust-moxcms+avx_shaper_fixed_point_paths-devel \
 rust-moxcms+avx_shaper_paths-devel \
 rust-moxcms+lut-devel \
 rust-moxcms+neon_luts-devel \
 rust-moxcms+neon_shaper_fixed_point_paths-devel \
 rust-moxcms+neon_shaper_paths-devel \
 rust-moxcms+sse_luts-devel \
 rust-moxcms+sse_shaper_fixed_point_paths-devel \
 rust-moxcms+sse_shaper_paths-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+extended_range-devel = " \
 cargo \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+in_place-devel = " \
 cargo \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+lut-devel = " \
 cargo \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+neon-devel = " \
 cargo \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+neon_luts-devel = " \
 cargo \
 rust-moxcms+lut-devel \
 rust-moxcms+neon-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+neon_shaper_fixed_point_paths-devel = " \
 cargo \
 rust-moxcms+neon-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+neon_shaper_optimized_paths-devel = " \
 cargo \
 rust-moxcms+neon-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+neon_shaper_paths-devel = " \
 cargo \
 rust-moxcms+neon-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+options-devel = " \
 cargo \
 rust-moxcms+lut-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+sse-devel = " \
 cargo \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+sse_luts-devel = " \
 cargo \
 rust-moxcms+lut-devel \
 rust-moxcms+sse-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+sse_shaper_fixed_point_paths-devel = " \
 cargo \
 rust-moxcms+sse-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+sse_shaper_optimized_paths-devel = " \
 cargo \
 rust-moxcms+sse-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+sse_shaper_paths-devel = " \
 cargo \
 rust-moxcms+sse-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms-devel = " \
 cargo \
 rust \
 rust-num-traits+default-devel \
 rust-pxfm+default-devel \
 "
