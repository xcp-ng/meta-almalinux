# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-target-lexicon"
PV = "0.13.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-target-lexicon+arch_z80-devel \
 rust-target-lexicon+arch_zkasm-devel \
 rust-target-lexicon+default-devel \
 rust-target-lexicon+serde-devel \
 rust-target-lexicon+serde_support-devel \
 rust-target-lexicon+std-devel \
 rust-target-lexicon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-target-lexicon-0.13.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "219da66e52771e60b9118a8202fce2d3293cdcfaad6d24e8fbb7ed98ea2239e1"

URI_x86_64_v2_rust-target-lexicon+arch_z80-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+arch_z80-devel-0.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+arch_z80-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+arch_z80-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+arch_z80-devel.sha256sum] = "960b06d213232da2aac9d115d4232e003540dac15376e132388e57c821bc5390"

URI_x86_64_v2_rust-target-lexicon+arch_zkasm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+arch_zkasm-devel-0.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+arch_zkasm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+arch_zkasm-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+arch_zkasm-devel.sha256sum] = "c36f0803020be7e4d44a3d15743701b737614a57c7941b2557504dcdd7e21b8e"

URI_x86_64_v2_rust-target-lexicon+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+default-devel-0.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+default-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+default-devel.sha256sum] = "3b4c821b15f4efb2cced8ade17fbd40902efbc7331dd5337f8b2ea09a762e0f2"

URI_x86_64_v2_rust-target-lexicon+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+serde-devel-0.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+serde-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+serde-devel.sha256sum] = "4cf83c55d281b0d9e8eea8382206f43732e42d65473872d660f2a428561f7111"

URI_x86_64_v2_rust-target-lexicon+serde_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+serde_support-devel-0.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+serde_support-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+serde_support-devel.sha256sum] = "1c2c7f84c2f810df9bc757bd68122c432219a8e08ab000fe041972a89fdbeee1"

URI_x86_64_v2_rust-target-lexicon+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+std-devel-0.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+std-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+std-devel.sha256sum] = "4349d5cac580b7e84de4e8a11af7bb911409d69e6cf5edf8b2ba4c121496fc12"

URI_x86_64_v2_rust-target-lexicon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon-devel-0.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon-devel.sha256sum] = "9db7f96f94136520d195d2b894587f3a41e4df4c34ed28bd66bf4f9e8c3f722a"

URI_aarch64_rust-target-lexicon+arch_z80-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+arch_z80-devel-0.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-target-lexicon+arch_z80-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+arch_z80-devel}"
SRC_URI[aarch64_rust-target-lexicon+arch_z80-devel.sha256sum] = "09aeb2021c8a726372a5701d4c92aa77fd72c1886026a6d0d65c1a4e21615339"

URI_aarch64_rust-target-lexicon+arch_zkasm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+arch_zkasm-devel-0.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-target-lexicon+arch_zkasm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+arch_zkasm-devel}"
SRC_URI[aarch64_rust-target-lexicon+arch_zkasm-devel.sha256sum] = "4219584299a58b12d99bbd0f2b685fcaf79ba7e4611022b5a1b4b88201f0b11a"

URI_aarch64_rust-target-lexicon+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+default-devel-0.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-target-lexicon+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+default-devel}"
SRC_URI[aarch64_rust-target-lexicon+default-devel.sha256sum] = "bb2859eec0733b2b4aec2beb312fd55b055f4eb098314f34c07d6562eef30b20"

URI_aarch64_rust-target-lexicon+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+serde-devel-0.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-target-lexicon+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+serde-devel}"
SRC_URI[aarch64_rust-target-lexicon+serde-devel.sha256sum] = "fb0cd2f75941f640d18204e6faff0f1ec18c2a52c2626f226097103edd1f3f41"

URI_aarch64_rust-target-lexicon+serde_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+serde_support-devel-0.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-target-lexicon+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+serde_support-devel}"
SRC_URI[aarch64_rust-target-lexicon+serde_support-devel.sha256sum] = "0af66063caa3232726a425787b502e7cb61d14c1a087aa5dee131af5a614a51b"

URI_aarch64_rust-target-lexicon+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+std-devel-0.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-target-lexicon+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+std-devel}"
SRC_URI[aarch64_rust-target-lexicon+std-devel.sha256sum] = "f5d42680cf54b40fe28ffd45ec9ad082bebab3825d882909fe2b632c5d4ea7aa"

URI_aarch64_rust-target-lexicon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon-devel-0.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-target-lexicon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon-devel}"
SRC_URI[aarch64_rust-target-lexicon-devel.sha256sum] = "5e703b276c22f9e138825ba9099ec7a3f5d71960a8229a7333e8cb67c101735a"

RDEPENDS:rust-target-lexicon+arch_z80-devel = " \
 cargo \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+arch_zkasm-devel = " \
 cargo \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+default-devel = " \
 cargo \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+serde_support-devel = " \
 cargo \
 rust-target-lexicon+serde-devel \
 rust-target-lexicon+std-devel \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+std-devel = " \
 cargo \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon-devel = " \
 bash \
 cargo \
 "
