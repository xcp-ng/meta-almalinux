# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpatch"
PV = "0.9.10"
PR = "20.el10"
PACKAGES = " \
 kpatch \
 kpatch-dnf \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kpatch-0.9.10-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "419100718728f21aeb31ba22fca02d0a4b05164f844073374c1972b2dab6dcdb"

URI_x86_64_v2_kpatch = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kpatch-0.9.10-20.el10.noarch.rpm;name=x86_64_v2_kpatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpatch}"
SRC_URI[x86_64_v2_kpatch.sha256sum] = "21799b56bacb0b46fe9526f96676f2bb4bdaafdb76dffc3aa57b482dc0062420"

URI_x86_64_v2_kpatch-dnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kpatch-dnf-0.9.10_0.5-20.el10.noarch.rpm;name=x86_64_v2_kpatch-dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpatch-dnf}"
SRC_URI[x86_64_v2_kpatch-dnf.sha256sum] = "b1ef9f278ba293d58de28a6472c55b029a1de6bdd8f3590d42c2d4d0d81e2db1"

URI_aarch64_kpatch = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kpatch-0.9.10-20.el10.noarch.rpm;name=aarch64_kpatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpatch}"
SRC_URI[aarch64_kpatch.sha256sum] = "21799b56bacb0b46fe9526f96676f2bb4bdaafdb76dffc3aa57b482dc0062420"

URI_aarch64_kpatch-dnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kpatch-dnf-0.9.10_0.5-20.el10.noarch.rpm;name=aarch64_kpatch-dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpatch-dnf}"
SRC_URI[aarch64_kpatch-dnf.sha256sum] = "b1ef9f278ba293d58de28a6472c55b029a1de6bdd8f3590d42c2d4d0d81e2db1"

RDEPENDS:kpatch = " \
 bash \
 binutils \
 kmod \
 "
RDEPENDS:kpatch-dnf = " \
 bash \
 python3 \
 python3-dnf \
 python3-hawkey \
 "
