# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libblockdev"
PV = "3.2.0"
PR = "5.el10.alma.1"
PACKAGES = " \
 libblockdev \
 libblockdev-btrfs \
 libblockdev-crypto \
 libblockdev-dm \
 libblockdev-fs \
 libblockdev-loop \
 libblockdev-lvm \
 libblockdev-lvm-dbus \
 libblockdev-mdraid \
 libblockdev-mpath \
 libblockdev-nvdimm \
 libblockdev-nvme \
 libblockdev-part \
 libblockdev-plugins-all \
 libblockdev-smart \
 libblockdev-smartmontools \
 libblockdev-swap \
 libblockdev-tools \
 libblockdev-utils \
 python3-blockdev \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libblockdev-3.2.0-5.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11aca998d6ca3b921d96149658c01a7d09b9baca10dabe825fb5e2dcaaad8161"

URI_x86_64_v2_libblockdev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev}"
SRC_URI[x86_64_v2_libblockdev.sha256sum] = "21201f38fbf2ab36ecd41ff3468b490228c9559e04ae64efbde464295ecb8e56"

URI_x86_64_v2_libblockdev-btrfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-btrfs-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-btrfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-btrfs}"
SRC_URI[x86_64_v2_libblockdev-btrfs.sha256sum] = "2cd0646979e089e7afc682dee2b34d8b427f2204368848505bd5da7c15dd166c"

URI_x86_64_v2_libblockdev-crypto = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-crypto-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-crypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-crypto}"
SRC_URI[x86_64_v2_libblockdev-crypto.sha256sum] = "30d082cccd9ae604a7e4ad637902c1a64d3b861c5d7b68cb5556d6c518e57836"

URI_x86_64_v2_libblockdev-dm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-dm-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-dm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-dm}"
SRC_URI[x86_64_v2_libblockdev-dm.sha256sum] = "0458e30aec26a36b04f5523a5f9e64a0e193935539c202e68ada59fbff98e913"

URI_x86_64_v2_libblockdev-fs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-fs-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-fs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-fs}"
SRC_URI[x86_64_v2_libblockdev-fs.sha256sum] = "ad886f889aa223866502d3fa6db7ab657c21d9b52c0cfbbe02e873837fc592aa"

URI_x86_64_v2_libblockdev-loop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-loop-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-loop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-loop}"
SRC_URI[x86_64_v2_libblockdev-loop.sha256sum] = "f3c42181d9ef7930369536dde133714d9a217d401c99bf4f8cab3cf83b66e967"

URI_x86_64_v2_libblockdev-lvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-lvm-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-lvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-lvm}"
SRC_URI[x86_64_v2_libblockdev-lvm.sha256sum] = "e2a9f0050910ea35fa0959c5a4ee11eee6dbb56f884b97714c7b3418c2b62195"

URI_x86_64_v2_libblockdev-lvm-dbus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-lvm-dbus-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-lvm-dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-lvm-dbus}"
SRC_URI[x86_64_v2_libblockdev-lvm-dbus.sha256sum] = "6df270dd8d4ca21b8739f808d14f3c17213263e6c2c37c0b9534dc5ac6a8a186"

URI_x86_64_v2_libblockdev-mdraid = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-mdraid-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-mdraid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-mdraid}"
SRC_URI[x86_64_v2_libblockdev-mdraid.sha256sum] = "386e3b6ecc4bf71fcd43f8d329a503bada7632f7d767f36eb47ec6869f903616"

URI_x86_64_v2_libblockdev-mpath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-mpath-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-mpath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-mpath}"
SRC_URI[x86_64_v2_libblockdev-mpath.sha256sum] = "6ae83f7d928b3497362902986b0b4352280335567007e3fcf306656d257156bf"

URI_x86_64_v2_libblockdev-nvdimm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-nvdimm-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-nvdimm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-nvdimm}"
SRC_URI[x86_64_v2_libblockdev-nvdimm.sha256sum] = "96f4b87073799f11c5b32f9d01ada80357fc8f7e402f2697ef7995e8e4494310"

URI_x86_64_v2_libblockdev-nvme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-nvme-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-nvme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-nvme}"
SRC_URI[x86_64_v2_libblockdev-nvme.sha256sum] = "f7df76df746ae672c5605dafd0ae9294e122dc12f2438feeb0d3dbfd2cb93ea8"

URI_x86_64_v2_libblockdev-part = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-part-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-part;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-part}"
SRC_URI[x86_64_v2_libblockdev-part.sha256sum] = "b60088ef16b5391d47ed956b2d4e5a5109d34655630750d47f2bcafabf76398b"

URI_x86_64_v2_libblockdev-plugins-all = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-plugins-all-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-plugins-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-plugins-all}"
SRC_URI[x86_64_v2_libblockdev-plugins-all.sha256sum] = "92de82da768502df0fd89592411e3ce38c6480acd4422a66ab67fc6588d3584a"

URI_x86_64_v2_libblockdev-smart = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-smart-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-smart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-smart}"
SRC_URI[x86_64_v2_libblockdev-smart.sha256sum] = "ddf3ddf901a3a91c98f74782f95fd83125d7f09565aa7e9e89cfb60aadcfced8"

URI_x86_64_v2_libblockdev-smartmontools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-smartmontools-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-smartmontools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-smartmontools}"
SRC_URI[x86_64_v2_libblockdev-smartmontools.sha256sum] = "06b3e92a6308d39546e3055fc2fd6e1086334e67bf3f0403a813a28dc8b59280"

URI_x86_64_v2_libblockdev-swap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-swap-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-swap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-swap}"
SRC_URI[x86_64_v2_libblockdev-swap.sha256sum] = "a62784b1f968945436bb8e2703700830394aee569653a6bc197957312319619a"

URI_x86_64_v2_libblockdev-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-tools-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-tools}"
SRC_URI[x86_64_v2_libblockdev-tools.sha256sum] = "6b70ed6be3eebcae01f605c2cc7ca5bbf9293861d76f07ca9efeb5691e927a0a"

URI_x86_64_v2_libblockdev-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-utils-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-utils}"
SRC_URI[x86_64_v2_libblockdev-utils.sha256sum] = "7f3fdbb3d7394b0e955fb2cc6c3f5448e411b250c520efe1cc21a94898448b8d"

URI_x86_64_v2_python3-blockdev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-blockdev-3.2.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-blockdev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-blockdev}"
SRC_URI[x86_64_v2_python3-blockdev.sha256sum] = "9c8afa09aa4aed09b6e471848adf8eee209b5813a98359c3a849c069620f3f6a"

URI_aarch64_libblockdev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev}"
SRC_URI[aarch64_libblockdev.sha256sum] = "44219a7176f338afd2f399c3d42d8acc2b7fbcd905c6eeae412da7823a95fdea"

URI_aarch64_libblockdev-btrfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-btrfs-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-btrfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-btrfs}"
SRC_URI[aarch64_libblockdev-btrfs.sha256sum] = "0690ae0a515601f75e59c7435363a8b7cde38bb1eeeadbea22d95c571c3d4373"

URI_aarch64_libblockdev-crypto = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-crypto-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-crypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-crypto}"
SRC_URI[aarch64_libblockdev-crypto.sha256sum] = "692a4fd3462965b58fc03e130a2f4b4ace41fc0f6bc92911510688f4a0b09e31"

URI_aarch64_libblockdev-dm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-dm-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-dm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-dm}"
SRC_URI[aarch64_libblockdev-dm.sha256sum] = "d11712eaf7c559f9a28bd7bd031118a0e0f2283e927ab1b4a6c982a7dff08898"

URI_aarch64_libblockdev-fs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-fs-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-fs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-fs}"
SRC_URI[aarch64_libblockdev-fs.sha256sum] = "8108b6f7a4f294a7273971f7ac863267890df148a592a60319a5901910a815c9"

URI_aarch64_libblockdev-loop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-loop-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-loop;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-loop}"
SRC_URI[aarch64_libblockdev-loop.sha256sum] = "2feef06f41f1a24d5c10c6faec776fa4cd1a00e993e51db33e2f3dd5533b88f1"

URI_aarch64_libblockdev-lvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-lvm-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-lvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-lvm}"
SRC_URI[aarch64_libblockdev-lvm.sha256sum] = "956c52ee7eea3dd8e08d6883ee71cffc77394b572fa1afcca39325b24ce0b220"

URI_aarch64_libblockdev-lvm-dbus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-lvm-dbus-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-lvm-dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-lvm-dbus}"
SRC_URI[aarch64_libblockdev-lvm-dbus.sha256sum] = "fdca3efec10e09f53d5d07037ae16945c92ebd2eda3b8fb35e30af27bc1f94bc"

URI_aarch64_libblockdev-mdraid = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-mdraid-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-mdraid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-mdraid}"
SRC_URI[aarch64_libblockdev-mdraid.sha256sum] = "57b467104b4b8710b2126413c333527c1489b013de3449fd988326d779cddce5"

URI_aarch64_libblockdev-mpath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-mpath-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-mpath;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-mpath}"
SRC_URI[aarch64_libblockdev-mpath.sha256sum] = "d15f9ff19d5ab84cf3314a32d56c2cecc40a1c4af05c6683e1e354eb60800c1c"

URI_aarch64_libblockdev-nvdimm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-nvdimm-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-nvdimm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-nvdimm}"
SRC_URI[aarch64_libblockdev-nvdimm.sha256sum] = "b4dfae9da7cc51ff218dfe241944b23245d83aa267d402c33f094ad0cdff5bed"

URI_aarch64_libblockdev-nvme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-nvme-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-nvme;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-nvme}"
SRC_URI[aarch64_libblockdev-nvme.sha256sum] = "abaff533ecde0b38f39a265b190d9d6c0527e77536ad7064047ec3d2eb7ac860"

URI_aarch64_libblockdev-part = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-part-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-part;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-part}"
SRC_URI[aarch64_libblockdev-part.sha256sum] = "382bcc61d89192c9a5e14b288093376a624f0b5ca620451b781a1c9e6e581b3c"

URI_aarch64_libblockdev-plugins-all = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-plugins-all-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-plugins-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-plugins-all}"
SRC_URI[aarch64_libblockdev-plugins-all.sha256sum] = "01b43ac0bcea46477269c20ed15ffc76a6985ab64f4cf03cee7e07fe0ac7e37c"

URI_aarch64_libblockdev-smart = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-smart-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-smart;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-smart}"
SRC_URI[aarch64_libblockdev-smart.sha256sum] = "85aeebc75fcdb194701239c2c1a166e7dc5c1a3c43f886fd62655992ca7bbf5b"

URI_aarch64_libblockdev-smartmontools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-smartmontools-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-smartmontools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-smartmontools}"
SRC_URI[aarch64_libblockdev-smartmontools.sha256sum] = "48a1d9291559e667d2d9239d419f657650537d5d1469934b7cff2fbd5a3b0b60"

URI_aarch64_libblockdev-swap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-swap-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-swap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-swap}"
SRC_URI[aarch64_libblockdev-swap.sha256sum] = "9433108e2deb3f8fa737e9fae3304dcf1c78a5c87c1509ce078812466634be2f"

URI_aarch64_libblockdev-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-tools-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-tools}"
SRC_URI[aarch64_libblockdev-tools.sha256sum] = "de4ae4b2dfe12efe812ca0b1e62143700b6e6c9c9262eb6c90bfbffabff773df"

URI_aarch64_libblockdev-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-utils-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-utils}"
SRC_URI[aarch64_libblockdev-utils.sha256sum] = "a524225af7ebd35eca70de0a3002331dd90092171caf1fbd0acdfe84aacbfc3c"

URI_aarch64_python3-blockdev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-blockdev-3.2.0-5.el10.alma.1.aarch64.rpm;name=aarch64_python3-blockdev;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-blockdev}"
SRC_URI[aarch64_python3-blockdev.sha256sum] = "74e3765917d286b6b0e9c031907b05ed2d2ee2ca4aaf394b1023040b6a1e12e1"

RDEPENDS:libblockdev = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 systemd-libs \
 "
RDEPENDS:libblockdev-btrfs = " \
 btrfs-progs \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libbytesize \
 systemd-libs \
 "
RDEPENDS:libblockdev-crypto = " \
 cryptsetup-libs \
 glib2 \
 glibc \
 keyutils-libs \
 kmod-libs \
 libblkid \
 libblockdev-utils \
 libgcc \
 nspr \
 nss \
 nss-util \
 systemd-libs \
 volume_key-libs \
 "
RDEPENDS:libblockdev-dm = " \
 device-mapper \
 device-mapper-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 systemd-libs \
 "
RDEPENDS:libblockdev-fs = " \
 e2fsprogs-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblkid \
 libblockdev-utils \
 libgcc \
 libmount \
 libuuid \
 systemd-libs \
 "
RDEPENDS:libblockdev-loop = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libgcc \
 systemd-libs \
 "
RDEPENDS:libblockdev-lvm = " \
 device-mapper-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libgcc \
 libyaml \
 lvm2 \
 systemd-libs \
 "
RDEPENDS:libblockdev-lvm-dbus = " \
 device-mapper-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libgcc \
 libyaml \
 lvm2-dbusd \
 systemd-libs \
 "
RDEPENDS:libblockdev-mdraid = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libbytesize \
 libgcc \
 mdadm \
 systemd-libs \
 "
RDEPENDS:libblockdev-mpath = " \
 device-mapper-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 systemd-libs \
 "
RDEPENDS:libblockdev-nvdimm = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libuuid \
 ndctl \
 ndctl-libs \
 systemd-libs \
 "
RDEPENDS:libblockdev-nvme = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libnvme \
 systemd-libs \
 "
RDEPENDS:libblockdev-part = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libfdisk \
 systemd-libs \
 util-linux \
 "
RDEPENDS:libblockdev-plugins-all = " \
 libblockdev \
 libblockdev-btrfs \
 libblockdev-crypto \
 libblockdev-dm \
 libblockdev-fs \
 libblockdev-loop \
 libblockdev-lvm \
 libblockdev-mdraid \
 libblockdev-mpath \
 libblockdev-nvdimm \
 libblockdev-nvme \
 libblockdev-part \
 libblockdev-smart \
 libblockdev-smartmontools \
 libblockdev-swap \
 "
RDEPENDS:libblockdev-smart = " \
 glib2 \
 glibc \
 kmod-libs \
 libatasmart \
 libblockdev-utils \
 systemd-libs \
 "
RDEPENDS:libblockdev-smartmontools = " \
 glib2 \
 glibc \
 json-glib \
 kmod-libs \
 libblockdev-utils \
 smartmontools \
 systemd-libs \
 "
RDEPENDS:libblockdev-swap = " \
 glib2 \
 glibc \
 kmod-libs \
 libblkid \
 libblockdev-utils \
 libgcc \
 libuuid \
 systemd-libs \
 util-linux \
 "
RDEPENDS:libblockdev-tools = " \
 glib2 \
 glibc \
 libblockdev \
 libblockdev-lvm \
 libbytesize \
 parted \
 "
RDEPENDS:libblockdev-utils = " \
 glib2 \
 glibc \
 kmod-libs \
 systemd-libs \
 "
RDEPENDS:python3-blockdev = " \
 libblockdev \
 python3 \
 python3-bytesize \
 python3-gobject-base \
 "
