# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmouth"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kmouth \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmouth-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7479fe8977cf6d581c1a1bfeae21312b773a57343cafd1fe7c68927de9179e4"

URI_x86_64_v2_kmouth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmouth-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmouth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmouth}"
SRC_URI[x86_64_v2_kmouth.sha256sum] = "3306e911b98e36f246ec1e8ad923efee1441de884a668561ef38c7a48d149ec1"

URI_aarch64_kmouth = "${EPEL_MIRROR}/aarch64/Packages/k/kmouth-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmouth;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmouth}"
SRC_URI[aarch64_kmouth.sha256sum] = "d86284ed0432b064540cacd3d177a01bb369f93927c3ff6037e389e1f53848f9"

RDEPENDS:kmouth = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 "
