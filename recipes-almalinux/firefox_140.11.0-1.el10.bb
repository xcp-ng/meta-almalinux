# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firefox"
PV = "140.11.0"
PR = "1.el10"
PACKAGES = " \
 firefox \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/firefox-140.11.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a24f875dec22b4a0e2748ede74a23b2769911f672a8cc8d90eb8f4d7bfbe156"

URI_x86_64_v2_firefox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firefox-140.11.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_firefox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firefox}"
SRC_URI[x86_64_v2_firefox.sha256sum] = "ce2d3aa201f5a0d87e30061f037a51904cf930bd08a866c97570e047b3f24443"

URI_aarch64_firefox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firefox-140.11.0-1.el10.aarch64.rpm;name=aarch64_firefox;unpack=0"
SRC_URI:append = " ${URI_aarch64_firefox}"
SRC_URI[aarch64_firefox.sha256sum] = "2f76ae4828d83a174cb0e8494641e1445a8ca3719d997004bca55d65e64ed62e"

RDEPENDS:firefox = " \
 almalinux-indexhtml \
 alsa-lib \
 atk \
 bash \
 cairo \
 cairo-gobject \
 dbus-libs \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libX11 \
 libX11-xcb \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXrandr \
 libXrender \
 libffi \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 libxcb \
 mozilla-filesystem \
 nspr \
 nss \
 nss-util \
 p11-kit-trust \
 pango \
 pciutils-libs \
 zlib-ng-compat \
 "
