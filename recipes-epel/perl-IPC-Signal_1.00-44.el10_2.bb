# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IPC-Signal"
PV = "1.00"
PR = "44.el10_2"
PACKAGES = " \
 perl-IPC-Signal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IPC-Signal-1.00-44.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d968d229b17f4b4dd4fe7fd2ee26076cb58de2fe5de5dc1ee4bc9723b3e8b18"

URI_x86_64_v2_perl-IPC-Signal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IPC-Signal-1.00-44.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IPC-Signal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IPC-Signal}"
SRC_URI[x86_64_v2_perl-IPC-Signal.sha256sum] = "76556fea7e56d91585b96be3eeb7305565fdb222da17d26592e1af8aa24875d4"

URI_aarch64_perl-IPC-Signal = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IPC-Signal-1.00-44.el10_2.noarch.rpm;name=aarch64_perl-IPC-Signal;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IPC-Signal}"
SRC_URI[aarch64_perl-IPC-Signal.sha256sum] = "8b14a103f54978da0c67444a5544d0fbf9b73f3c7e68122235087bd3279c4938"

RDEPENDS:perl-IPC-Signal = " \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
