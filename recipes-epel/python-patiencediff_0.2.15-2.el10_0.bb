# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-patiencediff"
PV = "0.2.15"
PR = "2.el10_0"
PACKAGES = " \
 python3-patiencediff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-patiencediff-0.2.15-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ea220c53ce5ff82a6e086b1e2f09d9a78597fc79b358c20037668604f4ecb64"

URI_x86_64_v2_python3-patiencediff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-patiencediff-0.2.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-patiencediff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-patiencediff}"
SRC_URI[x86_64_v2_python3-patiencediff.sha256sum] = "5dc744dc12042ee2a879acc331054d1aa3134aebc712713879248d70204fe07a"

URI_aarch64_python3-patiencediff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-patiencediff-0.2.15-2.el10_0.aarch64.rpm;name=aarch64_python3-patiencediff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-patiencediff}"
SRC_URI[aarch64_python3-patiencediff.sha256sum] = "296c371e73e54054fa08c7dcb8ddb4d20e75c93248eb2682a7680f638d802d07"

RDEPENDS:python3-patiencediff = " \
 glibc \
 python3 \
 "
