# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-davecgh-spew"
PV = "1.1.1"
PR = "17.el10_0"
PACKAGES = " \
 golang-github-davecgh-spew-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-davecgh-spew-1.1.1-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe24157cedc5500f76cf343857479640657ed51bc0c5c68cd680ca980112ba39"

URI_x86_64_v2_golang-github-davecgh-spew-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-davecgh-spew-devel-1.1.1-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-davecgh-spew-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-davecgh-spew-devel}"
SRC_URI[x86_64_v2_golang-github-davecgh-spew-devel.sha256sum] = "38ff48fd3cd40f9dc016352ea845d21ffc7466bff0c0917f2e0cd1ee2ac99730"

URI_aarch64_golang-github-davecgh-spew-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-davecgh-spew-devel-1.1.1-17.el10_0.noarch.rpm;name=aarch64_golang-github-davecgh-spew-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-davecgh-spew-devel}"
SRC_URI[aarch64_golang-github-davecgh-spew-devel.sha256sum] = "0ffb7ab3d9ad34b2b959f5251ed82e42e81a1eb8c3ae479981aa69ea0df2458e"

RDEPENDS:golang-github-davecgh-spew-devel = " \
 go-filesystem \
 "
