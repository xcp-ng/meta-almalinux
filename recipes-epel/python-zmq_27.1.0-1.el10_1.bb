# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-zmq"
PV = "27.1.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-pyzmq \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-zmq-27.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4c68ea0fc8c9e56dc07e1720d284a7764879c1baa733c4642326efda1c36cfd4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyzmq-27.1.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyzmq;unpack=0"
SRC_URI[x86_64_v2_python3-pyzmq.sha256sum] = "68c37c926db871f4cb142c1bf3e52e20ecafc35e80a421bedbef86ca10b603ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pyzmq-27.1.0-1.el10_1.aarch64.rpm;name=aarch64_python3-pyzmq;unpack=0"
SRC_URI[aarch64_python3-pyzmq.sha256sum] = "3ba8c5fa124d9329be34a92dc7c2949ffc94cff3d5f6a749342cd8ffd1a553ff"

RDEPENDS:python3-pyzmq = " \
 glibc \
 python3 \
 zeromq \
 "
