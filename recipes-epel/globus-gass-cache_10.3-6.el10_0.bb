# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gass-cache"
PV = "10.3"
PR = "6.el10_0"
PACKAGES = " \
 globus-gass-cache \
 globus-gass-cache-devel \
 globus-gass-cache-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gass-cache-10.3-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c9cd12841cbbef249e3819334e20922b17a772a332453cf9e2b4481aa5dbf4f"

URI_x86_64_v2_globus-gass-cache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-cache-10.3-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gass-cache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-cache}"
SRC_URI[x86_64_v2_globus-gass-cache.sha256sum] = "81d5830ae69410ef14cc2e3db9673654d8111e5da501e91f298ed096c55b3823"

URI_x86_64_v2_globus-gass-cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-cache-devel-10.3-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gass-cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-cache-devel}"
SRC_URI[x86_64_v2_globus-gass-cache-devel.sha256sum] = "6aeab18969821735e1f9294bafd5a93d7d4def8571b03053dc4de0e51b5c2425"

URI_x86_64_v2_globus-gass-cache-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-cache-doc-10.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gass-cache-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-cache-doc}"
SRC_URI[x86_64_v2_globus-gass-cache-doc.sha256sum] = "01c59e95c4bb11ec7c6ec9c5f508a3ec059508f2a67bb382d5dc36ad343deb35"

URI_aarch64_globus-gass-cache = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-cache-10.3-6.el10_0.aarch64.rpm;name=aarch64_globus-gass-cache;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-cache}"
SRC_URI[aarch64_globus-gass-cache.sha256sum] = "9b99fa76e284888eb414fdd7ee056e81677b9e7799979703c6488fbbf6ddb392"

URI_aarch64_globus-gass-cache-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-cache-devel-10.3-6.el10_0.aarch64.rpm;name=aarch64_globus-gass-cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-cache-devel}"
SRC_URI[aarch64_globus-gass-cache-devel.sha256sum] = "5814fa5c510286f73187805f5e0d4acf2362628e590b0463eb20e5c920150c56"

URI_aarch64_globus-gass-cache-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-cache-doc-10.3-6.el10_0.noarch.rpm;name=aarch64_globus-gass-cache-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-cache-doc}"
SRC_URI[aarch64_globus-gass-cache-doc.sha256sum] = "5c085a01a1ec54b3251dfadb7722e65b8b9970efee050d7f331acf47a966ad7a"

RDEPENDS:globus-gass-cache = " \
 glibc \
 globus-common \
 openssl-libs \
 "
RDEPENDS:globus-gass-cache-devel = " \
 globus-common-devel \
 globus-gass-cache \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gass-cache-doc = " \
 "
