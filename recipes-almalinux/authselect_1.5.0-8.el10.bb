# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "authselect"
PV = "1.5.0"
PR = "8.el10"
PACKAGES = " \
 authselect \
 authselect-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/authselect-1.5.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48f76e4539314d4616b9d9563769ac73a48668346427ab56338167f1a26e2c76"

URI_x86_64_v2_authselect = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/authselect-1.5.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_authselect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_authselect}"
SRC_URI[x86_64_v2_authselect.sha256sum] = "267319d3b3f834b684386531b0647d78f03eb10d759922a74d7d1d0906faeb4c"

URI_x86_64_v2_authselect-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/authselect-libs-1.5.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_authselect-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_authselect-libs}"
SRC_URI[x86_64_v2_authselect-libs.sha256sum] = "a5fd09a48d4f5deff61bd7cdbacfbe7201c97d44cc74c64a629ea9469d3682cb"

URI_aarch64_authselect = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/authselect-1.5.0-8.el10.aarch64.rpm;name=aarch64_authselect;unpack=0"
SRC_URI:append = " ${URI_aarch64_authselect}"
SRC_URI[aarch64_authselect.sha256sum] = "6a4e38a02e0f960c176b6f2a50805faa208cb305116782aff651f663baa99b9f"

URI_aarch64_authselect-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/authselect-libs-1.5.0-8.el10.aarch64.rpm;name=aarch64_authselect-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_authselect-libs}"
SRC_URI[aarch64_authselect-libs.sha256sum] = "2440c1604c9fad373b06d5445813d5fbc94a7bd05337cd022d49d6485ff880b3"

RDEPENDS:authselect = " \
 authselect-libs \
 bash \
 glibc \
 popt \
 "
RDEPENDS:authselect-libs = " \
 bash \
 glibc \
 libselinux \
 sed \
 virtual/coreutils \
 "
