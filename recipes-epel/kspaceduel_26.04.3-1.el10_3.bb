# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kspaceduel"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kspaceduel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kspaceduel-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eec280792f8fc0484fa7862525b93b8570701262e8c6f6f80241c79e9bec5064"

URI_x86_64_v2_kspaceduel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kspaceduel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kspaceduel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kspaceduel}"
SRC_URI[x86_64_v2_kspaceduel.sha256sum] = "6cf914144a76feafd11e8930aee35ca13409a1204c07a70202c4f3526e724e1f"

URI_aarch64_kspaceduel = "${EPEL_MIRROR}/aarch64/Packages/k/kspaceduel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kspaceduel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kspaceduel}"
SRC_URI[aarch64_kspaceduel.sha256sum] = "c7bf183bb4c43750bf0ceebaee6a8936ba964d78aae7a1e3a5582cb264cb27df"

RDEPENDS:kspaceduel = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
