# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "v-hacd"
PV = "4.1.0"
PR = "11.el10_0"
PACKAGES = " \
 v-hacd-devel \
 v-hacd-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/v-hacd-4.1.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51dba5c8daf85592cf4bf0277e640cb87c4ab5c68fa6b7fed25d14328f543c65"

URI_x86_64_v2_v-hacd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/v-hacd-devel-4.1.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_v-hacd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_v-hacd-devel}"
SRC_URI[x86_64_v2_v-hacd-devel.sha256sum] = "881077aedac77bf1b027729eb8092365b443b92f39a19304451d99dfdf1df29a"

URI_x86_64_v2_v-hacd-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/v-hacd-tools-4.1.0-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_v-hacd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_v-hacd-tools}"
SRC_URI[x86_64_v2_v-hacd-tools.sha256sum] = "e455a4fa9ba56c3150f32fa0fd0f265565d5261231af247949691009e9d1d4f4"

URI_aarch64_v-hacd-devel = "${EPEL_MIRROR}/aarch64/Packages/v/v-hacd-devel-4.1.0-11.el10_0.noarch.rpm;name=aarch64_v-hacd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_v-hacd-devel}"
SRC_URI[aarch64_v-hacd-devel.sha256sum] = "d7620fc6b987a76c60ffe3aee98c708669e23538cc7d2b4f5b7ee56ba97ee0de"

URI_aarch64_v-hacd-tools = "${EPEL_MIRROR}/aarch64/Packages/v/v-hacd-tools-4.1.0-11.el10_0.aarch64.rpm;name=aarch64_v-hacd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_v-hacd-tools}"
SRC_URI[aarch64_v-hacd-tools.sha256sum] = "69674d0d906be5a47bd070d30083d2c59ba0cab0f5c90e1072689fcfc2707d29"

RDEPENDS:v-hacd-devel = " \
 "
RDEPENDS:v-hacd-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 "
