# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cube"
PV = "4.9.1"
PR = "2.el10_2"
PACKAGES = " \
 cube \
 cube-devel \
 cube-doc \
 cube-guilib \
 cube-guilib-devel \
 cube-libs \
 cube-libs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cube-4.9.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b16c47c80692647befd0c43ab0f79826a8c230b9482c7ae3832339809625c9a6"

URI_x86_64_v2_cube = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-4.9.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube}"
SRC_URI[x86_64_v2_cube.sha256sum] = "2dadd172d2047a7b9d9dc98241ae27d3767b8da3ba071d863d81e6e034199a06"

URI_x86_64_v2_cube-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-devel-4.9.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-devel}"
SRC_URI[x86_64_v2_cube-devel.sha256sum] = "4d57bd1ede3912048e29fe95b3d50c4ba848e8c79c1b81262add861e64fe6e83"

URI_x86_64_v2_cube-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-doc-4.9.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_cube-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-doc}"
SRC_URI[x86_64_v2_cube-doc.sha256sum] = "87cbed84b6ae35703a6ae0ce79f8dd92629fa818d835bcf1b96419010ac6e77f"

URI_x86_64_v2_cube-guilib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-guilib-4.9.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-guilib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-guilib}"
SRC_URI[x86_64_v2_cube-guilib.sha256sum] = "38bfefe9ce7d0c0b3c71851b5001cadd1cd0dea9ac9f02b501ca213a058ba2a6"

URI_x86_64_v2_cube-guilib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-guilib-devel-4.9.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-guilib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-guilib-devel}"
SRC_URI[x86_64_v2_cube-guilib-devel.sha256sum] = "f413279c216c37e6a8b907464316e80d50a8d9c149d73b9dba29fe91935c1d53"

URI_x86_64_v2_cube-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-libs-4.9.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-libs}"
SRC_URI[x86_64_v2_cube-libs.sha256sum] = "5e386255a40f487f44850e33b7b5899ad88cf190064904131a49750009eec957"

URI_x86_64_v2_cube-libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-libs-devel-4.9.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-libs-devel}"
SRC_URI[x86_64_v2_cube-libs-devel.sha256sum] = "8afc8f24e8ee257a74f9b2b00ad9c7b74b2c2db9a03bbb6722fc143b80c7729c"

URI_aarch64_cube = "${EPEL_MIRROR}/aarch64/Packages/c/cube-4.9.1-2.el10_2.aarch64.rpm;name=aarch64_cube;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube}"
SRC_URI[aarch64_cube.sha256sum] = "f75768d9e75a74498bf109054cb83b3baf5ddc95774525a59cc7420b3da56189"

URI_aarch64_cube-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cube-devel-4.9.1-2.el10_2.aarch64.rpm;name=aarch64_cube-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-devel}"
SRC_URI[aarch64_cube-devel.sha256sum] = "3bf246a345162addd881c53d7c634bdece435665a1ada4a214fce78990f9b6da"

URI_aarch64_cube-doc = "${EPEL_MIRROR}/aarch64/Packages/c/cube-doc-4.9.1-2.el10_2.noarch.rpm;name=aarch64_cube-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-doc}"
SRC_URI[aarch64_cube-doc.sha256sum] = "ca5813b3c8085f7fe7090c3a8cddaa92dd6d3d8a0d8e5d94bc41a113f86a212d"

URI_aarch64_cube-guilib = "${EPEL_MIRROR}/aarch64/Packages/c/cube-guilib-4.9.1-2.el10_2.aarch64.rpm;name=aarch64_cube-guilib;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-guilib}"
SRC_URI[aarch64_cube-guilib.sha256sum] = "8e8c8e149d99f26ad2584a7c738f9ab7444da4e1a26ffab348da67a667648fec"

URI_aarch64_cube-guilib-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cube-guilib-devel-4.9.1-2.el10_2.aarch64.rpm;name=aarch64_cube-guilib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-guilib-devel}"
SRC_URI[aarch64_cube-guilib-devel.sha256sum] = "3cc55e862558dc184572049a542fa58a52dfc545efb696ba59a0a5315948a516"

URI_aarch64_cube-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cube-libs-4.9.1-2.el10_2.aarch64.rpm;name=aarch64_cube-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-libs}"
SRC_URI[aarch64_cube-libs.sha256sum] = "4acf5441df3b518f12f439489ee88daaa0e1746f9cf82be28a7fd3354b4fc24d"

URI_aarch64_cube-libs-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cube-libs-devel-4.9.1-2.el10_2.aarch64.rpm;name=aarch64_cube-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-libs-devel}"
SRC_URI[aarch64_cube-libs-devel.sha256sum] = "e7fe473bd77c152d35de3b3a739d7564ef47ed4923ba27700283b7cdb3e52b18"

RDEPENDS:cube = " \
 bash \
 cube-guilib \
 cube-libs \
 dbus-libs \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:cube-devel = " \
 cube-guilib-devel \
 cube-libs-devel \
 "
RDEPENDS:cube-doc = " \
 "
RDEPENDS:cube-guilib = " \
 cube-libs \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:cube-guilib-devel = " \
 cmake-filesystem \
 cube-guilib \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:cube-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:cube-libs-devel = " \
 cmake-filesystem \
 cube-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
