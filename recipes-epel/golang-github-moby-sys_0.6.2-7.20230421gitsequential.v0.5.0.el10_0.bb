# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-moby-sys"
PV = "0.6.2"
PR = "7.20230421gitsequential.v0.5.0.el10_0"
PACKAGES = " \
 golang-github-moby-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-moby-sys-0.6.2-7.20230421gitsequential.v0.5.0.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e731f451dfcbbb1119c2ac2940e38e601c2bdea021d240c869e162db8d468f9"

URI_aarch64_golang-github-moby-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-moby-sys-devel-0.6.2-7.20230421gitsequential.v0.5.0.el10_0.noarch.rpm;name=aarch64_golang-github-moby-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-moby-sys-devel}"
SRC_URI[aarch64_golang-github-moby-sys-devel.sha256sum] = "9fc77828b33117320d273e47032d6b4ec7ebfd56eca7ee89a50228e4dd7dcf9f"

RDEPENDS:golang-github-moby-sys-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
