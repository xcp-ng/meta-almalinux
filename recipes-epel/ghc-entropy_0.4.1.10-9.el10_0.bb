# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-entropy"
PV = "0.4.1.10"
PR = "9.el10_0"
PACKAGES = " \
 ghc-entropy \
 ghc-entropy-devel \
 ghc-entropy-doc \
 ghc-entropy-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-entropy-0.4.1.10-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65a6fd25fb416552dd9ddd3931e18f5ff7797b810f4b1fcd1919ee99856394a6"

URI_x86_64_v2_ghc-entropy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-entropy-0.4.1.10-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-entropy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-entropy}"
SRC_URI[x86_64_v2_ghc-entropy.sha256sum] = "88861cf8f04fe09a8f568673b28a1d921a6c7593111db56d4728205fa43a5815"

URI_x86_64_v2_ghc-entropy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-entropy-devel-0.4.1.10-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-entropy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-entropy-devel}"
SRC_URI[x86_64_v2_ghc-entropy-devel.sha256sum] = "210687f7d897ac25f11a9557fc774fcfaabbbf7c57c0677048af22307ecc5ca3"

URI_x86_64_v2_ghc-entropy-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-entropy-doc-0.4.1.10-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-entropy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-entropy-doc}"
SRC_URI[x86_64_v2_ghc-entropy-doc.sha256sum] = "581ce47c19d79aa69c1d6314c729b7a89b22fd45ac081dd8ea7b25b92eae8bba"

URI_x86_64_v2_ghc-entropy-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-entropy-prof-0.4.1.10-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-entropy-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-entropy-prof}"
SRC_URI[x86_64_v2_ghc-entropy-prof.sha256sum] = "cf7682f9a3d29fe740d2d1750bfd0da3a26d91b9565d897a562fa1bbda921c0c"

URI_aarch64_ghc-entropy = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-entropy-0.4.1.10-9.el10_0.aarch64.rpm;name=aarch64_ghc-entropy;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-entropy}"
SRC_URI[aarch64_ghc-entropy.sha256sum] = "cabbb143efdf1d5267b1be5b022efb18ab305e18b7db8a846b697756347c65b6"

URI_aarch64_ghc-entropy-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-entropy-devel-0.4.1.10-9.el10_0.aarch64.rpm;name=aarch64_ghc-entropy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-entropy-devel}"
SRC_URI[aarch64_ghc-entropy-devel.sha256sum] = "cf2f286adcdef1d9a2dfd1159f2987ec90ab18c1e39b5d49d1f36aa1299d372d"

URI_aarch64_ghc-entropy-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-entropy-doc-0.4.1.10-9.el10_0.noarch.rpm;name=aarch64_ghc-entropy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-entropy-doc}"
SRC_URI[aarch64_ghc-entropy-doc.sha256sum] = "31d12960fc5eeccee3497ee076ff6f2ee2d423716bb5a0c4500bac73a4bf8210"

URI_aarch64_ghc-entropy-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-entropy-prof-0.4.1.10-9.el10_0.aarch64.rpm;name=aarch64_ghc-entropy-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-entropy-prof}"
SRC_URI[aarch64_ghc-entropy-prof.sha256sum] = "434497bb01d4221cd6ce1c3e19680cc4efe29ce38d336bf032e0ecb0ee0c2c3b"

RDEPENDS:ghc-entropy = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-entropy-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-entropy \
 ghc-unix-devel \
 "
RDEPENDS:ghc-entropy-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-entropy-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-entropy-devel \
 ghc-unix-prof \
 "
