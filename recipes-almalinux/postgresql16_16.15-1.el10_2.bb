# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql16"
PV = "16.15"
PR = "1.el10_2"
PACKAGES = " \
 postgresql \
 postgresql-contrib \
 postgresql-docs \
 postgresql-plperl \
 postgresql-plpython3 \
 postgresql-pltcl \
 postgresql-private-devel \
 postgresql-private-libs \
 postgresql-server \
 postgresql-server-devel \
 postgresql-static \
 postgresql-test \
 postgresql-test-rpm-macros \
 postgresql-upgrade \
 postgresql-upgrade-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql16-16.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d99db604910700f95d47398f780bcfdf1070a29c20820b20163dffc702abcf7e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-16.15-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql;unpack=0"
SRC_URI[x86_64_v2_postgresql.sha256sum] = "a861b0930d6ba870279c53e95ece6c8788e4e8372dc9fa17bf07ea504eedf812"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-contrib-16.15-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-contrib;unpack=0"
SRC_URI[x86_64_v2_postgresql-contrib.sha256sum] = "3c361ed879d09f9ce1ec75a8892dfe098094a9b91acd2c2bfd29d35cbb38b4f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-docs-16.15-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-docs;unpack=0"
SRC_URI[x86_64_v2_postgresql-docs.sha256sum] = "bb3fd7da78d9dff8f6d3b2aa87675ae0a8695e1cebb8d2d2991280d41e923c66"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-plperl-16.15-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-plperl;unpack=0"
SRC_URI[x86_64_v2_postgresql-plperl.sha256sum] = "3c2250200e39ede7bf24f816d560b5b9655a987f1cb0afa6112ff788bcdff68f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-plpython3-16.15-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-plpython3;unpack=0"
SRC_URI[x86_64_v2_postgresql-plpython3.sha256sum] = "91f79be7f9e1cf396e520f6da55633a730d446edb7e3bd1079fc6ecf02ffe85e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-pltcl-16.15-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-pltcl;unpack=0"
SRC_URI[x86_64_v2_postgresql-pltcl.sha256sum] = "1326dbc470d5db068a3f3971fa369b0972fd3d3db39a73af0e067b39851a2844"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-private-devel-16.15-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-private-devel;unpack=0"
SRC_URI[x86_64_v2_postgresql-private-devel.sha256sum] = "1e21e1e2d97f85778794ebac2dcb7b92fc5023b4a582c9987d250ffe48b0cd5a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-private-libs-16.15-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-private-libs;unpack=0"
SRC_URI[x86_64_v2_postgresql-private-libs.sha256sum] = "4410cdc7b8c78075b622f71e7645c605dfa919993dc3cb3d4c5149c9af9b142d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-server-16.15-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-server;unpack=0"
SRC_URI[x86_64_v2_postgresql-server.sha256sum] = "6a41a10f457bf92a573ecc5aaaa9e204a728eadcf465c1bb2d4e066b8cc5ae71"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-server-devel-16.15-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-server-devel;unpack=0"
SRC_URI[x86_64_v2_postgresql-server-devel.sha256sum] = "a55c9718d237cf1349f0d206b305fbfe8e16caab680d4503ed87c277558567cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-static-16.15-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-static;unpack=0"
SRC_URI[x86_64_v2_postgresql-static.sha256sum] = "fc9b28c8b908ba8dd07f68246a30471595e091178a33f1304fad4c9744298c43"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-test-16.15-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-test;unpack=0"
SRC_URI[x86_64_v2_postgresql-test.sha256sum] = "807f674bff342bfff26675fd2c26add9902d17f82a3bc47a017d494f3844e8e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/postgresql-test-rpm-macros-16.15-1.el10_2.noarch.rpm;name=x86_64_v2_postgresql-test-rpm-macros;unpack=0"
SRC_URI[x86_64_v2_postgresql-test-rpm-macros.sha256sum] = "49bbad5117088919b1af51fbcff00683a55c6c9606a6c7c2c8c0e25341560b44"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-upgrade-16.15-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-upgrade;unpack=0"
SRC_URI[x86_64_v2_postgresql-upgrade.sha256sum] = "fa01aeded72e0bcec02ff789c3fd01e4169c7f1d81c3275a98c5551fea820b4f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-upgrade-devel-16.15-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-upgrade-devel;unpack=0"
SRC_URI[x86_64_v2_postgresql-upgrade-devel.sha256sum] = "ac252adbcd0a673b833140236550e81b856b04a7b2df703c156c36a6ba56c31b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-16.15-1.el10_2.aarch64.rpm;name=aarch64_postgresql;unpack=0"
SRC_URI[aarch64_postgresql.sha256sum] = "ccd5ea935adc75796b888c834e557f35e8b464c6fcaa5ee9834de457cc1e8744"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-contrib-16.15-1.el10_2.aarch64.rpm;name=aarch64_postgresql-contrib;unpack=0"
SRC_URI[aarch64_postgresql-contrib.sha256sum] = "a505c2d2644b0be48efd2d1cf688dea6dc54b56f7b9bd938323b9419e0422951"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-docs-16.15-1.el10_2.aarch64.rpm;name=aarch64_postgresql-docs;unpack=0"
SRC_URI[aarch64_postgresql-docs.sha256sum] = "c0f7d1ac0a14f01b6db10752ad89950c8e82e24992cd1e1596bba3b9c1c20db7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-plperl-16.15-1.el10_2.aarch64.rpm;name=aarch64_postgresql-plperl;unpack=0"
SRC_URI[aarch64_postgresql-plperl.sha256sum] = "17cffb2b5ff89c03aa6dea534385eb91b206f578ccace1f080d4c2e4d1eb9d46"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-plpython3-16.15-1.el10_2.aarch64.rpm;name=aarch64_postgresql-plpython3;unpack=0"
SRC_URI[aarch64_postgresql-plpython3.sha256sum] = "e0a8b095b518d7077795d3241be0e03b820f64706feef07dd3697309aac528cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-pltcl-16.15-1.el10_2.aarch64.rpm;name=aarch64_postgresql-pltcl;unpack=0"
SRC_URI[aarch64_postgresql-pltcl.sha256sum] = "36964d1d7600f7086b98a7ddf48074fcff960dadc4cd08d8d4b72c46bb982329"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-private-devel-16.15-1.el10_2.aarch64.rpm;name=aarch64_postgresql-private-devel;unpack=0"
SRC_URI[aarch64_postgresql-private-devel.sha256sum] = "3992b9543cf61bd8193edbf29ce87f6737a72332ffbf492c0faac37dd4a0ce9f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-private-libs-16.15-1.el10_2.aarch64.rpm;name=aarch64_postgresql-private-libs;unpack=0"
SRC_URI[aarch64_postgresql-private-libs.sha256sum] = "8f85d6617672ed928d9ca33b03a6ade831940084c15dc124896329bad9091f48"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-server-16.15-1.el10_2.aarch64.rpm;name=aarch64_postgresql-server;unpack=0"
SRC_URI[aarch64_postgresql-server.sha256sum] = "e25d89f0e25bb0c32a4c2ee661e3a41406373804efe5248fe16efe7fb054efa4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-server-devel-16.15-1.el10_2.aarch64.rpm;name=aarch64_postgresql-server-devel;unpack=0"
SRC_URI[aarch64_postgresql-server-devel.sha256sum] = "849cb5a277a1b57f332ff72de1f3911dfb640cf3fdffee1a43bf5344485301ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-static-16.15-1.el10_2.aarch64.rpm;name=aarch64_postgresql-static;unpack=0"
SRC_URI[aarch64_postgresql-static.sha256sum] = "567a542098fcb160af6e106092fca3f7fa5c151a548c152d5994d0dbf52d3920"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-test-16.15-1.el10_2.aarch64.rpm;name=aarch64_postgresql-test;unpack=0"
SRC_URI[aarch64_postgresql-test.sha256sum] = "5a4849edb92c3f83d44e6c17b628ab44201205a88ff7154edcdf4c34a6034b1b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/postgresql-test-rpm-macros-16.15-1.el10_2.noarch.rpm;name=aarch64_postgresql-test-rpm-macros;unpack=0"
SRC_URI[aarch64_postgresql-test-rpm-macros.sha256sum] = "49bbad5117088919b1af51fbcff00683a55c6c9606a6c7c2c8c0e25341560b44"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-upgrade-16.15-1.el10_2.aarch64.rpm;name=aarch64_postgresql-upgrade;unpack=0"
SRC_URI[aarch64_postgresql-upgrade.sha256sum] = "508633c21872d4fce187f07fa914a11081dc1616806ec219eaf20c2456efa686"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-upgrade-devel-16.15-1.el10_2.aarch64.rpm;name=aarch64_postgresql-upgrade-devel;unpack=0"
SRC_URI[aarch64_postgresql-upgrade-devel.sha256sum] = "932b5b74d3d3cda7a32bcc6b997b5c80150b6480053f67afd11e20ce90ceade4"

RDEPENDS:postgresql = " \
 glibc \
 libzstd \
 lz4-libs \
 openssl-libs \
 postgresql-private-libs \
 readline \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-contrib = " \
 glibc \
 libselinux \
 libxml2 \
 libxslt \
 libzstd \
 lz4-libs \
 openssl-libs \
 perl-libs \
 postgresql \
 postgresql-private-libs \
 python3-libs \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-docs = " \
 glibc \
 postgresql \
 "
RDEPENDS:postgresql-plperl = " \
 glibc \
 perl-libs \
 postgresql-server \
 "
RDEPENDS:postgresql-plpython3 = " \
 glibc \
 postgresql-server \
 python3-libs \
 "
RDEPENDS:postgresql-pltcl = " \
 glibc \
 postgresql-server \
 tcl \
 "
RDEPENDS:postgresql-private-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 postgresql-private-libs \
 "
RDEPENDS:postgresql-private-libs = " \
 glibc \
 krb5-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:postgresql-server = " \
 bash \
 glibc \
 krb5-libs \
 libicu \
 libxml2 \
 libzstd \
 lz4-libs \
 openldap \
 openssl-libs \
 pam-libs \
 postgresql \
 postgresql-private-libs \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-server-devel = " \
 bash \
 glibc \
 krb5-devel \
 libicu-devel \
 postgresql-private-devel \
 postgresql-private-libs \
 "
RDEPENDS:postgresql-static = " \
 postgresql-server-devel \
 "
RDEPENDS:postgresql-test = " \
 bash \
 glibc \
 postgresql-contrib \
 postgresql-server \
 postgresql-server-devel \
 "
RDEPENDS:postgresql-test-rpm-macros = " \
 postgresql-server \
 "
RDEPENDS:postgresql-upgrade = " \
 glibc \
 krb5-libs \
 libicu \
 libselinux \
 libxml2 \
 libxslt \
 openldap \
 openssl-libs \
 pam-libs \
 perl-libs \
 postgresql-private-libs \
 postgresql-server \
 python3-libs \
 tcl \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-upgrade-devel = " \
 bash \
 glibc \
 postgresql-upgrade \
 "
