# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-iso8601"
PV = "0.4.2"
PR = "10.el10_3"
PACKAGES = " \
 rust-iso8601+default-devel \
 rust-iso8601+std-devel \
 rust-iso8601-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-iso8601-0.4.2-10.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32d5edee0a9b24a121e27f51d0770ed2c7469882104265f40066615261361d70"

URI_x86_64_v2_rust-iso8601+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iso8601+default-devel-0.4.2-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iso8601+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iso8601+default-devel}"
SRC_URI[x86_64_v2_rust-iso8601+default-devel.sha256sum] = "89001aed82d1b48e701e7a3f97a6bb2ba140eee4adac2bb95c49b0f307ea0372"

URI_x86_64_v2_rust-iso8601+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iso8601+std-devel-0.4.2-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iso8601+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iso8601+std-devel}"
SRC_URI[x86_64_v2_rust-iso8601+std-devel.sha256sum] = "a02f496d1a32a0f57c6b8ae392ba02cd080ce1a096533d5f57a3978b45ca1edf"

URI_x86_64_v2_rust-iso8601-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iso8601-devel-0.4.2-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iso8601-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iso8601-devel}"
SRC_URI[x86_64_v2_rust-iso8601-devel.sha256sum] = "b9b6dba157897028fb1950b64c0d41e8c7d333502570b92aa2dce5c134213e46"

URI_aarch64_rust-iso8601+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iso8601+default-devel-0.4.2-10.el10_3.noarch.rpm;name=aarch64_rust-iso8601+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iso8601+default-devel}"
SRC_URI[aarch64_rust-iso8601+default-devel.sha256sum] = "2440cee3384bd3e0fb959f3cb798287603263e9c65da112dcd84041dbce243b3"

URI_aarch64_rust-iso8601+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iso8601+std-devel-0.4.2-10.el10_3.noarch.rpm;name=aarch64_rust-iso8601+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iso8601+std-devel}"
SRC_URI[aarch64_rust-iso8601+std-devel.sha256sum] = "152bf175c6dea5ac173fc69bf1567b5f9906acb5245f4fc7e504c96534fc9e14"

URI_aarch64_rust-iso8601-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iso8601-devel-0.4.2-10.el10_3.noarch.rpm;name=aarch64_rust-iso8601-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iso8601-devel}"
SRC_URI[aarch64_rust-iso8601-devel.sha256sum] = "47f44eb80ae4dd16bae4fdefa894287455f606d6dfc155d6f87f17655bed4069"

RDEPENDS:rust-iso8601+default-devel = " \
 cargo \
 rust-iso8601+std-devel \
 rust-iso8601-devel \
 "
RDEPENDS:rust-iso8601+std-devel = " \
 cargo \
 rust-iso8601-devel \
 rust-nom7+std-devel \
 "
RDEPENDS:rust-iso8601-devel = " \
 cargo \
 rust-nom7-devel \
 "
