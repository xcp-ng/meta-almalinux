# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-wayland"
PV = "1.1.21"
PR = "1.el10_1"
PACKAGES = " \
 egl-wayland \
 egl-wayland-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/egl-wayland-1.1.21-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f33ba8aa1b198cf3e8151b643d7f9f8785e7a4398019c37bd9916f62fc817fb0"

URI_x86_64_v2_egl-wayland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-wayland-1.1.21-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-wayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_egl-wayland}"
SRC_URI[x86_64_v2_egl-wayland.sha256sum] = "d56183a6c2a2f794b581fe28834cceed7adc9b9cdfde864a4f998e0c8ed2564f"

URI_x86_64_v2_egl-wayland-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-wayland-devel-1.1.21-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-wayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_egl-wayland-devel}"
SRC_URI[x86_64_v2_egl-wayland-devel.sha256sum] = "eadb370166c55f1298caeae1013e4aaab417023600b0f5bf17c3c1c983ba45d7"

URI_aarch64_egl-wayland = "${EPEL_MIRROR}/aarch64/Packages/e/egl-wayland-1.1.21-1.el10_1.aarch64.rpm;name=aarch64_egl-wayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-wayland}"
SRC_URI[aarch64_egl-wayland.sha256sum] = "adafd8097b36692e1e3ff00e533f03bf9977e3eac3f4be1626c4c060f3e99b2e"

URI_aarch64_egl-wayland-devel = "${EPEL_MIRROR}/aarch64/Packages/e/egl-wayland-devel-1.1.21-1.el10_1.aarch64.rpm;name=aarch64_egl-wayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-wayland-devel}"
SRC_URI[aarch64_egl-wayland-devel.sha256sum] = "b4f8b993f01b924b99fa1420390f4bb1d8c7a8bdc3b012533b875982d573e0a4"

RDEPENDS:egl-wayland = " \
 glibc \
 libdrm \
 libglvnd-egl \
 libwayland-client \
 libwayland-server \
 "
RDEPENDS:egl-wayland-devel = " \
 egl-wayland \
 eglexternalplatform-devel \
 pkgconf-pkg-config \
 "
