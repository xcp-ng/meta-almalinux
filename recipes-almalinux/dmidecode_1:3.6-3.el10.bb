# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dmidecode"
PE = "1"
PV = "3.6"
PR = "3.el10"
PACKAGES = " \
 dmidecode \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dmidecode-3.6-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4ef477130ca6716af8e715ebf51bd560135b78d225648a2dac60321c8e505a5"

URI_x86_64_v2_dmidecode = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dmidecode-3.6-3.el10.x86_64_v2.rpm;name=x86_64_v2_dmidecode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dmidecode}"
SRC_URI[x86_64_v2_dmidecode.sha256sum] = "b990ba5a720efd12acea0b76a0853a61c91ea10a52e6f2eb6fa349d37a869d32"

URI_aarch64_dmidecode = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dmidecode-3.6-3.el10.aarch64.rpm;name=aarch64_dmidecode;unpack=0"
SRC_URI:append = " ${URI_aarch64_dmidecode}"
SRC_URI[aarch64_dmidecode.sha256sum] = "392c0a0a06f5271eb149de70ad4e6d37fe83e59c3a6bddcfa460b83ce804bfae"

RDEPENDS:dmidecode = " \
 glibc \
 "
