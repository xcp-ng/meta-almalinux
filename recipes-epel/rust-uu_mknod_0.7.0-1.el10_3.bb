# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_mknod"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_mknod+default-devel \
 rust-uu_mknod+selinux-devel \
 rust-uu_mknod+smack-devel \
 rust-uu_mknod-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_mknod-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80ac7928dbdebcf684b31b90f8555450e02e0791c414b58cd1783b858ab4dfc2"

URI_x86_64_v2_rust-uu_mknod+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_mknod+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_mknod+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_mknod+default-devel}"
SRC_URI[x86_64_v2_rust-uu_mknod+default-devel.sha256sum] = "48d80c3f3c9355a0583802d3f31a94d149199c190f4a02735e21f26944eba53f"

URI_x86_64_v2_rust-uu_mknod+selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_mknod+selinux-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_mknod+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_mknod+selinux-devel}"
SRC_URI[x86_64_v2_rust-uu_mknod+selinux-devel.sha256sum] = "87510d510c253d8c66544ff28df308268a50928c14a9631a22a0aadcf0c3dd4b"

URI_x86_64_v2_rust-uu_mknod+smack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_mknod+smack-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_mknod+smack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_mknod+smack-devel}"
SRC_URI[x86_64_v2_rust-uu_mknod+smack-devel.sha256sum] = "61075cdf2b1f6c5952bc83db169a1889058331e9a9a4d56692dce91209a5a7ed"

URI_x86_64_v2_rust-uu_mknod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_mknod-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_mknod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_mknod-devel}"
SRC_URI[x86_64_v2_rust-uu_mknod-devel.sha256sum] = "9493b928b6c56485733191c370e30f6004a96462aa19ed9a1f4a828337a3757c"

URI_aarch64_rust-uu_mknod+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_mknod+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_mknod+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_mknod+default-devel}"
SRC_URI[aarch64_rust-uu_mknod+default-devel.sha256sum] = "69f13d1e1f12b15fb0824ae6a41cbf4ee060d1f6f5036ffbe3b1349b811a4fec"

URI_aarch64_rust-uu_mknod+selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_mknod+selinux-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_mknod+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_mknod+selinux-devel}"
SRC_URI[aarch64_rust-uu_mknod+selinux-devel.sha256sum] = "479da92bb0fd2f3d7a701e4655fc7eb1ee544b3e097548e044a66bf70ef239e2"

URI_aarch64_rust-uu_mknod+smack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_mknod+smack-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_mknod+smack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_mknod+smack-devel}"
SRC_URI[aarch64_rust-uu_mknod+smack-devel.sha256sum] = "b38df89bf3fadbb8e2666e219d3db72c8c4686bf126895044ac18298a74d9313"

URI_aarch64_rust-uu_mknod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_mknod-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_mknod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_mknod-devel}"
SRC_URI[aarch64_rust-uu_mknod-devel.sha256sum] = "d8e29bcdf021ea901b9aa183a1bacca4c70eab00700b922077efc39d3227bac5"

RDEPENDS:rust-uu_mknod+default-devel = " \
 cargo \
 rust-uu_mknod-devel \
 "
RDEPENDS:rust-uu_mknod+selinux-devel = " \
 cargo \
 rust-uu_mknod-devel \
 rust-uucore+selinux-devel \
 "
RDEPENDS:rust-uu_mknod+smack-devel = " \
 cargo \
 rust-uu_mknod-devel \
 rust-uucore+smack-devel \
 "
RDEPENDS:rust-uu_mknod-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-nix0.30-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 rust-uucore+mode-devel \
 "
