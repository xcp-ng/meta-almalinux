# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-traits"
PV = "0.2.19"
PR = "2.el10_0"
PACKAGES = " \
 rust-num-traits+default-devel \
 rust-num-traits+i128-devel \
 rust-num-traits+libm-devel \
 rust-num-traits+std-devel \
 rust-num-traits-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-traits-0.2.19-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fe28c933e76385c0d36f923579e29130ad9abe1f799f1bade73fbb279333dda"

URI_x86_64_v2_rust-num-traits+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-traits+default-devel-0.2.19-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-traits+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-traits+default-devel}"
SRC_URI[x86_64_v2_rust-num-traits+default-devel.sha256sum] = "5a1d91f19319b5de947e9fad6293f18e3f61503c637655b99b4b27b3399662ec"

URI_x86_64_v2_rust-num-traits+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-traits+i128-devel-0.2.19-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-traits+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-traits+i128-devel}"
SRC_URI[x86_64_v2_rust-num-traits+i128-devel.sha256sum] = "3c0452001a4545faf75f8d8f2fee5cac50ed5af59e61a75b65035ee7f440ce83"

URI_x86_64_v2_rust-num-traits+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-traits+libm-devel-0.2.19-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-traits+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-traits+libm-devel}"
SRC_URI[x86_64_v2_rust-num-traits+libm-devel.sha256sum] = "88ffcb8b8fa26425b62d8faad4336d639cb06127b6d68ba0d83a3dc83ca61239"

URI_x86_64_v2_rust-num-traits+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-traits+std-devel-0.2.19-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-traits+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-traits+std-devel}"
SRC_URI[x86_64_v2_rust-num-traits+std-devel.sha256sum] = "790ba333b0f99a07cfa9302f69a5e808e9f27c7dddeb63c1b821b950852c8ed4"

URI_x86_64_v2_rust-num-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-traits-devel-0.2.19-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-traits-devel}"
SRC_URI[x86_64_v2_rust-num-traits-devel.sha256sum] = "f49641602b5205cfc08b2cc35fb826726db26def244e19204d6b3d66ca754f45"

URI_aarch64_rust-num-traits+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-traits+default-devel-0.2.19-2.el10_0.noarch.rpm;name=aarch64_rust-num-traits+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-traits+default-devel}"
SRC_URI[aarch64_rust-num-traits+default-devel.sha256sum] = "8a942bf6cb224944cbb6c6b83a5617a495fa79859210a7b7af9f496dfe3c246c"

URI_aarch64_rust-num-traits+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-traits+i128-devel-0.2.19-2.el10_0.noarch.rpm;name=aarch64_rust-num-traits+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-traits+i128-devel}"
SRC_URI[aarch64_rust-num-traits+i128-devel.sha256sum] = "f8eda6eb9c06526bd626ef4996d066b9eaa0b69920313604ce4d978ef5533c8c"

URI_aarch64_rust-num-traits+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-traits+libm-devel-0.2.19-2.el10_0.noarch.rpm;name=aarch64_rust-num-traits+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-traits+libm-devel}"
SRC_URI[aarch64_rust-num-traits+libm-devel.sha256sum] = "3926f8f19264d1b291a24630f5438c6be8fd5324e1188482c695564ba041abdf"

URI_aarch64_rust-num-traits+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-traits+std-devel-0.2.19-2.el10_0.noarch.rpm;name=aarch64_rust-num-traits+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-traits+std-devel}"
SRC_URI[aarch64_rust-num-traits+std-devel.sha256sum] = "aa599a2ee5f5d1669a76fd5c55357af77f1a485a670eb69d70e2120ab99faba3"

URI_aarch64_rust-num-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-traits-devel-0.2.19-2.el10_0.noarch.rpm;name=aarch64_rust-num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-traits-devel}"
SRC_URI[aarch64_rust-num-traits-devel.sha256sum] = "569807af98c7f64334ae9238b0704e9c926f78fe43c5a838c0aa24c6a61c99d2"

RDEPENDS:rust-num-traits+default-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-num-traits-devel \
 "
RDEPENDS:rust-num-traits+i128-devel = " \
 cargo \
 rust-num-traits-devel \
 "
RDEPENDS:rust-num-traits+libm-devel = " \
 cargo \
 rust-libm+default-devel \
 rust-num-traits-devel \
 "
RDEPENDS:rust-num-traits+std-devel = " \
 cargo \
 rust-num-traits-devel \
 "
RDEPENDS:rust-num-traits-devel = " \
 cargo \
 rust \
 rust-autocfg+default-devel \
 "
