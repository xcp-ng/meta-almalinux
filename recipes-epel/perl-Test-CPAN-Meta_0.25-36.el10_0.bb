# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-CPAN-Meta"
PV = "0.25"
PR = "36.el10_0"
PACKAGES = " \
 perl-Test-CPAN-Meta \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-CPAN-Meta-0.25-36.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8b88b76685d03139a364010bda3b3fee2f110f7c0b5d34b5c63d2faba1467bf"

URI_x86_64_v2_perl-Test-CPAN-Meta = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-CPAN-Meta-0.25-36.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-CPAN-Meta;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-CPAN-Meta}"
SRC_URI[x86_64_v2_perl-Test-CPAN-Meta.sha256sum] = "069cd17f453b0b09a354027f5506121dbb2a6b8bb9025c77224c94b504dc80e6"

URI_aarch64_perl-Test-CPAN-Meta = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-CPAN-Meta-0.25-36.el10_0.noarch.rpm;name=aarch64_perl-Test-CPAN-Meta;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-CPAN-Meta}"
SRC_URI[aarch64_perl-Test-CPAN-Meta.sha256sum] = "4e73ebe7d3548b35ef5f81bcd0e271697945ad666f56005957ddf7fe9eb00e56"

RDEPENDS:perl-Test-CPAN-Meta = " \
 perl-CPAN-Meta \
 perl-Test-CPAN-Meta \
 perl-Test-Simple \
 perl-libs \
 perl-vars \
 "
