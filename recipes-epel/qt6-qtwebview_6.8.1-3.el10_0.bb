# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwebview"
PV = "6.8.1"
PR = "3.el10_0"
PACKAGES = " \
 qt6-qtwebview \
 qt6-qtwebview-devel \
 qt6-qtwebview-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtwebview-6.8.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acfe708bba63ffc31c171836b1ee19c7ed62db2e1d4137f400338d11496e8782"

URI_x86_64_v2_qt6-qtwebview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebview-6.8.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebview}"
SRC_URI[x86_64_v2_qt6-qtwebview.sha256sum] = "4f570af70305e463e8cd5ef388c5c1833bc815cff2530583cdaa523fcb170249"

URI_x86_64_v2_qt6-qtwebview-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebview-devel-6.8.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebview-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebview-devel}"
SRC_URI[x86_64_v2_qt6-qtwebview-devel.sha256sum] = "c1b5bc0a30818037a4bd05b7c0a3c235fa43953a77b9c3f06a06cdd7cc946a57"

URI_x86_64_v2_qt6-qtwebview-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebview-examples-6.8.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebview-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebview-examples}"
SRC_URI[x86_64_v2_qt6-qtwebview-examples.sha256sum] = "ebb3e9b3c0d7891f4e986ccd1ddb758fc5af707df8dd012822a15e55fe3d4a3a"

URI_aarch64_qt6-qtwebview = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebview-6.8.1-3.el10_0.aarch64.rpm;name=aarch64_qt6-qtwebview;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebview}"
SRC_URI[aarch64_qt6-qtwebview.sha256sum] = "ffbeebe0e508ecf47f9183f58c35149fae82c6b0c84a6e596b8bb76c6d388b52"

URI_aarch64_qt6-qtwebview-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebview-devel-6.8.1-3.el10_0.aarch64.rpm;name=aarch64_qt6-qtwebview-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebview-devel}"
SRC_URI[aarch64_qt6-qtwebview-devel.sha256sum] = "f37f1e952ac307a536d8ea219e113019e98b4f9affaef6f7efb44c0fe4e7c6dd"

URI_aarch64_qt6-qtwebview-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebview-examples-6.8.1-3.el10_0.aarch64.rpm;name=aarch64_qt6-qtwebview-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebview-examples}"
SRC_URI[aarch64_qt6-qtwebview-examples.sha256sum] = "0bfb47959b8b9ab1ac1cf0c61f0c09dc545850ed347b227fe6088c6939d8ec0e"

RDEPENDS:qt6-qtwebview = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 "
RDEPENDS:qt6-qtwebview-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtwebview \
 "
RDEPENDS:qt6-qtwebview-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebview \
 "
