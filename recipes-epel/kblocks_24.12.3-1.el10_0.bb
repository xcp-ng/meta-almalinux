# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kblocks"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kblocks \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kblocks-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7b264499bdce3ad946136ef2da28d21e6cf8593e0c7929e8f7cb10fa084667da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kblocks-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kblocks;unpack=0"
SRC_URI[x86_64_v2_kblocks.sha256sum] = "f81abe56eb141517087aeb99855413dce6fd6d74da2df8541e5731ec8342f07f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kblocks-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kblocks;unpack=0"
SRC_URI[aarch64_kblocks.sha256sum] = "681fe992309601b11c7edb5aa569b135dc4bf86596ebcb7484388a495dcab82c"

RDEPENDS:kblocks = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
