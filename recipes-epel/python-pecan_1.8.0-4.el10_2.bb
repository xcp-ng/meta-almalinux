# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pecan"
PV = "1.8.0"
PR = "4.el10_2"
PACKAGES = " \
 python3-pecan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pecan-1.8.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8588d510d622fb5b7ce8d2f00dd426fdf4ff29787db56f761b0c39f333675327"

URI_x86_64_v2_python3-pecan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pecan-1.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pecan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pecan}"
SRC_URI[x86_64_v2_python3-pecan.sha256sum] = "531650528252fa80506c0b98f17bceb81b9a6ecbcdc81f30eb881a3ad1152426"

URI_aarch64_python3-pecan = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pecan-1.8.0-4.el10_2.noarch.rpm;name=aarch64_python3-pecan;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pecan}"
SRC_URI[aarch64_python3-pecan.sha256sum] = "b2d0b39bf15aa1403a26ad782e521dac7e3e02c1604b51fcda07f372e3f87b0f"

RDEPENDS:python3-pecan = " \
 python3 \
 python3-mako \
 python3-setuptools \
 python3-webob \
 "
