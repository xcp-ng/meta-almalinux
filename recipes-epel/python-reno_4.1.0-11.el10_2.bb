# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-reno"
PV = "4.1.0"
PR = "11.el10_2"
PACKAGES = " \
 python-reno-doc \
 python3-reno \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-reno-4.1.0-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "699437f9722c1e1a4efbc1516d02ddc649db274740eb8e353a319fe005184c53"

URI_x86_64_v2_python-reno-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-reno-doc-4.1.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-reno-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-reno-doc}"
SRC_URI[x86_64_v2_python-reno-doc.sha256sum] = "ecd6f69ec0a56f46757cdca62abc6ed505c53045d5a84db1f3b10281055198c1"

URI_x86_64_v2_python3-reno = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-reno-4.1.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-reno;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-reno}"
SRC_URI[x86_64_v2_python3-reno.sha256sum] = "859cf623705974cc09521c44b91c4c4a9b543f0f325cbf93c5a88d9e9c687da7"

URI_aarch64_python-reno-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-reno-doc-4.1.0-11.el10_2.noarch.rpm;name=aarch64_python-reno-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-reno-doc}"
SRC_URI[aarch64_python-reno-doc.sha256sum] = "174668eb5590bd7e5769dadbe7d8ca5e954eb6072a9fbbecb7c90c8148c8c7f9"

URI_aarch64_python3-reno = "${EPEL_MIRROR}/aarch64/Packages/p/python3-reno-4.1.0-11.el10_2.noarch.rpm;name=aarch64_python3-reno;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-reno}"
SRC_URI[aarch64_python3-reno.sha256sum] = "0d2e042e338070a9b1b1a9d5554b6be2b60c128417351d05c9f8ac196684810d"

RDEPENDS:python-reno-doc = " \
 "
RDEPENDS:python3-reno = " \
 git-core \
 python3 \
 python3-dulwich \
 python3-packaging \
 python3-pbr \
 python3-pyyaml \
 "
