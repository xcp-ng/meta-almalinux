# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-adler2"
PV = "2.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-adler2+default-devel \
 rust-adler2+std-devel \
 rust-adler2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-adler2-2.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e83775ef6b8fc81ff4f97a464a783cfdf71c733e762b613917006e8d596a960"

URI_x86_64_v2_rust-adler2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adler2+default-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adler2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adler2+default-devel}"
SRC_URI[x86_64_v2_rust-adler2+default-devel.sha256sum] = "28156bfe7eb1d44316a34fe4bf63d39fba49ecc4be099ec69054a10dff8cac19"

URI_x86_64_v2_rust-adler2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adler2+std-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adler2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adler2+std-devel}"
SRC_URI[x86_64_v2_rust-adler2+std-devel.sha256sum] = "8e51edb77e8cff3d22d60907f0d3b966e5855d9f4ebd0c4469e4efb17ec4fe4f"

URI_x86_64_v2_rust-adler2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adler2-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adler2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adler2-devel}"
SRC_URI[x86_64_v2_rust-adler2-devel.sha256sum] = "bca934a11393820ceeb5b5dbcaf9d180ec2e247fe76d18ca6eb5a4986cf4a5b5"

URI_aarch64_rust-adler2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adler2+default-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-adler2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adler2+default-devel}"
SRC_URI[aarch64_rust-adler2+default-devel.sha256sum] = "567e75675f3a38d83790965f5b580b7199fb997cef9a0448fc684a17cbb91d10"

URI_aarch64_rust-adler2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adler2+std-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-adler2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adler2+std-devel}"
SRC_URI[aarch64_rust-adler2+std-devel.sha256sum] = "b0ba89f31963d03ef6ce52b7263ed40cc95d0155a660541e4f37a3a9bf317edf"

URI_aarch64_rust-adler2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adler2-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-adler2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adler2-devel}"
SRC_URI[aarch64_rust-adler2-devel.sha256sum] = "d1a91227a65618d4a2341b7ec7887cfc76129e6038158e700f96d3dc243b49fc"

RDEPENDS:rust-adler2+default-devel = " \
 cargo \
 rust-adler2+std-devel \
 rust-adler2-devel \
 "
RDEPENDS:rust-adler2+std-devel = " \
 cargo \
 rust-adler2-devel \
 "
RDEPENDS:rust-adler2-devel = " \
 cargo \
 "
