# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnuplot"
PV = "6.0.4"
PR = "2.el10_3"
PACKAGES = " \
 gnuplot \
 gnuplot-common \
 gnuplot-doc \
 gnuplot-latex \
 gnuplot-minimal \
 gnuplot-wx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnuplot-6.0.4-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ed5581c9638aba5e7d288a96231e106e2dac2a9c6cbc6743304e8d70fb6f478"

URI_x86_64_v2_gnuplot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuplot-6.0.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuplot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuplot}"
SRC_URI[x86_64_v2_gnuplot.sha256sum] = "5cbf3fb93d4be4dcb18ce7b831123381469eecc01cccb0953d4592d4ab3ce2ef"
RPROVIDES:gnuplot:x86_64_v2 = "virtual/gnuplot virtual/gnuplot_eq_6.0.4-2.el10_3.alma_altarch"

URI_x86_64_v2_gnuplot-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuplot-common-6.0.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuplot-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuplot-common}"
SRC_URI[x86_64_v2_gnuplot-common.sha256sum] = "d72ddb39534d1cd2425992cecba038bad7c176024cc935f350e1e29e4d828733"

URI_x86_64_v2_gnuplot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuplot-doc-6.0.4-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_gnuplot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuplot-doc}"
SRC_URI[x86_64_v2_gnuplot-doc.sha256sum] = "a41082fd6cce6846bc6ce7229fd825ea5e8d375f026bc7ee86e4436c266790b2"

URI_x86_64_v2_gnuplot-latex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuplot-latex-6.0.4-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_gnuplot-latex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuplot-latex}"
SRC_URI[x86_64_v2_gnuplot-latex.sha256sum] = "164e98e94f5c69249df285f3dd47eeb2847a77809a4e88b5eb18226cc2086ec3"

URI_x86_64_v2_gnuplot-minimal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuplot-minimal-6.0.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuplot-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuplot-minimal}"
SRC_URI[x86_64_v2_gnuplot-minimal.sha256sum] = "0498acb2c056ec4965b870b62b9383cc349b3115e46826bdc59c83884b531687"

URI_x86_64_v2_gnuplot-wx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuplot-wx-6.0.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuplot-wx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuplot-wx}"
SRC_URI[x86_64_v2_gnuplot-wx.sha256sum] = "cf0fa5de9f053f8dd7a0336b8c95dc3ca46083c34d22088c2379c1a9f90b573e"
RPROVIDES:gnuplot-wx:x86_64_v2 = "virtual/gnuplot virtual/gnuplot_eq_6.0.4-2.el10_3.alma_altarch"

URI_aarch64_gnuplot = "${EPEL_MIRROR}/aarch64/Packages/g/gnuplot-6.0.4-2.el10_3.aarch64.rpm;name=aarch64_gnuplot;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuplot}"
SRC_URI[aarch64_gnuplot.sha256sum] = "2c3ac69726fc60b32782e8ab3b8239905d3af27a57979bd5b0c21cb700257883"
RPROVIDES:gnuplot:aarch64 = "virtual/gnuplot virtual/gnuplot_eq_6.0.4-2.el10_3"

URI_aarch64_gnuplot-common = "${EPEL_MIRROR}/aarch64/Packages/g/gnuplot-common-6.0.4-2.el10_3.aarch64.rpm;name=aarch64_gnuplot-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuplot-common}"
SRC_URI[aarch64_gnuplot-common.sha256sum] = "c4ce091037d179dbf5963da765703846bc72cad7e6153172b063f23eaab7ec5f"

URI_aarch64_gnuplot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gnuplot-doc-6.0.4-2.el10_3.noarch.rpm;name=aarch64_gnuplot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuplot-doc}"
SRC_URI[aarch64_gnuplot-doc.sha256sum] = "fa48c558c5777337a990571dceeb7ee040d5d97bb1cd1a319ed4f04b5aff8d0d"

URI_aarch64_gnuplot-latex = "${EPEL_MIRROR}/aarch64/Packages/g/gnuplot-latex-6.0.4-2.el10_3.noarch.rpm;name=aarch64_gnuplot-latex;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuplot-latex}"
SRC_URI[aarch64_gnuplot-latex.sha256sum] = "fb2f007d9f6f5c6409d1030f52d25c79f3526435356982378a9a4aa13b548c49"

URI_aarch64_gnuplot-minimal = "${EPEL_MIRROR}/aarch64/Packages/g/gnuplot-minimal-6.0.4-2.el10_3.aarch64.rpm;name=aarch64_gnuplot-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuplot-minimal}"
SRC_URI[aarch64_gnuplot-minimal.sha256sum] = "2984fa4c821220e8c19ee31ae683e8531aacc33c27470c334f4c82268c8e0a14"

URI_aarch64_gnuplot-wx = "${EPEL_MIRROR}/aarch64/Packages/g/gnuplot-wx-6.0.4-2.el10_3.aarch64.rpm;name=aarch64_gnuplot-wx;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuplot-wx}"
SRC_URI[aarch64_gnuplot-wx.sha256sum] = "d0ded95e210db8b6e0a22d080736c825351e9350fe09d177f50ed17c25596f71"
RPROVIDES:gnuplot-wx:aarch64 = "virtual/gnuplot virtual/gnuplot_eq_6.0.4-2.el10_3"

RDEPENDS:gnuplot = " \
 alternatives \
 bash \
 cairo \
 dejavu-sans-fonts \
 gd \
 glib2 \
 glibc \
 gnuplot-common \
 libcerf \
 libgcc \
 libstdc++ \
 libwebp \
 lua-libs \
 openspecfun \
 pango \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:gnuplot-common = " \
 glibc \
 libX11 \
 "
RDEPENDS:gnuplot-doc = " \
 "
RDEPENDS:gnuplot-latex:x86_64_v2 = " \
 bash \
 tex-preview \
 texlive-cm-super \
 texlive-collection-latexrecommended \
 texlive-ec \
 texlive-ucs \
 virtual/gnuplot_eq_6.0.4-2.el10_3.alma_altarch \
"
RDEPENDS:gnuplot-latex:aarch64 = " \
 bash \
 tex-preview \
 texlive-cm-super \
 texlive-collection-latexrecommended \
 texlive-ec \
 texlive-ucs \
 virtual/gnuplot_eq_6.0.4-2.el10_3 \
"
RDEPENDS:gnuplot-minimal = " \
 alternatives \
 bash \
 cairo \
 gd \
 glib2 \
 glibc \
 gnuplot-common \
 libcerf \
 libgcc \
 libwebp \
 lua-libs \
 openspecfun \
 pango \
 "
RDEPENDS:gnuplot-wx = " \
 alternatives \
 bash \
 cairo \
 gd \
 glib2 \
 glibc \
 gnuplot-common \
 gtk3 \
 libcerf \
 libgcc \
 libstdc++ \
 libwebp \
 lua-libs \
 openspecfun \
 pango \
 wxBase \
 wxGTK \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/gnuplot rpm/virtual/gnuplot_eq_6.0.4-2.el10_3.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/gnuplot rpm/virtual/gnuplot_eq_6.0.4-2.el10_3"
