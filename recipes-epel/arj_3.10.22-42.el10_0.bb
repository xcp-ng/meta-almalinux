# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "arj"
PV = "3.10.22"
PR = "42.el10_0"
PACKAGES = " \
 arj \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/arj-3.10.22-42.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc6ba193a45cfd5c78401355c3a01098f3b02c8c233f647a178896fb3de6bb4c"

URI_x86_64_v2_arj = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arj-3.10.22-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_arj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_arj}"
SRC_URI[x86_64_v2_arj.sha256sum] = "3601ae0e6d394678d4e823638d22079b9a162531b3a395f963a42f0182ff5e7a"

URI_aarch64_arj = "${EPEL_MIRROR}/aarch64/Packages/a/arj-3.10.22-42.el10_0.aarch64.rpm;name=aarch64_arj;unpack=0"
SRC_URI:append = " ${URI_aarch64_arj}"
SRC_URI[aarch64_arj.sha256sum] = "079f3bc958fd102781d0e0deac12ef64dac54b80cea6c44ecaf82cc4d29aa9f3"

RDEPENDS:arj = " \
 bash \
 glibc \
 "
