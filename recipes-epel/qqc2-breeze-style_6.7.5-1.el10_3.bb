# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qqc2-breeze-style"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 qqc2-breeze-style \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qqc2-breeze-style-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7d0279671bfd88e0e5c1974f038c4c88acb73ea8bc4a49e4456694ebf659bb0e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qqc2-breeze-style-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qqc2-breeze-style;unpack=0"
SRC_URI[x86_64_v2_qqc2-breeze-style.sha256sum] = "75f7fb34af83bb6cf79c9ae42b2199e55b3747e6bf9bbe2a6758bee9ce860583"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qqc2-breeze-style-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_qqc2-breeze-style;unpack=0"
SRC_URI[aarch64_qqc2-breeze-style.sha256sum] = "e9c6aa4ed1364fca6c4ecccc265b2ae012f223aad1b4fab59445bdbe6a5fbd4a"

RDEPENDS:qqc2-breeze-style = " \
 cmake-filesystem \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-kquickcharts \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
