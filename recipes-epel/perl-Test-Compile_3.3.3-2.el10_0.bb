# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Compile"
PV = "3.3.3"
PR = "2.el10_0"
PACKAGES = " \
 perl-Test-Compile \
 perl-Test-Compile-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-Compile-3.3.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8509de5c5dfc242c481e792c84c9e14a5b3445076344ad1a50ef0810f81f9801"

URI_x86_64_v2_perl-Test-Compile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Compile-3.3.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Compile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Compile}"
SRC_URI[x86_64_v2_perl-Test-Compile.sha256sum] = "940a2d260986c96d6746d13ceb9db8760f69efaefee290074deffc146382c08b"

URI_x86_64_v2_perl-Test-Compile-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Compile-tests-3.3.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Compile-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Compile-tests}"
SRC_URI[x86_64_v2_perl-Test-Compile-tests.sha256sum] = "a31e0b0408648de3c3cb5c81a962a6d20f9fd33bd70d9bb0be61097e994ca14f"

URI_aarch64_perl-Test-Compile = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Compile-3.3.3-2.el10_0.noarch.rpm;name=aarch64_perl-Test-Compile;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Compile}"
SRC_URI[aarch64_perl-Test-Compile.sha256sum] = "3411ef6eab74a8e60c8c9ec2c16bcb8920674956f4ced462d1791081a27bb06c"

URI_aarch64_perl-Test-Compile-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Compile-tests-3.3.3-2.el10_0.noarch.rpm;name=aarch64_perl-Test-Compile-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Compile-tests}"
SRC_URI[aarch64_perl-Test-Compile-tests.sha256sum] = "e53a3241ae759b77fbeb449026da44494b65b86a5e37ded419f43606b78d3a46"

RDEPENDS:perl-Test-Compile = " \
 perl-Exporter \
 perl-File-Find \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-Test-Compile \
 perl-Test-Simple \
 perl-libs \
 perl-parent \
 perl-version \
 "
RDEPENDS:perl-Test-Compile-tests = " \
 bash \
 perl-PathTools \
 perl-Test-Compile \
 perl-Test-Exception \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Test-Warnings \
 perl-interpreter \
 perl-libs \
 "
