# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmix"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kmix \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmix-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "189668da35eae4d1b4998b9ba5ce16352f227ce9e986a0ced0663024919a1eb5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmix-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmix;unpack=0"
SRC_URI[x86_64_v2_kmix.sha256sum] = "47a8194d0b25b58d59f679613cd79d4de58e3a8b6cd37b53923096b6403d41b0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmix-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kmix;unpack=0"
SRC_URI[aarch64_kmix.sha256sum] = "43ccc7c7c6873b6ac24211c713aa3d702c06a0005efaeadc5a976ee6a17b5f1d"

RDEPENDS:kmix = " \
 alsa-lib \
 bash \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 libcanberra \
 libstdc++ \
 pulseaudio-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
