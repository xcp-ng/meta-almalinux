# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zune-jpeg"
PV = "0.4.21"
PR = "1.el10_0"
PACKAGES = " \
 rust-zune-jpeg+default-devel \
 rust-zune-jpeg+log-devel \
 rust-zune-jpeg+neon-devel \
 rust-zune-jpeg+std-devel \
 rust-zune-jpeg+x86-devel \
 rust-zune-jpeg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zune-jpeg-0.4.21-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a67d2890fa649e24049e7d63b3f732eaf89f0475812210143a1f1634e38a1f24"

URI_x86_64_v2_rust-zune-jpeg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+default-devel-0.4.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+default-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+default-devel.sha256sum] = "024ba93f03f97542a85e8715a790f6c6c68b14f08dce5a111665a36e7cdb63a1"

URI_x86_64_v2_rust-zune-jpeg+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+log-devel-0.4.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+log-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+log-devel.sha256sum] = "89c9a3fb7f110007709b9c0a218bd4bbb8da1a8ddb219e6f18f10cf40cd739b0"

URI_x86_64_v2_rust-zune-jpeg+neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+neon-devel-0.4.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+neon-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+neon-devel.sha256sum] = "eb3a973d3b98b344a727a959b245bf77cf7b3ef4004c3d920774872ffdf9dec5"

URI_x86_64_v2_rust-zune-jpeg+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+std-devel-0.4.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+std-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+std-devel.sha256sum] = "cc68e6299ea5850cb7e39822c07854ab0c5e91b84b674602753305f97ed5b487"

URI_x86_64_v2_rust-zune-jpeg+x86-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+x86-devel-0.4.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+x86-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+x86-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+x86-devel.sha256sum] = "64880ab088b457162cff795e7180dfff88c0e65790c5f3447501cb8ca2d9ffcc"

URI_x86_64_v2_rust-zune-jpeg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg-devel-0.4.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg-devel.sha256sum] = "064242c511f90bf825a00ae618dff7e7d71383c6234f3f5eec698787e799c531"

URI_aarch64_rust-zune-jpeg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+default-devel-0.4.21-1.el10_0.noarch.rpm;name=aarch64_rust-zune-jpeg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+default-devel}"
SRC_URI[aarch64_rust-zune-jpeg+default-devel.sha256sum] = "60ce9eb120db03e38b6b125d48b68292f4a2b48819335720efa2a24fad99361e"

URI_aarch64_rust-zune-jpeg+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+log-devel-0.4.21-1.el10_0.noarch.rpm;name=aarch64_rust-zune-jpeg+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+log-devel}"
SRC_URI[aarch64_rust-zune-jpeg+log-devel.sha256sum] = "da136eb15f33cd9314a7407f72b252ece5e1912f65e8a4449efe9714b834467d"

URI_aarch64_rust-zune-jpeg+neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+neon-devel-0.4.21-1.el10_0.noarch.rpm;name=aarch64_rust-zune-jpeg+neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+neon-devel}"
SRC_URI[aarch64_rust-zune-jpeg+neon-devel.sha256sum] = "848fd38af411775559870edc522e8d3234398f71e7a1f7112175e9526f24019e"

URI_aarch64_rust-zune-jpeg+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+std-devel-0.4.21-1.el10_0.noarch.rpm;name=aarch64_rust-zune-jpeg+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+std-devel}"
SRC_URI[aarch64_rust-zune-jpeg+std-devel.sha256sum] = "1f2305dfd4518d93de12999037c00563be9f19f01cee431bd57272701524e4fb"

URI_aarch64_rust-zune-jpeg+x86-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+x86-devel-0.4.21-1.el10_0.noarch.rpm;name=aarch64_rust-zune-jpeg+x86-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+x86-devel}"
SRC_URI[aarch64_rust-zune-jpeg+x86-devel.sha256sum] = "a26d2b211aadc67e7ce815c1993ced053a89b19c836e4b2b9fa8f85b5a67acd8"

URI_aarch64_rust-zune-jpeg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg-devel-0.4.21-1.el10_0.noarch.rpm;name=aarch64_rust-zune-jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg-devel}"
SRC_URI[aarch64_rust-zune-jpeg-devel.sha256sum] = "820fc81dcbc11acaf6d15198ac093149f0d20a896f09dfd46c508c3b2d037c71"

RDEPENDS:rust-zune-jpeg+default-devel = " \
 cargo \
 rust-zune-jpeg+neon-devel \
 rust-zune-jpeg+std-devel \
 rust-zune-jpeg+x86-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+log-devel = " \
 cargo \
 rust-zune-core+log-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+neon-devel = " \
 cargo \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+std-devel = " \
 cargo \
 rust-zune-core+std-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+x86-devel = " \
 cargo \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg-devel = " \
 cargo \
 rust-zune-core+default-devel \
 "
