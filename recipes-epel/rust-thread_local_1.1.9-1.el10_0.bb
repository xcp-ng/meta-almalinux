# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thread_local"
PV = "1.1.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-thread_local+default-devel \
 rust-thread_local+nightly-devel \
 rust-thread_local-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thread_local-1.1.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d192bfae7819f4e9e8e0395815197324979e9e0bfbf2661470d69b4aa57617ca"

URI_x86_64_v2_rust-thread_local+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread_local+default-devel-1.1.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread_local+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread_local+default-devel}"
SRC_URI[x86_64_v2_rust-thread_local+default-devel.sha256sum] = "4fc69ce01e926604ed88051c7c2fae4425f7c13b9151cebd961d2ca06bba2673"

URI_x86_64_v2_rust-thread_local+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread_local+nightly-devel-1.1.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread_local+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread_local+nightly-devel}"
SRC_URI[x86_64_v2_rust-thread_local+nightly-devel.sha256sum] = "050a36856b565baf4a0534ac8379c0d381f472fbfea9c1428535fa1e206a86b7"

URI_x86_64_v2_rust-thread_local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread_local-devel-1.1.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread_local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread_local-devel}"
SRC_URI[x86_64_v2_rust-thread_local-devel.sha256sum] = "8137ff2b0c951c64b73dbe44dfb615167a848b49afd46ced31d643f712486c86"

URI_aarch64_rust-thread_local+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread_local+default-devel-1.1.9-1.el10_0.noarch.rpm;name=aarch64_rust-thread_local+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread_local+default-devel}"
SRC_URI[aarch64_rust-thread_local+default-devel.sha256sum] = "6dcf704f7f1b239d89fce01197cf152a0585766ae9f1e1f09ea4b7d92dda5c23"

URI_aarch64_rust-thread_local+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread_local+nightly-devel-1.1.9-1.el10_0.noarch.rpm;name=aarch64_rust-thread_local+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread_local+nightly-devel}"
SRC_URI[aarch64_rust-thread_local+nightly-devel.sha256sum] = "a97d78bfb8cf1e1a2bd15262cc2b14810b7730a37dc28bdef153f5539fb1cb6f"

URI_aarch64_rust-thread_local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread_local-devel-1.1.9-1.el10_0.noarch.rpm;name=aarch64_rust-thread_local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread_local-devel}"
SRC_URI[aarch64_rust-thread_local-devel.sha256sum] = "a81e507aff4d09d306e5d520caefbf33a60e082b04a8413cbe2792baf1110bae"

RDEPENDS:rust-thread_local+default-devel = " \
 cargo \
 rust-thread_local-devel \
 "
RDEPENDS:rust-thread_local+nightly-devel = " \
 cargo \
 rust-thread_local-devel \
 "
RDEPENDS:rust-thread_local-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "
