# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-SysRandom"
PV = "0.007"
PR = "3.el10_3"
PACKAGES = " \
 perl-Crypt-SysRandom \
 perl-Crypt-SysRandom-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-SysRandom-0.007-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9ade77f9a94e4b30ccaf15922389ac460d04e703d1a9471963c8cc1feb510f19"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-SysRandom-0.007-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-SysRandom;unpack=0"
SRC_URI[x86_64_v2_perl-Crypt-SysRandom.sha256sum] = "ff662fdf17b858631452bcc0b5fd1dbee879d3b73c96b3f55398e6bf021dd914"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-SysRandom-tests-0.007-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-SysRandom-tests;unpack=0"
SRC_URI[x86_64_v2_perl-Crypt-SysRandom-tests.sha256sum] = "c988d0d9459f5c4eb76bbed0f297a320a41ba1468a9e5148fe1ebeb4013a4763"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-SysRandom-0.007-3.el10_3.noarch.rpm;name=aarch64_perl-Crypt-SysRandom;unpack=0"
SRC_URI[aarch64_perl-Crypt-SysRandom.sha256sum] = "45c08490e038c6cdf33d883856eefdcce6dd243793d3b17d29bc7d03a62030ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-SysRandom-tests-0.007-3.el10_3.noarch.rpm;name=aarch64_perl-Crypt-SysRandom-tests;unpack=0"
SRC_URI[aarch64_perl-Crypt-SysRandom-tests.sha256sum] = "802e1b22a342b7dd45964ba4b1419f5a6cf511e138fdf5f65a99c4dd56ce89a3"

RDEPENDS:perl-Crypt-SysRandom = " \
 perl-Carp \
 perl-Crypt-SysRandom-XS \
 perl-Errno \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Crypt-SysRandom-tests = " \
 bash \
 perl-Crypt-SysRandom \
 perl-IO \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
