# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-multipart"
PV = "1.3.1"
PR = "2.el10_1"
PACKAGES = " \
 python3-multipart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-multipart-1.3.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a3c67e8fe522a86389b0d4d2824ad59cbaa17af86837a0424cbf82f88741c1e"

URI_x86_64_v2_python3-multipart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-multipart-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-multipart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-multipart}"
SRC_URI[x86_64_v2_python3-multipart.sha256sum] = "d50408d515c5f5f73dc52f18c6d40e7c077350beab90153ce2b7884bf7f63926"

URI_aarch64_python3-multipart = "${EPEL_MIRROR}/aarch64/Packages/p/python3-multipart-1.3.1-2.el10_1.noarch.rpm;name=aarch64_python3-multipart;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-multipart}"
SRC_URI[aarch64_python3-multipart.sha256sum] = "8ed2777c8eb1069d6701a73952a3bec31176274d981df14049cd34cf272945ac"

RDEPENDS:python3-multipart = " \
 python3 \
 "
