# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libportal"
PV = "0.9.0"
PR = "1.el10"
PACKAGES = " \
 libportal \
 libportal-devel \
 libportal-devel-doc \
 libportal-gtk3 \
 libportal-gtk3-devel \
 libportal-gtk4 \
 libportal-gtk4-devel \
 libportal-qt6 \
 libportal-qt6-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libportal-0.9.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f744b37fcb0e56126049caf1542a657b3862f6864a515d3801fb40f81bcbe408"

URI_x86_64_v2_libportal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libportal-0.9.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libportal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal}"
SRC_URI[x86_64_v2_libportal.sha256sum] = "d6cdce7a9d9659e62a26da78f5aa7d16df88350604dd5eb525106822c546467e"

URI_x86_64_v2_libportal-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libportal-devel-0.9.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libportal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-devel}"
SRC_URI[x86_64_v2_libportal-devel.sha256sum] = "a90cdb46a6fd83a36fbf555865c24efd1b5edcf9278a0e144029c39fe1e2f90e"

URI_x86_64_v2_libportal-devel-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libportal-devel-doc-0.9.0-1.el10.noarch.rpm;name=x86_64_v2_libportal-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-devel-doc}"
SRC_URI[x86_64_v2_libportal-devel-doc.sha256sum] = "28d777d3656fa06ee5278c106ba35b219f6ff2d4571c8a41902668942800a3bf"

URI_x86_64_v2_libportal-gtk3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libportal-gtk3-0.9.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libportal-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-gtk3}"
SRC_URI[x86_64_v2_libportal-gtk3.sha256sum] = "5677f88f293131b6f09972fcfa7a60dec04041a63cac2aebd17b8f0f731419a5"

URI_x86_64_v2_libportal-gtk3-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libportal-gtk3-devel-0.9.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libportal-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-gtk3-devel}"
SRC_URI[x86_64_v2_libportal-gtk3-devel.sha256sum] = "d4c6d9276503684f8262ca396dfeafb00b0cc697ac76575ee37cd21f5eb52cd8"

URI_x86_64_v2_libportal-gtk4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libportal-gtk4-0.9.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libportal-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-gtk4}"
SRC_URI[x86_64_v2_libportal-gtk4.sha256sum] = "c8128bcb7dfb05150f946f3824f928e54b6c000fc155461296e8afd07a8dea32"

URI_x86_64_v2_libportal-gtk4-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libportal-gtk4-devel-0.9.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libportal-gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-gtk4-devel}"
SRC_URI[x86_64_v2_libportal-gtk4-devel.sha256sum] = "5b2a495bf12b37054177c1f711146dfa578aafae9f6ec4651b25ed69a27cb1ae"

URI_x86_64_v2_libportal-qt6 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libportal-qt6-0.9.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libportal-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-qt6}"
SRC_URI[x86_64_v2_libportal-qt6.sha256sum] = "b50132dc3cbb2356a189e42e3fba9746f15c0d792db7b459441c27610e4d015d"

URI_x86_64_v2_libportal-qt6-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libportal-qt6-devel-0.9.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libportal-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-qt6-devel}"
SRC_URI[x86_64_v2_libportal-qt6-devel.sha256sum] = "c05c7d2bb5a2a670b7b5040098ccf75ba751b44fbef4d59896908590a2380a7d"

URI_aarch64_libportal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libportal-0.9.0-1.el10.aarch64.rpm;name=aarch64_libportal;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal}"
SRC_URI[aarch64_libportal.sha256sum] = "1a443dceddcf445cef39925f48b4268d7fc6c63ec9c5dbe903946ad7fb57707f"

URI_aarch64_libportal-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libportal-devel-0.9.0-1.el10.aarch64.rpm;name=aarch64_libportal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-devel}"
SRC_URI[aarch64_libportal-devel.sha256sum] = "6eadd4bd01463439d42ba3e8c3740970e4cd43130c086ab873ec3d69c952bf2f"

URI_aarch64_libportal-devel-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libportal-devel-doc-0.9.0-1.el10.noarch.rpm;name=aarch64_libportal-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-devel-doc}"
SRC_URI[aarch64_libportal-devel-doc.sha256sum] = "28d777d3656fa06ee5278c106ba35b219f6ff2d4571c8a41902668942800a3bf"

URI_aarch64_libportal-gtk3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libportal-gtk3-0.9.0-1.el10.aarch64.rpm;name=aarch64_libportal-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-gtk3}"
SRC_URI[aarch64_libportal-gtk3.sha256sum] = "8d3504166d52234612e0b83f5c74985b97cb577fbc37ca3b6c8515db95924027"

URI_aarch64_libportal-gtk3-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libportal-gtk3-devel-0.9.0-1.el10.aarch64.rpm;name=aarch64_libportal-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-gtk3-devel}"
SRC_URI[aarch64_libportal-gtk3-devel.sha256sum] = "d58861ceafaf1bcabfd987dee107d57339ce8d9860211fd82b15b103c19c3cfb"

URI_aarch64_libportal-gtk4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libportal-gtk4-0.9.0-1.el10.aarch64.rpm;name=aarch64_libportal-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-gtk4}"
SRC_URI[aarch64_libportal-gtk4.sha256sum] = "28f962fab4229779d45bb3b9c936a7be894df3a0f1f3cebb130b148bf6171f83"

URI_aarch64_libportal-gtk4-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libportal-gtk4-devel-0.9.0-1.el10.aarch64.rpm;name=aarch64_libportal-gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-gtk4-devel}"
SRC_URI[aarch64_libportal-gtk4-devel.sha256sum] = "bea1ac2fd064276b2a29a5e1dd7576784c4032b56f07c7c241752f32d354444d"

URI_aarch64_libportal-qt6 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libportal-qt6-0.9.0-1.el10.aarch64.rpm;name=aarch64_libportal-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-qt6}"
SRC_URI[aarch64_libportal-qt6.sha256sum] = "d791c88bbef42a1ac8c293b61995283814458176dd734e73b5367d3c0a999bc9"

URI_aarch64_libportal-qt6-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libportal-qt6-devel-0.9.0-1.el10.aarch64.rpm;name=aarch64_libportal-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-qt6-devel}"
SRC_URI[aarch64_libportal-qt6-devel.sha256sum] = "ff4d53b747fbfd68fd94fd4b96f096af19a1445852cdb5cd77327c6632a7c523"

RDEPENDS:libportal = " \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:libportal-devel = " \
 glib2-devel \
 libportal \
 pkgconf-pkg-config \
 "
RDEPENDS:libportal-devel-doc = " \
 "
RDEPENDS:libportal-gtk3 = " \
 glib2 \
 glibc \
 gtk3 \
 libgcc \
 libportal \
 "
RDEPENDS:libportal-gtk3-devel = " \
 glib2-devel \
 gtk3-devel \
 libportal-devel \
 libportal-gtk3 \
 pkgconf-pkg-config \
 "
RDEPENDS:libportal-gtk4 = " \
 glib2 \
 glibc \
 gtk4 \
 libgcc \
 libportal \
 "
RDEPENDS:libportal-gtk4-devel = " \
 glib2-devel \
 gtk4-devel \
 libportal-devel \
 libportal-gtk4 \
 pkgconf-pkg-config \
 "
RDEPENDS:libportal-qt6 = " \
 glib2 \
 glibc \
 libgcc \
 libportal \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libportal-qt6-devel = " \
 glib2-devel \
 libportal-devel \
 libportal-qt6 \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
