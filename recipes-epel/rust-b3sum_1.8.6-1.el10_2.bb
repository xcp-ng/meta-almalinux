# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-b3sum"
PV = "1.8.6"
PR = "1.el10_2"
PACKAGES = " \
 b3sum \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-b3sum-1.8.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b2a3109f572e42827cbc1923326f57d73cab0c8ee5f465afb4131aa6d857d39"

URI_x86_64_v2_b3sum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/b3sum-1.8.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_b3sum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_b3sum}"
SRC_URI[x86_64_v2_b3sum.sha256sum] = "c9a3340d9e7abbdff92a8421a0a95bd570fe5df5fb8d31c4e75921568f395dc0"

URI_aarch64_b3sum = "${EPEL_MIRROR}/aarch64/Packages/b/b3sum-1.8.6-1.el10_2.aarch64.rpm;name=aarch64_b3sum;unpack=0"
SRC_URI:append = " ${URI_aarch64_b3sum}"
SRC_URI[aarch64_b3sum.sha256sum] = "093833cf2adfaf95eec06b04e6ae7c1c5cb114d3fc78646c092e23461c188eb5"

RDEPENDS:b3sum = " \
 glibc \
 libgcc \
 "
