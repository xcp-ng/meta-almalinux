# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-intrusive-collections"
PV = "0.10.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-intrusive-collections+alloc-devel \
 rust-intrusive-collections+default-devel \
 rust-intrusive-collections+nightly-devel \
 rust-intrusive-collections-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-intrusive-collections-0.10.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b8383dce60216c55ca93d7ea1f0c50b7d14c634f4a899b5e2dfe41f1ef45fd3"

URI_x86_64_v2_rust-intrusive-collections+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-intrusive-collections+alloc-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-intrusive-collections+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-intrusive-collections+alloc-devel}"
SRC_URI[x86_64_v2_rust-intrusive-collections+alloc-devel.sha256sum] = "7c4502980e931ae7e82d01296fa2d45f5585452dfa511c006f46f06b17335fb7"

URI_x86_64_v2_rust-intrusive-collections+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-intrusive-collections+default-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-intrusive-collections+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-intrusive-collections+default-devel}"
SRC_URI[x86_64_v2_rust-intrusive-collections+default-devel.sha256sum] = "2236efc25f43a31abf6568deaeddd7f7cf4c9d7565faa36f06ef0711a00634a3"

URI_x86_64_v2_rust-intrusive-collections+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-intrusive-collections+nightly-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-intrusive-collections+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-intrusive-collections+nightly-devel}"
SRC_URI[x86_64_v2_rust-intrusive-collections+nightly-devel.sha256sum] = "68979246cf3669f14de57b46e79c31c8083fb125c0b089475245a51b70a05a15"

URI_x86_64_v2_rust-intrusive-collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-intrusive-collections-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-intrusive-collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-intrusive-collections-devel}"
SRC_URI[x86_64_v2_rust-intrusive-collections-devel.sha256sum] = "e81904de146feb9bdfbdc6d9ffb6dc0eba72c16f7380e52e6701925bbdd16067"

URI_aarch64_rust-intrusive-collections+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-intrusive-collections+alloc-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-intrusive-collections+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-intrusive-collections+alloc-devel}"
SRC_URI[aarch64_rust-intrusive-collections+alloc-devel.sha256sum] = "3225a377118555cc5d39fb66f654727dd25e4d58a35dbd0a6f0ce89295bf09dd"

URI_aarch64_rust-intrusive-collections+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-intrusive-collections+default-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-intrusive-collections+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-intrusive-collections+default-devel}"
SRC_URI[aarch64_rust-intrusive-collections+default-devel.sha256sum] = "07b5b1c5d100aca01d08a0678fe5d312c528cb82bc07209b8a92d3c751f2e55b"

URI_aarch64_rust-intrusive-collections+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-intrusive-collections+nightly-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-intrusive-collections+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-intrusive-collections+nightly-devel}"
SRC_URI[aarch64_rust-intrusive-collections+nightly-devel.sha256sum] = "f1d441f7ae283051965e5855b42090f730b5a75fb93213ddb7545af345c1936e"

URI_aarch64_rust-intrusive-collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-intrusive-collections-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-intrusive-collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-intrusive-collections-devel}"
SRC_URI[aarch64_rust-intrusive-collections-devel.sha256sum] = "1b47c78df4db183c422bbd3e002510e8c4f54294722eb1fb5a1e6beff5b3b5a1"

RDEPENDS:rust-intrusive-collections+alloc-devel = " \
 cargo \
 rust-intrusive-collections-devel \
 "
RDEPENDS:rust-intrusive-collections+default-devel = " \
 cargo \
 rust-intrusive-collections+alloc-devel \
 rust-intrusive-collections-devel \
 "
RDEPENDS:rust-intrusive-collections+nightly-devel = " \
 cargo \
 rust-intrusive-collections-devel \
 "
RDEPENDS:rust-intrusive-collections-devel = " \
 cargo \
 rust \
 "
