# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-matttproud-protobuf-extensions"
PV = "1.0.1"
PR = "18.el10_0"
PACKAGES = " \
 golang-github-matttproud-protobuf-extensions-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-matttproud-protobuf-extensions-1.0.1-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ab2839db572361ec73be4220e527600ce15c50055e31f8863229df2866fe40a"

URI_x86_64_v2_golang-github-matttproud-protobuf-extensions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-matttproud-protobuf-extensions-devel-1.0.1-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-matttproud-protobuf-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-matttproud-protobuf-extensions-devel}"
SRC_URI[x86_64_v2_golang-github-matttproud-protobuf-extensions-devel.sha256sum] = "841ca8040f1fcc3d9484618b97344cf84eea69cc962d7e324e9384b2824fa99f"

URI_aarch64_golang-github-matttproud-protobuf-extensions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-matttproud-protobuf-extensions-devel-1.0.1-18.el10_0.noarch.rpm;name=aarch64_golang-github-matttproud-protobuf-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-matttproud-protobuf-extensions-devel}"
SRC_URI[aarch64_golang-github-matttproud-protobuf-extensions-devel.sha256sum] = "8d089a04d1c5593d99a61c49083a3523ce6c58c30ee0a407e800b81b2fee22bb"

RDEPENDS:golang-github-matttproud-protobuf-extensions-devel = " \
 go-filesystem \
 golang-github-protobuf-devel \
 "
