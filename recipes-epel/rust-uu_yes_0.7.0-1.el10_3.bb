# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_yes"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_yes+default-devel \
 rust-uu_yes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_yes-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6554924ff790286effa92e58a17189eca1fc4deac3d3e53387a61f2eb5f0b80"

URI_x86_64_v2_rust-uu_yes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_yes+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_yes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_yes+default-devel}"
SRC_URI[x86_64_v2_rust-uu_yes+default-devel.sha256sum] = "66e13f6121de865b76bec0114fb6e1f38aae46c7e99edf534824cc6aac91c689"

URI_x86_64_v2_rust-uu_yes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_yes-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_yes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_yes-devel}"
SRC_URI[x86_64_v2_rust-uu_yes-devel.sha256sum] = "54b99125351d669626dd2bc5af90d58a4c332e1677405c3c11588626f335bbcb"

URI_aarch64_rust-uu_yes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_yes+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_yes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_yes+default-devel}"
SRC_URI[aarch64_rust-uu_yes+default-devel.sha256sum] = "32cb8aed6b15981a2c6ae7808ecf102cf4fbc18e87dda48ed61ace78023f15fd"

URI_aarch64_rust-uu_yes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_yes-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_yes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_yes-devel}"
SRC_URI[aarch64_rust-uu_yes-devel.sha256sum] = "6a108215c9c8741f002e4d2a246489eb0629df305bd888213b6e2e7e9bf5a498"

RDEPENDS:rust-uu_yes+default-devel = " \
 cargo \
 rust-uu_yes-devel \
 "
RDEPENDS:rust-uu_yes-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-itertools0.14+default-devel \
 rust-uucore+default-devel \
 rust-uucore+pipes-devel \
 rust-uucore+signals-devel \
 "
