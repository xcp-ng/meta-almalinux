# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "3proxy"
PV = "0.9.5"
PR = "1.el10_1"
PACKAGES = " \
 3proxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/3/3proxy-0.9.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe7b83eecbf670d12330f7ffc81bac756560daa50ac552abef9ca470a37c4dbd"

URI_x86_64_v2_3proxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/3proxy-0.9.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_3proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_3proxy}"
SRC_URI[x86_64_v2_3proxy.sha256sum] = "4e611fbe1c5c46b3282d85c825b66e1cb8f78faada9b319a06183ef493695ede"

URI_aarch64_3proxy = "${EPEL_MIRROR}/aarch64/Packages/3/3proxy-0.9.5-1.el10_1.aarch64.rpm;name=aarch64_3proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_3proxy}"
SRC_URI[aarch64_3proxy.sha256sum] = "d54f91d17373019fe021ea4fbaee3dc35a5b6f0af54ab30df25417f13f00eed9"

RDEPENDS:3proxy = " \
 bash \
 glibc \
 "
