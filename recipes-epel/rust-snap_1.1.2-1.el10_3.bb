# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snap"
PV = "1.1.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-snap+default-devel \
 rust-snap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snap-1.1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b8efd7bec3a86963b4d297af718353b31e01d9c8b40691dea8d67b811fc8694"

URI_x86_64_v2_rust-snap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snap+default-devel-1.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snap+default-devel}"
SRC_URI[x86_64_v2_rust-snap+default-devel.sha256sum] = "133a5d74f03905050718dd651ff25c8a378583a6a4158ee20aeb547f45d52f20"

URI_x86_64_v2_rust-snap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snap-devel-1.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snap-devel}"
SRC_URI[x86_64_v2_rust-snap-devel.sha256sum] = "ae0b2370bc86aba83f507d97a593d0311299478801c8d41097eabcc16a7b599d"

URI_aarch64_rust-snap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snap+default-devel-1.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-snap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snap+default-devel}"
SRC_URI[aarch64_rust-snap+default-devel.sha256sum] = "10cb71768e4bdd603d594fad109054c3f637410f862226386d178ba038e10390"

URI_aarch64_rust-snap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snap-devel-1.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-snap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snap-devel}"
SRC_URI[aarch64_rust-snap-devel.sha256sum] = "2526c72db6c54927e1c135102376074223cb103638f779210933dc003f1b41fd"

RDEPENDS:rust-snap+default-devel = " \
 cargo \
 rust-snap-devel \
 "
RDEPENDS:rust-snap-devel = " \
 cargo \
 "
