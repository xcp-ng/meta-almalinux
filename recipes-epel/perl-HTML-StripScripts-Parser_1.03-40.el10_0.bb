# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTML-StripScripts-Parser"
PV = "1.03"
PR = "40.el10_0"
PACKAGES = " \
 perl-HTML-StripScripts-Parser \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTML-StripScripts-Parser-1.03-40.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e203b9f5f8a0752d22c8ea65ca81cbbb6c39a1286352fe747c92b2c7f8777e1"

URI_x86_64_v2_perl-HTML-StripScripts-Parser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTML-StripScripts-Parser-1.03-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTML-StripScripts-Parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTML-StripScripts-Parser}"
SRC_URI[x86_64_v2_perl-HTML-StripScripts-Parser.sha256sum] = "65c397e4455fdab55f04368772082763efd09ea5e97218f3df36cd7b2ae401ad"

URI_aarch64_perl-HTML-StripScripts-Parser = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTML-StripScripts-Parser-1.03-40.el10_0.noarch.rpm;name=aarch64_perl-HTML-StripScripts-Parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTML-StripScripts-Parser}"
SRC_URI[aarch64_perl-HTML-StripScripts-Parser.sha256sum] = "c8f8f5b4137c2fda4873c1648293060e1ef8e42c80b86571a379c26315aff5c9"

RDEPENDS:perl-HTML-StripScripts-Parser = " \
 perl-HTML-Parser \
 perl-HTML-StripScripts \
 perl-base \
 perl-libs \
 perl-vars \
 "
