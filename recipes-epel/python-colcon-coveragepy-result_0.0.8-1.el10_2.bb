# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-coveragepy-result"
PV = "0.0.8"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-coveragepy-result \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-coveragepy-result-0.0.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39b57486a22e930bac8216a4e1492b34d25356c417f74232f75787770a20b051"

URI_x86_64_v2_python3-colcon-coveragepy-result = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-coveragepy-result-0.0.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-coveragepy-result;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-coveragepy-result}"
SRC_URI[x86_64_v2_python3-colcon-coveragepy-result.sha256sum] = "528303237e634c56372ef8ccd464ea40b1397582cca872a5b7d975a6388ac96d"

URI_aarch64_python3-colcon-coveragepy-result = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-coveragepy-result-0.0.8-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-coveragepy-result;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-coveragepy-result}"
SRC_URI[aarch64_python3-colcon-coveragepy-result.sha256sum] = "e1a4a3a664e3da78014e092aa32326602dfc1953cc428181cb0a5a2886c4cc7f"

RDEPENDS:python3-colcon-coveragepy-result = " \
 python3 \
 python3-colcon-core \
 python3-coverage \
 "
