# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-netlink-packet-route"
PV = "0.22.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-netlink-packet-route+default-devel \
 rust-netlink-packet-route+rich_nlas-devel \
 rust-netlink-packet-route-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-netlink-packet-route-0.22.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "435dd260ac3e8212147fce609cbf1fadc13ee062e3b302accceefe6b54577f75"

URI_x86_64_v2_rust-netlink-packet-route+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-packet-route+default-devel-0.22.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-packet-route+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-packet-route+default-devel}"
SRC_URI[x86_64_v2_rust-netlink-packet-route+default-devel.sha256sum] = "01df8ba562b781e04719883a9b2a21245c9980e4aa716f1df92e6e4e9a2c247c"

URI_x86_64_v2_rust-netlink-packet-route+rich_nlas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-packet-route+rich_nlas-devel-0.22.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-packet-route+rich_nlas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-packet-route+rich_nlas-devel}"
SRC_URI[x86_64_v2_rust-netlink-packet-route+rich_nlas-devel.sha256sum] = "bd2bb5603b98961bfd299ffb433a6dd14c2ead0fe9c29fe51647daae01194140"

URI_x86_64_v2_rust-netlink-packet-route-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-packet-route-devel-0.22.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-packet-route-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-packet-route-devel}"
SRC_URI[x86_64_v2_rust-netlink-packet-route-devel.sha256sum] = "329d62295a3dfbf63cf26cadd4cecb67a253815548332f3894e4d9490c27388e"

URI_aarch64_rust-netlink-packet-route+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-packet-route+default-devel-0.22.0-2.el10_1.noarch.rpm;name=aarch64_rust-netlink-packet-route+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-packet-route+default-devel}"
SRC_URI[aarch64_rust-netlink-packet-route+default-devel.sha256sum] = "c09ebd909112e8aab8952192063443888f260f0ad06eb9290d2081c085f1cafe"

URI_aarch64_rust-netlink-packet-route+rich_nlas-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-packet-route+rich_nlas-devel-0.22.0-2.el10_1.noarch.rpm;name=aarch64_rust-netlink-packet-route+rich_nlas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-packet-route+rich_nlas-devel}"
SRC_URI[aarch64_rust-netlink-packet-route+rich_nlas-devel.sha256sum] = "6f4676e4b2f1fe1e1dae1a3729b78733f87be19ee87cca0e1b90e1d8ea62a4f5"

URI_aarch64_rust-netlink-packet-route-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-packet-route-devel-0.22.0-2.el10_1.noarch.rpm;name=aarch64_rust-netlink-packet-route-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-packet-route-devel}"
SRC_URI[aarch64_rust-netlink-packet-route-devel.sha256sum] = "17dd564d45327bb4f1f8a2f8a35cd67fd895cc1a9601b9c0bab30491d9f08020"

RDEPENDS:rust-netlink-packet-route+default-devel = " \
 cargo \
 rust-netlink-packet-route-devel \
 "
RDEPENDS:rust-netlink-packet-route+rich_nlas-devel = " \
 cargo \
 rust-netlink-packet-route-devel \
 "
RDEPENDS:rust-netlink-packet-route-devel = " \
 bash \
 cargo \
 python3 \
 rust-anyhow+default-devel \
 rust-bitflags+default-devel \
 rust-byteorder+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-log+std-devel \
 rust-netlink-packet-core+default-devel \
 rust-netlink-packet-utils+default-devel \
 "
