# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-urlgrabber"
PV = "4.1.0"
PR = "22.el10_0"
PACKAGES = " \
 python3-urlgrabber \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-urlgrabber-4.1.0-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "093be5e1e13d4832f3df14c8577d3c78f17fc3d34a3f06c6daa209015216a141"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-urlgrabber-4.1.0-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-urlgrabber;unpack=0"
SRC_URI[x86_64_v2_python3-urlgrabber.sha256sum] = "0e0cbb869bae44564b2ed452d4b509f148e9f9bd963d33f83c1154e42384d549"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-urlgrabber-4.1.0-22.el10_0.noarch.rpm;name=aarch64_python3-urlgrabber;unpack=0"
SRC_URI[aarch64_python3-urlgrabber.sha256sum] = "774db36a2a577b5fcf4d8c1087e465aefa23ac1a2ae0f4ad10695e24069fed8a"

RDEPENDS:python3-urlgrabber = " \
 python3 \
 python3-pycurl \
 python3-setuptools \
 python3-six \
 "
