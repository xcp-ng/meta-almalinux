# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-ansi-terminal"
PV = "1.0.2"
PR = "5.el10_0"
PACKAGES = " \
 ghc-ansi-terminal \
 ghc-ansi-terminal-devel \
 ghc-ansi-terminal-doc \
 ghc-ansi-terminal-prof \
 ghc-ansi-terminal-types \
 ghc-ansi-terminal-types-devel \
 ghc-ansi-terminal-types-doc \
 ghc-ansi-terminal-types-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-ansi-terminal-1.0.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b906d03631b28a98769f26cd47f8fe3aab358df71c09b957ace8093b11c1aae"

URI_x86_64_v2_ghc-ansi-terminal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ansi-terminal-1.0.2-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ansi-terminal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ansi-terminal}"
SRC_URI[x86_64_v2_ghc-ansi-terminal.sha256sum] = "6ceaa35d373a9139b4320515ba4ee9cb634adc06ad3bb47c479ee9b0cfeee7b2"

URI_x86_64_v2_ghc-ansi-terminal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ansi-terminal-devel-1.0.2-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ansi-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ansi-terminal-devel}"
SRC_URI[x86_64_v2_ghc-ansi-terminal-devel.sha256sum] = "076c2ecee99ed2e793bcffba3927729e2b4ad2ef804f1ae5c4c4fff4621141b3"

URI_x86_64_v2_ghc-ansi-terminal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ansi-terminal-doc-1.0.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ansi-terminal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ansi-terminal-doc}"
SRC_URI[x86_64_v2_ghc-ansi-terminal-doc.sha256sum] = "7ff63ace9556d6b6465f11e82d51de97d35b653a639c9b3efafcb03048ec1e49"

URI_x86_64_v2_ghc-ansi-terminal-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ansi-terminal-prof-1.0.2-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ansi-terminal-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ansi-terminal-prof}"
SRC_URI[x86_64_v2_ghc-ansi-terminal-prof.sha256sum] = "fc0ba69d0e068ec32be115727cbf67a24e1f61d85dd985865a1f87be76d8c22b"

URI_x86_64_v2_ghc-ansi-terminal-types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ansi-terminal-types-0.11.5-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ansi-terminal-types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ansi-terminal-types}"
SRC_URI[x86_64_v2_ghc-ansi-terminal-types.sha256sum] = "cffcccf87a40513b7851841d08ec02d2f187ee81cf3156a580272234a1979513"

URI_x86_64_v2_ghc-ansi-terminal-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ansi-terminal-types-devel-0.11.5-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ansi-terminal-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ansi-terminal-types-devel}"
SRC_URI[x86_64_v2_ghc-ansi-terminal-types-devel.sha256sum] = "e0ab7703dc2cab3981cc63cb85b2bf13e85dba8f0501ec4a70cb95aa0fcabd01"

URI_x86_64_v2_ghc-ansi-terminal-types-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ansi-terminal-types-doc-0.11.5-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ansi-terminal-types-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ansi-terminal-types-doc}"
SRC_URI[x86_64_v2_ghc-ansi-terminal-types-doc.sha256sum] = "ddf4793d4775cd4a414748f315a514d07fdbb231ab534800839655a485231f3d"

URI_x86_64_v2_ghc-ansi-terminal-types-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ansi-terminal-types-prof-0.11.5-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ansi-terminal-types-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ansi-terminal-types-prof}"
SRC_URI[x86_64_v2_ghc-ansi-terminal-types-prof.sha256sum] = "f511b353adae1e0058515d257d248e9a79d051ba00622f7e0d1938705d40e1c9"

URI_aarch64_ghc-ansi-terminal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ansi-terminal-1.0.2-5.el10_0.aarch64.rpm;name=aarch64_ghc-ansi-terminal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ansi-terminal}"
SRC_URI[aarch64_ghc-ansi-terminal.sha256sum] = "66dbc10e88fb661b6ffaa98cabe782e867b1f9f426b50dc7f3f74af4b93a654b"

URI_aarch64_ghc-ansi-terminal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ansi-terminal-devel-1.0.2-5.el10_0.aarch64.rpm;name=aarch64_ghc-ansi-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ansi-terminal-devel}"
SRC_URI[aarch64_ghc-ansi-terminal-devel.sha256sum] = "6c99c991ee73bc04c7043567ec5d5c56752dec8742faf8ff4d4f9a82f0c753f5"

URI_aarch64_ghc-ansi-terminal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ansi-terminal-doc-1.0.2-5.el10_0.noarch.rpm;name=aarch64_ghc-ansi-terminal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ansi-terminal-doc}"
SRC_URI[aarch64_ghc-ansi-terminal-doc.sha256sum] = "cc5cf1556841816580da146ca22a45d8cf3e23e1e2076d7b6bbf6357e7af4eb7"

URI_aarch64_ghc-ansi-terminal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ansi-terminal-prof-1.0.2-5.el10_0.aarch64.rpm;name=aarch64_ghc-ansi-terminal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ansi-terminal-prof}"
SRC_URI[aarch64_ghc-ansi-terminal-prof.sha256sum] = "d65653332caf1ac85bacd2892ff83e00b0d079557b84f08ded3782a64b97ad4e"

URI_aarch64_ghc-ansi-terminal-types = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ansi-terminal-types-0.11.5-5.el10_0.aarch64.rpm;name=aarch64_ghc-ansi-terminal-types;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ansi-terminal-types}"
SRC_URI[aarch64_ghc-ansi-terminal-types.sha256sum] = "da223daa87ae1af58f49dafbb2642a742c8591f095669e41037deb52707b6f93"

URI_aarch64_ghc-ansi-terminal-types-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ansi-terminal-types-devel-0.11.5-5.el10_0.aarch64.rpm;name=aarch64_ghc-ansi-terminal-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ansi-terminal-types-devel}"
SRC_URI[aarch64_ghc-ansi-terminal-types-devel.sha256sum] = "5b17e2f8e0e4134c53f9790b656b8262d3755063aba85f36023d111b537476e8"

URI_aarch64_ghc-ansi-terminal-types-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ansi-terminal-types-doc-0.11.5-5.el10_0.noarch.rpm;name=aarch64_ghc-ansi-terminal-types-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ansi-terminal-types-doc}"
SRC_URI[aarch64_ghc-ansi-terminal-types-doc.sha256sum] = "a14684662868d46432ea0abf4320a0a8875caebd53a9f1dee881dfd335b6fe9f"

URI_aarch64_ghc-ansi-terminal-types-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ansi-terminal-types-prof-0.11.5-5.el10_0.aarch64.rpm;name=aarch64_ghc-ansi-terminal-types-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ansi-terminal-types-prof}"
SRC_URI[aarch64_ghc-ansi-terminal-types-prof.sha256sum] = "2d89d0a7fa40ea57ef589c55a8a52a0349a9e697555b46639ae934fec7ce0c1f"

RDEPENDS:ghc-ansi-terminal = " \
 ghc-ansi-terminal-types \
 ghc-base \
 ghc-colour \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ansi-terminal-devel = " \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types-devel \
 ghc-base-devel \
 ghc-colour-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-ansi-terminal-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ansi-terminal-prof = " \
 ghc-ansi-terminal-devel \
 ghc-ansi-terminal-types-prof \
 ghc-base-prof \
 ghc-colour-prof \
 "
RDEPENDS:ghc-ansi-terminal-types = " \
 ghc-base \
 ghc-colour \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ansi-terminal-types-devel = " \
 ghc-ansi-terminal-types \
 ghc-base-devel \
 ghc-colour-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-ansi-terminal-types-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ansi-terminal-types-prof = " \
 ghc-ansi-terminal-types-devel \
 ghc-base-prof \
 ghc-colour-prof \
 "
