# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DBIx-ContextualFetch"
PV = "1.03"
PR = "56.el10_3"
PACKAGES = " \
 perl-DBIx-ContextualFetch \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-DBIx-ContextualFetch-1.03-56.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6b1598bcdf6c9ab21007563ee7c9b55462d5ab8d3f336f2c8679423aa7cc67bf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DBIx-ContextualFetch-1.03-56.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DBIx-ContextualFetch;unpack=0"
SRC_URI[x86_64_v2_perl-DBIx-ContextualFetch.sha256sum] = "c551a4774111cb363f05dab98e91a79816827dee74abdee62fa3872efc650c87"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-DBIx-ContextualFetch-1.03-56.el10_3.noarch.rpm;name=aarch64_perl-DBIx-ContextualFetch;unpack=0"
SRC_URI[aarch64_perl-DBIx-ContextualFetch.sha256sum] = "8f9b7fd7115d51f15108385c9f903cac5a8a309614ffb0b92ea64a54a65a9bc6"

RDEPENDS:perl-DBIx-ContextualFetch = " \
 perl-DBI \
 perl-base \
 perl-libs \
 "
