# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clamav-unofficial-sigs"
PV = "7.2.5"
PR = "14.el10_1"
PACKAGES = " \
 clamav-unofficial-sigs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clamav-unofficial-sigs-7.2.5-14.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5001f4aad123bcafdcf5c7c9e24b72ea39581912182331e0d1c71d972cfe17ef"

URI_x86_64_v2_clamav-unofficial-sigs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-unofficial-sigs-7.2.5-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-unofficial-sigs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-unofficial-sigs}"
SRC_URI[x86_64_v2_clamav-unofficial-sigs.sha256sum] = "f3e3449648e4795b738af37ec1c5fa92c0f945f79f8889e29443a8c04c3f7889"

URI_aarch64_clamav-unofficial-sigs = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-unofficial-sigs-7.2.5-14.el10_1.noarch.rpm;name=aarch64_clamav-unofficial-sigs;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-unofficial-sigs}"
SRC_URI[aarch64_clamav-unofficial-sigs.sha256sum] = "11addb0a43c89a2e2f54d49e29d000ce13c14c1a8123459e42d815daa9c30280"

RDEPENDS:clamav-unofficial-sigs = " \
 bash \
 bind-utils \
 clamav \
 clamav-freshclam \
 curl \
 diffutils \
 gnupg2 \
 rsync \
 systemd \
 "
