# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-smbpasswd"
PV = "1.0.2"
PR = "20.el10_0"
PACKAGES = " \
 python3-smbpasswd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-smbpasswd-1.0.2-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ad3cb619320cefd28a7ca521df969700261a55a1864d5f23b7c52fd7abd7f52"

URI_x86_64_v2_python3-smbpasswd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-smbpasswd-1.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-smbpasswd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-smbpasswd}"
SRC_URI[x86_64_v2_python3-smbpasswd.sha256sum] = "07e44b74544c28d59bc55ae4e0fd8e818d2fdf8a1c15b801b3ee9058b5ccb919"

URI_aarch64_python3-smbpasswd = "${EPEL_MIRROR}/aarch64/Packages/p/python3-smbpasswd-1.0.2-20.el10_0.aarch64.rpm;name=aarch64_python3-smbpasswd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-smbpasswd}"
SRC_URI[aarch64_python3-smbpasswd.sha256sum] = "e1a6902d62a7109c037e3724499c7dffad0bd1a2b5ebf696e45a41a2be67de03"

RDEPENDS:python3-smbpasswd = " \
 glibc \
 python3 \
 "
