# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lorax"
PV = "40.5.15"
PR = "1.el10.alma.1"
PACKAGES = " \
 lorax \
 lorax-docs \
 lorax-lmc-novirt \
 lorax-lmc-virt \
 lorax-templates-generic \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lorax-40.5.15-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3aff854d8bdce07f211fab79a578f4030ee6b4c0adcc50a1d7fac84d9454e5f2"

URI_x86_64_v2_lorax = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-40.5.15-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax}"
SRC_URI[x86_64_v2_lorax.sha256sum] = "abed020172b5e20579c500037157a9cb4727358ee4e08677bb70de6ae43c5fa1"

URI_x86_64_v2_lorax-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-docs-40.5.15-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-docs}"
SRC_URI[x86_64_v2_lorax-docs.sha256sum] = "d18aa4e12348a5b165e17df83e28d0cb2e00bd1875ad0d95da3ca5b0e6295c06"

URI_x86_64_v2_lorax-lmc-novirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-lmc-novirt-40.5.15-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-lmc-novirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-lmc-novirt}"
SRC_URI[x86_64_v2_lorax-lmc-novirt.sha256sum] = "d31e9198c10144d2c0ff8c2674b4df66e463c3da50b6cdb5375f13d15ddb3055"

URI_x86_64_v2_lorax-lmc-virt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-lmc-virt-40.5.15-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-lmc-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-lmc-virt}"
SRC_URI[x86_64_v2_lorax-lmc-virt.sha256sum] = "991febff20abab4d1cd682c626ba87e01cda21888bd0b8c5c49bbab2867fe17f"

URI_x86_64_v2_lorax-templates-generic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-generic-40.5.15-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-templates-generic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-templates-generic}"
SRC_URI[x86_64_v2_lorax-templates-generic.sha256sum] = "aae73405cfe361eeb01cf586cffb2bde85189958947e80ece43898502a8c5f33"
RPROVIDES:lorax-templates-generic:x86_64_v2 = "virtual/lorax-templates"

URI_aarch64_lorax = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-40.5.15-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax}"
SRC_URI[aarch64_lorax.sha256sum] = "9c2459adaeb72352f06562b81ef17585bf5c3e6cd4af75dc433a8eaf21bfc3ae"

URI_aarch64_lorax-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-docs-40.5.15-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-docs}"
SRC_URI[aarch64_lorax-docs.sha256sum] = "d4d897a3c10c821962ad9415356c4bb33b53e572cba9cf782b7c193e9f13c377"

URI_aarch64_lorax-lmc-novirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-lmc-novirt-40.5.15-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-lmc-novirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-lmc-novirt}"
SRC_URI[aarch64_lorax-lmc-novirt.sha256sum] = "d0d7d7f18dc67b82b7ba9c81cf8df2b4e1d6e5ed83ae651b10785e06f08adb24"

URI_aarch64_lorax-lmc-virt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-lmc-virt-40.5.15-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-lmc-virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-lmc-virt}"
SRC_URI[aarch64_lorax-lmc-virt.sha256sum] = "db781afac0f90bd301245e14ce054d368208cb272e54d2feec692793432d506d"

URI_aarch64_lorax-templates-generic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-generic-40.5.15-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-templates-generic;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-templates-generic}"
SRC_URI[aarch64_lorax-templates-generic.sha256sum] = "582d0135de850837e744a0c4c8041058a8637a147c4bd8d103ca3f406a841026"
RPROVIDES:lorax-templates-generic:aarch64 = "virtual/lorax-templates"

RDEPENDS:lorax:x86_64_v2 = " \
 cpio \
 device-mapper \
 dosfstools \
 dracut \
 e2fsprogs \
 erofs-utils \
 findutils \
 gawk \
 glib2 \
 glibc \
 glibc-common \
 grub2-pc \
 grub2-tools \
 gzip \
 isomd5sum \
 kmod \
 kpartx \
 lorax-templates-rhel \
 parted \
 pbzip2 \
 pigz \
 psmisc \
 python3 \
 python3-dnf \
 python3-kickstart \
 python3-librepo \
 python3-libselinux \
 python3-mako \
 python3-pycdio \
 squashfs-tools \
 util-linux \
 virtual/lorax-templates \
 xorriso \
 xz \
 xz-lzma-compat \
"
RDEPENDS:lorax:aarch64 = " \
 cpio \
 device-mapper \
 dosfstools \
 dracut \
 e2fsprogs \
 erofs-utils \
 findutils \
 gawk \
 glib2 \
 glibc \
 glibc-common \
 gzip \
 isomd5sum \
 kmod \
 kpartx \
 lorax-templates-rhel \
 parted \
 pbzip2 \
 pigz \
 psmisc \
 python3 \
 python3-dnf \
 python3-kickstart \
 python3-librepo \
 python3-libselinux \
 python3-mako \
 python3-pycdio \
 squashfs-tools \
 util-linux \
 virtual/lorax-templates \
 xorriso \
 xz \
 xz-lzma-compat \
"
RDEPENDS:lorax-docs = " \
 lorax \
 "
RDEPENDS:lorax-lmc-novirt = " \
 almalinux-logos \
 anaconda-core \
 anaconda-install-env-deps \
 anaconda-tui \
 lorax \
 python3-psutil \
 tar \
 "
RDEPENDS:lorax-lmc-virt:x86_64_v2 = " \
 edk2-ovmf \
 lorax \
 qemu-kvm \
 tar \
"
RDEPENDS:lorax-lmc-virt:aarch64 = " \
 edk2-aarch64 \
 lorax \
 qemu-kvm \
 tar \
"
RDEPENDS:lorax-templates-generic = " \
 lorax \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/lorax-templates"

PROVIDES:append:aarch64 = " rpm/virtual/lorax-templates"
