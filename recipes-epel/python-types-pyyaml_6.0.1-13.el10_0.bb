# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-types-pyyaml"
PV = "6.0.1"
PR = "13.el10_0"
PACKAGES = " \
 python3-types-pyyaml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-types-pyyaml-6.0.1-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "596137bc84050f1590bfe73f560823eea07ef2474685bf34440d7a82edd57ff8"

URI_x86_64_v2_python3-types-pyyaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-types-pyyaml-6.0.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-types-pyyaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-types-pyyaml}"
SRC_URI[x86_64_v2_python3-types-pyyaml.sha256sum] = "b7a15966d7cb9df6418fc3c525f3a5738d3b6bb0443480caa53e73d00b804305"

URI_aarch64_python3-types-pyyaml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-types-pyyaml-6.0.1-13.el10_0.noarch.rpm;name=aarch64_python3-types-pyyaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-types-pyyaml}"
SRC_URI[aarch64_python3-types-pyyaml.sha256sum] = "a3ecfdc32c03085d844bce2cd9150fed1a0d0b3cff58f43a9cb3b63a72f50c34"

RDEPENDS:python3-types-pyyaml = " \
 python3 \
 "
