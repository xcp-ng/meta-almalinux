# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bugreport"
PV = "0.5.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-bugreport+collector_operating_system-devel \
 rust-bugreport+default-devel \
 rust-bugreport+format_markdown-devel \
 rust-bugreport+format_plaintext-devel \
 rust-bugreport+git-version-devel \
 rust-bugreport+git_hash-devel \
 rust-bugreport-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bugreport-0.5.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4e0a14561eadf1623d3e3faa7adcaa0efd15d7a84d65b183211822a04f5f644"

URI_x86_64_v2_rust-bugreport+collector_operating_system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bugreport+collector_operating_system-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bugreport+collector_operating_system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bugreport+collector_operating_system-devel}"
SRC_URI[x86_64_v2_rust-bugreport+collector_operating_system-devel.sha256sum] = "44599866203fa424b163564f4f6a169b23a7fcbc8d13ed29e6799436ff8f7cab"

URI_x86_64_v2_rust-bugreport+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bugreport+default-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bugreport+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bugreport+default-devel}"
SRC_URI[x86_64_v2_rust-bugreport+default-devel.sha256sum] = "09c36d50c34c025076df316e8d56e9ff41469a39c4b284742b56c2cfb28910f3"

URI_x86_64_v2_rust-bugreport+format_markdown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bugreport+format_markdown-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bugreport+format_markdown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bugreport+format_markdown-devel}"
SRC_URI[x86_64_v2_rust-bugreport+format_markdown-devel.sha256sum] = "8ebfd06a45ff350d27b60ec72028ff725163097f4d0e6b4b8a9f4b68caec3b91"

URI_x86_64_v2_rust-bugreport+format_plaintext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bugreport+format_plaintext-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bugreport+format_plaintext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bugreport+format_plaintext-devel}"
SRC_URI[x86_64_v2_rust-bugreport+format_plaintext-devel.sha256sum] = "a5d088b700c0fcfbc4137858923fd4f0f1788289a81e9333bce7a389be206e88"

URI_x86_64_v2_rust-bugreport+git-version-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bugreport+git-version-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bugreport+git-version-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bugreport+git-version-devel}"
SRC_URI[x86_64_v2_rust-bugreport+git-version-devel.sha256sum] = "d76deda044e4a5d7860ef7967007435510c98a5125eba84afd0bc988b4eba1c8"

URI_x86_64_v2_rust-bugreport+git_hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bugreport+git_hash-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bugreport+git_hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bugreport+git_hash-devel}"
SRC_URI[x86_64_v2_rust-bugreport+git_hash-devel.sha256sum] = "5056655a95ba2309c614b854778168fc04b47bb3b03707538b52a571851d8d6d"

URI_x86_64_v2_rust-bugreport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bugreport-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bugreport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bugreport-devel}"
SRC_URI[x86_64_v2_rust-bugreport-devel.sha256sum] = "7c342588a50d334fd6a944af0d13bec58bbea4d6913e09f70ba4f8f66fe2a917"

URI_aarch64_rust-bugreport+collector_operating_system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bugreport+collector_operating_system-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-bugreport+collector_operating_system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bugreport+collector_operating_system-devel}"
SRC_URI[aarch64_rust-bugreport+collector_operating_system-devel.sha256sum] = "e57a6c0301e9e9e37cbec71f00d5b1b5fee4013a0d801f9aec74f913a6c51ece"

URI_aarch64_rust-bugreport+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bugreport+default-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-bugreport+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bugreport+default-devel}"
SRC_URI[aarch64_rust-bugreport+default-devel.sha256sum] = "070179bd213e7efcd0d79c650cdd28163b59c2bdb6100b3bedbcf545ecae4abb"

URI_aarch64_rust-bugreport+format_markdown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bugreport+format_markdown-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-bugreport+format_markdown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bugreport+format_markdown-devel}"
SRC_URI[aarch64_rust-bugreport+format_markdown-devel.sha256sum] = "625e541e268e1f37c89ba6ce582e6f23e092384868d3e41ab7a70fe831c3eac6"

URI_aarch64_rust-bugreport+format_plaintext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bugreport+format_plaintext-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-bugreport+format_plaintext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bugreport+format_plaintext-devel}"
SRC_URI[aarch64_rust-bugreport+format_plaintext-devel.sha256sum] = "27a0a7f6b263d1fdb1f1e2e7c3c62fdd6c09a8d3548469591d32ae531c98bd9b"

URI_aarch64_rust-bugreport+git-version-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bugreport+git-version-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-bugreport+git-version-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bugreport+git-version-devel}"
SRC_URI[aarch64_rust-bugreport+git-version-devel.sha256sum] = "f2f99e57fc153bc93ed2f30a266475f08d872dc249b6c7248cefc3e060cf2b81"

URI_aarch64_rust-bugreport+git_hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bugreport+git_hash-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-bugreport+git_hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bugreport+git_hash-devel}"
SRC_URI[aarch64_rust-bugreport+git_hash-devel.sha256sum] = "d1797f6d26aef4dd53c684e43a6764a9aa4cc8ff4ad40d581a7398a4e3f66937"

URI_aarch64_rust-bugreport-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bugreport-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-bugreport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bugreport-devel}"
SRC_URI[aarch64_rust-bugreport-devel.sha256sum] = "21644ea338e9b0f46c25f0b6e239d16d5e6eabcae0500f5a454724b05b367a96"

RDEPENDS:rust-bugreport+collector_operating_system-devel = " \
 cargo \
 rust-bugreport-devel \
 rust-sysinfo0.33+default-devel \
 "
RDEPENDS:rust-bugreport+default-devel = " \
 cargo \
 rust-bugreport+collector_operating_system-devel \
 rust-bugreport+format_markdown-devel \
 rust-bugreport+git_hash-devel \
 rust-bugreport-devel \
 "
RDEPENDS:rust-bugreport+format_markdown-devel = " \
 cargo \
 rust-bugreport-devel \
 "
RDEPENDS:rust-bugreport+format_plaintext-devel = " \
 cargo \
 rust-bugreport-devel \
 "
RDEPENDS:rust-bugreport+git-version-devel = " \
 cargo \
 rust-bugreport-devel \
 rust-git-version+default-devel \
 "
RDEPENDS:rust-bugreport+git_hash-devel = " \
 cargo \
 rust-bugreport+git-version-devel \
 rust-bugreport-devel \
 "
RDEPENDS:rust-bugreport-devel = " \
 bash \
 cargo \
 rust-shell-escape+default-devel \
 "
