# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-color-spantrace"
PV = "0.3.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-color-spantrace+default-devel \
 rust-color-spantrace-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-color-spantrace-0.3.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65dc1278e984b6ea586ed4bce65bf38865c27fa7dd5ea712c82d14ba68e44e6b"

URI_x86_64_v2_rust-color-spantrace+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-spantrace+default-devel-0.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-spantrace+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-color-spantrace+default-devel}"
SRC_URI[x86_64_v2_rust-color-spantrace+default-devel.sha256sum] = "1cd02c4c4574ea02dd381f7fd831c409972ac98083406edd67601966b606ae80"

URI_x86_64_v2_rust-color-spantrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-spantrace-devel-0.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-spantrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-color-spantrace-devel}"
SRC_URI[x86_64_v2_rust-color-spantrace-devel.sha256sum] = "b01515fc7d0330c7e84b6b206e2168fa80ee58fc77f78899c2a511a3d6f68261"

URI_aarch64_rust-color-spantrace+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-color-spantrace+default-devel-0.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-color-spantrace+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-color-spantrace+default-devel}"
SRC_URI[aarch64_rust-color-spantrace+default-devel.sha256sum] = "5adece43a5d1bd68abe3425b6110ea0349e65cbf3d0cedf645570551b646ae28"

URI_aarch64_rust-color-spantrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-color-spantrace-devel-0.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-color-spantrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-color-spantrace-devel}"
SRC_URI[aarch64_rust-color-spantrace-devel.sha256sum] = "2cf021fc696aac027e8d070d1156b0640252e3fceda275596c942d73fe2d70b3"

RDEPENDS:rust-color-spantrace+default-devel = " \
 cargo \
 rust-color-spantrace-devel \
 "
RDEPENDS:rust-color-spantrace-devel = " \
 cargo \
 rust \
 rust-once_cell+default-devel \
 rust-owo-colors+default-devel \
 rust-tracing-core+default-devel \
 rust-tracing-error+default-devel \
 "
