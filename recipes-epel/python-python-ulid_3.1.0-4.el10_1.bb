# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-python-ulid"
PV = "3.1.0"
PR = "4.el10_1"
PACKAGES = " \
 python3-python-ulid \
 python3-python-ulid+pydantic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-python-ulid-3.1.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f28a79996601d48ef443f395ec00d5996b3a83a89c1caa7681a37c4fa601f46f"

URI_x86_64_v2_python3-python-ulid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-python-ulid-3.1.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-python-ulid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-python-ulid}"
SRC_URI[x86_64_v2_python3-python-ulid.sha256sum] = "f2806e257a85a6d19dfa65db774c3ca1c3e8ee617b778ac550397186c4270898"

URI_x86_64_v2_python3-python-ulid+pydantic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-python-ulid+pydantic-3.1.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-python-ulid+pydantic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-python-ulid+pydantic}"
SRC_URI[x86_64_v2_python3-python-ulid+pydantic.sha256sum] = "fbc699dfe977fdee512bbb984bda2013011234e7eb9625dd9c74d3fd8793eab5"

URI_aarch64_python3-python-ulid = "${EPEL_MIRROR}/aarch64/Packages/p/python3-python-ulid-3.1.0-4.el10_1.noarch.rpm;name=aarch64_python3-python-ulid;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-python-ulid}"
SRC_URI[aarch64_python3-python-ulid.sha256sum] = "44565b1a5b9a707f712aa462016bf9e335aad0324c39015da8a6fb3036e96430"

URI_aarch64_python3-python-ulid+pydantic = "${EPEL_MIRROR}/aarch64/Packages/p/python3-python-ulid+pydantic-3.1.0-4.el10_1.noarch.rpm;name=aarch64_python3-python-ulid+pydantic;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-python-ulid+pydantic}"
SRC_URI[aarch64_python3-python-ulid+pydantic.sha256sum] = "263ab7812076c1248a530d95f5a9f9e1a5a589ccf94d632b81831352e0bc96b3"

RDEPENDS:python3-python-ulid = " \
 python3 \
 "
RDEPENDS:python3-python-ulid+pydantic = " \
 python3 \
 python3-pydantic \
 python3-python-ulid \
 "
