# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "miniz"
PV = "3.0.2"
PR = "5.el10_0"
PACKAGES = " \
 miniz \
 miniz-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/miniz-3.0.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fa54bc42941ab91a2f708fbb76d2873582dbe716ecd58999699025b3732b851"

URI_x86_64_v2_miniz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/miniz-3.0.2-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_miniz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_miniz}"
SRC_URI[x86_64_v2_miniz.sha256sum] = "863b984c12bc07b34b58a9a590b6faba609a1962e1e56467521a42c5b7f75bd0"

URI_x86_64_v2_miniz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/miniz-devel-3.0.2-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_miniz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_miniz-devel}"
SRC_URI[x86_64_v2_miniz-devel.sha256sum] = "c30ca2f9facf28dac53bd4d75de236f211aff9b4caaafb37e4515e2ffc97149a"

URI_aarch64_miniz = "${EPEL_MIRROR}/aarch64/Packages/m/miniz-3.0.2-5.el10_0.aarch64.rpm;name=aarch64_miniz;unpack=0"
SRC_URI:append = " ${URI_aarch64_miniz}"
SRC_URI[aarch64_miniz.sha256sum] = "e04129128407392c076c174ce4ed85f6b64e0fa6adb22113ba9613c2cffb9a06"

URI_aarch64_miniz-devel = "${EPEL_MIRROR}/aarch64/Packages/m/miniz-devel-3.0.2-5.el10_0.aarch64.rpm;name=aarch64_miniz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_miniz-devel}"
SRC_URI[aarch64_miniz-devel.sha256sum] = "8edf0ccc234db08e766d433a03a605d6a51be8462020d66a863ec0254e7fc083"

RDEPENDS:miniz = " \
 glibc \
 "
RDEPENDS:miniz-devel = " \
 miniz \
 "
