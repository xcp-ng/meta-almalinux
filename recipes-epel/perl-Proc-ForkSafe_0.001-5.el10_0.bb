# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Proc-ForkSafe"
PV = "0.001"
PR = "5.el10_0"
PACKAGES = " \
 perl-Proc-ForkSafe \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Proc-ForkSafe-0.001-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0005d55ea20533229f7efc7167fe3fba08b6acab67270631f19b68924da2b2ea"

URI_x86_64_v2_perl-Proc-ForkSafe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Proc-ForkSafe-0.001-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Proc-ForkSafe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Proc-ForkSafe}"
SRC_URI[x86_64_v2_perl-Proc-ForkSafe.sha256sum] = "4b5be2f2a4639b4747234f4b79c81a3bcd938ea169f7aef2e533e643f2421dcb"

URI_aarch64_perl-Proc-ForkSafe = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Proc-ForkSafe-0.001-5.el10_0.noarch.rpm;name=aarch64_perl-Proc-ForkSafe;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Proc-ForkSafe}"
SRC_URI[aarch64_perl-Proc-ForkSafe.sha256sum] = "4ee87460082270a41f1160672e7e1d3d023db3b352e0bcc88bc47eddfc77a57b"

RDEPENDS:perl-Proc-ForkSafe = " \
 perl-libs \
 "
