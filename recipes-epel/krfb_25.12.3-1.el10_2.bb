# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krfb"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 krfb \
 krfb-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krfb-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "703edad346344dbee7e2424519bc9862fa3a6835921af74f4f996cb17b605fd4"

URI_x86_64_v2_krfb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krfb-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krfb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krfb}"
SRC_URI[x86_64_v2_krfb.sha256sum] = "61fecb6e0699672e5e4ecb829c789f01d6fe403eb366fb5cc566d32a9414d9bc"

URI_x86_64_v2_krfb-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krfb-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krfb-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krfb-libs}"
SRC_URI[x86_64_v2_krfb-libs.sha256sum] = "98738e4faeb81290746847a12c1c46d7f5e3643e9ec790ce68cc1e1152a0adde"

URI_aarch64_krfb = "${EPEL_MIRROR}/aarch64/Packages/k/krfb-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_krfb;unpack=0"
SRC_URI:append = " ${URI_aarch64_krfb}"
SRC_URI[aarch64_krfb.sha256sum] = "e5eb061d3d21068eedf4ab422b5ff4a4d399c833355899ecc2625efc14f3bb21"

URI_aarch64_krfb-libs = "${EPEL_MIRROR}/aarch64/Packages/k/krfb-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_krfb-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_krfb-libs}"
SRC_URI[aarch64_krfb-libs.sha256sum] = "16ed5455b5fac31cd097a75a5b21b92e0cb12a2a9fb087989463e056ef040e3f"

RDEPENDS:krfb = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 krfb-libs \
 libXtst \
 libstdc++ \
 libvncserver \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:krfb-libs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kpipewire \
 krfb \
 kwayland \
 libX11 \
 libXtst \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 xcb-util-image \
 "
