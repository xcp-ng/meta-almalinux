# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sgml-common"
PV = "0.6.3"
PR = "65.el10"
PACKAGES = " \
 sgml-common \
 xml-common \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sgml-common-0.6.3-65.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02dfdef31d17613cee599ab22f67d1cb0d14e5ff475d6c4979c18e668658518d"

URI_x86_64_v2_sgml-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sgml-common-0.6.3-65.el10.noarch.rpm;name=x86_64_v2_sgml-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sgml-common}"
SRC_URI[x86_64_v2_sgml-common.sha256sum] = "d7d004aec9666eadb1df40ced663a833fdc41725047ee8e736d946eb0631738e"

URI_x86_64_v2_xml-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xml-common-0.6.3-65.el10.noarch.rpm;name=x86_64_v2_xml-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xml-common}"
SRC_URI[x86_64_v2_xml-common.sha256sum] = "850cda3bbf605e45e08c33124c08b9f42eb5a3a5ce7f9947c2a124b383ebe30d"

URI_aarch64_sgml-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sgml-common-0.6.3-65.el10.noarch.rpm;name=aarch64_sgml-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_sgml-common}"
SRC_URI[aarch64_sgml-common.sha256sum] = "d7d004aec9666eadb1df40ced663a833fdc41725047ee8e736d946eb0631738e"

URI_aarch64_xml-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xml-common-0.6.3-65.el10.noarch.rpm;name=aarch64_xml-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_xml-common}"
SRC_URI[aarch64_xml-common.sha256sum] = "850cda3bbf605e45e08c33124c08b9f42eb5a3a5ce7f9947c2a124b383ebe30d"

RDEPENDS:sgml-common = " \
 bash \
 virtual//usr/bin/basename \
 "
RDEPENDS:xml-common = " \
 bash \
 libxml2 \
 "
