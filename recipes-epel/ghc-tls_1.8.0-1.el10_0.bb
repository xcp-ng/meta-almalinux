# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-tls"
PV = "1.8.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-tls \
 ghc-tls-devel \
 ghc-tls-doc \
 ghc-tls-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-tls-1.8.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7f5f56462e975d7ae8b235426ced5b43f04a1721d36b47d472995ccdc36397f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tls-1.8.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tls;unpack=0"
SRC_URI[x86_64_v2_ghc-tls.sha256sum] = "f067ea96760c7e52313c60bc6f3d50c7b0bcf74e661014584fd5f92440fb6b85"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tls-devel-1.8.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tls-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-tls-devel.sha256sum] = "8372adfabd1150d3fd5bc9360d38fc267182f164a224b90f4b693e78fe0774cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tls-doc-1.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-tls-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-tls-doc.sha256sum] = "0a0dd2973263b32a6068ab9e0933de58a421eb2dafe2c07d4a7ec6bebf20aebd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tls-prof-1.8.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tls-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-tls-prof.sha256sum] = "1a6b94b10cec350a180aee6b7a167d21941a3c90de6d35d416ca263961e5b281"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-tls-1.8.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-tls;unpack=0"
SRC_URI[aarch64_ghc-tls.sha256sum] = "9c0930a722eccd260d5a09bc9f56f22d80bbb1e848bf45970ca5965a2643725e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-tls-devel-1.8.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-tls-devel;unpack=0"
SRC_URI[aarch64_ghc-tls-devel.sha256sum] = "81974102c455b03099eec6be9087e4ba1d485605374ea9023d1c1a0d98fbcf89"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-tls-doc-1.8.0-1.el10_0.noarch.rpm;name=aarch64_ghc-tls-doc;unpack=0"
SRC_URI[aarch64_ghc-tls-doc.sha256sum] = "a74f6ae8b4eaa85d6d901110f13a38ed72d325864c1465eca9ba462bc5d2dec2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-tls-prof-1.8.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-tls-prof;unpack=0"
SRC_URI[aarch64_ghc-tls-prof.sha256sum] = "2bc9da9cf68916479963f4a4d4e2ebf4e34fe329d31fda726b35f07bbe5aefe1"

RDEPENDS:ghc-tls = " \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-async \
 ghc-base \
 ghc-basement \
 ghc-binary \
 ghc-bytestring \
 ghc-cereal \
 ghc-containers \
 ghc-crypton \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-memory \
 ghc-mtl \
 ghc-network \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-pem \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-unix-time \
 glibc \
 gmp \
 "
RDEPENDS:ghc-tls-devel = " \
 ghc-asn1-encoding-devel \
 ghc-asn1-types-devel \
 ghc-async-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-cereal-devel \
 ghc-compiler \
 ghc-crypton-devel \
 ghc-crypton-x509-devel \
 ghc-crypton-x509-store-devel \
 ghc-crypton-x509-validation-devel \
 ghc-data-default-class-devel \
 ghc-memory-devel \
 ghc-mtl-devel \
 ghc-network-devel \
 ghc-tls \
 ghc-transformers-devel \
 ghc-unix-time-devel \
 "
RDEPENDS:ghc-tls-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-tls-prof = " \
 ghc-asn1-encoding-prof \
 ghc-asn1-types-prof \
 ghc-async-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cereal-prof \
 ghc-crypton-prof \
 ghc-crypton-x509-prof \
 ghc-crypton-x509-store-prof \
 ghc-crypton-x509-validation-prof \
 ghc-data-default-class-prof \
 ghc-memory-prof \
 ghc-mtl-prof \
 ghc-network-prof \
 ghc-tls-devel \
 ghc-transformers-prof \
 ghc-unix-time-prof \
 "
