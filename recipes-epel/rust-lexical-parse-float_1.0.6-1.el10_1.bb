# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexical-parse-float"
PV = "1.0.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-lexical-parse-float+compact-devel \
 rust-lexical-parse-float+default-devel \
 rust-lexical-parse-float+f128-devel \
 rust-lexical-parse-float+f16-devel \
 rust-lexical-parse-float+format-devel \
 rust-lexical-parse-float+lint-devel \
 rust-lexical-parse-float+power-of-two-devel \
 rust-lexical-parse-float+radix-devel \
 rust-lexical-parse-float+std-devel \
 rust-lexical-parse-float-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexical-parse-float-1.0.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d76afce9032ee14e24ed798b2babac776b7190654f6fcfa428809f8c22e4e9cd"

URI_x86_64_v2_rust-lexical-parse-float+compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+compact-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+compact-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+compact-devel.sha256sum] = "e8667206590fccb9a9509a7b4522eafc1f1310ac7e13f8c7a6101c046b3e7972"

URI_x86_64_v2_rust-lexical-parse-float+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+default-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+default-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+default-devel.sha256sum] = "c1c812737edb09d49aae21953ab8afc268f50ed3dca4048c37c8f2fead5e9f0e"

URI_x86_64_v2_rust-lexical-parse-float+f128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+f128-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+f128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+f128-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+f128-devel.sha256sum] = "7c2b860ff26d6f002c2c305d0495fe13ae8fb4a68dc01906041fe97c8503bb83"

URI_x86_64_v2_rust-lexical-parse-float+f16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+f16-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+f16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+f16-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+f16-devel.sha256sum] = "01424cf79c55d64096e5f0a9856a6d431fc5eec1b0398e9b146e33b904aa4bb7"

URI_x86_64_v2_rust-lexical-parse-float+format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+format-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+format-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+format-devel.sha256sum] = "d63c6e362640d85ea96f480c4139cd260d0a2fc7583df3941af98faaf9451b9e"

URI_x86_64_v2_rust-lexical-parse-float+lint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+lint-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+lint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+lint-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+lint-devel.sha256sum] = "ea295aaff57b240f35fd2f58cc16a0623235f85da8848640f411e9040d133c1e"

URI_x86_64_v2_rust-lexical-parse-float+power-of-two-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+power-of-two-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+power-of-two-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+power-of-two-devel.sha256sum] = "18a7c950ba246a79a0f31838e53abcf0d06ab1f60567d22a4ce1bfd804ba4c3d"

URI_x86_64_v2_rust-lexical-parse-float+radix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+radix-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+radix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+radix-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+radix-devel.sha256sum] = "ec8d7093660b375662f3b7a6ac6e248001ba97c1dcd9954b0555fbcaee8f2b78"

URI_x86_64_v2_rust-lexical-parse-float+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+std-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+std-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+std-devel.sha256sum] = "bb25fddac238ea9bb9f3229ff17c6e9156d29ea186536a762c93aa7ececbeb19"

URI_x86_64_v2_rust-lexical-parse-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float-devel.sha256sum] = "52a869e835e32484a2a6c877019b0a47af0d00366af47bdb0fb9e1c7c43c5f92"

URI_aarch64_rust-lexical-parse-float+compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+compact-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-float+compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+compact-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+compact-devel.sha256sum] = "19420f0432454b4c1c9b94bf5db650caf1c64f962e20ff47828d17e21f6460fa"

URI_aarch64_rust-lexical-parse-float+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+default-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-float+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+default-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+default-devel.sha256sum] = "2c0113a04bf84e9ee669fc92834c1ff0e6e9cea565f101a2917eaf6cb708b8d2"

URI_aarch64_rust-lexical-parse-float+f128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+f128-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-float+f128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+f128-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+f128-devel.sha256sum] = "e46da2378555ea2d4c4a8f992ff76e6c9b459fd90d05ec3492a893b775501c24"

URI_aarch64_rust-lexical-parse-float+f16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+f16-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-float+f16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+f16-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+f16-devel.sha256sum] = "04f7554d24e18e9d4a76609c46c6b052cce6da369a27a3b5a281a2dff9a94b16"

URI_aarch64_rust-lexical-parse-float+format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+format-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-float+format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+format-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+format-devel.sha256sum] = "250b1f06bdd0cb4e17eea07aa6a875338a8499f4d467df694a3d5912f1b04e0b"

URI_aarch64_rust-lexical-parse-float+lint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+lint-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-float+lint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+lint-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+lint-devel.sha256sum] = "cb258940c8d64ab12688069d67c0a791671370336c1ed8854166b857255c8136"

URI_aarch64_rust-lexical-parse-float+power-of-two-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+power-of-two-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-float+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+power-of-two-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+power-of-two-devel.sha256sum] = "2eba14ad63fea9e16070b9dc050635f97b56942479710b6a2b89ca15fc6eebd2"

URI_aarch64_rust-lexical-parse-float+radix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+radix-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-float+radix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+radix-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+radix-devel.sha256sum] = "1e6aee9342e81b477119c98c6bb050cc6354c69dd6a44344dd1335a0a40a8255"

URI_aarch64_rust-lexical-parse-float+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+std-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-float+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+std-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+std-devel.sha256sum] = "b971efc7bffc388e00a7613d2f7a3f197af1b9fec1f2b6411e2623c80369a28a"

URI_aarch64_rust-lexical-parse-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float-devel}"
SRC_URI[aarch64_rust-lexical-parse-float-devel.sha256sum] = "c39aef0cafad4f1289f22dba0c9c9f51b725d9472f3a4e2f8e7fd1d4c0d588c7"

RDEPENDS:rust-lexical-parse-float+compact-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+compact-devel \
 rust-lexical-util+compact-devel \
 "
RDEPENDS:rust-lexical-parse-float+default-devel = " \
 cargo \
 rust-lexical-parse-float+std-devel \
 rust-lexical-parse-float-devel \
 "
RDEPENDS:rust-lexical-parse-float+f128-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-util+f128-devel \
 "
RDEPENDS:rust-lexical-parse-float+f16-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-util+f16-devel \
 "
RDEPENDS:rust-lexical-parse-float+format-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+format-devel \
 rust-lexical-util+format-devel \
 "
RDEPENDS:rust-lexical-parse-float+lint-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+lint-devel \
 rust-lexical-util+lint-devel \
 "
RDEPENDS:rust-lexical-parse-float+power-of-two-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+power-of-two-devel \
 rust-lexical-util+power-of-two-devel \
 "
RDEPENDS:rust-lexical-parse-float+radix-devel = " \
 cargo \
 rust-lexical-parse-float+power-of-two-devel \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+radix-devel \
 rust-lexical-util+radix-devel \
 "
RDEPENDS:rust-lexical-parse-float+std-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+std-devel \
 rust-lexical-util+std-devel \
 "
RDEPENDS:rust-lexical-parse-float-devel = " \
 cargo \
 rust \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+parse-floats-devel \
 rust-lexical-util-devel \
 "
