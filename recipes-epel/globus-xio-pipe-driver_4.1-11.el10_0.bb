# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-xio-pipe-driver"
PV = "4.1"
PR = "11.el10_0"
PACKAGES = " \
 globus-xio-pipe-driver \
 globus-xio-pipe-driver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-xio-pipe-driver-4.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84e975bd4c20bd485473ee16b3cda1b1172d389e185f1f20bc74808f7ccfb5d5"

URI_x86_64_v2_globus-xio-pipe-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-pipe-driver-4.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-pipe-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-pipe-driver}"
SRC_URI[x86_64_v2_globus-xio-pipe-driver.sha256sum] = "5c2cc440210f64907e99a1055c717df7442672c022e0109efa096d27c6a501b9"

URI_x86_64_v2_globus-xio-pipe-driver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-pipe-driver-devel-4.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-pipe-driver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-pipe-driver-devel}"
SRC_URI[x86_64_v2_globus-xio-pipe-driver-devel.sha256sum] = "22734f99e56ca19970a53a531913f697cc8c61db3a2b098e4d29edc683cd4c20"

URI_aarch64_globus-xio-pipe-driver = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-pipe-driver-4.1-11.el10_0.aarch64.rpm;name=aarch64_globus-xio-pipe-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-pipe-driver}"
SRC_URI[aarch64_globus-xio-pipe-driver.sha256sum] = "e7ca5d61cabfc42aeb42fa952f70186b0f0f9bce438ebc013cea74b5080a3220"

URI_aarch64_globus-xio-pipe-driver-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-pipe-driver-devel-4.1-11.el10_0.aarch64.rpm;name=aarch64_globus-xio-pipe-driver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-pipe-driver-devel}"
SRC_URI[aarch64_globus-xio-pipe-driver-devel.sha256sum] = "9157ecd93e535445bc16dac161aa6726713073645633c668c7a9a7c47450ae2d"

RDEPENDS:globus-xio-pipe-driver = " \
 glibc \
 globus-common \
 globus-xio \
 "
RDEPENDS:globus-xio-pipe-driver-devel = " \
 globus-common-devel \
 globus-xio-devel \
 globus-xio-pipe-driver \
 pkgconf-pkg-config \
 "
