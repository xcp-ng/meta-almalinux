# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust-embed"
PV = "8.11.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-rust-embed+debug-embed-devel \
 rust-rust-embed+default-devel \
 rust-rust-embed+deterministic-timestamps-devel \
 rust-rust-embed+hex-devel \
 rust-rust-embed+include-exclude-devel \
 rust-rust-embed+interpolate-folder-path-devel \
 rust-rust-embed-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust-embed-8.11.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93029da6b6293afefd66fb6af67e694db48f4ec1859a19677d72578cd8574699"

URI_x86_64_v2_rust-rust-embed+debug-embed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+debug-embed-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+debug-embed-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+debug-embed-devel.sha256sum] = "6ef3570981393ef29bc8f806fa83eda9dd77e80c2a5a8f7445ff05c08b7d452a"

URI_x86_64_v2_rust-rust-embed+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+default-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+default-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+default-devel.sha256sum] = "ffefef08b76a2b3a107a650518e58679ec1f20e9ce438be882c27f19b62b6b25"

URI_x86_64_v2_rust-rust-embed+deterministic-timestamps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+deterministic-timestamps-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+deterministic-timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+deterministic-timestamps-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+deterministic-timestamps-devel.sha256sum] = "929546b941f9e8ab18215302722b063338eea11b6704e0ac9a0a715e2729f88d"

URI_x86_64_v2_rust-rust-embed+hex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+hex-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+hex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+hex-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+hex-devel.sha256sum] = "13b2cb3fd1dadb8a1871bc8912d80e7e3b4bc79c795b4e17dde085e148b0f78b"

URI_x86_64_v2_rust-rust-embed+include-exclude-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+include-exclude-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+include-exclude-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+include-exclude-devel.sha256sum] = "d10c3af41acf017b07fb3af009fa1a451c1574d6538b2691b5dd00eebd323580"

URI_x86_64_v2_rust-rust-embed+interpolate-folder-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+interpolate-folder-path-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+interpolate-folder-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+interpolate-folder-path-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+interpolate-folder-path-devel.sha256sum] = "356f1c48f6bfe677e06488c351de3b3af3213b42c797111cb374c8e478e1e5e6"

URI_x86_64_v2_rust-rust-embed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-devel.sha256sum] = "92156330b6b706f151413ef16880d2b33c7a28fd583709cdf273a6610764a642"

URI_aarch64_rust-rust-embed+debug-embed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+debug-embed-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+debug-embed-devel}"
SRC_URI[aarch64_rust-rust-embed+debug-embed-devel.sha256sum] = "0d082d11f968620e3270a2224037cd59c63fb5893df1645e50739ca587d911d8"

URI_aarch64_rust-rust-embed+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+default-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+default-devel}"
SRC_URI[aarch64_rust-rust-embed+default-devel.sha256sum] = "6d3437e8bb6058ce8f7ceec6f987c5872f6c6f2bfbef6a153c3d142090f85b5d"

URI_aarch64_rust-rust-embed+deterministic-timestamps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+deterministic-timestamps-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed+deterministic-timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+deterministic-timestamps-devel}"
SRC_URI[aarch64_rust-rust-embed+deterministic-timestamps-devel.sha256sum] = "1936699718c50ada88c20883458a929bf3f39706351d892efed804ce4e4b081f"

URI_aarch64_rust-rust-embed+hex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+hex-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed+hex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+hex-devel}"
SRC_URI[aarch64_rust-rust-embed+hex-devel.sha256sum] = "8b8726e926c5ed0acdf8dac2eadb2924521df2b563a27b98edd14b8c0e37b483"

URI_aarch64_rust-rust-embed+include-exclude-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+include-exclude-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+include-exclude-devel}"
SRC_URI[aarch64_rust-rust-embed+include-exclude-devel.sha256sum] = "b2ac88d8f9765f581cb294111df519b5eb0818e9665ecc09e26b5a639b5d2a97"

URI_aarch64_rust-rust-embed+interpolate-folder-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+interpolate-folder-path-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed+interpolate-folder-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+interpolate-folder-path-devel}"
SRC_URI[aarch64_rust-rust-embed+interpolate-folder-path-devel.sha256sum] = "201cb5f3ea38ca49f7bd7a8b30e33119a242c0560ef78bcc56c97593a3056d51"

URI_aarch64_rust-rust-embed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-devel}"
SRC_URI[aarch64_rust-rust-embed-devel.sha256sum] = "2d324a17bcc41a9536828b11ac7947a45acaeb2d4e2f991ae80a64d85331ea60"

RDEPENDS:rust-rust-embed+debug-embed-devel = " \
 cargo \
 rust-rust-embed-devel \
 rust-rust-embed-impl+debug-embed-devel \
 rust-rust-embed-utils+debug-embed-devel \
 "
RDEPENDS:rust-rust-embed+default-devel = " \
 cargo \
 rust-rust-embed-devel \
 "
RDEPENDS:rust-rust-embed+deterministic-timestamps-devel = " \
 cargo \
 rust-rust-embed-devel \
 rust-rust-embed-impl+deterministic-timestamps-devel \
 "
RDEPENDS:rust-rust-embed+hex-devel = " \
 cargo \
 rust-hex+default-devel \
 rust-rust-embed-devel \
 "
RDEPENDS:rust-rust-embed+include-exclude-devel = " \
 cargo \
 rust-rust-embed-devel \
 rust-rust-embed-impl+include-exclude-devel \
 rust-rust-embed-utils+include-exclude-devel \
 "
RDEPENDS:rust-rust-embed+interpolate-folder-path-devel = " \
 cargo \
 rust-rust-embed-devel \
 rust-rust-embed-impl+interpolate-folder-path-devel \
 "
RDEPENDS:rust-rust-embed-devel = " \
 cargo \
 rust \
 rust-rust-embed-impl+default-devel \
 rust-rust-embed-utils+default-devel \
 rust-walkdir+default-devel \
 "
