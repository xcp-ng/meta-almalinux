# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.13"
PV = "3.13.15"
PR = "1.el10_2"
PACKAGES = " \
 python3.13 \
 python3.13-debug \
 python3.13-devel \
 python3.13-freethreading \
 python3.13-freethreading-debug \
 python3.13-idle \
 python3.13-libs \
 python3.13-test \
 python3.13-tkinter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3.13-3.13.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12a126af549dfd74868ff05bf3864f9dbca628868701074a56929790f6ff6717"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3.13-freethreading: (python3.13-wheel-wheel if python3.13-setuptools-wheel < 71)
# - python3.13-test: (python3.13-wheel-wheel if python3.13-setuptools-wheel < 71)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - python3.13-freethreading: (python3.13-wheel-wheel if python3.13-setuptools-wheel < 71)
# - python3.13-test: (python3.13-wheel-wheel if python3.13-setuptools-wheel < 71)

URI_x86_64_v2_python3.13 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-3.13.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13}"
SRC_URI[x86_64_v2_python3.13.sha256sum] = "eadfcf0158ee64a1f2c261757521199c503d2e54562889aa3820e2055558a7ac"

URI_x86_64_v2_python3.13-debug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-debug-3.13.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-debug}"
SRC_URI[x86_64_v2_python3.13-debug.sha256sum] = "c4f409f6d12be5b35a08236f4c0dc55d84cdb544c62b94d5ee0aac7bf5452da2"

URI_x86_64_v2_python3.13-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-devel-3.13.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-devel}"
SRC_URI[x86_64_v2_python3.13-devel.sha256sum] = "cedc0f61041c7350f3ee4a1d7ace918eb00d65eea21f999a73554080a3713456"

URI_x86_64_v2_python3.13-freethreading = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-freethreading-3.13.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-freethreading;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-freethreading}"
SRC_URI[x86_64_v2_python3.13-freethreading.sha256sum] = "c107c09cdf1a885377e9bb8c80cca1296a8791fc7b426abb91345927f47bef29"

URI_x86_64_v2_python3.13-freethreading-debug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-freethreading-debug-3.13.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-freethreading-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-freethreading-debug}"
SRC_URI[x86_64_v2_python3.13-freethreading-debug.sha256sum] = "48f31b771e808e4671d59a2ac7547e8b3f0ab132f129e4e0ff7f00f325eb2a11"

URI_x86_64_v2_python3.13-idle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-idle-3.13.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-idle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-idle}"
SRC_URI[x86_64_v2_python3.13-idle.sha256sum] = "2be5763b55e1629aa23f7c3050d989e84f85600b5cd28d7db7c91dc2669d9b4d"

URI_x86_64_v2_python3.13-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-libs-3.13.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-libs}"
SRC_URI[x86_64_v2_python3.13-libs.sha256sum] = "e851f8bfba66cab5d57e2bc39de443eefc556da966ba30e699c3a037545680ea"

URI_x86_64_v2_python3.13-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-test-3.13.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-test}"
SRC_URI[x86_64_v2_python3.13-test.sha256sum] = "f02a637fa4ed1fe6425785366d49ef013739d0e50cdc25cf72ac86d387aa2321"

URI_x86_64_v2_python3.13-tkinter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-tkinter-3.13.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-tkinter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-tkinter}"
SRC_URI[x86_64_v2_python3.13-tkinter.sha256sum] = "df9803081917a52d2c0499f5d4ed505a67c0d55820adae33798eda39fbb3401a"

URI_aarch64_python3.13 = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-3.13.15-1.el10_2.aarch64.rpm;name=aarch64_python3.13;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13}"
SRC_URI[aarch64_python3.13.sha256sum] = "647768d3b267df91b03001b3a4fb078bce3c4b222fde27aea37f1e004a064831"

URI_aarch64_python3.13-debug = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-debug-3.13.15-1.el10_2.aarch64.rpm;name=aarch64_python3.13-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-debug}"
SRC_URI[aarch64_python3.13-debug.sha256sum] = "6001463d8d87f0eef354b93fa9718026ce4128b7240bca8d41ae97b806d2e4b3"

URI_aarch64_python3.13-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-devel-3.13.15-1.el10_2.aarch64.rpm;name=aarch64_python3.13-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-devel}"
SRC_URI[aarch64_python3.13-devel.sha256sum] = "0bf7cbd5c978e955febfdee025146e0a8ca608096e9a9342cec98fe42b29cb21"

URI_aarch64_python3.13-freethreading = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-freethreading-3.13.15-1.el10_2.aarch64.rpm;name=aarch64_python3.13-freethreading;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-freethreading}"
SRC_URI[aarch64_python3.13-freethreading.sha256sum] = "773a571c5ba7ebcc36447021cb515c5e6f5899022b94b880961f1532f4936520"

URI_aarch64_python3.13-freethreading-debug = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-freethreading-debug-3.13.15-1.el10_2.aarch64.rpm;name=aarch64_python3.13-freethreading-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-freethreading-debug}"
SRC_URI[aarch64_python3.13-freethreading-debug.sha256sum] = "8e474c9103c3e3700af4f0907efc2b2414fef08770ab2263b684f952079b6bb5"

URI_aarch64_python3.13-idle = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-idle-3.13.15-1.el10_2.aarch64.rpm;name=aarch64_python3.13-idle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-idle}"
SRC_URI[aarch64_python3.13-idle.sha256sum] = "9e25050208864821d8621b6780a45afa45d81faed9d866c368ad83585d984203"

URI_aarch64_python3.13-libs = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-libs-3.13.15-1.el10_2.aarch64.rpm;name=aarch64_python3.13-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-libs}"
SRC_URI[aarch64_python3.13-libs.sha256sum] = "4fdf7417fd16fc457ddbfe4e456e5fc756ff3e5df11351f688e3cdd4b83d7c6f"

URI_aarch64_python3.13-test = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-test-3.13.15-1.el10_2.aarch64.rpm;name=aarch64_python3.13-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-test}"
SRC_URI[aarch64_python3.13-test.sha256sum] = "3ccb08f8aeb255f51aecac4d956085467d44cfa2a63ae0eb30766c05d8b1c7bd"

URI_aarch64_python3.13-tkinter = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-tkinter-3.13.15-1.el10_2.aarch64.rpm;name=aarch64_python3.13-tkinter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-tkinter}"
SRC_URI[aarch64_python3.13-tkinter.sha256sum] = "cdfb871d625d114cb9fdf28c959ac38ac499e639d0e0b2bdf5297322eed64a86"

RDEPENDS:python3.13 = " \
 glibc \
 python3.13-libs \
 "
RDEPENDS:python3.13-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.13 \
 python3.13-devel \
 python3.13-idle \
 python3.13-libs \
 python3.13-test \
 python3.13-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.13-devel = " \
 bash \
 pkgconf-pkg-config \
 python-rpm-macros \
 python3-rpm-generators \
 python3-rpm-macros \
 python3.13 \
 python3.13-libs \
 "
RDEPENDS:python3.13-freethreading = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.13-pip-wheel \
 python3.13-setuptools-wheel \
 readline \
 sqlite-libs \
 tcl \
 tk \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.13-freethreading-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.13-freethreading \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.13-idle = " \
 python3.13 \
 python3.13-tkinter \
 "
RDEPENDS:python3.13-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3.13-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.13-test = " \
 bash \
 glibc \
 libgcc \
 python3.13 \
 python3.13-libs \
 python3.13-setuptools-wheel \
 "
RDEPENDS:python3.13-tkinter = " \
 glibc \
 python3.13 \
 tcl \
 tk \
 "
