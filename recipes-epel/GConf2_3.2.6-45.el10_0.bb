# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "GConf2"
PV = "3.2.6"
PR = "45.el10_0"
PACKAGES = " \
 GConf2 \
 GConf2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/GConf2-3.2.6-45.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44ab67a474d54a97eb9577ea823697c590e5cfeb5621d1443bb11f9a483049ca"

URI_x86_64_v2_GConf2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/GConf2-3.2.6-45.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_GConf2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_GConf2}"
SRC_URI[x86_64_v2_GConf2.sha256sum] = "6d53c3c434e32e90f811f073e29bf23c1b27d2abc04749e1026fb663b077dfab"

URI_x86_64_v2_GConf2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/GConf2-devel-3.2.6-45.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_GConf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_GConf2-devel}"
SRC_URI[x86_64_v2_GConf2-devel.sha256sum] = "55d84102cfcfa01dd62d516df475028d21c5d5a13e7ed330c809908610ebe37c"

URI_aarch64_GConf2 = "${EPEL_MIRROR}/aarch64/Packages/g/GConf2-3.2.6-45.el10_0.aarch64.rpm;name=aarch64_GConf2;unpack=0"
SRC_URI:append = " ${URI_aarch64_GConf2}"
SRC_URI[aarch64_GConf2.sha256sum] = "b7e9d843da147b165f11e4e8d672da70cd650019cb8179841c834f8908115f7d"

URI_aarch64_GConf2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/GConf2-devel-3.2.6-45.el10_0.aarch64.rpm;name=aarch64_GConf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_GConf2-devel}"
SRC_URI[aarch64_GConf2-devel.sha256sum] = "6b33dd010dfb57a31d78deba76f00b392120911e8a4221c92371e5d2ec28f6c7"

RDEPENDS:GConf2 = " \
 bash \
 dbus \
 dbus-glib \
 dbus-libs \
 glib2 \
 glibc \
 libxml2 \
 polkit-libs \
 procps-ng \
 "
RDEPENDS:GConf2-devel = " \
 GConf2 \
 dbus-devel \
 glib2-devel \
 pkgconf-pkg-config \
 "
