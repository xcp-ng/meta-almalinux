# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mxml"
PV = "3.3.1"
PR = "8.el10_1"
PACKAGES = " \
 mxml \
 mxml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mxml-3.3.1-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b990f6964e3299ec7923344bdbf0b99c0fba79ab976117dd266bf0d194c5b3a"

URI_x86_64_v2_mxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mxml-3.3.1-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mxml}"
SRC_URI[x86_64_v2_mxml.sha256sum] = "40b10acdb081c8d807d4a3c6a0653d3a47c50a3fb2f75c4befac8a5b2cc9debb"

URI_x86_64_v2_mxml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mxml-devel-3.3.1-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mxml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mxml-devel}"
SRC_URI[x86_64_v2_mxml-devel.sha256sum] = "8f99e1a7cd7dcd7ad93ea8be36a4e456b850cbd34e646a8175b5f8a162099f49"

URI_aarch64_mxml = "${EPEL_MIRROR}/aarch64/Packages/m/mxml-3.3.1-8.el10_1.aarch64.rpm;name=aarch64_mxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_mxml}"
SRC_URI[aarch64_mxml.sha256sum] = "15d5b4a7f453c094d2d7960dd5fdb1de94fd70665fa83d2c95bda8c3e1fd42e8"

URI_aarch64_mxml-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mxml-devel-3.3.1-8.el10_1.aarch64.rpm;name=aarch64_mxml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mxml-devel}"
SRC_URI[aarch64_mxml-devel.sha256sum] = "24e7f9d6b57bbc32109534b1763fee274bca4cb4aa281ba9e51b9707841ef0da"

RDEPENDS:mxml = " \
 glibc \
 "
RDEPENDS:mxml-devel = " \
 mxml \
 pkgconf-pkg-config \
 "
