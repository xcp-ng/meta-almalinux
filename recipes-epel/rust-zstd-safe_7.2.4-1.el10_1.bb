# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zstd-safe"
PV = "7.2.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-zstd-safe+arrays-devel \
 rust-zstd-safe+bindgen-devel \
 rust-zstd-safe+debug-devel \
 rust-zstd-safe+default-devel \
 rust-zstd-safe+doc-cfg-devel \
 rust-zstd-safe+experimental-devel \
 rust-zstd-safe+fat-lto-devel \
 rust-zstd-safe+legacy-devel \
 rust-zstd-safe+no_asm-devel \
 rust-zstd-safe+pkg-config-devel \
 rust-zstd-safe+seekable-devel \
 rust-zstd-safe+std-devel \
 rust-zstd-safe+thin-devel \
 rust-zstd-safe+thin-lto-devel \
 rust-zstd-safe+zdict_builder-devel \
 rust-zstd-safe+zstdmt-devel \
 rust-zstd-safe-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zstd-safe-7.2.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92274f1144eaa4eb2405b81d099289b8f57f011643c4e545ff1524f84ce03a09"

URI_x86_64_v2_rust-zstd-safe+arrays-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+arrays-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+arrays-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+arrays-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+arrays-devel.sha256sum] = "e6ffd7a49014a5462ee0ebeba612a9f8bbd17d2a9284263fb24d26cb75779622"

URI_x86_64_v2_rust-zstd-safe+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+bindgen-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+bindgen-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+bindgen-devel.sha256sum] = "6d810ebd06995835764495808a7998df63a7942de62038f6fa23e5af6d37e5f3"

URI_x86_64_v2_rust-zstd-safe+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+debug-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+debug-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+debug-devel.sha256sum] = "8c38eed3b6f23034dd7d93b8754fd671724c1615983bc506e82062ba9113bc76"

URI_x86_64_v2_rust-zstd-safe+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+default-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+default-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+default-devel.sha256sum] = "3111833e1b7ceb67a2126796900d3960662674ab1d15a0eeba4093b2f1e21319"

URI_x86_64_v2_rust-zstd-safe+doc-cfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+doc-cfg-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+doc-cfg-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+doc-cfg-devel.sha256sum] = "1b5a596bb594610c28f7dc4adec2635bd07b6d9285cbd1697e58c4415868e68f"

URI_x86_64_v2_rust-zstd-safe+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+experimental-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+experimental-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+experimental-devel.sha256sum] = "266a11acd405b51c6754e08e94360a798ab72057dc17a904fe6592dbcdf1872b"

URI_x86_64_v2_rust-zstd-safe+fat-lto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+fat-lto-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+fat-lto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+fat-lto-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+fat-lto-devel.sha256sum] = "5f7f76dc3ae1f902843f9c8371295c0d05a3490fe159f2f3e7860eece2703bc8"

URI_x86_64_v2_rust-zstd-safe+legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+legacy-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+legacy-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+legacy-devel.sha256sum] = "e526f9b1fd59de28144e2208f01f69ae5037626e33c1f37615246bb9b993e3fb"

URI_x86_64_v2_rust-zstd-safe+no_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+no_asm-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+no_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+no_asm-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+no_asm-devel.sha256sum] = "457e8f3ab9cf5c4a3ff7cbb36aae9aff87277bf23a1bd5c77b7d0018d4bdbd23"

URI_x86_64_v2_rust-zstd-safe+pkg-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+pkg-config-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+pkg-config-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+pkg-config-devel.sha256sum] = "a412aea8d00d3dca32884e25db80aaa7d924a41c02814c13c23e899d99b3c1cc"

URI_x86_64_v2_rust-zstd-safe+seekable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+seekable-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+seekable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+seekable-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+seekable-devel.sha256sum] = "b35c5657da2f8d9083964be1e00e3d984076b9e180034314f510dfd8a730cd60"

URI_x86_64_v2_rust-zstd-safe+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+std-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+std-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+std-devel.sha256sum] = "6542958e20844cf7436dfd6d40de1429c8830fb0d09350be7b7b820338dbd60c"

URI_x86_64_v2_rust-zstd-safe+thin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+thin-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+thin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+thin-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+thin-devel.sha256sum] = "1d3983d113a83297df3f7f8ad66472993d633a630c0912d9ee28bf349f4c95ac"

URI_x86_64_v2_rust-zstd-safe+thin-lto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+thin-lto-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+thin-lto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+thin-lto-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+thin-lto-devel.sha256sum] = "2a3515774ff142d4d0b6d70e17dfdcebb87a4f59ac3987ca436e06428bbc0d43"

URI_x86_64_v2_rust-zstd-safe+zdict_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+zdict_builder-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+zdict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+zdict_builder-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+zdict_builder-devel.sha256sum] = "7d7e8dbd25dc6526d01ee781d32d7f824b5bc9ca6422268bcfa78030d2f95906"

URI_x86_64_v2_rust-zstd-safe+zstdmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+zstdmt-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+zstdmt-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+zstdmt-devel.sha256sum] = "aeee8db3dc3c882d4ee3311d5f3fc8e8f54a02f2b79cf54b2266153f705bfd69"

URI_x86_64_v2_rust-zstd-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe-devel-7.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe-devel.sha256sum] = "81701b3e493fd57fc4f4645cab4d13284213cf459de8c78417b175f54725071c"

URI_aarch64_rust-zstd-safe+arrays-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+arrays-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+arrays-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+arrays-devel}"
SRC_URI[aarch64_rust-zstd-safe+arrays-devel.sha256sum] = "bb1ad4e7b06f8b116bed33af12cd536b6a94283f69686135f4a1625126c1529c"

URI_aarch64_rust-zstd-safe+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+bindgen-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+bindgen-devel}"
SRC_URI[aarch64_rust-zstd-safe+bindgen-devel.sha256sum] = "ea2a875dabc797dd7a16f0869e36900ea95063235e77fee7330b1440643200e3"

URI_aarch64_rust-zstd-safe+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+debug-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+debug-devel}"
SRC_URI[aarch64_rust-zstd-safe+debug-devel.sha256sum] = "2d4688821d931c834165f1a8cb0b0298259517e1f1e2e5b6cbefa98b5e202957"

URI_aarch64_rust-zstd-safe+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+default-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+default-devel}"
SRC_URI[aarch64_rust-zstd-safe+default-devel.sha256sum] = "290ca4173a1d0dfed5ed73836ac0bdc661e328f5f2556de208a80e063c50a166"

URI_aarch64_rust-zstd-safe+doc-cfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+doc-cfg-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+doc-cfg-devel}"
SRC_URI[aarch64_rust-zstd-safe+doc-cfg-devel.sha256sum] = "72fdf4ef419d55f36f9b389ad4ddeb0badb54fb74e5a94d6831cdc7c825e32bd"

URI_aarch64_rust-zstd-safe+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+experimental-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+experimental-devel}"
SRC_URI[aarch64_rust-zstd-safe+experimental-devel.sha256sum] = "12d1696e34eb94ff295902678de8fb53486eac523aedaea9983a1a752306fa02"

URI_aarch64_rust-zstd-safe+fat-lto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+fat-lto-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+fat-lto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+fat-lto-devel}"
SRC_URI[aarch64_rust-zstd-safe+fat-lto-devel.sha256sum] = "6af8e40834bb8517a41cf0482f659bd8cf2a90c4eb422006d71704386631aefb"

URI_aarch64_rust-zstd-safe+legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+legacy-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+legacy-devel}"
SRC_URI[aarch64_rust-zstd-safe+legacy-devel.sha256sum] = "51a17a46e4252f0eef05401af5f9057e84f9339c56cf186e52a9be6f5005c6d3"

URI_aarch64_rust-zstd-safe+no_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+no_asm-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+no_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+no_asm-devel}"
SRC_URI[aarch64_rust-zstd-safe+no_asm-devel.sha256sum] = "e5255a772847d20a6873149f6bc44c9b7f024b987de18e1d2fa01cf655bbf861"

URI_aarch64_rust-zstd-safe+pkg-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+pkg-config-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+pkg-config-devel}"
SRC_URI[aarch64_rust-zstd-safe+pkg-config-devel.sha256sum] = "e021e40b478808d6f9eafd9df8c8ae2faa86dc5e1d3fb2fc6f6b24cca64e3a71"

URI_aarch64_rust-zstd-safe+seekable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+seekable-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+seekable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+seekable-devel}"
SRC_URI[aarch64_rust-zstd-safe+seekable-devel.sha256sum] = "6ce99112917076a33efb937455f549f921db7f5935048cd38a273ec2146d35a4"

URI_aarch64_rust-zstd-safe+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+std-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+std-devel}"
SRC_URI[aarch64_rust-zstd-safe+std-devel.sha256sum] = "11826351ba09347aebd6ada7e4e96f305780291e2a1f6fcde80be1e8506a3348"

URI_aarch64_rust-zstd-safe+thin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+thin-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+thin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+thin-devel}"
SRC_URI[aarch64_rust-zstd-safe+thin-devel.sha256sum] = "94376e678df5613368f2cf32c285781515800c31eb40fdb69b7b0b70ccafffcb"

URI_aarch64_rust-zstd-safe+thin-lto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+thin-lto-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+thin-lto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+thin-lto-devel}"
SRC_URI[aarch64_rust-zstd-safe+thin-lto-devel.sha256sum] = "78b03ce5103573f5236e849e715bdb2fb13f73080857c0b2f9e435856516ee3f"

URI_aarch64_rust-zstd-safe+zdict_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+zdict_builder-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+zdict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+zdict_builder-devel}"
SRC_URI[aarch64_rust-zstd-safe+zdict_builder-devel.sha256sum] = "0aab8fd1f37d3ad61d2cb5a750d98861e8e0c3bcf3dd5fdb65c659a968261a80"

URI_aarch64_rust-zstd-safe+zstdmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+zstdmt-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+zstdmt-devel}"
SRC_URI[aarch64_rust-zstd-safe+zstdmt-devel.sha256sum] = "2669e86164b8ada9ac4d652746334d20e6266b176381cf4871c0ab28c4d46c11"

URI_aarch64_rust-zstd-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe-devel-7.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe-devel}"
SRC_URI[aarch64_rust-zstd-safe-devel.sha256sum] = "0df51f0f8be2cfb61b30cf4a120e2e37583c51ec0dffa268009efea1cb4701e2"

RDEPENDS:rust-zstd-safe+arrays-devel = " \
 cargo \
 rust-zstd-safe-devel \
 "
RDEPENDS:rust-zstd-safe+bindgen-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+bindgen-devel \
 "
RDEPENDS:rust-zstd-safe+debug-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+debug-devel \
 "
RDEPENDS:rust-zstd-safe+default-devel = " \
 cargo \
 rust-zstd-safe+arrays-devel \
 rust-zstd-safe+legacy-devel \
 rust-zstd-safe+zdict_builder-devel \
 rust-zstd-safe-devel \
 "
RDEPENDS:rust-zstd-safe+doc-cfg-devel = " \
 cargo \
 rust-zstd-safe-devel \
 "
RDEPENDS:rust-zstd-safe+experimental-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+experimental-devel \
 "
RDEPENDS:rust-zstd-safe+fat-lto-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+fat-lto-devel \
 "
RDEPENDS:rust-zstd-safe+legacy-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+legacy-devel \
 "
RDEPENDS:rust-zstd-safe+no_asm-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+no_asm-devel \
 "
RDEPENDS:rust-zstd-safe+pkg-config-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+pkg-config-devel \
 "
RDEPENDS:rust-zstd-safe+seekable-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+seekable-devel \
 "
RDEPENDS:rust-zstd-safe+std-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+std-devel \
 "
RDEPENDS:rust-zstd-safe+thin-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+thin-devel \
 "
RDEPENDS:rust-zstd-safe+thin-lto-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+thin-lto-devel \
 "
RDEPENDS:rust-zstd-safe+zdict_builder-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+zdict_builder-devel \
 "
RDEPENDS:rust-zstd-safe+zstdmt-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+zstdmt-devel \
 "
RDEPENDS:rust-zstd-safe-devel = " \
 cargo \
 rust \
 rust-zstd-sys-devel \
 "
