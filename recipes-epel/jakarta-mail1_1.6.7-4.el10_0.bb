# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jakarta-mail1"
PV = "1.6.7"
PR = "4.el10_0"
PACKAGES = " \
 jakarta-mail1 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jakarta-mail1-1.6.7-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da982d00dbda89d1972d77256b028e3d42f535cbdfcea105ea34bb02e1ad3e18"

URI_x86_64_v2_jakarta-mail1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jakarta-mail1-1.6.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_jakarta-mail1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jakarta-mail1}"
SRC_URI[x86_64_v2_jakarta-mail1.sha256sum] = "d610b9629fbfb00cadc067d65fbc6929f2e5082a37774a2f14cceb1ab12317a8"

URI_aarch64_jakarta-mail1 = "${EPEL_MIRROR}/aarch64/Packages/j/jakarta-mail1-1.6.7-4.el10_0.noarch.rpm;name=aarch64_jakarta-mail1;unpack=0"
SRC_URI:append = " ${URI_aarch64_jakarta-mail1}"
SRC_URI[aarch64_jakarta-mail1.sha256sum] = "44e62e3062d32739442ffa8ac08f72db9cf9b8de3a6290485eb1f83f5b8a1066"

RDEPENDS:jakarta-mail1 = " \
 jakarta-activation1 \
 javapackages-filesystem \
 "
