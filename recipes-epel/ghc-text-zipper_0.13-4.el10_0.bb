# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-text-zipper"
PV = "0.13"
PR = "4.el10_0"
PACKAGES = " \
 ghc-text-zipper \
 ghc-text-zipper-devel \
 ghc-text-zipper-doc \
 ghc-text-zipper-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-text-zipper-0.13-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "183f1c0479127451bfa18157b28b1b436ff3672ef7b78f0a48b396480bc3bafc"

URI_x86_64_v2_ghc-text-zipper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-zipper-0.13-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-zipper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-zipper}"
SRC_URI[x86_64_v2_ghc-text-zipper.sha256sum] = "cf0f9a074ae8f07bf6664488e2cec5f40182d8dbed5b5af398beb6a6f04397ac"

URI_x86_64_v2_ghc-text-zipper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-zipper-devel-0.13-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-zipper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-zipper-devel}"
SRC_URI[x86_64_v2_ghc-text-zipper-devel.sha256sum] = "fe46ab7a93da54b685b52584111f118e7237e6a3a10d3194faa5ce1abf32b8e0"

URI_x86_64_v2_ghc-text-zipper-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-zipper-doc-0.13-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-text-zipper-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-zipper-doc}"
SRC_URI[x86_64_v2_ghc-text-zipper-doc.sha256sum] = "cde9f9f4ccd05e504dea68ef9614250f4df317b99eac81ab6cd307945b5913eb"

URI_x86_64_v2_ghc-text-zipper-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-zipper-prof-0.13-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-zipper-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-zipper-prof}"
SRC_URI[x86_64_v2_ghc-text-zipper-prof.sha256sum] = "46692f427a69c1778aff8e2d6ff626f35e59839323842044d894ee0ab3ebbec2"

URI_aarch64_ghc-text-zipper = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-zipper-0.13-4.el10_0.aarch64.rpm;name=aarch64_ghc-text-zipper;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-zipper}"
SRC_URI[aarch64_ghc-text-zipper.sha256sum] = "f05e82c32750cdcacec585e8b752260b2a62dbe9ddf7a88ffcc80833d990d8ef"

URI_aarch64_ghc-text-zipper-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-zipper-devel-0.13-4.el10_0.aarch64.rpm;name=aarch64_ghc-text-zipper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-zipper-devel}"
SRC_URI[aarch64_ghc-text-zipper-devel.sha256sum] = "c2c04e95592b8601470837eccc6f4632704bac82a54757c9c937ce7926157230"

URI_aarch64_ghc-text-zipper-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-zipper-doc-0.13-4.el10_0.noarch.rpm;name=aarch64_ghc-text-zipper-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-zipper-doc}"
SRC_URI[aarch64_ghc-text-zipper-doc.sha256sum] = "88084fcd05dda91e439a6a120859e2e4e041b47fef6df6f961cf8be13beab487"

URI_aarch64_ghc-text-zipper-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-zipper-prof-0.13-4.el10_0.aarch64.rpm;name=aarch64_ghc-text-zipper-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-zipper-prof}"
SRC_URI[aarch64_ghc-text-zipper-prof.sha256sum] = "5a6298922173856537f65b0d0a439c9942ec15cbfefd0d564d45bcaf0662e6e3"

RDEPENDS:ghc-text-zipper = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-primitive \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-text-zipper-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-text-devel \
 ghc-text-zipper \
 ghc-vector-devel \
 "
RDEPENDS:ghc-text-zipper-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-text-zipper-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-text-prof \
 ghc-text-zipper-devel \
 ghc-vector-prof \
 "
