# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lldb"
PV = "18.1.8"
PR = "1.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lldb-18.1.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bb7627508b5308c6cfac6de4b70895b89d87b2c64c143dffaa4b19b5f4fb198"

