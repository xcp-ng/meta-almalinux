# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvpl"
PE = "1"
PV = "2.15.0"
PR = "2.el10_0"
PACKAGES:x86_64_v2 = " \
 libvpl \
 libvpl-devel \
 libvpl-samples \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/l/libvpl-2.15.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e651af26d8ad52dffe0228309810c0309f6f018eaaae32eb5dc21c386253f51"

URI_x86_64_v2_libvpl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-2.15.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl}"
SRC_URI[x86_64_v2_libvpl.sha256sum] = "4fd67a1de6d247a85415d60c253fdaf359baa21b4025b1aecb92e308dd3c19f4"

URI_x86_64_v2_libvpl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-devel-2.15.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-devel}"
SRC_URI[x86_64_v2_libvpl-devel.sha256sum] = "bf154c2f80f0395b470e3bfa93f38fe19fc99f5df6409da804d6a211ad471dc4"

URI_x86_64_v2_libvpl-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-samples-2.15.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-samples}"
SRC_URI[x86_64_v2_libvpl-samples.sha256sum] = "43196448efb23c9543b7b08de63b04bc4da56d23b29f5586a501999a9ca64d2e"

RDEPENDS:libvpl = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libvpl-devel = " \
 cmake-filesystem \
 libvpl \
 pkgconf-pkg-config \
 "
RDEPENDS:libvpl-samples = " \
 libvpl-devel \
 "
