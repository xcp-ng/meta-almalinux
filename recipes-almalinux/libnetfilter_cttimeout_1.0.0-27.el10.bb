# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnetfilter_cttimeout"
PV = "1.0.0"
PR = "27.el10"
PACKAGES = " \
 libnetfilter_cttimeout \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libnetfilter_cttimeout-1.0.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2993f28d9722db6d0518539f1be04e48bb92727f6311f00b82daa1af1941f41a"

URI_x86_64_v2_libnetfilter_cttimeout = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnetfilter_cttimeout-1.0.0-27.el10.x86_64_v2.rpm;name=x86_64_v2_libnetfilter_cttimeout;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnetfilter_cttimeout}"
SRC_URI[x86_64_v2_libnetfilter_cttimeout.sha256sum] = "fdb6b64395cb0d93fd69ac89dccb6e4d469d46e2915e0b1d078f569f2ddfe5bd"

URI_aarch64_libnetfilter_cttimeout = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnetfilter_cttimeout-1.0.0-27.el10.aarch64.rpm;name=aarch64_libnetfilter_cttimeout;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnetfilter_cttimeout}"
SRC_URI[aarch64_libnetfilter_cttimeout.sha256sum] = "cf02e18d252bc2b36209ffe907d50fd362aef0074f8c01f3d7a9767e841423f5"

RDEPENDS:libnetfilter_cttimeout = " \
 glibc \
 libmnl \
 "
