# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-exr"
PV = "1.74.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-exr+default-devel \
 rust-exr+rayon-devel \
 rust-exr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-exr-1.74.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fbf418c1c97ee84357e980d0cdeba663136c11cd14ff6fa867e20cd5c4dc46f"

URI_x86_64_v2_rust-exr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-exr+default-devel-1.74.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-exr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-exr+default-devel}"
SRC_URI[x86_64_v2_rust-exr+default-devel.sha256sum] = "6acae66c6ec4ca51fc36db88f2ee63947877d712790da7390213165f93ec1cab"

URI_x86_64_v2_rust-exr+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-exr+rayon-devel-1.74.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-exr+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-exr+rayon-devel}"
SRC_URI[x86_64_v2_rust-exr+rayon-devel.sha256sum] = "0adca792c10a3efcafff159bcb346531a56958e59d1766efbab1876985d38f8e"

URI_x86_64_v2_rust-exr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-exr-devel-1.74.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-exr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-exr-devel}"
SRC_URI[x86_64_v2_rust-exr-devel.sha256sum] = "b9d764e6548e0face4e69ba61242e6d6e496ff763b8c658a2f0a9400baf49100"

URI_aarch64_rust-exr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-exr+default-devel-1.74.0-1.el10_1.noarch.rpm;name=aarch64_rust-exr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-exr+default-devel}"
SRC_URI[aarch64_rust-exr+default-devel.sha256sum] = "2adfb946cb1cf0949336c1ef7abb5d531a13f88a06c0d8cd61299ad1c2102eb7"

URI_aarch64_rust-exr+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-exr+rayon-devel-1.74.0-1.el10_1.noarch.rpm;name=aarch64_rust-exr+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-exr+rayon-devel}"
SRC_URI[aarch64_rust-exr+rayon-devel.sha256sum] = "df27e25ce7e77985a7702927f31b35d19b9b50fbd1574a241aa102069660a775"

URI_aarch64_rust-exr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-exr-devel-1.74.0-1.el10_1.noarch.rpm;name=aarch64_rust-exr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-exr-devel}"
SRC_URI[aarch64_rust-exr-devel.sha256sum] = "5ec763f246d64a89153a5d57ce1235f8a6724387c9ff8732782833e945006d83"

RDEPENDS:rust-exr+default-devel = " \
 cargo \
 rust-exr+rayon-devel \
 rust-exr-devel \
 "
RDEPENDS:rust-exr+rayon-devel = " \
 cargo \
 rust-exr-devel \
 rust-rayon-core+default-devel \
 "
RDEPENDS:rust-exr-devel = " \
 cargo \
 rust \
 rust-bit_field+default-devel \
 rust-half+default-devel \
 rust-lebe+default-devel \
 rust-miniz_oxide+default-devel \
 rust-smallvec+default-devel \
 rust-zune-inflate+zlib-devel \
 rust-zune-inflate-devel \
 "
