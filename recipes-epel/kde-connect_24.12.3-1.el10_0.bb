# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-connect"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kde-connect \
 kde-connect-libs \
 kde-connect-nautilus \
 kdeconnectd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-connect-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c741f58df2389a4d19dc92673a26b2cca405ec31441d0d865467555c0e20c44"

URI_x86_64_v2_kde-connect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-connect-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-connect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-connect}"
SRC_URI[x86_64_v2_kde-connect.sha256sum] = "ff2dd20f02c726e63e25373e473148e1d968bdf3b46e0041dc4fdf11f7b4307c"

URI_x86_64_v2_kde-connect-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-connect-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-connect-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-connect-libs}"
SRC_URI[x86_64_v2_kde-connect-libs.sha256sum] = "3b57ff97a62e60a7cac42a053d8bde678ce5c8bf1528c59a78554ff733bd4cd5"

URI_x86_64_v2_kde-connect-nautilus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-connect-nautilus-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-connect-nautilus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-connect-nautilus}"
SRC_URI[x86_64_v2_kde-connect-nautilus.sha256sum] = "364297119d2312599ec3614ff00d995dbacbc644c6f2f088ebbad0c8e7e2071b"

URI_x86_64_v2_kdeconnectd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeconnectd-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdeconnectd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdeconnectd}"
SRC_URI[x86_64_v2_kdeconnectd.sha256sum] = "25593725053c3568865d194c3886030b7120a716769413eba938a8de9f71a885"

URI_aarch64_kde-connect = "${EPEL_MIRROR}/aarch64/Packages/k/kde-connect-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kde-connect;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-connect}"
SRC_URI[aarch64_kde-connect.sha256sum] = "26184049ab8dbc658b2b8bac450d78a90dc9eed0b0fe3e76ebad14f2abaa0c31"

URI_aarch64_kde-connect-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kde-connect-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kde-connect-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-connect-libs}"
SRC_URI[aarch64_kde-connect-libs.sha256sum] = "98cd05de7d364f6690e48c9bee74d2fcfdeb2c3c58baa387f96cdc9fa75758cf"

URI_aarch64_kde-connect-nautilus = "${EPEL_MIRROR}/aarch64/Packages/k/kde-connect-nautilus-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kde-connect-nautilus;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-connect-nautilus}"
SRC_URI[aarch64_kde-connect-nautilus.sha256sum] = "1ad7a6677c2fe1ac2273772c96d6cd2ec880ce2f9066e5398358297e5cae2094"

URI_aarch64_kdeconnectd = "${EPEL_MIRROR}/aarch64/Packages/k/kdeconnectd-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdeconnectd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdeconnectd}"
SRC_URI[aarch64_kdeconnectd.sha256sum] = "e330ad5a19c6c463131ad8bc902000164f5e11446d666d6deefac5f389c2c4bd"

RDEPENDS:kde-connect = " \
 fuse-sshfs \
 glibc \
 kde-cli-tools \
 kde-connect-libs \
 kdeconnectd \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kpeople \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 libwayland-client \
 qca-qt6-ossl \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
RDEPENDS:kde-connect-libs = " \
 dbus-libs \
 glibc \
 kde-connect \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-modemmanager-qt \
 kf6-solid \
 libX11 \
 libXtst \
 libfakekey \
 libstdc++ \
 libxkbcommon \
 openssl-libs \
 pulseaudio-qt-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtconnectivity \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
RDEPENDS:kde-connect-nautilus = " \
 kdeconnectd \
 nautilus-python \
 "
RDEPENDS:kdeconnectd = " \
 glibc \
 kde-connect-libs \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-knotifications \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
