# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kitemmodels"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kitemmodels \
 kf6-kitemmodels-devel \
 kf6-kitemmodels-doc \
 kf6-kitemmodels-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kitemmodels-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f38bcbe53d07b737b02c5c242a9e0c3c335f257777fd26fb05d16882e9e35771"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemmodels;unpack=0"
SRC_URI[x86_64_v2_kf6-kitemmodels.sha256sum] = "b2bb6b12832fe0ae8af52908e6e376ee8407cb377928fbebb3309d18866c8863"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemmodels-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kitemmodels-devel.sha256sum] = "cc9f4357c7939371598d87b946f7bc8e283365f25f525901bb13f79fa74e3e66"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemmodels-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kitemmodels-doc.sha256sum] = "e75c15f7d885c8ec11d42e9f441e19390f6aeddb82aed6402d89e4579a882c17"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemmodels-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kitemmodels-html.sha256sum] = "bd209c6a2b9e31a06c90a65f89ad7b8dd56895570f010f44661482d2b490a16a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kitemmodels;unpack=0"
SRC_URI[aarch64_kf6-kitemmodels.sha256sum] = "952c5b272d7e2660a04a9ef86b7bbf73b98570555787b40801ae711f81adaaa1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kitemmodels-devel;unpack=0"
SRC_URI[aarch64_kf6-kitemmodels-devel.sha256sum] = "c8414704d7057fccab515e8cf6fa5667882ee45e92f2fb0d39559b5841d03d67"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kitemmodels-doc;unpack=0"
SRC_URI[aarch64_kf6-kitemmodels-doc.sha256sum] = "63e4af02640a28942b09e02b5a68a8bc6a567fb158444bd2e5024d22f4a7b356"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kitemmodels-html;unpack=0"
SRC_URI[aarch64_kf6-kitemmodels-html.sha256sum] = "e34ad8bcfa1184883d0cef5a6ce5e7436c43d5bd9148cfa9fb26d9e70ec67e42"

RDEPENDS:kf6-kitemmodels = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kitemmodels-devel = " \
 cmake-filesystem \
 kf6-kitemmodels \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kitemmodels-doc = " \
 "
RDEPENDS:kf6-kitemmodels-html = " \
 "
