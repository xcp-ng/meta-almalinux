# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-http-types"
PV = "0.12.4"
PR = "1.el10_0"
PACKAGES = " \
 ghc-http-types \
 ghc-http-types-devel \
 ghc-http-types-doc \
 ghc-http-types-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-http-types-0.12.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7810212d29b567fc46501db9852ac8d8fd0e078ea286307f72b3a1e2db9583cb"

URI_x86_64_v2_ghc-http-types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-types-0.12.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http-types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-types}"
SRC_URI[x86_64_v2_ghc-http-types.sha256sum] = "8db7fb1551622c4b08ce470cc716494f66bc489d15bb3052822620f9baad2cf8"

URI_x86_64_v2_ghc-http-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-types-devel-0.12.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-types-devel}"
SRC_URI[x86_64_v2_ghc-http-types-devel.sha256sum] = "3b2a86beb07bb4aa7e10141da708f5f323164cfcc40d15570432111d2d56a954"

URI_x86_64_v2_ghc-http-types-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-types-doc-0.12.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-http-types-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-types-doc}"
SRC_URI[x86_64_v2_ghc-http-types-doc.sha256sum] = "037eb87519e804c20ee95a65585005d5a96a4eaedc2e0155ef5190575d0aa08e"

URI_x86_64_v2_ghc-http-types-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-types-prof-0.12.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http-types-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-types-prof}"
SRC_URI[x86_64_v2_ghc-http-types-prof.sha256sum] = "75134e002a1e16d66615a95793788531424226ea375a33c456632fdb38ed71c7"

URI_aarch64_ghc-http-types = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-types-0.12.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-http-types;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-types}"
SRC_URI[aarch64_ghc-http-types.sha256sum] = "fa910f261d89d3460b447cd6339b6d92b11fb09c12c6742f804002bf01d5d574"

URI_aarch64_ghc-http-types-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-types-devel-0.12.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-http-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-types-devel}"
SRC_URI[aarch64_ghc-http-types-devel.sha256sum] = "27002ab4a0f1848454e7694b05bd83a611c38ccfbb6de3a528be4ddac1899ef9"

URI_aarch64_ghc-http-types-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-types-doc-0.12.4-1.el10_0.noarch.rpm;name=aarch64_ghc-http-types-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-types-doc}"
SRC_URI[aarch64_ghc-http-types-doc.sha256sum] = "64f48ac2af042e6ee4e0e38cdecd893a676c34da8089f63185e1d232fd1e47ea"

URI_aarch64_ghc-http-types-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-types-prof-0.12.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-http-types-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-types-prof}"
SRC_URI[aarch64_ghc-http-types-prof.sha256sum] = "f5608fca8808badc6775abff230bfba0e75ceebf76da01600e2520e1f4d1483f"

RDEPENDS:ghc-http-types = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-http-types-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-compiler \
 ghc-http-types \
 ghc-text-devel \
 "
RDEPENDS:ghc-http-types-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-http-types-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-http-types-devel \
 ghc-text-prof \
 "
