# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro-error2"
PV = "2.0.1"
PR = "4.el10_3"
PACKAGES = " \
 rust-proc-macro-error2+default-devel \
 rust-proc-macro-error2+nightly-devel \
 rust-proc-macro-error2+syn-error-devel \
 rust-proc-macro-error2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro-error2-2.0.1-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29fbcd4445decc1ccdf6d64f0a9a36eaa4e76e8465a56b2e6ce31a272101a687"

URI_x86_64_v2_rust-proc-macro-error2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error2+default-devel-2.0.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-error2+default-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-error2+default-devel.sha256sum] = "5bfa34f0b2babfdbc8911e6a929fc6b587bafeb015c763669a274897f5105dac"

URI_x86_64_v2_rust-proc-macro-error2+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error2+nightly-devel-2.0.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error2+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-error2+nightly-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-error2+nightly-devel.sha256sum] = "2c9e380d410e0d6af89238974dc01366243cd2e1acbaacf59fb84eb566360df5"

URI_x86_64_v2_rust-proc-macro-error2+syn-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error2+syn-error-devel-2.0.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error2+syn-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-error2+syn-error-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-error2+syn-error-devel.sha256sum] = "c7d83479fac7ee9e2260cc2283ecbed90551c8c7fe408d8fc0b88fd4ee3aac86"

URI_x86_64_v2_rust-proc-macro-error2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error2-devel-2.0.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-error2-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-error2-devel.sha256sum] = "f0ac8c2efb5c9afc321b14dc1baee1728bfb66dc6a4895309ccb441038dc44b0"

URI_aarch64_rust-proc-macro-error2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error2+default-devel-2.0.1-4.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-error2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-error2+default-devel}"
SRC_URI[aarch64_rust-proc-macro-error2+default-devel.sha256sum] = "03a148b0687e0c5084c238f30fd1b29b639843219a6c9635bcc906e9654ee792"

URI_aarch64_rust-proc-macro-error2+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error2+nightly-devel-2.0.1-4.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-error2+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-error2+nightly-devel}"
SRC_URI[aarch64_rust-proc-macro-error2+nightly-devel.sha256sum] = "a381dda6a9e90ed673e81ba0af30722e0ef8d681007325d4485d44bcdb1a77e3"

URI_aarch64_rust-proc-macro-error2+syn-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error2+syn-error-devel-2.0.1-4.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-error2+syn-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-error2+syn-error-devel}"
SRC_URI[aarch64_rust-proc-macro-error2+syn-error-devel.sha256sum] = "575c2c725f1559edb9dc5eb2fd2eaea5f72c83101856c7db564f3c910a36439b"

URI_aarch64_rust-proc-macro-error2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error2-devel-2.0.1-4.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-error2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-error2-devel}"
SRC_URI[aarch64_rust-proc-macro-error2-devel.sha256sum] = "6bd9c179bf7d7b574b0bcc0a4b9743fedb9ea293fd8d34d652f67db4ae61365f"

RDEPENDS:rust-proc-macro-error2+default-devel = " \
 cargo \
 rust-proc-macro-error2+syn-error-devel \
 rust-proc-macro-error2-devel \
 "
RDEPENDS:rust-proc-macro-error2+nightly-devel = " \
 cargo \
 rust-proc-macro-error2-devel \
 "
RDEPENDS:rust-proc-macro-error2+syn-error-devel = " \
 cargo \
 rust-proc-macro-error2-devel \
 rust-syn2-devel \
 "
RDEPENDS:rust-proc-macro-error2-devel = " \
 cargo \
 rust \
 rust-proc-macro-error-attr2+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
