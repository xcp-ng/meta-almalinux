# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyqt5-sip"
PV = "12.15.0"
PR = "3.el10_1"
PACKAGES = " \
 python3-pyqt5-sip \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyqt5-sip-12.15.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e4995fc66ee6622a20a34b162401ae9f0c67f0ae0f6460841400930caa0a98c"

URI_x86_64_v2_python3-pyqt5-sip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyqt5-sip-12.15.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt5-sip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt5-sip}"
SRC_URI[x86_64_v2_python3-pyqt5-sip.sha256sum] = "85f2019b7985f1f3f0ea17c29b0edeeaddef4bf21fb8eed63f57c657dd39a6d5"

URI_aarch64_python3-pyqt5-sip = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyqt5-sip-12.15.0-3.el10_1.aarch64.rpm;name=aarch64_python3-pyqt5-sip;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt5-sip}"
SRC_URI[aarch64_python3-pyqt5-sip.sha256sum] = "427555fa051b9528aa1a91dc95373a319fc4eabd308e442e3e8334df926680b0"

RDEPENDS:python3-pyqt5-sip = " \
 glibc \
 python3 \
 "
