# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ciborium-io"
PV = "0.2.2"
PR = "6.el10_3"
PACKAGES = " \
 rust-ciborium-io+alloc-devel \
 rust-ciborium-io+default-devel \
 rust-ciborium-io+std-devel \
 rust-ciborium-io-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ciborium-io-0.2.2-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "006f6cc0ffb03ee6b816452be6c11b0594a730f9be994a13a3f971e96398865c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ciborium-io+alloc-devel-0.2.2-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ciborium-io+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ciborium-io+alloc-devel.sha256sum] = "56b480e785d8573f3c84d38cac2a12d54eea8101edb8aa4c9a208ab7ae606e94"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ciborium-io+default-devel-0.2.2-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ciborium-io+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ciborium-io+default-devel.sha256sum] = "b81b4f0587ecc5feaf4c6083bc79fa07fdd2138f89d10b2be7e20456e85fb6f8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ciborium-io+std-devel-0.2.2-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ciborium-io+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ciborium-io+std-devel.sha256sum] = "67676fd5edf685e9c799b8538b45adc7c1f6331cf42135873c611c54b30dd880"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ciborium-io-devel-0.2.2-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ciborium-io-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ciborium-io-devel.sha256sum] = "5d1faf06f83ff395439b5d4b40b4b9c8b5775256f789d360263d10bc125669d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ciborium-io+alloc-devel-0.2.2-6.el10_3.noarch.rpm;name=aarch64_rust-ciborium-io+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-ciborium-io+alloc-devel.sha256sum] = "7c0ea27c11c7edb22a2c488287a0c8ee7cc2a03a7f222eae44dacdac54277e90"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ciborium-io+default-devel-0.2.2-6.el10_3.noarch.rpm;name=aarch64_rust-ciborium-io+default-devel;unpack=0"
SRC_URI[aarch64_rust-ciborium-io+default-devel.sha256sum] = "1d01c023ed4b269efc35b0d96d230ed7a2386d7e833bd2c70b3551e40dbaac90"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ciborium-io+std-devel-0.2.2-6.el10_3.noarch.rpm;name=aarch64_rust-ciborium-io+std-devel;unpack=0"
SRC_URI[aarch64_rust-ciborium-io+std-devel.sha256sum] = "6fc25d9814a56962b3a9a97487e1192f677708871347b7a9df0d1688e29f19fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ciborium-io-devel-0.2.2-6.el10_3.noarch.rpm;name=aarch64_rust-ciborium-io-devel;unpack=0"
SRC_URI[aarch64_rust-ciborium-io-devel.sha256sum] = "2e66076cac7bf0287e1934e6c32aec3a4b184427674660f569f6acd45a180f6e"

RDEPENDS:rust-ciborium-io+alloc-devel = " \
 cargo \
 rust-ciborium-io-devel \
 "
RDEPENDS:rust-ciborium-io+default-devel = " \
 cargo \
 rust-ciborium-io-devel \
 "
RDEPENDS:rust-ciborium-io+std-devel = " \
 cargo \
 rust-ciborium-io+alloc-devel \
 rust-ciborium-io-devel \
 "
RDEPENDS:rust-ciborium-io-devel = " \
 cargo \
 rust \
 "
