# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-vmihailenco-tagparser-2"
PV = "2.0.0"
PR = "5.el10_0"
PACKAGES = " \
 golang-github-vmihailenco-tagparser-2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-vmihailenco-tagparser-2-2.0.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fdefeced23de243fba1e1bea7e06eb0a9962b7026eca1e75ddd07367ca903f8"

URI_x86_64_v2_golang-github-vmihailenco-tagparser-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-vmihailenco-tagparser-2-devel-2.0.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-vmihailenco-tagparser-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-vmihailenco-tagparser-2-devel}"
SRC_URI[x86_64_v2_golang-github-vmihailenco-tagparser-2-devel.sha256sum] = "c8ed51e5c6eb43dbc70503e03cfdcab5870e018e4b8afa5072ef7a48f2a1951f"

URI_aarch64_golang-github-vmihailenco-tagparser-2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-vmihailenco-tagparser-2-devel-2.0.0-5.el10_0.noarch.rpm;name=aarch64_golang-github-vmihailenco-tagparser-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-vmihailenco-tagparser-2-devel}"
SRC_URI[aarch64_golang-github-vmihailenco-tagparser-2-devel.sha256sum] = "473b60856859b28d73f49e114af1d8671de46e2d6ebcee8e2d63fe8f91499ddf"

RDEPENDS:golang-github-vmihailenco-tagparser-2-devel = " \
 go-filesystem \
 "
