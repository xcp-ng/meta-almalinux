# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osinfo-db"
PV = "20250606"
PR = "2.el10_2"
PACKAGES = " \
 osinfo-db \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/osinfo-db-20250606-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f4986e68d8a1eb677ba50f86d2ee3027f311aff4d88c94d6ee9d066e92d0ab4"

URI_x86_64_v2_osinfo-db = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osinfo-db-20250606-2.el10_2.noarch.rpm;name=x86_64_v2_osinfo-db;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osinfo-db}"
SRC_URI[x86_64_v2_osinfo-db.sha256sum] = "abf201528bfdf55da9bd22401f0d82704a0fcc84d9af13c1157bd6b9e4dd1497"

URI_aarch64_osinfo-db = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osinfo-db-20250606-2.el10_2.noarch.rpm;name=aarch64_osinfo-db;unpack=0"
SRC_URI:append = " ${URI_aarch64_osinfo-db}"
SRC_URI[aarch64_osinfo-db.sha256sum] = "abf201528bfdf55da9bd22401f0d82704a0fcc84d9af13c1157bd6b9e4dd1497"

RDEPENDS:osinfo-db = " \
 hwdata \
 "
