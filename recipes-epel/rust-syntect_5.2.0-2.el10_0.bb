# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-syntect"
PV = "5.2.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-syntect+bincode-devel \
 rust-syntect+default-devel \
 rust-syntect+default-fancy-devel \
 rust-syntect+default-onig-devel \
 rust-syntect+default-syntaxes-devel \
 rust-syntect+default-themes-devel \
 rust-syntect+dump-create-devel \
 rust-syntect+dump-load-devel \
 rust-syntect+fancy-regex-devel \
 rust-syntect+flate2-devel \
 rust-syntect+fnv-devel \
 rust-syntect+html-devel \
 rust-syntect+metadata-devel \
 rust-syntect+onig-devel \
 rust-syntect+parsing-devel \
 rust-syntect+plist-devel \
 rust-syntect+plist-load-devel \
 rust-syntect+regex-fancy-devel \
 rust-syntect+regex-onig-devel \
 rust-syntect+regex-syntax-devel \
 rust-syntect+yaml-load-devel \
 rust-syntect+yaml-rust-devel \
 rust-syntect-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-syntect-5.2.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6c7b59c9122ca90376b7795289cbbb534b781050e2e58268b798838bb1f452c"

URI_x86_64_v2_rust-syntect+bincode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+bincode-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+bincode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+bincode-devel}"
SRC_URI[x86_64_v2_rust-syntect+bincode-devel.sha256sum] = "01dc6622248d80c0ebf07321390f0f49319fb914337af1b2ce5f50f7a9792f8d"

URI_x86_64_v2_rust-syntect+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-devel.sha256sum] = "f8abc1523e751415d681921198a45c4be1f1b29b1ef9e35d05d0a654a57bdf0f"

URI_x86_64_v2_rust-syntect+default-fancy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-fancy-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-fancy-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-fancy-devel.sha256sum] = "05326a23bd06124960d6a6cbc06f0ca645f8665eebe16ca77e949c20c91ebb8a"

URI_x86_64_v2_rust-syntect+default-onig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-onig-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-onig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-onig-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-onig-devel.sha256sum] = "fc89293eaaadee9af4f99ef84eef160fcd3ad1ea61eceea70f63a00d22ad581e"

URI_x86_64_v2_rust-syntect+default-syntaxes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-syntaxes-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-syntaxes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-syntaxes-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-syntaxes-devel.sha256sum] = "149148dc6236a4faeb3f150e250aab39ee4dffb3e7b436e2fb85205c4a7fbe43"

URI_x86_64_v2_rust-syntect+default-themes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-themes-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-themes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-themes-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-themes-devel.sha256sum] = "52143c5a868ea68a1c5216359e7d370fef08aa2857e746db3b13839e25155b0c"

URI_x86_64_v2_rust-syntect+dump-create-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+dump-create-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+dump-create-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+dump-create-devel}"
SRC_URI[x86_64_v2_rust-syntect+dump-create-devel.sha256sum] = "66084e9ed9fdc932c9014bcf6af0764a48b3fe01a105e592382f77fefb222a9d"

URI_x86_64_v2_rust-syntect+dump-load-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+dump-load-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+dump-load-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+dump-load-devel}"
SRC_URI[x86_64_v2_rust-syntect+dump-load-devel.sha256sum] = "93bad000d3b811a71b2e574359f3b53f5d2bc04df11a1d02cb4aa157eb1ebfa3"

URI_x86_64_v2_rust-syntect+fancy-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+fancy-regex-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+fancy-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+fancy-regex-devel}"
SRC_URI[x86_64_v2_rust-syntect+fancy-regex-devel.sha256sum] = "b7d24b6f10b79c3c0df8dfea6bf4c3a9a6d0f6352442f8a1feed55ca62fbecad"

URI_x86_64_v2_rust-syntect+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+flate2-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+flate2-devel}"
SRC_URI[x86_64_v2_rust-syntect+flate2-devel.sha256sum] = "7567807b8db2234c83c777faa801774d6576fe81ffe7e681ff8b85d2217beab2"

URI_x86_64_v2_rust-syntect+fnv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+fnv-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+fnv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+fnv-devel}"
SRC_URI[x86_64_v2_rust-syntect+fnv-devel.sha256sum] = "f9560b3de8f40d52a6c8428e35b22a8ad6b0bff2022f95be11fbbfc71b0f0535"

URI_x86_64_v2_rust-syntect+html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+html-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+html-devel}"
SRC_URI[x86_64_v2_rust-syntect+html-devel.sha256sum] = "6cc604c9604543b0e576c94760d232d4d52740f0cdfc5abfc782c326c8b1dc88"

URI_x86_64_v2_rust-syntect+metadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+metadata-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+metadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+metadata-devel}"
SRC_URI[x86_64_v2_rust-syntect+metadata-devel.sha256sum] = "c90d0f601f9051531d7387388baa61aeb49b9ac56a9e42ac190d8acb18f383c9"

URI_x86_64_v2_rust-syntect+onig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+onig-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+onig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+onig-devel}"
SRC_URI[x86_64_v2_rust-syntect+onig-devel.sha256sum] = "762825459c87c53bab998b696608834eeca37940fc9cedb568406aa3606a800a"

URI_x86_64_v2_rust-syntect+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+parsing-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+parsing-devel}"
SRC_URI[x86_64_v2_rust-syntect+parsing-devel.sha256sum] = "fb623f2a3d8b8e65459226192625cbcf95f44359dc722b0027b2118ad9367095"

URI_x86_64_v2_rust-syntect+plist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+plist-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+plist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+plist-devel}"
SRC_URI[x86_64_v2_rust-syntect+plist-devel.sha256sum] = "642d8e526daf37e125443d18f3e2606618a3d611bb9e92f02b7b869e71810e44"

URI_x86_64_v2_rust-syntect+plist-load-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+plist-load-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+plist-load-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+plist-load-devel}"
SRC_URI[x86_64_v2_rust-syntect+plist-load-devel.sha256sum] = "0dacbac81964b0a21add622a6742a2da03b23724b193fac4ff4af3d1ab8e9dc0"

URI_x86_64_v2_rust-syntect+regex-fancy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+regex-fancy-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+regex-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+regex-fancy-devel}"
SRC_URI[x86_64_v2_rust-syntect+regex-fancy-devel.sha256sum] = "8e0b1dd3f7ddaa89f7726d9899e85e00a303ae0cc6b83cfb34fd5a9ab980d15e"

URI_x86_64_v2_rust-syntect+regex-onig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+regex-onig-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+regex-onig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+regex-onig-devel}"
SRC_URI[x86_64_v2_rust-syntect+regex-onig-devel.sha256sum] = "8c92787cc148718569d7f369ccf5790bfad8b886208f99ba7b5f7b8900ff2ae2"

URI_x86_64_v2_rust-syntect+regex-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+regex-syntax-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+regex-syntax-devel}"
SRC_URI[x86_64_v2_rust-syntect+regex-syntax-devel.sha256sum] = "f3f0b1a09efd8b541aec365b730933a914107d56436f23088d5d3e4847de813b"

URI_x86_64_v2_rust-syntect+yaml-load-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+yaml-load-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+yaml-load-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+yaml-load-devel}"
SRC_URI[x86_64_v2_rust-syntect+yaml-load-devel.sha256sum] = "490f7d3c8b7e0fc503d86ee4b2ab4ff5b06b220486b35d65cb9b519bf5ad9236"

URI_x86_64_v2_rust-syntect+yaml-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+yaml-rust-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+yaml-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+yaml-rust-devel}"
SRC_URI[x86_64_v2_rust-syntect+yaml-rust-devel.sha256sum] = "d22fdabc0298d08b8486579e47e7e7106c21199ac0d10341f35eaee7c561de5a"

URI_x86_64_v2_rust-syntect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect-devel-5.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect-devel}"
SRC_URI[x86_64_v2_rust-syntect-devel.sha256sum] = "ff5e57d3226f68cb8caf24c2ef1fd1380e153e7878f3f5567506d9d2fa91a0cf"

URI_aarch64_rust-syntect+bincode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+bincode-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+bincode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+bincode-devel}"
SRC_URI[aarch64_rust-syntect+bincode-devel.sha256sum] = "fa4fb44ff13a9593c8134361c93f240d637d059c58976d3a8f169bdac5beaca1"

URI_aarch64_rust-syntect+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-devel}"
SRC_URI[aarch64_rust-syntect+default-devel.sha256sum] = "a1591354cc66e7f2fe20df94adb21d65c7259db03d99467dc65f3b60b7535ceb"

URI_aarch64_rust-syntect+default-fancy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-fancy-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+default-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-fancy-devel}"
SRC_URI[aarch64_rust-syntect+default-fancy-devel.sha256sum] = "cf99af45033f233e869ea7d3416ed4238d2cdb59839d136f58b51ccb059afec5"

URI_aarch64_rust-syntect+default-onig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-onig-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+default-onig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-onig-devel}"
SRC_URI[aarch64_rust-syntect+default-onig-devel.sha256sum] = "ff6a2e435b3a8b8fa5a9ed66e501b3bcb0005a01b75bd571ad7ceb6090add282"

URI_aarch64_rust-syntect+default-syntaxes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-syntaxes-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+default-syntaxes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-syntaxes-devel}"
SRC_URI[aarch64_rust-syntect+default-syntaxes-devel.sha256sum] = "aff19d31c2f881ec94b728e1637f45cd4b29f93767c5839a1ec5225e0aa92ae6"

URI_aarch64_rust-syntect+default-themes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-themes-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+default-themes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-themes-devel}"
SRC_URI[aarch64_rust-syntect+default-themes-devel.sha256sum] = "b2b36e85a3d0f132954917c1d6a72935b036b1d937d9d22fe45eef9468e01380"

URI_aarch64_rust-syntect+dump-create-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+dump-create-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+dump-create-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+dump-create-devel}"
SRC_URI[aarch64_rust-syntect+dump-create-devel.sha256sum] = "0dd0ec355b318ed245d3d39592142e0a64222e56ae3f35e9ac2bbeadcabbd5b6"

URI_aarch64_rust-syntect+dump-load-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+dump-load-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+dump-load-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+dump-load-devel}"
SRC_URI[aarch64_rust-syntect+dump-load-devel.sha256sum] = "fb7967097ee99a7985e84c65de877970577ed7931844f0a2169f8893b1fb18d6"

URI_aarch64_rust-syntect+fancy-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+fancy-regex-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+fancy-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+fancy-regex-devel}"
SRC_URI[aarch64_rust-syntect+fancy-regex-devel.sha256sum] = "577b97fa711fbc54a00ccf5a615bd2adc02fd02a8dbe91ab1f957093064ddea4"

URI_aarch64_rust-syntect+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+flate2-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+flate2-devel}"
SRC_URI[aarch64_rust-syntect+flate2-devel.sha256sum] = "1a285d4691f7cbf28e20f5320b14de96d151d73deba8733091cdb48c66e2dff5"

URI_aarch64_rust-syntect+fnv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+fnv-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+fnv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+fnv-devel}"
SRC_URI[aarch64_rust-syntect+fnv-devel.sha256sum] = "4a17b35316190b496f1ba9732887aefc065fa059a1c54be69b7746a811458665"

URI_aarch64_rust-syntect+html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+html-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+html-devel}"
SRC_URI[aarch64_rust-syntect+html-devel.sha256sum] = "827c9a99f903bc1fc8fea7896f45120605b6c99056b3e9840ab24c004819fdd0"

URI_aarch64_rust-syntect+metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+metadata-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+metadata-devel}"
SRC_URI[aarch64_rust-syntect+metadata-devel.sha256sum] = "bd707aca47f8223962eb7bd82c883e10424b9b2da8ff551ab95cfad6f4b9037f"

URI_aarch64_rust-syntect+onig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+onig-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+onig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+onig-devel}"
SRC_URI[aarch64_rust-syntect+onig-devel.sha256sum] = "01b8fde817df4b0aa2a473a6fd63c44e0cf44d881916fce93d7815f72b9f6cd9"

URI_aarch64_rust-syntect+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+parsing-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+parsing-devel}"
SRC_URI[aarch64_rust-syntect+parsing-devel.sha256sum] = "dcb672b67f081ca1f7c2dec5591a1b4ef9f8cb24d7e5f91c4e7dca5a50ea96af"

URI_aarch64_rust-syntect+plist-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+plist-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+plist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+plist-devel}"
SRC_URI[aarch64_rust-syntect+plist-devel.sha256sum] = "1288661f627af1436a8986a628718ba035815f6b0cd0fc7fc02c49504e035429"

URI_aarch64_rust-syntect+plist-load-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+plist-load-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+plist-load-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+plist-load-devel}"
SRC_URI[aarch64_rust-syntect+plist-load-devel.sha256sum] = "130dfb7bfd24157a168e88462f85da5e28a52b7997c00fd62b1f8aa661e04345"

URI_aarch64_rust-syntect+regex-fancy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+regex-fancy-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+regex-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+regex-fancy-devel}"
SRC_URI[aarch64_rust-syntect+regex-fancy-devel.sha256sum] = "9c9bc4b97314678024e0c0170cd0060dfda9d5e6dcd4df0242835e43a8c25f28"

URI_aarch64_rust-syntect+regex-onig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+regex-onig-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+regex-onig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+regex-onig-devel}"
SRC_URI[aarch64_rust-syntect+regex-onig-devel.sha256sum] = "09873709a5c07328206351eb2204bbb9658f6913e2389e9a12c55a50ffd2fac7"

URI_aarch64_rust-syntect+regex-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+regex-syntax-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+regex-syntax-devel}"
SRC_URI[aarch64_rust-syntect+regex-syntax-devel.sha256sum] = "96da6b8fdb178fdfc3adebe347fd26861d6ed887dcaaa67c8e824f140937d869"

URI_aarch64_rust-syntect+yaml-load-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+yaml-load-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+yaml-load-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+yaml-load-devel}"
SRC_URI[aarch64_rust-syntect+yaml-load-devel.sha256sum] = "c879d7fd4792ad38d64603e6dba5189de7d3bb172c9be686bc5c5a7b263983b1"

URI_aarch64_rust-syntect+yaml-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+yaml-rust-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect+yaml-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+yaml-rust-devel}"
SRC_URI[aarch64_rust-syntect+yaml-rust-devel.sha256sum] = "9e68ffa185f15b814591e8dc61ce713c824745422430d86adccf2545d260a36c"

URI_aarch64_rust-syntect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect-devel-5.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-syntect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect-devel}"
SRC_URI[aarch64_rust-syntect-devel.sha256sum] = "1047e5b39c6bf4cb560bff9ccd0650a13b8ea51376f5e04b44c7c4f2824b7d6e"

RDEPENDS:rust-syntect+bincode-devel = " \
 cargo \
 rust-bincode+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-devel = " \
 cargo \
 rust-syntect+default-onig-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-fancy-devel = " \
 cargo \
 rust-syntect+default-syntaxes-devel \
 rust-syntect+default-themes-devel \
 rust-syntect+dump-create-devel \
 rust-syntect+dump-load-devel \
 rust-syntect+html-devel \
 rust-syntect+parsing-devel \
 rust-syntect+plist-load-devel \
 rust-syntect+regex-fancy-devel \
 rust-syntect+yaml-load-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-onig-devel = " \
 cargo \
 rust-syntect+default-syntaxes-devel \
 rust-syntect+default-themes-devel \
 rust-syntect+dump-create-devel \
 rust-syntect+dump-load-devel \
 rust-syntect+html-devel \
 rust-syntect+parsing-devel \
 rust-syntect+plist-load-devel \
 rust-syntect+regex-onig-devel \
 rust-syntect+yaml-load-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-syntaxes-devel = " \
 cargo \
 rust-syntect+dump-load-devel \
 rust-syntect+parsing-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-themes-devel = " \
 cargo \
 rust-syntect+dump-load-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+dump-create-devel = " \
 cargo \
 rust-syntect+bincode-devel \
 rust-syntect+flate2-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+dump-load-devel = " \
 cargo \
 rust-syntect+bincode-devel \
 rust-syntect+flate2-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+fancy-regex-devel = " \
 cargo \
 rust-fancy-regex0.11+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+flate2-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+fnv-devel = " \
 cargo \
 rust-fnv+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+html-devel = " \
 cargo \
 rust-syntect+parsing-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+metadata-devel = " \
 cargo \
 rust-syntect+parsing-devel \
 rust-syntect+plist-load-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+onig-devel = " \
 cargo \
 rust-onig-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+parsing-devel = " \
 cargo \
 rust-syntect+dump-create-devel \
 rust-syntect+dump-load-devel \
 rust-syntect+fnv-devel \
 rust-syntect+regex-syntax-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+plist-devel = " \
 cargo \
 rust-plist+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+plist-load-devel = " \
 cargo \
 rust-syntect+plist-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+regex-fancy-devel = " \
 cargo \
 rust-syntect+fancy-regex-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+regex-onig-devel = " \
 cargo \
 rust-syntect+onig-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+regex-syntax-devel = " \
 cargo \
 rust-regex-syntax+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+yaml-load-devel = " \
 cargo \
 rust-syntect+parsing-devel \
 rust-syntect+yaml-rust-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+yaml-rust-devel = " \
 cargo \
 rust-syntect-devel \
 rust-yaml-rust+default-devel \
 "
RDEPENDS:rust-syntect-devel = " \
 cargo \
 rust-bitflags1+default-devel \
 rust-once_cell+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-thiserror1+default-devel \
 rust-walkdir+default-devel \
 "
