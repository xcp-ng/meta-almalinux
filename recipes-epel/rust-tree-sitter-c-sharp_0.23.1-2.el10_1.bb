# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-c-sharp"
PV = "0.23.1"
PR = "2.el10_1"
PACKAGES = " \
 rust-tree-sitter-c-sharp+default-devel \
 rust-tree-sitter-c-sharp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-c-sharp-0.23.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0fe4dd446f7cdf3140e125de79d38603083bb5584d06a6ab38a685be3445982"

URI_x86_64_v2_rust-tree-sitter-c-sharp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-c-sharp+default-devel-0.23.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-c-sharp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-c-sharp+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-c-sharp+default-devel.sha256sum] = "8fa936bc9cb421bc88a7f0da057d2ad9aa7f49cc59017fc18df2744c4b0d82f6"

URI_x86_64_v2_rust-tree-sitter-c-sharp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-c-sharp-devel-0.23.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-c-sharp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-c-sharp-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-c-sharp-devel.sha256sum] = "9abf7a788145bf1196c6b55c64642dbaa4032d9ab6b8d4ae7a8c9c496c9e0391"

URI_aarch64_rust-tree-sitter-c-sharp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-c-sharp+default-devel-0.23.1-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-c-sharp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-c-sharp+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-c-sharp+default-devel.sha256sum] = "f084905cd685a8127044793e29bfe266c640429dfac970245a15d64ca04f1a68"

URI_aarch64_rust-tree-sitter-c-sharp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-c-sharp-devel-0.23.1-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-c-sharp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-c-sharp-devel}"
SRC_URI[aarch64_rust-tree-sitter-c-sharp-devel.sha256sum] = "4a26fff31dffa72864d746fffee622326ffd7e7e39ce626c15d2b9db38979cab"

RDEPENDS:rust-tree-sitter-c-sharp+default-devel = " \
 cargo \
 rust-tree-sitter-c-sharp-devel \
 "
RDEPENDS:rust-tree-sitter-c-sharp-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
