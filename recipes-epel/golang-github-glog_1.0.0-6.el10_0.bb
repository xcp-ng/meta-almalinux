# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-glog"
PV = "1.0.0"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-glog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-glog-1.0.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fca659036b49bb0d009f3677bc81168b005701a4cfda2b58d2e8dc4babc0cd0"

URI_x86_64_v2_golang-github-glog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-glog-devel-1.0.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-glog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-glog-devel}"
SRC_URI[x86_64_v2_golang-github-glog-devel.sha256sum] = "b75177a98e840d53bb4b5b224a3161d197e87f3273b8be454d9041b5099fd4cd"

URI_aarch64_golang-github-glog-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-glog-devel-1.0.0-6.el10_0.noarch.rpm;name=aarch64_golang-github-glog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-glog-devel}"
SRC_URI[aarch64_golang-github-glog-devel.sha256sum] = "0b7da5d21a187e2ad46d139c385f54673cbbf4458e44e45632887d33a3507859"

RDEPENDS:golang-github-glog-devel = " \
 go-filesystem \
 "
