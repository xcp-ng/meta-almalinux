# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "g2clib"
PV = "2.2.0"
PR = "1.el10_0"
PACKAGES = " \
 g2clib \
 g2clib-devel \
 g2clib-static \
 g2clib-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/g2clib-2.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22b02bbd2e792480a98670374893c57b0c7d808a26693157daaae8f7debebea1"

URI_x86_64_v2_g2clib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/g2clib-2.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_g2clib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_g2clib}"
SRC_URI[x86_64_v2_g2clib.sha256sum] = "6c9aa2d2f39eab06355a19b463644da818684ca3ea0c0e480dfa92dfd3fefa15"

URI_x86_64_v2_g2clib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/g2clib-devel-2.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_g2clib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_g2clib-devel}"
SRC_URI[x86_64_v2_g2clib-devel.sha256sum] = "0943ed31f5ebceb6330119c3d412ae8c0f654e492d243804a6dd97981b574bcf"

URI_x86_64_v2_g2clib-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/g2clib-static-2.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_g2clib-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_g2clib-static}"
SRC_URI[x86_64_v2_g2clib-static.sha256sum] = "7b942b4c8114e3605c07653e5b6063085e0330e4831221a519a4482bd2c0a382"

URI_x86_64_v2_g2clib-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/g2clib-utils-2.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_g2clib-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_g2clib-utils}"
SRC_URI[x86_64_v2_g2clib-utils.sha256sum] = "4497a407fa351026371b6989f640cfce889cd36ede739cd52e2af7e62fd3dd6e"

URI_aarch64_g2clib = "${EPEL_MIRROR}/aarch64/Packages/g/g2clib-2.2.0-1.el10_0.aarch64.rpm;name=aarch64_g2clib;unpack=0"
SRC_URI:append = " ${URI_aarch64_g2clib}"
SRC_URI[aarch64_g2clib.sha256sum] = "3d2370ee56b45b903a999f053dcabe4e13b33bf03126008bad08ff8c38f12b89"

URI_aarch64_g2clib-devel = "${EPEL_MIRROR}/aarch64/Packages/g/g2clib-devel-2.2.0-1.el10_0.aarch64.rpm;name=aarch64_g2clib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_g2clib-devel}"
SRC_URI[aarch64_g2clib-devel.sha256sum] = "dce0edd584ee37e40f9c0140b265070bf975f3c31eb66bb43c9f80e8b6b6f07b"

URI_aarch64_g2clib-static = "${EPEL_MIRROR}/aarch64/Packages/g/g2clib-static-2.2.0-1.el10_0.aarch64.rpm;name=aarch64_g2clib-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_g2clib-static}"
SRC_URI[aarch64_g2clib-static.sha256sum] = "1aaf3c7d298168a66424b8f03bcf8aa454a5a73b7353747e2a92ead77922bb66"

URI_aarch64_g2clib-utils = "${EPEL_MIRROR}/aarch64/Packages/g/g2clib-utils-2.2.0-1.el10_0.aarch64.rpm;name=aarch64_g2clib-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_g2clib-utils}"
SRC_URI[aarch64_g2clib-utils.sha256sum] = "dc3ccbd9d0a555b42652307c8c9467acd8d3de6495a23fb7fcf43e35feefeda5"

RDEPENDS:g2clib = " \
 glibc \
 jasper-libs \
 libaec \
 libpng \
 "
RDEPENDS:g2clib-devel = " \
 cmake-filesystem \
 g2clib \
 g2clib-static \
 jasper-devel \
 libpng-devel \
 "
RDEPENDS:g2clib-static = " \
 g2clib-devel \
 "
RDEPENDS:g2clib-utils = " \
 g2clib \
 glibc \
 jasper-libs \
 libaec \
 libpng \
 "
