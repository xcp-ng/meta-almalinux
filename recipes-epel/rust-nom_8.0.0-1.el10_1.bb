# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nom"
PV = "8.0.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-nom+alloc-devel \
 rust-nom+default-devel \
 rust-nom+docsrs-devel \
 rust-nom+std-devel \
 rust-nom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nom-8.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da81bde8c5736ba60a4d9d1f69b41593715488b920ce90e3678265e708eef94c"

URI_x86_64_v2_rust-nom+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom+alloc-devel-8.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom+alloc-devel}"
SRC_URI[x86_64_v2_rust-nom+alloc-devel.sha256sum] = "d75eec9f98a82ba3677ae59c3aa0995061ef2f69df7db5c5b9072ac5c6628807"

URI_x86_64_v2_rust-nom+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom+default-devel-8.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom+default-devel}"
SRC_URI[x86_64_v2_rust-nom+default-devel.sha256sum] = "4a90506c70390cb4a65190d06015f4f5e9ca63ba4fed1b6d685ed188195b6f88"

URI_x86_64_v2_rust-nom+docsrs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom+docsrs-devel-8.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom+docsrs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom+docsrs-devel}"
SRC_URI[x86_64_v2_rust-nom+docsrs-devel.sha256sum] = "842b4dae1022dc7385f5f3178fcb503cf245cb5ef52eed34531b95acdfa6f820"

URI_x86_64_v2_rust-nom+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom+std-devel-8.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom+std-devel}"
SRC_URI[x86_64_v2_rust-nom+std-devel.sha256sum] = "d7255da698fb5d2ff14a30c630fd65b1a205765a9fbced303c8bb4d47a616eef"

URI_x86_64_v2_rust-nom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom-devel-8.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom-devel}"
SRC_URI[x86_64_v2_rust-nom-devel.sha256sum] = "48eaca8ac72b85db856c0411bf7f1ff56fda96a63edc04197f27fed9fc43418e"

URI_aarch64_rust-nom+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom+alloc-devel-8.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-nom+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom+alloc-devel}"
SRC_URI[aarch64_rust-nom+alloc-devel.sha256sum] = "612e1f52ebeb6cfd94719faa2cb9795c4c4f29e8fc6013fbc0c1acb20a20d6af"

URI_aarch64_rust-nom+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom+default-devel-8.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-nom+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom+default-devel}"
SRC_URI[aarch64_rust-nom+default-devel.sha256sum] = "25228de5d11fd491595be9559d390b1ddd5440be9b6dfed62f748a828d305c82"

URI_aarch64_rust-nom+docsrs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom+docsrs-devel-8.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-nom+docsrs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom+docsrs-devel}"
SRC_URI[aarch64_rust-nom+docsrs-devel.sha256sum] = "768f1bdcd770688d35ab6532629564dbe789203a055a0866fe6cb3c1032c95b2"

URI_aarch64_rust-nom+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom+std-devel-8.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-nom+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom+std-devel}"
SRC_URI[aarch64_rust-nom+std-devel.sha256sum] = "5f1035da390e53ffe54bbf186711865435c9aec6894274eb111e17cdb054bba6"

URI_aarch64_rust-nom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom-devel-8.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-nom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom-devel}"
SRC_URI[aarch64_rust-nom-devel.sha256sum] = "7650142f45075531e7de415ffcfa66bf4ee6be14205b984e0d80c7b2775237a2"

RDEPENDS:rust-nom+alloc-devel = " \
 cargo \
 rust-nom-devel \
 "
RDEPENDS:rust-nom+default-devel = " \
 cargo \
 rust-nom+std-devel \
 rust-nom-devel \
 "
RDEPENDS:rust-nom+docsrs-devel = " \
 cargo \
 rust-nom-devel \
 "
RDEPENDS:rust-nom+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-nom+alloc-devel \
 rust-nom-devel \
 "
RDEPENDS:rust-nom-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "
