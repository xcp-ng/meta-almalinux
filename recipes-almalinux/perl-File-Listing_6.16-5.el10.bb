# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Listing"
PV = "6.16"
PR = "5.el10"
PACKAGES = " \
 perl-File-Listing \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-File-Listing-6.16-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "767ea4b9ac24619c2c58d741fdf0ff93b16a36f5013532a38ba113f317009ed3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Listing-6.16-5.el10.noarch.rpm;name=x86_64_v2_perl-File-Listing;unpack=0"
SRC_URI[x86_64_v2_perl-File-Listing.sha256sum] = "021dbf088c167ab8055e3932db959b79f306fe7d5d67aa4ec7293a11b8fcc97b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Listing-6.16-5.el10.noarch.rpm;name=aarch64_perl-File-Listing;unpack=0"
SRC_URI[aarch64_perl-File-Listing.sha256sum] = "021dbf088c167ab8055e3932db959b79f306fe7d5d67aa4ec7293a11b8fcc97b"

RDEPENDS:perl-File-Listing = " \
 perl-Carp \
 perl-Exporter \
 perl-HTTP-Date \
 perl-libs \
 "
