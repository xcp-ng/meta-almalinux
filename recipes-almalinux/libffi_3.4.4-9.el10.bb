# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libffi"
PV = "3.4.4"
PR = "9.el10"
PACKAGES = " \
 libffi \
 libffi-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libffi-3.4.4-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f919f86ab2273a4874e6448627c569adb84a4c503689d9dd7a98f39ff8ad3a02"

URI_x86_64_v2_libffi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libffi-3.4.4-9.el10.x86_64_v2.rpm;name=x86_64_v2_libffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libffi}"
SRC_URI[x86_64_v2_libffi.sha256sum] = "c76ec65a4e4fcb8e4aff0c382cbea2ea78655bc18126df671d210d70c525fea9"

URI_x86_64_v2_libffi-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libffi-devel-3.4.4-9.el10.x86_64_v2.rpm;name=x86_64_v2_libffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libffi-devel}"
SRC_URI[x86_64_v2_libffi-devel.sha256sum] = "a4e70cf5eb6988207bb68d77bc909f4741a919883e1d77d322d92aca4f83772d"

URI_aarch64_libffi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libffi-3.4.4-9.el10.aarch64.rpm;name=aarch64_libffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libffi}"
SRC_URI[aarch64_libffi.sha256sum] = "c984071fafa1e6cf8f7d1f4d2cd059d5b0022691dc9351186a9f4dd9e1be8ffb"

URI_aarch64_libffi-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libffi-devel-3.4.4-9.el10.aarch64.rpm;name=aarch64_libffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libffi-devel}"
SRC_URI[aarch64_libffi-devel.sha256sum] = "9a88b2a0f8accefc87a3efdc78eaf7cf1bd26597401d274970be02aa1a9428b4"

RDEPENDS:libffi = " \
 glibc \
 "
RDEPENDS:libffi-devel = " \
 libffi \
 pkgconf-pkg-config \
 "
