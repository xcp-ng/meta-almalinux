# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust_decimal"
PV = "1.40.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-rust_decimal+align16-devel \
 rust-rust_decimal+c-repr-devel \
 rust-rust_decimal+default-devel \
 rust-rust_decimal+legacy-ops-devel \
 rust-rust_decimal+macros-devel \
 rust-rust_decimal+maths-devel \
 rust-rust_decimal+maths-nopanic-devel \
 rust-rust_decimal+proptest-devel \
 rust-rust_decimal+rand-0_9-devel \
 rust-rust_decimal+rand-devel \
 rust-rust_decimal+rkyv-devel \
 rust-rust_decimal+rkyv-safe-devel \
 rust-rust_decimal+ryu-devel \
 rust-rust_decimal+serde-arbitrary-precision-devel \
 rust-rust_decimal+serde-bincode-devel \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal+serde-float-devel \
 rust-rust_decimal+serde-str-devel \
 rust-rust_decimal+serde-with-arbitrary-precision-devel \
 rust-rust_decimal+serde-with-float-devel \
 rust-rust_decimal+serde-with-str-devel \
 rust-rust_decimal+serde_json-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust_decimal-1.40.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f903f78a995c7d783b43ab638f9e065af3f35c2d8d1cebbf84436487fde4a485"

URI_x86_64_v2_rust-rust_decimal+align16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+align16-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+align16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+align16-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+align16-devel.sha256sum] = "ee23e95e99ca5c47dba09c0b9aeca2c0773bf5e17f3940d27b687ba88c519c4a"

URI_x86_64_v2_rust-rust_decimal+c-repr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+c-repr-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+c-repr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+c-repr-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+c-repr-devel.sha256sum] = "3dd7b081516b5fa0a5fde1f975580261b1fbc0e922b95fce7473f303a155b2dc"

URI_x86_64_v2_rust-rust_decimal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+default-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+default-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+default-devel.sha256sum] = "261ca35d500852c3bac683da4a6ed3f6d0d7a18494b9ecd799e42623f33cf6b2"

URI_x86_64_v2_rust-rust_decimal+legacy-ops-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+legacy-ops-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+legacy-ops-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+legacy-ops-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+legacy-ops-devel.sha256sum] = "4ebac2736ea450fe1628fd651661687d9346a861af6300f7ea8009be96788b8f"

URI_x86_64_v2_rust-rust_decimal+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+macros-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+macros-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+macros-devel.sha256sum] = "bc7b6d1dd917483e5adc9de181b02adc6fee277d1d698dfcd8cdf3f813072253"

URI_x86_64_v2_rust-rust_decimal+maths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+maths-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+maths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+maths-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+maths-devel.sha256sum] = "ae047f7503efb9efbafae10111d0899a0595e919799d526a61fb750575fb544b"

URI_x86_64_v2_rust-rust_decimal+maths-nopanic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+maths-nopanic-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+maths-nopanic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+maths-nopanic-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+maths-nopanic-devel.sha256sum] = "f1586d35c63697f2e406025e531f5b0a21f02cf9b8f5790c28987e994906298c"

URI_x86_64_v2_rust-rust_decimal+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+proptest-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+proptest-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+proptest-devel.sha256sum] = "247de09d081e1ee28da78abb64ab6f5e5c5acd69e6b459d24ee5cb7c53f33416"

URI_x86_64_v2_rust-rust_decimal+rand-0_9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rand-0_9-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rand-0_9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rand-0_9-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rand-0_9-devel.sha256sum] = "11e0bc3e10c7cc020cdbb03ccb7a420e9629d6d0545ffaa76c3ae5a698ca5048"

URI_x86_64_v2_rust-rust_decimal+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rand-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rand-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rand-devel.sha256sum] = "4866424de9eafdf22ef98e903e602062e94542c4c295afb3d14e786b2696fa30"

URI_x86_64_v2_rust-rust_decimal+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rkyv-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rkyv-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rkyv-devel.sha256sum] = "3be879f77e21ba53a1c90a2bb7d75076ad21304190ab7c98e6d23cf3562fb8ad"

URI_x86_64_v2_rust-rust_decimal+rkyv-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rkyv-safe-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rkyv-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rkyv-safe-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rkyv-safe-devel.sha256sum] = "9f9112c1090f6b397dd8d56a27dd7840d8de4e0dbd0c7ff9a5030d2c73ab7af6"

URI_x86_64_v2_rust-rust_decimal+ryu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+ryu-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+ryu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+ryu-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+ryu-devel.sha256sum] = "af4576ec3ea6df9b0c40a6056f429f0ad9f0f1c2dc6bb959acd0b8ee43c838e5"

URI_x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-arbitrary-precision-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel.sha256sum] = "3cae40a441b85ff71b38b5378cc88a2448120fdddd79efd74507d64cbab04361"

URI_x86_64_v2_rust-rust_decimal+serde-bincode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-bincode-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-bincode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-bincode-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-bincode-devel.sha256sum] = "6f320798118a8da3964ac0f0aab4c01e869bd754c4ace93e783b41826e22ccb6"

URI_x86_64_v2_rust-rust_decimal+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-devel.sha256sum] = "4921ce221258ed5bd361e70df48a2554ee0b48e2e24dcbf1b9ef688fff21e9fd"

URI_x86_64_v2_rust-rust_decimal+serde-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-float-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-float-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-float-devel.sha256sum] = "d21061a7a1017ef1e77df8e142fc66edeb15a4a082a124efa7059491840535ce"

URI_x86_64_v2_rust-rust_decimal+serde-str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-str-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-str-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-str-devel.sha256sum] = "e3019cbf0c12dc7ebbcbe41229c651a103bb496eeb17733ef99787ff9ebd03a3"

URI_x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-with-arbitrary-precision-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel.sha256sum] = "4cf3ae5c2479099d8b92b70a6457e9cb0596ed94b04f08fa6cb169d97acd04a5"

URI_x86_64_v2_rust-rust_decimal+serde-with-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-with-float-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-with-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-with-float-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-with-float-devel.sha256sum] = "c2bdd9d490c6db6461c4c2a876dc29f105729787b8bc2ee4adacbe17e1ce8e59"

URI_x86_64_v2_rust-rust_decimal+serde-with-str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-with-str-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-with-str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-with-str-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-with-str-devel.sha256sum] = "f9817611504156e8f73f22b4fa7b6803bfd1f27575b3150378e86ab552c107df"

URI_x86_64_v2_rust-rust_decimal+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde_json-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde_json-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde_json-devel.sha256sum] = "3fdae42f6e35fde01d9ffea75b13887cc3ed3421f4ca37e897081e95d66c0108"

URI_x86_64_v2_rust-rust_decimal+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+std-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+std-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+std-devel.sha256sum] = "ed4470c225186a7a3fc97c9336d60893ba73740061a377bfed102e29e532eddb"

URI_x86_64_v2_rust-rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal-devel.sha256sum] = "985814ac1feb250616fc94c3b67e905fb74157e2cd8efae1387d10e041878b67"

URI_aarch64_rust-rust_decimal+align16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+align16-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+align16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+align16-devel}"
SRC_URI[aarch64_rust-rust_decimal+align16-devel.sha256sum] = "8c02538d4e7c72e3ecff8dd28b2b373c52d0a42dcfa139db24b0b157dce8692f"

URI_aarch64_rust-rust_decimal+c-repr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+c-repr-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+c-repr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+c-repr-devel}"
SRC_URI[aarch64_rust-rust_decimal+c-repr-devel.sha256sum] = "97fc46dd0b43aa8696955ef81f11a6eda442f2e6b808c0d79028d914a24ac7b6"

URI_aarch64_rust-rust_decimal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+default-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+default-devel}"
SRC_URI[aarch64_rust-rust_decimal+default-devel.sha256sum] = "c6d4db2dfa139165aad6f802d36b2499304abe46bca5e2f83fe75478a3a73452"

URI_aarch64_rust-rust_decimal+legacy-ops-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+legacy-ops-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+legacy-ops-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+legacy-ops-devel}"
SRC_URI[aarch64_rust-rust_decimal+legacy-ops-devel.sha256sum] = "f17bd4a87270a4b118d5bb06a732a61ba252622d661a2b50fdebcd16b2f78f7c"

URI_aarch64_rust-rust_decimal+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+macros-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+macros-devel}"
SRC_URI[aarch64_rust-rust_decimal+macros-devel.sha256sum] = "d5ba3caa3bfb7e8f41f3745456c9f4172f32b088835a6ccae5cd4b1b3ff090b9"

URI_aarch64_rust-rust_decimal+maths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+maths-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+maths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+maths-devel}"
SRC_URI[aarch64_rust-rust_decimal+maths-devel.sha256sum] = "2d38584965490ce353718c140ca917f96f5fc8010e6737f787abd2e6f9712746"

URI_aarch64_rust-rust_decimal+maths-nopanic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+maths-nopanic-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+maths-nopanic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+maths-nopanic-devel}"
SRC_URI[aarch64_rust-rust_decimal+maths-nopanic-devel.sha256sum] = "8c6e2d461d85d8ed1789f2a8acdc0507afa2567413694c98cc358ae661bc6f85"

URI_aarch64_rust-rust_decimal+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+proptest-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+proptest-devel}"
SRC_URI[aarch64_rust-rust_decimal+proptest-devel.sha256sum] = "88b51ff787293362608c92640127833018a4dccdd3fcfb9fe85bb7bbf3bfa929"

URI_aarch64_rust-rust_decimal+rand-0_9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rand-0_9-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+rand-0_9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rand-0_9-devel}"
SRC_URI[aarch64_rust-rust_decimal+rand-0_9-devel.sha256sum] = "8de2993af4e9989fcfd269dd0ba387491ff9c2ffb9448818a60ac41f23e62d31"

URI_aarch64_rust-rust_decimal+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rand-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rand-devel}"
SRC_URI[aarch64_rust-rust_decimal+rand-devel.sha256sum] = "a1dc5a50c02a6c1ad5468ccc3907136e7f951b82a1bd87537776198fb7eeba57"

URI_aarch64_rust-rust_decimal+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rkyv-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rkyv-devel}"
SRC_URI[aarch64_rust-rust_decimal+rkyv-devel.sha256sum] = "38e4b03c9e650230f4dcb762772b55a13c2c718537bad1ddc974667e86b4a098"

URI_aarch64_rust-rust_decimal+rkyv-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rkyv-safe-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+rkyv-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rkyv-safe-devel}"
SRC_URI[aarch64_rust-rust_decimal+rkyv-safe-devel.sha256sum] = "052811ea823f2847f47145df852310ae1a12018010090ee11e97924acd985aea"

URI_aarch64_rust-rust_decimal+ryu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+ryu-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+ryu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+ryu-devel}"
SRC_URI[aarch64_rust-rust_decimal+ryu-devel.sha256sum] = "bc1831bbf462a3c90eee9fd424570bb13d2cad84baabb51b2e7734bb0b76d4a6"

URI_aarch64_rust-rust_decimal+serde-arbitrary-precision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-arbitrary-precision-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+serde-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-arbitrary-precision-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-arbitrary-precision-devel.sha256sum] = "b0255b7f952d1ef043d84c8e099c43b1a40a2725e533e3b5bad32a7270c52fcd"

URI_aarch64_rust-rust_decimal+serde-bincode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-bincode-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+serde-bincode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-bincode-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-bincode-devel.sha256sum] = "15b6c1cc7d6c6fcb62289780ed24b0bebf4c325061fbecad26515a26a35439a4"

URI_aarch64_rust-rust_decimal+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-devel.sha256sum] = "7cacf396effdeea2a3bd5925bc550df063c991f224a8e27d72b1c41f20386ab8"

URI_aarch64_rust-rust_decimal+serde-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-float-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+serde-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-float-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-float-devel.sha256sum] = "4ec2a768a392c52627482dc5544a68481442715598ebe57078f5b825f1ff04e3"

URI_aarch64_rust-rust_decimal+serde-str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-str-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+serde-str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-str-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-str-devel.sha256sum] = "0b5a6011bcf1797dff30bfc76ebd202a9109cf1318c98d363df94b0b60fb5b01"

URI_aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-with-arbitrary-precision-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel.sha256sum] = "79f8fafe7a11b23befeab86bdf6bb1ee77f6168b4fdff5e87cdfd24da2626f1b"

URI_aarch64_rust-rust_decimal+serde-with-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-with-float-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+serde-with-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-with-float-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-with-float-devel.sha256sum] = "3c47e6bd649e5974b2cac2d2499b256e56a44bf40e3ac8e07225ebff4359e91a"

URI_aarch64_rust-rust_decimal+serde-with-str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-with-str-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+serde-with-str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-with-str-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-with-str-devel.sha256sum] = "bf7d2012ba34d2a184e154f9328d93d90b203d52d0f80442d9116068f9301f1c"

URI_aarch64_rust-rust_decimal+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde_json-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde_json-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde_json-devel.sha256sum] = "9882374bc2760294b68893182f5b3aa91d7e26100f8459d380ff4987d4c20ad0"

URI_aarch64_rust-rust_decimal+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+std-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+std-devel}"
SRC_URI[aarch64_rust-rust_decimal+std-devel.sha256sum] = "d1db2f120b58626d71eeb09f248f174df8b3c1bbf190868d447398ac3d1fc5c0"

URI_aarch64_rust-rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal-devel}"
SRC_URI[aarch64_rust-rust_decimal-devel.sha256sum] = "ac347593bb4ac015c4051a3eb3b3ce9abe1edd1b64e613030e1ef63141b62fda"

RDEPENDS:rust-rust_decimal+align16-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+c-repr-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+default-devel = " \
 cargo \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+legacy-ops-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+macros-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-rust_decimal_macros-devel \
 "
RDEPENDS:rust-rust_decimal+maths-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+maths-nopanic-devel = " \
 cargo \
 rust-rust_decimal+maths-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+proptest-devel = " \
 cargo \
 rust-proptest+std-devel \
 rust-proptest-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rand-0_9-devel = " \
 cargo \
 rust-rand0.9-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rand-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rkyv-devel = " \
 cargo \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rkyv-safe-devel = " \
 cargo \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7+validation-devel \
 rust-rkyv0.7-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+ryu-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-ryu-devel \
 "
RDEPENDS:rust-rust_decimal+serde-arbitrary-precision-devel = " \
 cargo \
 rust-rust_decimal+serde-with-arbitrary-precision-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-bincode-devel = " \
 cargo \
 rust-rust_decimal+serde-str-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rust_decimal+serde-float-devel = " \
 cargo \
 rust-rust_decimal+serde-with-float-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-str-devel = " \
 cargo \
 rust-rust_decimal+serde-with-str-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-with-arbitrary-precision-devel = " \
 cargo \
 rust-rust_decimal+ryu-devel \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal-devel \
 rust-serde_json+arbitrary_precision-devel \
 rust-serde_json+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-rust_decimal+serde-with-float-devel = " \
 cargo \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-with-str-devel = " \
 cargo \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde_json-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-rust_decimal+std-devel = " \
 cargo \
 rust-arrayvec+std-devel \
 rust-bytes+std-devel \
 rust-bytes-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7-devel \
 rust-rust_decimal-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-serde_json+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-rust_decimal-devel = " \
 cargo \
 rust \
 rust-arrayvec-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
