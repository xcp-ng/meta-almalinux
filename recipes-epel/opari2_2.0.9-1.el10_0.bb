# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opari2"
PV = "2.0.9"
PR = "1.el10_0"
PACKAGES = " \
 opari2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opari2-2.0.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05336bd8226d211ae5a39b8b215e7bf8b10621c442c982c37a14d8cde4f1623a"

URI_x86_64_v2_opari2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opari2-2.0.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opari2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opari2}"
SRC_URI[x86_64_v2_opari2.sha256sum] = "d89ff186fe25cfdc1890e928ef00f5f512a91c37465cd0ff4ccb457bd444a7a7"

URI_aarch64_opari2 = "${EPEL_MIRROR}/aarch64/Packages/o/opari2-2.0.9-1.el10_0.aarch64.rpm;name=aarch64_opari2;unpack=0"
SRC_URI:append = " ${URI_aarch64_opari2}"
SRC_URI[aarch64_opari2.sha256sum] = "442ffd8329db56daca3fa80df3b53f24947dd0ec164af2cedf4c1232258f5dcf"

RDEPENDS:opari2 = " \
 gawk \
 glibc \
 libgcc \
 libstdc++ \
 "
