# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcanlock"
PV = "3.3.3"
PR = "2.el10_2"
PACKAGES = " \
 canlock \
 libcanlock \
 libcanlock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcanlock-3.3.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ed29360f1ca8c2ed91bb5acb84e9221b9be951e01e43bc2bb177a97cedeb437"

URI_x86_64_v2_canlock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/canlock-3.3.3-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_canlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_canlock}"
SRC_URI[x86_64_v2_canlock.sha256sum] = "5f5250fced194281c76d154751efc5e310a740c3acd141a5cfc4a507c6259d84"

URI_x86_64_v2_libcanlock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcanlock-3.3.3-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcanlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcanlock}"
SRC_URI[x86_64_v2_libcanlock.sha256sum] = "3efb9382da1878666a3127b6df87a5dd89f7309b40a0cdfc9c37fab56e9d6752"

URI_x86_64_v2_libcanlock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcanlock-devel-3.3.3-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcanlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcanlock-devel}"
SRC_URI[x86_64_v2_libcanlock-devel.sha256sum] = "dc42730fb2bf5fb70acb604afc952a44163c546a5e080203d88fe74dab16e0a8"

URI_aarch64_canlock = "${EPEL_MIRROR}/aarch64/Packages/c/canlock-3.3.3-2.el10_2.aarch64.rpm;name=aarch64_canlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_canlock}"
SRC_URI[aarch64_canlock.sha256sum] = "80397ea48af7707c9ec7b4bc9dd055e80e8d983fc240494ca29da24bcaefac36"

URI_aarch64_libcanlock = "${EPEL_MIRROR}/aarch64/Packages/l/libcanlock-3.3.3-2.el10_2.aarch64.rpm;name=aarch64_libcanlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcanlock}"
SRC_URI[aarch64_libcanlock.sha256sum] = "d86b8945e6bc749ff4b9485a594c3c00af821b8f3ecd29402fed7d1d4e562f14"

URI_aarch64_libcanlock-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcanlock-devel-3.3.3-2.el10_2.aarch64.rpm;name=aarch64_libcanlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcanlock-devel}"
SRC_URI[aarch64_libcanlock-devel.sha256sum] = "39d6677b2fdc834b8787a4ccaa999b572b4ba7c19ac5b1bf58ccc9ef7f4b9492"

RDEPENDS:canlock = " \
 glibc \
 libcanlock \
 "
RDEPENDS:libcanlock = " \
 glibc \
 "
RDEPENDS:libcanlock-devel = " \
 libcanlock \
 pkgconf-pkg-config \
 "
