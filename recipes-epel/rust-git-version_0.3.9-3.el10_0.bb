# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-git-version"
PV = "0.3.9"
PR = "3.el10_0"
PACKAGES = " \
 rust-git-version+default-devel \
 rust-git-version-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-git-version-0.3.9-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "938cc87ce4618b513c3b81bf911b59e44f232bc2d728a490b188051c9e58e6fe"

URI_x86_64_v2_rust-git-version+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git-version+default-devel-0.3.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git-version+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git-version+default-devel}"
SRC_URI[x86_64_v2_rust-git-version+default-devel.sha256sum] = "6809160281b3f6b400f64c6c9dd99e9dde72b744aa370dfecfad1f233e21fd68"

URI_x86_64_v2_rust-git-version-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git-version-devel-0.3.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git-version-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git-version-devel}"
SRC_URI[x86_64_v2_rust-git-version-devel.sha256sum] = "83954b8a65368c45a05eac938d07501efba6dcbba8ddd49754c8fb6708154c7a"

URI_aarch64_rust-git-version+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git-version+default-devel-0.3.9-3.el10_0.noarch.rpm;name=aarch64_rust-git-version+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git-version+default-devel}"
SRC_URI[aarch64_rust-git-version+default-devel.sha256sum] = "67ffb089b47eeebab19061bb22de2146a1dd8e68dc812508b9e26d813e0e7435"

URI_aarch64_rust-git-version-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git-version-devel-0.3.9-3.el10_0.noarch.rpm;name=aarch64_rust-git-version-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git-version-devel}"
SRC_URI[aarch64_rust-git-version-devel.sha256sum] = "4f0e3f26165a01b8238e8af1b33288e65a97c9a541a4faa6e0dc587e28363dd1"

RDEPENDS:rust-git-version+default-devel = " \
 cargo \
 rust-git-version-devel \
 "
RDEPENDS:rust-git-version-devel = " \
 cargo \
 rust-git-version-macro+default-devel \
 "
