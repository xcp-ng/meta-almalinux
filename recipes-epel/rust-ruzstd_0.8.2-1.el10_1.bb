# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ruzstd"
PV = "0.8.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-ruzstd+default-devel \
 rust-ruzstd+dict_builder-devel \
 rust-ruzstd+hash-devel \
 rust-ruzstd+std-devel \
 rust-ruzstd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ruzstd-0.8.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f843b297c4924631a51425d32549bb5fb16b8e029eb1831004275f8ab85c0b0"

URI_x86_64_v2_rust-ruzstd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+default-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd+default-devel}"
SRC_URI[x86_64_v2_rust-ruzstd+default-devel.sha256sum] = "b69420361169d9329c65ffde1777a4d58e466ca957c7b8e014c0b7d1d4d534bf"

URI_x86_64_v2_rust-ruzstd+dict_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+dict_builder-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+dict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd+dict_builder-devel}"
SRC_URI[x86_64_v2_rust-ruzstd+dict_builder-devel.sha256sum] = "d70e67514b43cf6c8c0fd55c27addfee504e42f47ac2b261194b7b4bd7c4edab"

URI_x86_64_v2_rust-ruzstd+hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+hash-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd+hash-devel}"
SRC_URI[x86_64_v2_rust-ruzstd+hash-devel.sha256sum] = "cf2b50c5ab043d9c4531423736c9fcaec5cc0ca59a65624c2c5413a8eae80653"

URI_x86_64_v2_rust-ruzstd+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+std-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd+std-devel}"
SRC_URI[x86_64_v2_rust-ruzstd+std-devel.sha256sum] = "b7ee85ff06690587e610c16b3206c94ce983c924609321202cfa1f0f2d976512"

URI_x86_64_v2_rust-ruzstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd-devel}"
SRC_URI[x86_64_v2_rust-ruzstd-devel.sha256sum] = "99853f6558495db0a67b0f578ba868fefccff7f83f8f18e9d824bbd12fd008c1"

URI_aarch64_rust-ruzstd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+default-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-ruzstd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd+default-devel}"
SRC_URI[aarch64_rust-ruzstd+default-devel.sha256sum] = "c01db3fe9fa408e69eac947ddbb5228a3f3455e54a56aa66e369e74de6601acb"

URI_aarch64_rust-ruzstd+dict_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+dict_builder-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-ruzstd+dict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd+dict_builder-devel}"
SRC_URI[aarch64_rust-ruzstd+dict_builder-devel.sha256sum] = "f5292f6b8b95f6b9f7a9d73d8278f369ac8039ac881060b4f89dc4acbc452668"

URI_aarch64_rust-ruzstd+hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+hash-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-ruzstd+hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd+hash-devel}"
SRC_URI[aarch64_rust-ruzstd+hash-devel.sha256sum] = "a7d3c7a7f6b9ffb0891859f570c91b8870d5d53ffb03e67a55e743d412566de9"

URI_aarch64_rust-ruzstd+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+std-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-ruzstd+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd+std-devel}"
SRC_URI[aarch64_rust-ruzstd+std-devel.sha256sum] = "778e580d333052910ca8e3472b0c11badb4d1a4fae85c60f9dfef7841e6c6ef5"

URI_aarch64_rust-ruzstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-ruzstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd-devel}"
SRC_URI[aarch64_rust-ruzstd-devel.sha256sum] = "e76c0ae8928a15481b13f9dc5ddb51a130648265eb9e6f8b8a05cb81c8df73d8"

RDEPENDS:rust-ruzstd+default-devel = " \
 cargo \
 rust-ruzstd+hash-devel \
 rust-ruzstd+std-devel \
 rust-ruzstd-devel \
 "
RDEPENDS:rust-ruzstd+dict_builder-devel = " \
 cargo \
 rust-fastrand+default-devel \
 rust-ruzstd+std-devel \
 rust-ruzstd-devel \
 "
RDEPENDS:rust-ruzstd+hash-devel = " \
 cargo \
 rust-ruzstd-devel \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-ruzstd+std-devel = " \
 cargo \
 rust-ruzstd-devel \
 "
RDEPENDS:rust-ruzstd-devel = " \
 cargo \
 "
