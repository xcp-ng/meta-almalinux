# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam-kwallet"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 pam-kwallet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam-kwallet-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "739f768cb654a5e45d438aa9d75ee9712b81f9d600d8fe342e742788efadce29"

URI_x86_64_v2_pam-kwallet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam-kwallet-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam-kwallet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam-kwallet}"
SRC_URI[x86_64_v2_pam-kwallet.sha256sum] = "668d6993895097a2ccc3425c8eff1d73be89fec1ca2f2d663b9464e7fc1a82e8"

URI_aarch64_pam-kwallet = "${EPEL_MIRROR}/aarch64/Packages/p/pam-kwallet-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_pam-kwallet;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam-kwallet}"
SRC_URI[aarch64_pam-kwallet.sha256sum] = "d120e43bb27071d241b7161b4fbdccbeb52704f0a0d9a6704a34469daa39088b"

RDEPENDS:pam-kwallet = " \
 bash \
 glibc \
 kf6-kwallet \
 libgcrypt \
 pam-libs \
 socat \
 "
