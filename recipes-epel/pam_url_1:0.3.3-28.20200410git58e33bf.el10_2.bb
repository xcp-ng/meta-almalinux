# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam_url"
PE = "1"
PV = "0.3.3"
PR = "28.20200410git58e33bf.el10_2"
PACKAGES = " \
 pam_url \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam_url-0.3.3-28.20200410git58e33bf.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcb985a14cae875fcae8c95bee0a34764724987bf4c8bcac9c0a28274ffdbbcb"

URI_aarch64_pam_url = "${EPEL_MIRROR}/aarch64/Packages/p/pam_url-0.3.3-28.20200410git58e33bf.el10_2.aarch64.rpm;name=aarch64_pam_url;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_url}"
SRC_URI[aarch64_pam_url.sha256sum] = "afc4af88e8993c9fbd7b9be60dddf9a76086306aa40e3fb618ee073f39837588"

RDEPENDS:pam_url = " \
 glibc \
 libconfig \
 pam \
 pam-libs \
 virtual/libcurl.so.4___64bit_ \
 "
