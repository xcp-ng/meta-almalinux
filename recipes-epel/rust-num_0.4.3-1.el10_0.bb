# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num"
PV = "0.4.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-num+alloc-devel \
 rust-num+default-devel \
 rust-num+libm-devel \
 rust-num+num-bigint-devel \
 rust-num+rand-devel \
 rust-num+serde-devel \
 rust-num+std-devel \
 rust-num-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-0.4.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "542adcec62f05f94343e4b4bb54901945830bf090003fd0746834c72665bc613"

URI_x86_64_v2_rust-num+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num+alloc-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num+alloc-devel}"
SRC_URI[x86_64_v2_rust-num+alloc-devel.sha256sum] = "c60756608230e7393daef3235dbbfee5fc276aeca51b7dbac95b81b757580d6a"

URI_x86_64_v2_rust-num+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num+default-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num+default-devel}"
SRC_URI[x86_64_v2_rust-num+default-devel.sha256sum] = "aae72fa1337630ccbae5e511265a5bc5f71c32e8612099e65c3bbce1baf6b80b"

URI_x86_64_v2_rust-num+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num+libm-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num+libm-devel}"
SRC_URI[x86_64_v2_rust-num+libm-devel.sha256sum] = "ad468a2718a711501272180c5cc0b777c48b052364f64d53e60da5cec4bbc649"

URI_x86_64_v2_rust-num+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num+num-bigint-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-num+num-bigint-devel.sha256sum] = "606c9e4aa9aaf9dd2979f9e15d55da234205bae161e8d189483c85bfb1f377cf"

URI_x86_64_v2_rust-num+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num+rand-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num+rand-devel}"
SRC_URI[x86_64_v2_rust-num+rand-devel.sha256sum] = "26e785459e51f84180d6624cf119610faf96bb6a50048850eb7dd111711bb2da"

URI_x86_64_v2_rust-num+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num+serde-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num+serde-devel}"
SRC_URI[x86_64_v2_rust-num+serde-devel.sha256sum] = "d77ae761bed3dba0f49743a0c4b6b5594e6670fdddf53fbd9f1f00b061f1978d"

URI_x86_64_v2_rust-num+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num+std-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num+std-devel}"
SRC_URI[x86_64_v2_rust-num+std-devel.sha256sum] = "9eb508272557a370bf28c31b748ec73b37fdb3c021a5a49963d973416ac882c6"

URI_x86_64_v2_rust-num-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-devel}"
SRC_URI[x86_64_v2_rust-num-devel.sha256sum] = "fa2a2d22bc68da7d56f7a69323b1e486497b8ed318c102d9ea0daf66ceea2e16"

URI_aarch64_rust-num+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num+alloc-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-num+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num+alloc-devel}"
SRC_URI[aarch64_rust-num+alloc-devel.sha256sum] = "66769e4ae9b93ef5c0e51107d6626869c6bb0d5d82ee2fcd468c141320782716"

URI_aarch64_rust-num+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num+default-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-num+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num+default-devel}"
SRC_URI[aarch64_rust-num+default-devel.sha256sum] = "6831ac13183227f2e1e8bce1f312a243d795765b5e651f4e0a52d99938a005b4"

URI_aarch64_rust-num+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num+libm-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-num+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num+libm-devel}"
SRC_URI[aarch64_rust-num+libm-devel.sha256sum] = "df80bdcabd75dd6c2346666d845a369ea7e5be13d7e4a17a6593f354c86c2a89"

URI_aarch64_rust-num+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num+num-bigint-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-num+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num+num-bigint-devel}"
SRC_URI[aarch64_rust-num+num-bigint-devel.sha256sum] = "a15dadef79ad69264d12bb42561f44773218f632fd94b289895fe8b333d4f080"

URI_aarch64_rust-num+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num+rand-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-num+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num+rand-devel}"
SRC_URI[aarch64_rust-num+rand-devel.sha256sum] = "c274d4cc1a96ecdbc9b6c416afe96e5842819a556c65df453a4590d9edbdaac1"

URI_aarch64_rust-num+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num+serde-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-num+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num+serde-devel}"
SRC_URI[aarch64_rust-num+serde-devel.sha256sum] = "6fed759722d803b9f8b9da482479343e241c04c47b745f74282f93e4520e788e"

URI_aarch64_rust-num+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num+std-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-num+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num+std-devel}"
SRC_URI[aarch64_rust-num+std-devel.sha256sum] = "bf5182ec994287619ce2c9a781dc70a95ff0ea19d9af811b50657d6a681ee776"

URI_aarch64_rust-num-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-num-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-devel}"
SRC_URI[aarch64_rust-num-devel.sha256sum] = "eeed98fae8f2a14a66d3a7981a6df51d255d7b062d8f831d5a2d7fd9fd105261"

RDEPENDS:rust-num+alloc-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-num-devel \
 rust-num-rational+num-bigint-devel \
 "
RDEPENDS:rust-num+default-devel = " \
 cargo \
 rust-num+std-devel \
 rust-num-devel \
 "
RDEPENDS:rust-num+libm-devel = " \
 cargo \
 rust-num-complex+libm-devel \
 rust-num-devel \
 rust-num-traits+libm-devel \
 "
RDEPENDS:rust-num+num-bigint-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-num-devel \
 "
RDEPENDS:rust-num+rand-devel = " \
 cargo \
 rust-num-bigint+rand-devel \
 rust-num-bigint-devel \
 rust-num-complex+rand-devel \
 rust-num-devel \
 "
RDEPENDS:rust-num+serde-devel = " \
 cargo \
 rust-num-bigint+serde-devel \
 rust-num-bigint-devel \
 rust-num-complex+serde-devel \
 rust-num-devel \
 rust-num-rational+serde-devel \
 "
RDEPENDS:rust-num+std-devel = " \
 cargo \
 rust-num-bigint+std-devel \
 rust-num-bigint-devel \
 rust-num-complex+std-devel \
 rust-num-devel \
 rust-num-integer+std-devel \
 rust-num-iter+std-devel \
 rust-num-rational+num-bigint-std-devel \
 rust-num-rational+std-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-num-devel = " \
 cargo \
 rust \
 rust-num-complex-devel \
 rust-num-integer+i128-devel \
 rust-num-integer-devel \
 rust-num-iter+i128-devel \
 rust-num-iter-devel \
 rust-num-rational-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
