# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-ref"
PV = "0.55.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-ref+default-devel \
 rust-gix-ref+document-features-devel \
 rust-gix-ref+serde-devel \
 rust-gix-ref-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-ref-0.55.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60b33a25386063ea14e73763237c19cce382888a859c5cf201d54af720fe2aa9"

URI_x86_64_v2_rust-gix-ref+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+default-devel-0.55.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+default-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+default-devel.sha256sum] = "3409887c263187e25be1aeda379a749433d2ecc4ed777347e2d30c83442b10f2"

URI_x86_64_v2_rust-gix-ref+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+document-features-devel-0.55.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+document-features-devel.sha256sum] = "98405898d7e7f8057ba85ec2cb872bf6053755840fa1bfcf2b359b1531cc0d51"

URI_x86_64_v2_rust-gix-ref+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+serde-devel-0.55.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+serde-devel.sha256sum] = "67bccd62992d2019a0064632d40c2ca21b68b3ac4a6db747174d049ef5501ef3"

URI_x86_64_v2_rust-gix-ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref-devel-0.55.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref-devel}"
SRC_URI[x86_64_v2_rust-gix-ref-devel.sha256sum] = "31dcc0864dd9caa1b389c19b4970de334b7e7b58046f8ffe717a9139ee250e2c"

URI_aarch64_rust-gix-ref+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+default-devel-0.55.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-ref+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+default-devel}"
SRC_URI[aarch64_rust-gix-ref+default-devel.sha256sum] = "971b92d00471681e6df9f846dd20ecda8b5640ba4c6c42c6bf8828478f779619"

URI_aarch64_rust-gix-ref+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+document-features-devel-0.55.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-ref+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+document-features-devel}"
SRC_URI[aarch64_rust-gix-ref+document-features-devel.sha256sum] = "574796d2907759fa6c0553f0a25e11f6d2ac5f323397e8f91f44280aba8fe022"

URI_aarch64_rust-gix-ref+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+serde-devel-0.55.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-ref+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+serde-devel}"
SRC_URI[aarch64_rust-gix-ref+serde-devel.sha256sum] = "ed81c6df851600be18a955bd72f5a127c988263f4c456550695f5b24dd5145fc"

URI_aarch64_rust-gix-ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref-devel-0.55.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref-devel}"
SRC_URI[aarch64_rust-gix-ref-devel.sha256sum] = "f983d4295052a4985b0f700b7c7c191e63ebfccd28ddcd647986f0d1e8418e0f"

RDEPENDS:rust-gix-ref+default-devel = " \
 cargo \
 rust-gix-ref-devel \
 "
RDEPENDS:rust-gix-ref+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-ref-devel \
 "
RDEPENDS:rust-gix-ref+serde-devel = " \
 cargo \
 rust-gix-actor+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-ref-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-ref-devel = " \
 cargo \
 rust \
 rust-gix-actor+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+walkdir-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-lock+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-tempfile-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-memmap2+default-devel \
 rust-thiserror+default-devel \
 rust-winnow+default-devel \
 rust-winnow+simd-devel \
 "
