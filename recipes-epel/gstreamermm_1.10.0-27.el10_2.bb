# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamermm"
PV = "1.10.0"
PR = "27.el10_2"
PACKAGES = " \
 gstreamermm \
 gstreamermm-devel \
 gstreamermm-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gstreamermm-1.10.0-27.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09ad9cc9199d4216799f77fdc83c2488f52c16868dfb719ac98273d29237a088"

URI_x86_64_v2_gstreamermm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gstreamermm-1.10.0-27.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gstreamermm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamermm}"
SRC_URI[x86_64_v2_gstreamermm.sha256sum] = "01de3a3ec0c81ac92930e0de998bdeed7ed14eb0ad4e3f29c5731431f9cf7478"

URI_x86_64_v2_gstreamermm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gstreamermm-devel-1.10.0-27.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gstreamermm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamermm-devel}"
SRC_URI[x86_64_v2_gstreamermm-devel.sha256sum] = "b469541bb1288190d767de66e95417a1e9ec28d8422aee67ea9f474fc82661d9"

URI_x86_64_v2_gstreamermm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gstreamermm-doc-1.10.0-27.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gstreamermm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamermm-doc}"
SRC_URI[x86_64_v2_gstreamermm-doc.sha256sum] = "c52a99b27d81e8dba3e2943039defc30b0d273c35ad2f60140cf981bcd32729c"

URI_aarch64_gstreamermm = "${EPEL_MIRROR}/aarch64/Packages/g/gstreamermm-1.10.0-27.el10_2.aarch64.rpm;name=aarch64_gstreamermm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamermm}"
SRC_URI[aarch64_gstreamermm.sha256sum] = "58ed1870eda708ecc0baeeb08cf7891d3cdf71ebb839d21cd3f99423f4b514cb"

URI_aarch64_gstreamermm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gstreamermm-devel-1.10.0-27.el10_2.aarch64.rpm;name=aarch64_gstreamermm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamermm-devel}"
SRC_URI[aarch64_gstreamermm-devel.sha256sum] = "abdf9d367474ccd70d3e87c539d6e095b846f8eb74f946b75345156accbdfb35"

URI_aarch64_gstreamermm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gstreamermm-doc-1.10.0-27.el10_2.noarch.rpm;name=aarch64_gstreamermm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamermm-doc}"
SRC_URI[aarch64_gstreamermm-doc.sha256sum] = "460b597ba8ccaebd66f3fa9bb7c3c9f0593847028125dcf8efe77b8a81bb295e"

RDEPENDS:gstreamermm = " \
 glib2 \
 glibc \
 glibmm2.4 \
 gstreamer1 \
 gstreamer1-plugins-base \
 libdrm \
 libgcc \
 libsigc++20 \
 libstdc++ \
 "
RDEPENDS:gstreamermm-devel = " \
 glib2 \
 glibc \
 glibmm2.4 \
 glibmm2.4-devel \
 gstreamer1 \
 gstreamer1-devel \
 gstreamer1-plugins-base-devel \
 gstreamermm \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 "
RDEPENDS:gstreamermm-doc = " \
 glibmm2.4-doc \
 "
