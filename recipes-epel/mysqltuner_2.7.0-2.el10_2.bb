# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mysqltuner"
PV = "2.7.0"
PR = "2.el10_2"
PACKAGES = " \
 mysqltuner \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mysqltuner-2.7.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42ed0c6c5c9220259336cf98a3a67e00e2da95ae0c852da29bf6b058ebf214c8"

URI_x86_64_v2_mysqltuner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mysqltuner-2.7.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mysqltuner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysqltuner}"
SRC_URI[x86_64_v2_mysqltuner.sha256sum] = "00126c5f10d39a8042117bb57f76d94163160ad16084c13511c79fbab0bd292a"

URI_aarch64_mysqltuner = "${EPEL_MIRROR}/aarch64/Packages/m/mysqltuner-2.7.0-2.el10_2.noarch.rpm;name=aarch64_mysqltuner;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysqltuner}"
SRC_URI[aarch64_mysqltuner.sha256sum] = "d8f4edd121112ac2302f44fcdc3cafe610a5e4daefbbadc9ae7979c7ff14c9c1"

RDEPENDS:mysqltuner = " \
 mariadb \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Usage \
 perl-diagnostics \
 perl-interpreter \
 perl-libs \
 which \
 "
