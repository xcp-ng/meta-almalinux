# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kblocks"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kblocks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kblocks-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d789a170e92a1a0f51662260d2c2e57373ef989feee64b4536719a7ae8ad418e"

URI_x86_64_v2_kblocks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kblocks-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kblocks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kblocks}"
SRC_URI[x86_64_v2_kblocks.sha256sum] = "db7ac66e4dc75dbde25417d4c5826314cc40ba1f330c1de0a10f9b86fff8f1d3"

URI_aarch64_kblocks = "${EPEL_MIRROR}/aarch64/Packages/k/kblocks-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kblocks;unpack=0"
SRC_URI:append = " ${URI_aarch64_kblocks}"
SRC_URI[aarch64_kblocks.sha256sum] = "11c6b6f2cf9fc9900d429359847a00d221003d19a7d597ae9f730d839104ac3b"

RDEPENDS:kblocks = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
