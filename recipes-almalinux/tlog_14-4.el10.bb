# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tlog"
PV = "14"
PR = "4.el10"
PACKAGES = " \
 tlog \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tlog-14-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f040c9379853c4fe347f9dec6a0c9355f2a2909afff2b592df0be044c20e3d1a"

URI_x86_64_v2_tlog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tlog-14-4.el10.x86_64_v2.rpm;name=x86_64_v2_tlog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tlog}"
SRC_URI[x86_64_v2_tlog.sha256sum] = "56933abacca9f763c0977be59980e5eff908e5017352b0e911c7ced72d9f233d"

URI_aarch64_tlog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tlog-14-4.el10.aarch64.rpm;name=aarch64_tlog;unpack=0"
SRC_URI:append = " ${URI_aarch64_tlog}"
SRC_URI[aarch64_tlog.sha256sum] = "83484f528ad8580e5cfc757f6261762e96051dd121a56c906b49be328f4f774a"

RDEPENDS:tlog = " \
 bash \
 glibc \
 json-c \
 libutempter \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
