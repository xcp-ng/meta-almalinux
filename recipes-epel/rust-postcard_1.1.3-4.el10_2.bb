# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-postcard"
PV = "1.1.3"
PR = "4.el10_2"
PACKAGES = " \
 rust-postcard+alloc-devel \
 rust-postcard+core-num-saturating-devel \
 rust-postcard+crc-devel \
 rust-postcard+default-devel \
 rust-postcard+experimental-derive-devel \
 rust-postcard+heapless-cas-devel \
 rust-postcard+heapless-devel \
 rust-postcard+nalgebra-v0_33-devel \
 rust-postcard+nalgebra_v0_33-devel \
 rust-postcard+paste-devel \
 rust-postcard+postcard-derive-devel \
 rust-postcard+use-crc-devel \
 rust-postcard+use-std-devel \
 rust-postcard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-postcard-1.1.3-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a18070990faf00a3e7cfc0cd31ef92f40fa94e3c1bcf26ea41080c27aea58a4"

URI_x86_64_v2_rust-postcard+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+alloc-devel-1.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+alloc-devel}"
SRC_URI[x86_64_v2_rust-postcard+alloc-devel.sha256sum] = "fc5af9cadbbb67697a1c74499e168f1c3db1243681661c6a097f9538175d02d0"

URI_x86_64_v2_rust-postcard+core-num-saturating-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+core-num-saturating-devel-1.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+core-num-saturating-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+core-num-saturating-devel}"
SRC_URI[x86_64_v2_rust-postcard+core-num-saturating-devel.sha256sum] = "e1035d6e4a6ff6ea56b93b0434f176bc5f2e584a92196a24b561b198bb4998fe"

URI_x86_64_v2_rust-postcard+crc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+crc-devel-1.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+crc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+crc-devel}"
SRC_URI[x86_64_v2_rust-postcard+crc-devel.sha256sum] = "015e0f3bd6556611cf3243864e713b1b2fc95304414a4dd22abeeafa99608600"

URI_x86_64_v2_rust-postcard+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+default-devel-1.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+default-devel}"
SRC_URI[x86_64_v2_rust-postcard+default-devel.sha256sum] = "751ddf3924acb6956e9008935dfaa0f7345a949624542ae052f3efed81ff6f1f"

URI_x86_64_v2_rust-postcard+experimental-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+experimental-derive-devel-1.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+experimental-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+experimental-derive-devel}"
SRC_URI[x86_64_v2_rust-postcard+experimental-derive-devel.sha256sum] = "5ef64b86be630f59d44ed1e0f0088aeb47db872df7d77125fbdbadbdd94bcd4e"

URI_x86_64_v2_rust-postcard+heapless-cas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+heapless-cas-devel-1.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+heapless-cas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+heapless-cas-devel}"
SRC_URI[x86_64_v2_rust-postcard+heapless-cas-devel.sha256sum] = "5032484c02f618f6a80b648d5939ab5d1c6c8579d1470e5aaa2440f7f45910e0"

URI_x86_64_v2_rust-postcard+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+heapless-devel-1.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+heapless-devel}"
SRC_URI[x86_64_v2_rust-postcard+heapless-devel.sha256sum] = "1912a51cf441ef168d2240180b7e467850c1531107a7e49a95dae24db65fc20d"

URI_x86_64_v2_rust-postcard+nalgebra-v0_33-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+nalgebra-v0_33-devel-1.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+nalgebra-v0_33-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+nalgebra-v0_33-devel}"
SRC_URI[x86_64_v2_rust-postcard+nalgebra-v0_33-devel.sha256sum] = "201bd04aafb059c28271c91c10f9bd494012b32491ffd512a7a0c1a78d9fa617"

URI_x86_64_v2_rust-postcard+nalgebra_v0_33-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+nalgebra_v0_33-devel-1.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+nalgebra_v0_33-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+nalgebra_v0_33-devel}"
SRC_URI[x86_64_v2_rust-postcard+nalgebra_v0_33-devel.sha256sum] = "75e0f2f7c6f760e8d45391e709b6415e9be1e4ce224fcc89ef7813249d4fa7fa"

URI_x86_64_v2_rust-postcard+paste-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+paste-devel-1.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+paste-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+paste-devel}"
SRC_URI[x86_64_v2_rust-postcard+paste-devel.sha256sum] = "d9ae1803e1eb0e2b9e3c92debc4656cc23e99264312700285edc4438dac9eca7"

URI_x86_64_v2_rust-postcard+postcard-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+postcard-derive-devel-1.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+postcard-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+postcard-derive-devel}"
SRC_URI[x86_64_v2_rust-postcard+postcard-derive-devel.sha256sum] = "27e4428c66d2de7de54c174b8c818f3ee623f0ddfdb43e6003d7efadbf0f41db"

URI_x86_64_v2_rust-postcard+use-crc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+use-crc-devel-1.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+use-crc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+use-crc-devel}"
SRC_URI[x86_64_v2_rust-postcard+use-crc-devel.sha256sum] = "b34e928b471702c01b01e9d3b7922115c889c6a3afc19eb5f26ad2083548df4b"

URI_x86_64_v2_rust-postcard+use-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+use-std-devel-1.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+use-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+use-std-devel}"
SRC_URI[x86_64_v2_rust-postcard+use-std-devel.sha256sum] = "828484a26871f02a7cc09aae9e7f90900dfb757f45e3fbe4b30d61aa00ed3636"

URI_x86_64_v2_rust-postcard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard-devel-1.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard-devel}"
SRC_URI[x86_64_v2_rust-postcard-devel.sha256sum] = "89eb78006bdea6410664a2f18381df6b7ea88fcac5b3515cdef1560a3bf423e9"

URI_aarch64_rust-postcard+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+alloc-devel-1.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-postcard+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+alloc-devel}"
SRC_URI[aarch64_rust-postcard+alloc-devel.sha256sum] = "65a91c3f9b33194a9de1b13c026b39d8a48ea9d82d63549e2bc49e9cf4588a4c"

URI_aarch64_rust-postcard+core-num-saturating-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+core-num-saturating-devel-1.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-postcard+core-num-saturating-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+core-num-saturating-devel}"
SRC_URI[aarch64_rust-postcard+core-num-saturating-devel.sha256sum] = "557651312177bda37d7dec439e967fd5d7bfa7868286b8e7bdb38c7f0b2a3787"

URI_aarch64_rust-postcard+crc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+crc-devel-1.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-postcard+crc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+crc-devel}"
SRC_URI[aarch64_rust-postcard+crc-devel.sha256sum] = "2f426e96b0dd8f6d95e6f4a04b5e452c4d488242fe3d90886106d209333ec45b"

URI_aarch64_rust-postcard+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+default-devel-1.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-postcard+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+default-devel}"
SRC_URI[aarch64_rust-postcard+default-devel.sha256sum] = "30a8139a322621fd31f0f651ea62a7527816937c28055574c4074161553969f9"

URI_aarch64_rust-postcard+experimental-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+experimental-derive-devel-1.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-postcard+experimental-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+experimental-derive-devel}"
SRC_URI[aarch64_rust-postcard+experimental-derive-devel.sha256sum] = "395cfc66e261e57109205f43923c737e30ad33d644462fdd8a2e0ca3ab4074c9"

URI_aarch64_rust-postcard+heapless-cas-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+heapless-cas-devel-1.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-postcard+heapless-cas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+heapless-cas-devel}"
SRC_URI[aarch64_rust-postcard+heapless-cas-devel.sha256sum] = "8c6ae435d480b14c07f6e98612a443068afd8c65287aca89a4b6c2f21a356f6c"

URI_aarch64_rust-postcard+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+heapless-devel-1.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-postcard+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+heapless-devel}"
SRC_URI[aarch64_rust-postcard+heapless-devel.sha256sum] = "05b4c2863f5892a49c565f89242148aa9441831c769a739a06bd5b0ca761b96f"

URI_aarch64_rust-postcard+nalgebra-v0_33-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+nalgebra-v0_33-devel-1.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-postcard+nalgebra-v0_33-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+nalgebra-v0_33-devel}"
SRC_URI[aarch64_rust-postcard+nalgebra-v0_33-devel.sha256sum] = "60f518835a13894bcd2ae8a9103ca06bef5ef0e16c4bb5de6867d1f5ea1e5221"

URI_aarch64_rust-postcard+nalgebra_v0_33-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+nalgebra_v0_33-devel-1.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-postcard+nalgebra_v0_33-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+nalgebra_v0_33-devel}"
SRC_URI[aarch64_rust-postcard+nalgebra_v0_33-devel.sha256sum] = "589ae77a9c788548ee745aeec351a3f9c3a1b9d27351263b9e3099d9c7424d34"

URI_aarch64_rust-postcard+paste-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+paste-devel-1.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-postcard+paste-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+paste-devel}"
SRC_URI[aarch64_rust-postcard+paste-devel.sha256sum] = "99abe66eb52ca23d452c6f60db1d3f1551397abc708ccded8d1bbab02b26d88c"

URI_aarch64_rust-postcard+postcard-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+postcard-derive-devel-1.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-postcard+postcard-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+postcard-derive-devel}"
SRC_URI[aarch64_rust-postcard+postcard-derive-devel.sha256sum] = "3b97b9f4cc2fe3f438b2328330706e9f60c7ed6cba26edfaae47a99095b7efeb"

URI_aarch64_rust-postcard+use-crc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+use-crc-devel-1.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-postcard+use-crc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+use-crc-devel}"
SRC_URI[aarch64_rust-postcard+use-crc-devel.sha256sum] = "dd44d752d649588077f71da2e5ee3af685e9dc84b9d58c8323182bb12aba4401"

URI_aarch64_rust-postcard+use-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+use-std-devel-1.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-postcard+use-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+use-std-devel}"
SRC_URI[aarch64_rust-postcard+use-std-devel.sha256sum] = "db5f21b8156e211447d62151a41f138a0461b1854c24baae3d6a6761ef3d0122"

URI_aarch64_rust-postcard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard-devel-1.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-postcard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard-devel}"
SRC_URI[aarch64_rust-postcard-devel.sha256sum] = "7dd2de38dac5701230f389dc07018cc4df6ae8253fecda0cf3548cc64653fd91"

RDEPENDS:rust-postcard+alloc-devel = " \
 cargo \
 rust-postcard-devel \
 rust-serde+alloc-devel \
 "
RDEPENDS:rust-postcard+core-num-saturating-devel = " \
 cargo \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+crc-devel = " \
 cargo \
 rust-crc+default-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+default-devel = " \
 cargo \
 rust-postcard+heapless-cas-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+experimental-derive-devel = " \
 cargo \
 rust-postcard+postcard-derive-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+heapless-cas-devel = " \
 cargo \
 rust-heapless0.7+cas-devel \
 rust-heapless0.7+serde-devel \
 rust-heapless0.7-devel \
 rust-postcard+heapless-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+heapless-devel = " \
 cargo \
 rust-heapless0.7+serde-devel \
 rust-heapless0.7-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+nalgebra-v0_33-devel = " \
 cargo \
 rust-postcard+nalgebra_v0_33-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+nalgebra_v0_33-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+paste-devel = " \
 cargo \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+postcard-derive-devel = " \
 cargo \
 rust-postcard-derive+default-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+use-crc-devel = " \
 cargo \
 rust-postcard+crc-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+use-std-devel = " \
 cargo \
 rust-postcard+alloc-devel \
 rust-postcard-devel \
 rust-serde+std-devel \
 "
RDEPENDS:rust-postcard-devel = " \
 cargo \
 rust-cobs-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
