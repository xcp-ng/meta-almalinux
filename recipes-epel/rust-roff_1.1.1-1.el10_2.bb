# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-roff"
PV = "1.1.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-roff+default-devel \
 rust-roff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-roff-1.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "272494bd20b877b1306f16e576569c8842495f300bf7b01cd280bc9abff840c5"

URI_x86_64_v2_rust-roff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roff+default-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roff+default-devel}"
SRC_URI[x86_64_v2_rust-roff+default-devel.sha256sum] = "298f03371b0fee96d89c90c8fad73f24d50ee260b38da4eb16376ee13af041de"

URI_x86_64_v2_rust-roff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roff-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roff-devel}"
SRC_URI[x86_64_v2_rust-roff-devel.sha256sum] = "ce8e2fe1662aba22ed019ced639ecb69e68f9d7369081977bb6d5f831edc8976"

URI_aarch64_rust-roff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roff+default-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-roff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roff+default-devel}"
SRC_URI[aarch64_rust-roff+default-devel.sha256sum] = "3bbab46a4f0f5b9231dccad4f17f59a276ed3193f20e429859502ed77fb3dc94"

URI_aarch64_rust-roff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roff-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-roff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roff-devel}"
SRC_URI[aarch64_rust-roff-devel.sha256sum] = "7543cca62026586224bfe046ce651f30ae1f00cee5d5d81a743bc541b1ea57ca"

RDEPENDS:rust-roff+default-devel = " \
 cargo \
 rust-roff-devel \
 "
RDEPENDS:rust-roff-devel = " \
 cargo \
 rust \
 "
