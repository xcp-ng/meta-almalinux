# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serial_test"
PV = "3.2.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-serial_test+async-devel \
 rust-serial_test+default-devel \
 rust-serial_test+docsrs-devel \
 rust-serial_test+file_locks-devel \
 rust-serial_test+logging-devel \
 rust-serial_test+test_logging-devel \
 rust-serial_test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serial_test-3.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fe8a0b3ed19a2a234fcfc782090915133583ee3f0e3f0beff6d8584a472f1ae"

URI_x86_64_v2_rust-serial_test+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+async-devel-3.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+async-devel}"
SRC_URI[x86_64_v2_rust-serial_test+async-devel.sha256sum] = "87450496f73a9bc80ee0870f71472e11421192c770608c9481559291a7e8e17b"

URI_x86_64_v2_rust-serial_test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+default-devel-3.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+default-devel}"
SRC_URI[x86_64_v2_rust-serial_test+default-devel.sha256sum] = "9a5e745bbfde33ff2f995245bb82f276373fb5340c19ed692d222207be4beed3"

URI_x86_64_v2_rust-serial_test+docsrs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+docsrs-devel-3.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+docsrs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+docsrs-devel}"
SRC_URI[x86_64_v2_rust-serial_test+docsrs-devel.sha256sum] = "9b1dee0a62002c12768614500d945d66cee83e3a550aecc896a9cdd22d6856af"

URI_x86_64_v2_rust-serial_test+file_locks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+file_locks-devel-3.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+file_locks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+file_locks-devel}"
SRC_URI[x86_64_v2_rust-serial_test+file_locks-devel.sha256sum] = "afdbd5fe62ac437fc5c7e3b1fe17996b4e7f334bb8ce8082b3f70d52bb3718b1"

URI_x86_64_v2_rust-serial_test+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+logging-devel-3.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+logging-devel}"
SRC_URI[x86_64_v2_rust-serial_test+logging-devel.sha256sum] = "4de35b119aefa27bd1f2a0ff59e3b486a17d10f547b5f73c22a2303b728dfa8b"

URI_x86_64_v2_rust-serial_test+test_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+test_logging-devel-3.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+test_logging-devel}"
SRC_URI[x86_64_v2_rust-serial_test+test_logging-devel.sha256sum] = "d3b8a70a1a6a4b7ebe35b401ef32c7253896f2f8bda4332a6c67b34cd2f080b4"

URI_x86_64_v2_rust-serial_test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test-devel-3.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test-devel}"
SRC_URI[x86_64_v2_rust-serial_test-devel.sha256sum] = "33d96507c0065179f091abe1d85f460dd640e5dc35d17b2492043b643dc510f4"

URI_aarch64_rust-serial_test+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+async-devel-3.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-serial_test+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+async-devel}"
SRC_URI[aarch64_rust-serial_test+async-devel.sha256sum] = "621b70f3785e62f13a2643f54641329ac4809902ff7993b0960f1f3f3b55c124"

URI_aarch64_rust-serial_test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+default-devel-3.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-serial_test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+default-devel}"
SRC_URI[aarch64_rust-serial_test+default-devel.sha256sum] = "d9e334e43abfa8315185743c873d1a800005709f1fbc9c78182d17d1549ea225"

URI_aarch64_rust-serial_test+docsrs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+docsrs-devel-3.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-serial_test+docsrs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+docsrs-devel}"
SRC_URI[aarch64_rust-serial_test+docsrs-devel.sha256sum] = "ed95c710a0dbb956d7f14722febd73d27370770a0de78e34e943804ea7c88b05"

URI_aarch64_rust-serial_test+file_locks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+file_locks-devel-3.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-serial_test+file_locks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+file_locks-devel}"
SRC_URI[aarch64_rust-serial_test+file_locks-devel.sha256sum] = "0e1e022af2c6451496addef6908eea7d3ea66cb0733e93fa7763eac77575e085"

URI_aarch64_rust-serial_test+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+logging-devel-3.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-serial_test+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+logging-devel}"
SRC_URI[aarch64_rust-serial_test+logging-devel.sha256sum] = "8395e87f8287abfeb31a70aeb735fc3fa887eea24b7618f4b66808d1c294c822"

URI_aarch64_rust-serial_test+test_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+test_logging-devel-3.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-serial_test+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+test_logging-devel}"
SRC_URI[aarch64_rust-serial_test+test_logging-devel.sha256sum] = "e7188e3df5e75ed7f4f6b4a0fd0dd475a49e3933685d81338e961f614784069c"

URI_aarch64_rust-serial_test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test-devel-3.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-serial_test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test-devel}"
SRC_URI[aarch64_rust-serial_test-devel.sha256sum] = "01bfa55f3b07908db5687b3561f718d92a8b027138764807e48ef46a59bca80d"

RDEPENDS:rust-serial_test+async-devel = " \
 cargo \
 rust-futures+executor-devel \
 rust-futures-devel \
 rust-serial_test-devel \
 rust-serial_test_derive+async-devel \
 "
RDEPENDS:rust-serial_test+default-devel = " \
 cargo \
 rust-serial_test+async-devel \
 rust-serial_test+logging-devel \
 rust-serial_test-devel \
 "
RDEPENDS:rust-serial_test+docsrs-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-serial_test-devel \
 "
RDEPENDS:rust-serial_test+file_locks-devel = " \
 cargo \
 rust-fslock+std-devel \
 rust-fslock-devel \
 rust-serial_test-devel \
 "
RDEPENDS:rust-serial_test+logging-devel = " \
 cargo \
 rust-log+default-devel \
 rust-serial_test-devel \
 "
RDEPENDS:rust-serial_test+test_logging-devel = " \
 cargo \
 rust-serial_test+logging-devel \
 rust-serial_test-devel \
 rust-serial_test_derive+test_logging-devel \
 virtual/crate_env_logger__ge_0.6.1 \
 "
RDEPENDS:rust-serial_test-devel = " \
 cargo \
 rust-once_cell+std-devel \
 rust-once_cell-devel \
 rust-parking_lot-devel \
 rust-scc-devel \
 rust-serial_test_derive+default-devel \
 "
