# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql-odbc"
PV = "16.00.0000"
PR = "5.el10"
PACKAGES = " \
 postgresql-odbc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql-odbc-16.00.0000-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b00317c07e63810dfc927c72ee4340435cd0f9e083cfb8baff77790cf1a2cb9d"

URI_x86_64_v2_postgresql-odbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-odbc-16.00.0000-5.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-odbc}"
SRC_URI[x86_64_v2_postgresql-odbc.sha256sum] = "d1cf7cd0dd6ce1d059efe3d42e6684c1ce55a4d7113d60d95da4f20bcbb64f12"

URI_aarch64_postgresql-odbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-odbc-16.00.0000-5.el10.aarch64.rpm;name=aarch64_postgresql-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-odbc}"
SRC_URI[aarch64_postgresql-odbc.sha256sum] = "2415ca6180327385d4d13df584497a3481248955604bcf363b1fb572e639ed1c"

RDEPENDS:postgresql-odbc = " \
 glibc \
 libpq \
 unixODBC \
 "
