# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bcder"
PV = "0.7.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-bcder+default-devel \
 rust-bcder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bcder-0.7.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ef50a926e706f05896e3b1412b027968e2ffebc9ddd608d13c075732041cda4"

URI_x86_64_v2_rust-bcder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcder+default-devel-0.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcder+default-devel}"
SRC_URI[x86_64_v2_rust-bcder+default-devel.sha256sum] = "83e03414a64b0d88cb1c2f80387333da827c3264df0e9137b6764fb7dfe6a277"

URI_x86_64_v2_rust-bcder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcder-devel-0.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcder-devel}"
SRC_URI[x86_64_v2_rust-bcder-devel.sha256sum] = "30bf6e3ce1266fa81617f69b80fb7a8ba6476ac4e313e3bb55433b78681a9291"

URI_aarch64_rust-bcder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcder+default-devel-0.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-bcder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcder+default-devel}"
SRC_URI[aarch64_rust-bcder+default-devel.sha256sum] = "d88d7a7404544e7141a12d85dcd0ea2ed9080d80e99d978e85517847195d0bf4"

URI_aarch64_rust-bcder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcder-devel-0.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-bcder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcder-devel}"
SRC_URI[aarch64_rust-bcder-devel.sha256sum] = "332196683298be535aa96ff826e2344af2ef3ef9bee9027019b0be5cf0aed34d"

RDEPENDS:rust-bcder+default-devel = " \
 cargo \
 rust-bcder-devel \
 "
RDEPENDS:rust-bcder-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-smallvec+default-devel \
 "
