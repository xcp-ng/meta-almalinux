# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crypto-policies"
PV = "20260708"
PR = "1.git988eb15.el10.alma.1"
PACKAGES = " \
 crypto-policies \
 crypto-policies-scripts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/crypto-policies-20260708-1.git988eb15.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8fd7435a6b0a12c3dcdc4bf3d75d29c50243948c2635a80f5df8a56728e9e21"

URI_x86_64_v2_crypto-policies = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/crypto-policies-20260708-1.git988eb15.el10.alma.1.noarch.rpm;name=x86_64_v2_crypto-policies;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crypto-policies}"
SRC_URI[x86_64_v2_crypto-policies.sha256sum] = "99d3dc29e0d42cc13b41703c1159f37fd381932093a9d3b3b807fcd021e8880b"

URI_x86_64_v2_crypto-policies-scripts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/crypto-policies-scripts-20260708-1.git988eb15.el10.alma.1.noarch.rpm;name=x86_64_v2_crypto-policies-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crypto-policies-scripts}"
SRC_URI[x86_64_v2_crypto-policies-scripts.sha256sum] = "07efc1809f82e91ee16fbcb5cd6c0ed3927dc12bdb47d84e60eb4d9f22713e9a"

URI_aarch64_crypto-policies = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/crypto-policies-20260708-1.git988eb15.el10.alma.1.noarch.rpm;name=aarch64_crypto-policies;unpack=0"
SRC_URI:append = " ${URI_aarch64_crypto-policies}"
SRC_URI[aarch64_crypto-policies.sha256sum] = "99d3dc29e0d42cc13b41703c1159f37fd381932093a9d3b3b807fcd021e8880b"

URI_aarch64_crypto-policies-scripts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/crypto-policies-scripts-20260708-1.git988eb15.el10.alma.1.noarch.rpm;name=aarch64_crypto-policies-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_crypto-policies-scripts}"
SRC_URI[aarch64_crypto-policies-scripts.sha256sum] = "07efc1809f82e91ee16fbcb5cd6c0ed3927dc12bdb47d84e60eb4d9f22713e9a"

RDEPENDS:crypto-policies = " \
 bash \
 "
RDEPENDS:crypto-policies-scripts = " \
 bash \
 crypto-policies \
 python3 \
 "
