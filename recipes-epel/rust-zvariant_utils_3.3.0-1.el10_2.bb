# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zvariant_utils"
PV = "3.3.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-zvariant_utils+default-devel \
 rust-zvariant_utils+gvariant-devel \
 rust-zvariant_utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zvariant_utils-3.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23c123ce25a9e0900494df9b1ffbd8dc0c5bfc4fa12fc99913789baf639c21bd"

URI_x86_64_v2_rust-zvariant_utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_utils+default-devel-3.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_utils+default-devel}"
SRC_URI[x86_64_v2_rust-zvariant_utils+default-devel.sha256sum] = "6b570f9957fb92a048f05d9bafaf6944cde0bd6e3906a7cff7c541d056a3122f"

URI_x86_64_v2_rust-zvariant_utils+gvariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_utils+gvariant-devel-3.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_utils+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_utils+gvariant-devel}"
SRC_URI[x86_64_v2_rust-zvariant_utils+gvariant-devel.sha256sum] = "4cd392ef1d90646edcb204d3fd7585e7874f79ea0ccd55723c6309c46076ebb4"

URI_x86_64_v2_rust-zvariant_utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_utils-devel-3.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_utils-devel}"
SRC_URI[x86_64_v2_rust-zvariant_utils-devel.sha256sum] = "bc5cd257a69939086f46b4b8aa352f98313918e7eada50e028045861700ca347"

URI_aarch64_rust-zvariant_utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_utils+default-devel-3.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant_utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_utils+default-devel}"
SRC_URI[aarch64_rust-zvariant_utils+default-devel.sha256sum] = "24ffeb36e275e383f5e9de01c83b80e3fd2437f163924c2c5be0cf750cd28b3b"

URI_aarch64_rust-zvariant_utils+gvariant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_utils+gvariant-devel-3.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant_utils+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_utils+gvariant-devel}"
SRC_URI[aarch64_rust-zvariant_utils+gvariant-devel.sha256sum] = "772e2a89ddc015f9cef63e74ec499ee1a47cd621e82a4f728e070e350d278a28"

URI_aarch64_rust-zvariant_utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_utils-devel-3.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant_utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_utils-devel}"
SRC_URI[aarch64_rust-zvariant_utils-devel.sha256sum] = "4a33b652dcf742432fa82e1eaa57cda975f5d020f50ca1a919f230d8c664f563"

RDEPENDS:rust-zvariant_utils+default-devel = " \
 cargo \
 rust-zvariant_utils-devel \
 "
RDEPENDS:rust-zvariant_utils+gvariant-devel = " \
 cargo \
 rust-zvariant_utils-devel \
 "
RDEPENDS:rust-zvariant_utils-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-winnow+default-devel \
 "
