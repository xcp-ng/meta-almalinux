# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-mobile"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-mobile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-mobile-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a92dcb36d07fa492654788f4f10876c3c5404849138c401d2ccbbed7bcf975a2"

URI_x86_64_v2_plasma-mobile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-mobile-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-mobile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-mobile}"
SRC_URI[x86_64_v2_plasma-mobile.sha256sum] = "10cc70f78350b8774a79bbb45d69316f53e10497fba0d9772bb181ba0934a020"

URI_aarch64_plasma-mobile = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-mobile-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-mobile;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-mobile}"
SRC_URI[aarch64_plasma-mobile.sha256sum] = "12565af224ce9550d11001b950d5058a45bb7542d19f12e34d21128dc615e281"

RDEPENDS:plasma-mobile = " \
 bash \
 glib2 \
 glibc \
 kf6-bluez-qt \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-modemmanager-qt \
 kf6-networkmanager-qt \
 kf6-solid \
 kpipewire \
 kscreen \
 kwayland \
 kwin \
 kwin-libs \
 layer-shell-qt \
 libgcc \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 plasma-activities \
 plasma-milou \
 plasma-nano \
 plasma-nm \
 plasma-pa \
 plasma-workspace \
 qcoro-qt6 \
 qqc2-breeze-style \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsensors \
 qt6-qtwayland \
 systemd-libs \
 "
