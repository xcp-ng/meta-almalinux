# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-tagged"
PV = "0.8.8"
PR = "1.el10_0"
PACKAGES = " \
 ghc-tagged \
 ghc-tagged-devel \
 ghc-tagged-doc \
 ghc-tagged-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-tagged-0.8.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ded64e3960ffc86df9c4e92d892ed2b367179fe2c1c3c2c4522435684911971"

URI_x86_64_v2_ghc-tagged = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tagged-0.8.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tagged;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tagged}"
SRC_URI[x86_64_v2_ghc-tagged.sha256sum] = "15c2d2491eec412a3e398ec624745e813c16f6df0a1ed856e1f3928c7777b391"

URI_x86_64_v2_ghc-tagged-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tagged-devel-0.8.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tagged-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tagged-devel}"
SRC_URI[x86_64_v2_ghc-tagged-devel.sha256sum] = "545332aee5a46860e4a04d1cd2940ffea5a6d6d17a07f7ed3cb1f68c09f7cc30"

URI_x86_64_v2_ghc-tagged-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tagged-doc-0.8.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-tagged-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tagged-doc}"
SRC_URI[x86_64_v2_ghc-tagged-doc.sha256sum] = "d4e6844f81c78529c3866bae57d58d1edafdd8d2d7e5fffa1ca017f10782fda1"

URI_x86_64_v2_ghc-tagged-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tagged-prof-0.8.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tagged-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tagged-prof}"
SRC_URI[x86_64_v2_ghc-tagged-prof.sha256sum] = "791e98165b70d9bed42e95a588f41ac91b308727602fad3a2e342ee125b543e9"

URI_aarch64_ghc-tagged = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tagged-0.8.8-1.el10_0.aarch64.rpm;name=aarch64_ghc-tagged;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tagged}"
SRC_URI[aarch64_ghc-tagged.sha256sum] = "cf54ac3f3a81d1b15627d92161d7b117d72cc12c07eef5dc5fc40c27e9ce5c14"

URI_aarch64_ghc-tagged-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tagged-devel-0.8.8-1.el10_0.aarch64.rpm;name=aarch64_ghc-tagged-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tagged-devel}"
SRC_URI[aarch64_ghc-tagged-devel.sha256sum] = "180ee7d4b763da3e742820543c7a1c8e9ff0be23599fdc6b086daa1292692a8d"

URI_aarch64_ghc-tagged-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tagged-doc-0.8.8-1.el10_0.noarch.rpm;name=aarch64_ghc-tagged-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tagged-doc}"
SRC_URI[aarch64_ghc-tagged-doc.sha256sum] = "9d1b640470491e2e36e50d92b7f018dd27f368f80e261072049c4598481ef203"

URI_aarch64_ghc-tagged-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tagged-prof-0.8.8-1.el10_0.aarch64.rpm;name=aarch64_ghc-tagged-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tagged-prof}"
SRC_URI[aarch64_ghc-tagged-prof.sha256sum] = "9e4132bbcd7b424855b65849e49986121e39e990ebc05bf82e02726dfe1c44b1"

RDEPENDS:ghc-tagged = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-tagged-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-tagged \
 ghc-template-haskell-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-tagged-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-tagged-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-tagged-devel \
 ghc-template-haskell-prof \
 ghc-transformers-prof \
 "
