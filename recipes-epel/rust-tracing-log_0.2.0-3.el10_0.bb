# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-log"
PV = "0.2.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-tracing-log+default-devel \
 rust-tracing-log+log-tracer-devel \
 rust-tracing-log+std-devel \
 rust-tracing-log-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-log-0.2.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7912e7304dd6d800267d6bc02a04955c8fcd8da1c658be2032fd3b431a3141b1"

URI_x86_64_v2_rust-tracing-log+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-log+default-devel-0.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-log+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-log+default-devel.sha256sum] = "b7235e1dcae0136a390d4d72318319b36cfc7e88fe52347a1b966b68a7b0707a"

URI_x86_64_v2_rust-tracing-log+log-tracer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-log+log-tracer-devel-0.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-log+log-tracer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-log+log-tracer-devel}"
SRC_URI[x86_64_v2_rust-tracing-log+log-tracer-devel.sha256sum] = "8e3d8251d99d5aee346400dc45f68043bd10ca103391453c91cc00e75226cf21"

URI_x86_64_v2_rust-tracing-log+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-log+std-devel-0.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-log+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-log+std-devel}"
SRC_URI[x86_64_v2_rust-tracing-log+std-devel.sha256sum] = "49940d3fa0c44fd6f31a8a4d67a9bb4f9d67864071460089161e10aab3764ef8"

URI_x86_64_v2_rust-tracing-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-log-devel-0.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-log-devel}"
SRC_URI[x86_64_v2_rust-tracing-log-devel.sha256sum] = "22c7a730ecb44c9c74f0db5fb597e5b94c05ff12c46695e434165347290e9f1e"

URI_aarch64_rust-tracing-log+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-log+default-devel-0.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-tracing-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-log+default-devel}"
SRC_URI[aarch64_rust-tracing-log+default-devel.sha256sum] = "bcbe106a9f380b1483bc65334ebf75f839418a4fb3096e606468b264d3aa260a"

URI_aarch64_rust-tracing-log+log-tracer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-log+log-tracer-devel-0.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-tracing-log+log-tracer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-log+log-tracer-devel}"
SRC_URI[aarch64_rust-tracing-log+log-tracer-devel.sha256sum] = "1384b898387c0ea80c7c09d29f1cebed87cbdb69d8b4def9d3e011fd9735b299"

URI_aarch64_rust-tracing-log+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-log+std-devel-0.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-tracing-log+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-log+std-devel}"
SRC_URI[aarch64_rust-tracing-log+std-devel.sha256sum] = "083212bcd99cd1010578b6e671a6bd045ed2093dc6caecf94e062d66e906d59a"

URI_aarch64_rust-tracing-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-log-devel-0.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-tracing-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-log-devel}"
SRC_URI[aarch64_rust-tracing-log-devel.sha256sum] = "bb88a6e06ee66173aa4a318bee865f12f7a33b2d94f1e95dfb6845519eeb2805"

RDEPENDS:rust-tracing-log+default-devel = " \
 cargo \
 rust-tracing-log+log-tracer-devel \
 rust-tracing-log+std-devel \
 rust-tracing-log-devel \
 "
RDEPENDS:rust-tracing-log+log-tracer-devel = " \
 cargo \
 rust-tracing-log-devel \
 "
RDEPENDS:rust-tracing-log+std-devel = " \
 cargo \
 rust-log+std-devel \
 rust-tracing-log-devel \
 "
RDEPENDS:rust-tracing-log-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-once_cell+default-devel \
 rust-tracing-core+default-devel \
 "
