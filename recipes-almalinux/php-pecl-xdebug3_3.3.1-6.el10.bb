# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-xdebug3"
PV = "3.3.1"
PR = "6.el10"
PACKAGES = " \
 php-pecl-xdebug3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/php-pecl-xdebug3-3.3.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "848799b965e362c185151fc246c9c25b7209971a63c7f71ab5e8410626f4e1c4"

URI_x86_64_v2_php-pecl-xdebug3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pecl-xdebug3-3.3.1-6.el10.x86_64_v2.rpm;name=x86_64_v2_php-pecl-xdebug3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-xdebug3}"
SRC_URI[x86_64_v2_php-pecl-xdebug3.sha256sum] = "b209a54421a00164dcd33865713d259e0c36dcbabed7a887f9388d450a9a3170"

URI_aarch64_php-pecl-xdebug3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pecl-xdebug3-3.3.1-6.el10.aarch64.rpm;name=aarch64_php-pecl-xdebug3;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-xdebug3}"
SRC_URI[aarch64_php-pecl-xdebug3.sha256sum] = "cb046a05cae89f2fbe2e80e3b6c2255591909a4c108e53aad0ab64aee75fd18f"

RDEPENDS:php-pecl-xdebug3 = " \
 glibc \
 php-common \
 zlib-ng-compat \
 "
