# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-mailmap"
PV = "0.27.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-mailmap+default-devel \
 rust-gix-mailmap+document-features-devel \
 rust-gix-mailmap+serde-devel \
 rust-gix-mailmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-mailmap-0.27.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "530a40d6253840a06af6033b1e5ca5c1bd95221cd02a5b8e48524b96d977376d"

URI_x86_64_v2_rust-gix-mailmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap+default-devel-0.27.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap+default-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap+default-devel.sha256sum] = "9cdf6c8d4bf205db8043fe7778369da918be530fcac19732c4c42d15c0ea3d48"

URI_x86_64_v2_rust-gix-mailmap+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap+document-features-devel-0.27.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap+document-features-devel.sha256sum] = "3703977a51f684bf2e01df59a8edf6c1e38967770c1303eb132d4e4758382c39"

URI_x86_64_v2_rust-gix-mailmap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap+serde-devel-0.27.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap+serde-devel.sha256sum] = "8e79fbb065d2993d605cd93bab75827fb309e9fe53034345cd9e2d5e1f826b75"

URI_x86_64_v2_rust-gix-mailmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap-devel-0.27.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap-devel.sha256sum] = "281a98e3dc1457a52a739b891e87064ddcefcfc707b2b2e1595f600b22523d00"

URI_aarch64_rust-gix-mailmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap+default-devel-0.27.2-1.el10_1.noarch.rpm;name=aarch64_rust-gix-mailmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap+default-devel}"
SRC_URI[aarch64_rust-gix-mailmap+default-devel.sha256sum] = "7568ad6725922a0ec6f5ccb81ee9cf6da588c9b323366321afe879bc6cb452cd"

URI_aarch64_rust-gix-mailmap+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap+document-features-devel-0.27.2-1.el10_1.noarch.rpm;name=aarch64_rust-gix-mailmap+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap+document-features-devel}"
SRC_URI[aarch64_rust-gix-mailmap+document-features-devel.sha256sum] = "4c58f528790cd79ea1d70a4dc0d6c6efd17b2519896e72445558f2dadf4a257a"

URI_aarch64_rust-gix-mailmap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap+serde-devel-0.27.2-1.el10_1.noarch.rpm;name=aarch64_rust-gix-mailmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap+serde-devel}"
SRC_URI[aarch64_rust-gix-mailmap+serde-devel.sha256sum] = "23f8be80ea1155dca5c266a1d1e3a91a1283fbd51132ce21b5b5f4874ecd6f99"

URI_aarch64_rust-gix-mailmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap-devel-0.27.2-1.el10_1.noarch.rpm;name=aarch64_rust-gix-mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap-devel}"
SRC_URI[aarch64_rust-gix-mailmap-devel.sha256sum] = "bd4dc64e30d6c2da81a012dc2837338a7db44e8e4c8e66c9e9c9dfb98d39a186"

RDEPENDS:rust-gix-mailmap+default-devel = " \
 cargo \
 rust-gix-mailmap-devel \
 "
RDEPENDS:rust-gix-mailmap+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-mailmap-devel \
 "
RDEPENDS:rust-gix-mailmap+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-actor+serde-devel \
 rust-gix-mailmap-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-mailmap-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-actor+default-devel \
 rust-gix-date+default-devel \
 rust-thiserror+default-devel \
 "
