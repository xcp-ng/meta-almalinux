# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kstatusnotifieritem"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kstatusnotifieritem \
 kf6-kstatusnotifieritem-devel \
 kf6-kstatusnotifieritem-doc \
 kf6-kstatusnotifieritem-html \
 python3-kf6-kstatusnotifieritem \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kstatusnotifieritem-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "441e0ccbb908549872e08d0e84abf5d0c9d387f90a9050fabb8d27df39da8054"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kstatusnotifieritem;unpack=0"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem.sha256sum] = "c6716aa00ec99c3ef6d5586c690eb20e8a9955fd7bca4158d51c33793a132566"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kstatusnotifieritem-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem-devel.sha256sum] = "3446eb95bf2e1ba2dcb855db8bfac1e9d17122dad65186e992e253f627ca2496"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kstatusnotifieritem-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem-doc.sha256sum] = "6d833916adce74606b6455f12d898a112e05a1e6472f5f5faabb94f2c319cef2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kstatusnotifieritem-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem-html.sha256sum] = "da99b860dbd3564f1567b47028b20353f434ec5d58b2a8526ae734e242d48be0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kstatusnotifieritem-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kstatusnotifieritem;unpack=0"
SRC_URI[x86_64_v2_python3-kf6-kstatusnotifieritem.sha256sum] = "b16e451eb72fe19c80bec97628554bf7ef00a4ecb4df4f24136e5afed19fdb3c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kstatusnotifieritem;unpack=0"
SRC_URI[aarch64_kf6-kstatusnotifieritem.sha256sum] = "dd89ea4cf0b751b15d6c1f7c468be25791a01f5aee4968ab61f15e700e9e42ee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kstatusnotifieritem-devel;unpack=0"
SRC_URI[aarch64_kf6-kstatusnotifieritem-devel.sha256sum] = "df6e24549f859023e755a5a2452ecf1d5b59b5ad0379df0ee90956f1dc01d67e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kstatusnotifieritem-doc;unpack=0"
SRC_URI[aarch64_kf6-kstatusnotifieritem-doc.sha256sum] = "6bc7a45f78354d7b19d7e58124493712dd2730c20981dc9f1f3854fee32f1591"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kstatusnotifieritem-html;unpack=0"
SRC_URI[aarch64_kf6-kstatusnotifieritem-html.sha256sum] = "a0f41fa107a6f822a5bb257d5d5f852293a18e1445e0804d30e0d13c22adf5d4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kstatusnotifieritem-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kstatusnotifieritem;unpack=0"
SRC_URI[aarch64_python3-kf6-kstatusnotifieritem.sha256sum] = "14f62d60f3776a9806fbda129c193c33ae2cce5e9539d6bd1b9946b8d428ca4d"

RDEPENDS:kf6-kstatusnotifieritem = " \
 glibc \
 kf6-filesystem \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kstatusnotifieritem-devel = " \
 cmake-filesystem \
 kf6-kstatusnotifieritem \
 "
RDEPENDS:kf6-kstatusnotifieritem-doc = " \
 "
RDEPENDS:kf6-kstatusnotifieritem-html = " \
 "
RDEPENDS:python3-kf6-kstatusnotifieritem = " \
 glibc \
 kf6-kstatusnotifieritem \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
