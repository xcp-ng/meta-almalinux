# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yq"
PV = "4.53.3"
PR = "1.el10_2"
PACKAGES = " \
 yq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yq-4.53.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7ee66dc0ec1db4b82c91adb4873b72633f2c38b33117ef5f229dd50359060b4"

URI_x86_64_v2_yq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yq-4.53.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yq}"
SRC_URI[x86_64_v2_yq.sha256sum] = "63e69302bb64b2fa71daf5ec4f4ec8227d3eb84e12366d9ee41bd09c6206db62"

URI_aarch64_yq = "${EPEL_MIRROR}/aarch64/Packages/y/yq-4.53.3-1.el10_2.aarch64.rpm;name=aarch64_yq;unpack=0"
SRC_URI:append = " ${URI_aarch64_yq}"
SRC_URI[aarch64_yq.sha256sum] = "3526d342a1819e5c09a856f348499413e0addbddf4e31b58897443391bf112a3"

RDEPENDS:yq = " \
 glibc \
 "
