# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-stable_deref_trait"
PV = "1.2.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-stable_deref_trait+alloc-devel \
 rust-stable_deref_trait+default-devel \
 rust-stable_deref_trait+std-devel \
 rust-stable_deref_trait-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-stable_deref_trait-1.2.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69242a2334ce6bd90546208ec51289db326d3971c18dc480a5b49f722734b815"

URI_x86_64_v2_rust-stable_deref_trait+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stable_deref_trait+alloc-devel-1.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stable_deref_trait+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stable_deref_trait+alloc-devel}"
SRC_URI[x86_64_v2_rust-stable_deref_trait+alloc-devel.sha256sum] = "9be4d8b37b8db0d86fe36e548cfc7b703574dd98c2d20ca2767209f72d299f23"

URI_x86_64_v2_rust-stable_deref_trait+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stable_deref_trait+default-devel-1.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stable_deref_trait+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stable_deref_trait+default-devel}"
SRC_URI[x86_64_v2_rust-stable_deref_trait+default-devel.sha256sum] = "edb60fec06998880ff1cd1ea297a9aa598d3372a3873a3e83817c7e5ad0e883a"

URI_x86_64_v2_rust-stable_deref_trait+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stable_deref_trait+std-devel-1.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stable_deref_trait+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stable_deref_trait+std-devel}"
SRC_URI[x86_64_v2_rust-stable_deref_trait+std-devel.sha256sum] = "3995d2ead1e65776387a2daa54fb635f612b18ae2f31e272b3f2cfdb25d3335c"

URI_x86_64_v2_rust-stable_deref_trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stable_deref_trait-devel-1.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stable_deref_trait-devel}"
SRC_URI[x86_64_v2_rust-stable_deref_trait-devel.sha256sum] = "b7a4bb72162b4b517e0fc1e364505896338148a857d4b3e761fff0ed464376d1"

URI_aarch64_rust-stable_deref_trait+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stable_deref_trait+alloc-devel-1.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-stable_deref_trait+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stable_deref_trait+alloc-devel}"
SRC_URI[aarch64_rust-stable_deref_trait+alloc-devel.sha256sum] = "1b3f88cd4ab518b2f1ab2c9ceebbe2f9d3d2cd216cb613ef2a241e1eb1020b8f"

URI_aarch64_rust-stable_deref_trait+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stable_deref_trait+default-devel-1.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-stable_deref_trait+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stable_deref_trait+default-devel}"
SRC_URI[aarch64_rust-stable_deref_trait+default-devel.sha256sum] = "ae376dc62f504ad0635279c7aa79337fe09459a2705b61e077d2338c77bdd8a5"

URI_aarch64_rust-stable_deref_trait+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stable_deref_trait+std-devel-1.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-stable_deref_trait+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stable_deref_trait+std-devel}"
SRC_URI[aarch64_rust-stable_deref_trait+std-devel.sha256sum] = "2b91298b0f09b4d16a56256c20bf663a85e6da7a98313c7eb1466c6042f5d965"

URI_aarch64_rust-stable_deref_trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stable_deref_trait-devel-1.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stable_deref_trait-devel}"
SRC_URI[aarch64_rust-stable_deref_trait-devel.sha256sum] = "647dfed511e517ad945a9339e4fe82957e463f3f2fb388965b879fe5839f7ecd"

RDEPENDS:rust-stable_deref_trait+alloc-devel = " \
 cargo \
 rust-stable_deref_trait-devel \
 "
RDEPENDS:rust-stable_deref_trait+default-devel = " \
 cargo \
 rust-stable_deref_trait+std-devel \
 rust-stable_deref_trait-devel \
 "
RDEPENDS:rust-stable_deref_trait+std-devel = " \
 cargo \
 rust-stable_deref_trait+alloc-devel \
 rust-stable_deref_trait-devel \
 "
RDEPENDS:rust-stable_deref_trait-devel = " \
 cargo \
 "
