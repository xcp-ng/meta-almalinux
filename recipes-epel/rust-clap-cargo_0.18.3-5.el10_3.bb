# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap-cargo"
PV = "0.18.3"
PR = "5.el10_3"
PACKAGES = " \
 rust-clap-cargo+cargo_metadata-devel \
 rust-clap-cargo+clap-devel \
 rust-clap-cargo+default-devel \
 rust-clap-cargo+testing_colors-devel \
 rust-clap-cargo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap-cargo-0.18.3-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8470ac3827bff3692f4e071fcf0264aa31f9e75637efe1964104380e1438f3e"

URI_x86_64_v2_rust-clap-cargo+cargo_metadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-cargo+cargo_metadata-devel-0.18.3-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-cargo+cargo_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-cargo+cargo_metadata-devel}"
SRC_URI[x86_64_v2_rust-clap-cargo+cargo_metadata-devel.sha256sum] = "bd988224537c509060517e10506a4563f9e7d08e67f1e8eb41000731105aa5b8"

URI_x86_64_v2_rust-clap-cargo+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-cargo+clap-devel-0.18.3-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-cargo+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-cargo+clap-devel}"
SRC_URI[x86_64_v2_rust-clap-cargo+clap-devel.sha256sum] = "95e7255d03acc198b151e84fe0cfbd2e830bac9778f0919e52a1407d54982f29"

URI_x86_64_v2_rust-clap-cargo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-cargo+default-devel-0.18.3-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-cargo+default-devel}"
SRC_URI[x86_64_v2_rust-clap-cargo+default-devel.sha256sum] = "0d85f6eea67868ba51e7dd9c7bb37dc59d414d261f051d8e970c497ea8c70c91"

URI_x86_64_v2_rust-clap-cargo+testing_colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-cargo+testing_colors-devel-0.18.3-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-cargo+testing_colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-cargo+testing_colors-devel}"
SRC_URI[x86_64_v2_rust-clap-cargo+testing_colors-devel.sha256sum] = "de8e56dc73c03cdb2304e321b8a8586284d09b8603ca7ee8618c311fc6c8cf48"

URI_x86_64_v2_rust-clap-cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-cargo-devel-0.18.3-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-cargo-devel}"
SRC_URI[x86_64_v2_rust-clap-cargo-devel.sha256sum] = "e10601ece0b01ca08eaff45093e69120c182de90bca9eb5eb8b937ec8a2c838e"

URI_aarch64_rust-clap-cargo+cargo_metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-cargo+cargo_metadata-devel-0.18.3-5.el10_3.noarch.rpm;name=aarch64_rust-clap-cargo+cargo_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-cargo+cargo_metadata-devel}"
SRC_URI[aarch64_rust-clap-cargo+cargo_metadata-devel.sha256sum] = "26e472030f6d4807fc5457667e1a9219cb0ce7a037f254a68d37e5095556fb81"

URI_aarch64_rust-clap-cargo+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-cargo+clap-devel-0.18.3-5.el10_3.noarch.rpm;name=aarch64_rust-clap-cargo+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-cargo+clap-devel}"
SRC_URI[aarch64_rust-clap-cargo+clap-devel.sha256sum] = "dfea4b4985d18f3f6af7c6c0d0a29a5d2668b26884a8ac1ed3185551a0cf7d37"

URI_aarch64_rust-clap-cargo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-cargo+default-devel-0.18.3-5.el10_3.noarch.rpm;name=aarch64_rust-clap-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-cargo+default-devel}"
SRC_URI[aarch64_rust-clap-cargo+default-devel.sha256sum] = "3e4e5a394e8520af739add5902ef5e18c7e6e191728969f066eea9eb99fbd21e"

URI_aarch64_rust-clap-cargo+testing_colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-cargo+testing_colors-devel-0.18.3-5.el10_3.noarch.rpm;name=aarch64_rust-clap-cargo+testing_colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-cargo+testing_colors-devel}"
SRC_URI[aarch64_rust-clap-cargo+testing_colors-devel.sha256sum] = "cf58d8f2eee2459009ded3758872913af11f78eb83b12f46bb3c346ab4e772a5"

URI_aarch64_rust-clap-cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-cargo-devel-0.18.3-5.el10_3.noarch.rpm;name=aarch64_rust-clap-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-cargo-devel}"
SRC_URI[aarch64_rust-clap-cargo-devel.sha256sum] = "0c17c91f2e7ab304a1332a5c7fba0c83d4bcb0dc7a57ee3123eb84b7c292195f"

RDEPENDS:rust-clap-cargo+cargo_metadata-devel = " \
 cargo \
 rust-cargo_metadata+default-devel \
 rust-clap-cargo-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-clap-cargo+clap-devel = " \
 cargo \
 rust-clap+derive-devel \
 rust-clap+std-devel \
 rust-clap-cargo-devel \
 rust-clap-devel \
 "
RDEPENDS:rust-clap-cargo+default-devel = " \
 cargo \
 rust-clap-cargo+clap-devel \
 rust-clap-cargo-devel \
 "
RDEPENDS:rust-clap-cargo+testing_colors-devel = " \
 cargo \
 rust-clap-cargo-devel \
 "
RDEPENDS:rust-clap-cargo-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 "
