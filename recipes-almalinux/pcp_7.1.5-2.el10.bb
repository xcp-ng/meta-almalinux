# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcp"
PV = "7.1.5"
PR = "2.el10"
PACKAGES:x86_64_v2 = " \
 pcp \
 pcp-conf \
 pcp-devel \
 pcp-doc \
 pcp-export-pcp2elasticsearch \
 pcp-export-pcp2graphite \
 pcp-export-pcp2influxdb \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2opentelemetry \
 pcp-export-pcp2spark \
 pcp-export-pcp2xml \
 pcp-export-pcp2zabbix \
 pcp-export-zabbix-agent \
 pcp-geolocate \
 pcp-gui \
 pcp-import-benchmarks \
 pcp-import-collectl2pcp \
 pcp-import-ganglia2pcp \
 pcp-import-iostat2pcp \
 pcp-import-mrtg2pcp \
 pcp-import-pmseries \
 pcp-import-sar2pcp \
 pcp-libs \
 pcp-libs-devel \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-cifs \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 pcp-pmda-hacluster \
 pcp-pmda-haproxy \
 pcp-pmda-hdb \
 pcp-pmda-infiniband \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mssql \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 pcp-pmda-opentelemetry \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 pcp-pmda-pdns \
 pcp-pmda-perfevent \
 pcp-pmda-podman \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-redis \
 pcp-pmda-resctrl \
 pcp-pmda-rocestat \
 pcp-pmda-roomtemp \
 pcp-pmda-rsyslog \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-systemd \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-selinux \
 pcp-system-tools \
 pcp-testsuite \
 pcp-zeroconf \
 perl-PCP-LogImport \
 perl-PCP-LogSummary \
 perl-PCP-MMV \
 perl-PCP-PMDA \
 python3-pcp \
"
PACKAGES:aarch64 = " \
 pcp \
 pcp-conf \
 pcp-devel \
 pcp-doc \
 pcp-export-pcp2elasticsearch \
 pcp-export-pcp2graphite \
 pcp-export-pcp2influxdb \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2opentelemetry \
 pcp-export-pcp2spark \
 pcp-export-pcp2xml \
 pcp-export-pcp2zabbix \
 pcp-export-zabbix-agent \
 pcp-geolocate \
 pcp-gui \
 pcp-import-benchmarks \
 pcp-import-collectl2pcp \
 pcp-import-ganglia2pcp \
 pcp-import-iostat2pcp \
 pcp-import-mrtg2pcp \
 pcp-import-pmseries \
 pcp-import-sar2pcp \
 pcp-libs \
 pcp-libs-devel \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-cifs \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 pcp-pmda-hacluster \
 pcp-pmda-haproxy \
 pcp-pmda-hdb \
 pcp-pmda-infiniband \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 pcp-pmda-opentelemetry \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 pcp-pmda-pdns \
 pcp-pmda-perfevent \
 pcp-pmda-podman \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-redis \
 pcp-pmda-rocestat \
 pcp-pmda-roomtemp \
 pcp-pmda-rsyslog \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-systemd \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-selinux \
 pcp-system-tools \
 pcp-testsuite \
 pcp-zeroconf \
 perl-PCP-LogImport \
 perl-PCP-LogSummary \
 perl-PCP-MMV \
 perl-PCP-PMDA \
 python3-pcp \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pcp-7.1.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "482f044b3e44df23f2e483fc1983e01a0e34a12190dcf76b640ab8a7273be1f7"

URI_x86_64_v2_pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp}"
SRC_URI[x86_64_v2_pcp.sha256sum] = "c55277213bed48ec7be5ba6131272b4e801afb1d1de686b839e4b20aa75bc9f5"

URI_x86_64_v2_pcp-conf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-conf-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-conf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-conf}"
SRC_URI[x86_64_v2_pcp-conf.sha256sum] = "3a6a2f63c05eda94c5af000618da72da8206da28ab218f06255a52e5c822059a"

URI_x86_64_v2_pcp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-devel-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-devel}"
SRC_URI[x86_64_v2_pcp-devel.sha256sum] = "008640617d4a5b21751ba9d90d20b39b457a30a578c29feb1dc0f29651bd6785"

URI_x86_64_v2_pcp-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-doc-7.1.5-2.el10.noarch.rpm;name=x86_64_v2_pcp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-doc}"
SRC_URI[x86_64_v2_pcp-doc.sha256sum] = "dc4b0a9749fb3cd2602ccf3dae673f0ae21971258f61f8dd4602d13c88b0adec"

URI_x86_64_v2_pcp-export-pcp2elasticsearch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2elasticsearch-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2elasticsearch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2elasticsearch}"
SRC_URI[x86_64_v2_pcp-export-pcp2elasticsearch.sha256sum] = "8718efa27e390d109ca57ba5481862b5c7dd269ad042c17e4eb363a217a8e102"

URI_x86_64_v2_pcp-export-pcp2graphite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2graphite-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2graphite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2graphite}"
SRC_URI[x86_64_v2_pcp-export-pcp2graphite.sha256sum] = "80a23526707c8970bd9f5d9ecdde289263a04f6d10dc561152e851a54b0fb486"

URI_x86_64_v2_pcp-export-pcp2influxdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2influxdb-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2influxdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2influxdb}"
SRC_URI[x86_64_v2_pcp-export-pcp2influxdb.sha256sum] = "247dfa4952dfb826d3cb5b58efbbd332bd11024464d09cc5a6e9d2df12c38058"

URI_x86_64_v2_pcp-export-pcp2json = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2json-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2json}"
SRC_URI[x86_64_v2_pcp-export-pcp2json.sha256sum] = "6c71fa5ab73588d12128b7b9b06553c2ec7a55eec340a6aedb524a176c53b5d4"

URI_x86_64_v2_pcp-export-pcp2openmetrics = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2openmetrics-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2openmetrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2openmetrics}"
SRC_URI[x86_64_v2_pcp-export-pcp2openmetrics.sha256sum] = "4ceee23a7ae95c6d707a17923d117aab7bf2bc37d726fe77f5d4fcea8ca351a7"

URI_x86_64_v2_pcp-export-pcp2opentelemetry = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2opentelemetry-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2opentelemetry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2opentelemetry}"
SRC_URI[x86_64_v2_pcp-export-pcp2opentelemetry.sha256sum] = "2bfed6276a409a6a95d8da512faffaa3fdc734a99aabb88f05844ea72d1033f6"

URI_x86_64_v2_pcp-export-pcp2spark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2spark-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2spark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2spark}"
SRC_URI[x86_64_v2_pcp-export-pcp2spark.sha256sum] = "75140073e99e6d79f8f79ca184040942743a89e3cf5644cfce93aaa0a580507b"

URI_x86_64_v2_pcp-export-pcp2xml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2xml-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2xml}"
SRC_URI[x86_64_v2_pcp-export-pcp2xml.sha256sum] = "4eb78050b5e0ec4adc78876060c2c642a8a8390ee4d208c1e937c58103761e30"

URI_x86_64_v2_pcp-export-pcp2zabbix = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2zabbix-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2zabbix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2zabbix}"
SRC_URI[x86_64_v2_pcp-export-pcp2zabbix.sha256sum] = "893818e1049cba708d83b300fe7f4845ba39937a3ac56f0e4978e430e188890b"

URI_x86_64_v2_pcp-export-zabbix-agent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-zabbix-agent-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-zabbix-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-zabbix-agent}"
SRC_URI[x86_64_v2_pcp-export-zabbix-agent.sha256sum] = "e983e11d84786776957fc1d5a0c938dde8ca67610d6f6543d46441c74b81b597"

URI_x86_64_v2_pcp-geolocate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-geolocate-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-geolocate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-geolocate}"
SRC_URI[x86_64_v2_pcp-geolocate.sha256sum] = "580ccfdad086e7de83365cad6d2449defab73a7aa5755655f19e6a5d1c663539"

URI_x86_64_v2_pcp-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-gui-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-gui}"
SRC_URI[x86_64_v2_pcp-gui.sha256sum] = "055f94e326182ca2b2d86766cb84b32cd77b6366d08398d51543b167405d9a4d"

URI_x86_64_v2_pcp-import-benchmarks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-benchmarks-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-benchmarks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-benchmarks}"
SRC_URI[x86_64_v2_pcp-import-benchmarks.sha256sum] = "1ec33b1c6e2a6c65b7588fc20ad18474e35686fbb57dd1e7c1bdbfed4113ecd7"

URI_x86_64_v2_pcp-import-collectl2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-collectl2pcp-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-collectl2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-collectl2pcp}"
SRC_URI[x86_64_v2_pcp-import-collectl2pcp.sha256sum] = "f401db7352187ef33ed18b5c06fe9b06b809d0a9464b24a18c5f769ac41db8f9"

URI_x86_64_v2_pcp-import-ganglia2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-ganglia2pcp-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-ganglia2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-ganglia2pcp}"
SRC_URI[x86_64_v2_pcp-import-ganglia2pcp.sha256sum] = "f7d5641e749d91cd5503456003db791b523c5286cef8944c38ed18bc3f8a2a0e"

URI_x86_64_v2_pcp-import-iostat2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-iostat2pcp-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-iostat2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-iostat2pcp}"
SRC_URI[x86_64_v2_pcp-import-iostat2pcp.sha256sum] = "396a9453ab1c3e49599d4476857b7ba758795e77ee39681e15aeb44ff97df61c"

URI_x86_64_v2_pcp-import-mrtg2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-mrtg2pcp-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-mrtg2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-mrtg2pcp}"
SRC_URI[x86_64_v2_pcp-import-mrtg2pcp.sha256sum] = "b9b99c78801fd93c83911c482a091831c76966f150960487be7afc63f7d3fad9"

URI_x86_64_v2_pcp-import-pmseries = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-pmseries-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-pmseries;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-pmseries}"
SRC_URI[x86_64_v2_pcp-import-pmseries.sha256sum] = "d0b13556955782606953abf55b8439a9e0de57da323825f66eddd137a2836d13"

URI_x86_64_v2_pcp-import-sar2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-sar2pcp-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-sar2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-sar2pcp}"
SRC_URI[x86_64_v2_pcp-import-sar2pcp.sha256sum] = "fcdd63fc390f8a89a3be526176e73d79483a8fb94300ca09e4f5641e936a0f9d"

URI_x86_64_v2_pcp-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-libs-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-libs}"
SRC_URI[x86_64_v2_pcp-libs.sha256sum] = "bf71d780be5ea5941b8c2d46b14fdbc6578713b6812381adc6b238f5beea509a"

URI_x86_64_v2_pcp-libs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-libs-devel-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-libs-devel}"
SRC_URI[x86_64_v2_pcp-libs-devel.sha256sum] = "4aa5b2e7fdd90efa06a4d407d0bceacdb2182ea4a263a30cccb17d7880786023"

URI_x86_64_v2_pcp-pmda-activemq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-activemq-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-activemq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-activemq}"
SRC_URI[x86_64_v2_pcp-pmda-activemq.sha256sum] = "6005ecc521c4c9d231cb557dba27bb01f5061fa228f47907a7a727c02b825a6b"

URI_x86_64_v2_pcp-pmda-amdgpu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-amdgpu-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-amdgpu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-amdgpu}"
SRC_URI[x86_64_v2_pcp-pmda-amdgpu.sha256sum] = "20483ed03804c3908180b5c40b3cc0d0c2ac42e664a8cd55a2b8f37b707182d3"

URI_x86_64_v2_pcp-pmda-apache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-apache-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-apache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-apache}"
SRC_URI[x86_64_v2_pcp-pmda-apache.sha256sum] = "9986ce0423a65b79d3b850fcbc102e066df93d6fefdd951705359596fba41163"

URI_x86_64_v2_pcp-pmda-bash = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bash-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bash}"
SRC_URI[x86_64_v2_pcp-pmda-bash.sha256sum] = "8f84f87c168b8c47263cf27ca50ad18aa62bdb1ea9a5bd4fbee621b57278e1a8"

URI_x86_64_v2_pcp-pmda-bind2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bind2-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bind2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bind2}"
SRC_URI[x86_64_v2_pcp-pmda-bind2.sha256sum] = "1246baf6c6d7bc4711e77f754b69d25f3407ebcd2a4daad6011f1ccb07ccec1c"

URI_x86_64_v2_pcp-pmda-bonding = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bonding-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bonding;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bonding}"
SRC_URI[x86_64_v2_pcp-pmda-bonding.sha256sum] = "4c6f3e3344cdcb2f804294108e31ba9a913e01b2d034d03d3ba7e4dc11a6dbb3"

URI_x86_64_v2_pcp-pmda-bpf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bpf-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bpf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bpf}"
SRC_URI[x86_64_v2_pcp-pmda-bpf.sha256sum] = "d1ecea00f1f0f3d05c4d99d50fa340fa7b95c3581e4fb23ef011479dcbf78563"

URI_x86_64_v2_pcp-pmda-bpftrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bpftrace-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bpftrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bpftrace}"
SRC_URI[x86_64_v2_pcp-pmda-bpftrace.sha256sum] = "40c23d3483eef7b76253a3bd2ab0e55fb9fda9c11cda742d0b529403fbe6efd8"

URI_x86_64_v2_pcp-pmda-cifs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-cifs-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-cifs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-cifs}"
SRC_URI[x86_64_v2_pcp-pmda-cifs.sha256sum] = "8c29472d04fe2ac3fc27147d916f14ceacd21708ac485651cfef3443f7a909cc"

URI_x86_64_v2_pcp-pmda-cisco = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-cisco-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-cisco;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-cisco}"
SRC_URI[x86_64_v2_pcp-pmda-cisco.sha256sum] = "df2abbac72b5ee54856f85bee2fcc74a11beae6528c16c10da856f60a2c7291c"

URI_x86_64_v2_pcp-pmda-dbping = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-dbping-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-dbping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-dbping}"
SRC_URI[x86_64_v2_pcp-pmda-dbping.sha256sum] = "f706a7d87d1d436888b35c33d893bb1d279b1d779de400f32d0554477cde1cd9"

URI_x86_64_v2_pcp-pmda-denki = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-denki-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-denki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-denki}"
SRC_URI[x86_64_v2_pcp-pmda-denki.sha256sum] = "bbcdbd27215835c4fd5518d12f857d9687bf7bdb346fcea728ae3e597cc25851"

URI_x86_64_v2_pcp-pmda-dm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-dm-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-dm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-dm}"
SRC_URI[x86_64_v2_pcp-pmda-dm.sha256sum] = "6a696a911bdb7663122979d707294336c06c68ae5bf96bb430ff36af17df61ff"

URI_x86_64_v2_pcp-pmda-docker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-docker-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-docker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-docker}"
SRC_URI[x86_64_v2_pcp-pmda-docker.sha256sum] = "5acf07970b156784cccb905bf61c68bb08fb98ddf03f16c1c4888f3c13acec49"

URI_x86_64_v2_pcp-pmda-ds389 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-ds389-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-ds389;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-ds389}"
SRC_URI[x86_64_v2_pcp-pmda-ds389.sha256sum] = "18cbdaca4d2ccf0340d41850f0eb59c363dab5c1dc8332b1ad50255beb59424a"

URI_x86_64_v2_pcp-pmda-ds389log = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-ds389log-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-ds389log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-ds389log}"
SRC_URI[x86_64_v2_pcp-pmda-ds389log.sha256sum] = "b373d21e6341c40c2a5878947356582060020822fe2f63a26324826d1070396c"

URI_x86_64_v2_pcp-pmda-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-elasticsearch-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-elasticsearch}"
SRC_URI[x86_64_v2_pcp-pmda-elasticsearch.sha256sum] = "7ec62d70af6c2a18a9f476a77744e504900ef47fc705227acdd928cccdf142a9"

URI_x86_64_v2_pcp-pmda-farm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-farm-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-farm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-farm}"
SRC_URI[x86_64_v2_pcp-pmda-farm.sha256sum] = "f6cb7bb6a29802477055188ea292a27b58a83fae8a7c4d6f5c317424967d4eb1"

URI_x86_64_v2_pcp-pmda-gluster = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gluster-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gluster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-gluster}"
SRC_URI[x86_64_v2_pcp-pmda-gluster.sha256sum] = "6ce7ac2efc52013da6b22b347b13490589fd9269f1e377212b17bb4395510276"

URI_x86_64_v2_pcp-pmda-gpfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gpfs-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gpfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-gpfs}"
SRC_URI[x86_64_v2_pcp-pmda-gpfs.sha256sum] = "255aa79277d72afd2917fc32d5335eef209dd85eefbe45c72b1590f45473d23b"

URI_x86_64_v2_pcp-pmda-gpsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gpsd-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gpsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-gpsd}"
SRC_URI[x86_64_v2_pcp-pmda-gpsd.sha256sum] = "6bea8f6761bfa1cc681fe209eb74dc0d012813a68de45d099259b478eedc0257"

URI_x86_64_v2_pcp-pmda-hacluster = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-hacluster-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-hacluster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-hacluster}"
SRC_URI[x86_64_v2_pcp-pmda-hacluster.sha256sum] = "d11c5278b01449e486faa1dcc777b6cb3f31cbedcbd7af25334b5afe75cbdb9e"

URI_x86_64_v2_pcp-pmda-haproxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-haproxy-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-haproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-haproxy}"
SRC_URI[x86_64_v2_pcp-pmda-haproxy.sha256sum] = "2054980b6c8e2bff3b893ee32b5041f92b807dd0e07d91ed5b89d4be1238283a"

URI_x86_64_v2_pcp-pmda-hdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-hdb-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-hdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-hdb}"
SRC_URI[x86_64_v2_pcp-pmda-hdb.sha256sum] = "1909ed3f81472714780778b50cd4d3e9468453319e8957fb5939fd71e4389644"

URI_x86_64_v2_pcp-pmda-infiniband = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-infiniband-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-infiniband;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-infiniband}"
SRC_URI[x86_64_v2_pcp-pmda-infiniband.sha256sum] = "7f4daf5304e8e9f48e3bbfe0abad6be0883a201117426aaed27901d03ddd63e1"

URI_x86_64_v2_pcp-pmda-libvirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-libvirt-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-libvirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-libvirt}"
SRC_URI[x86_64_v2_pcp-pmda-libvirt.sha256sum] = "d62b2c61de8499e494fb9685c7d6207064c640c3f1ebd360e18bf62840b5a5c1"

URI_x86_64_v2_pcp-pmda-lio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lio-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lio}"
SRC_URI[x86_64_v2_pcp-pmda-lio.sha256sum] = "88aeef8d8d924f6a6d658d8eaf1b3f85d6a2587e7130ff482e4a16dddc14cd88"

URI_x86_64_v2_pcp-pmda-lmsensors = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lmsensors-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lmsensors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lmsensors}"
SRC_URI[x86_64_v2_pcp-pmda-lmsensors.sha256sum] = "385b9a88450f967d95e4d02b9edf2a99e966960162a13428218ee3153885172e"

URI_x86_64_v2_pcp-pmda-logger = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-logger-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-logger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-logger}"
SRC_URI[x86_64_v2_pcp-pmda-logger.sha256sum] = "71824c301655fd9bb6634f6ce712b337fdb3ea271fcd8f338249dc13839325a1"

URI_x86_64_v2_pcp-pmda-lustre = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lustre-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lustre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lustre}"
SRC_URI[x86_64_v2_pcp-pmda-lustre.sha256sum] = "aef25e8c3e4f4fa595a83d356acab72e3c86fe9ead617624866e816fe833f32e"

URI_x86_64_v2_pcp-pmda-lustrecomm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lustrecomm-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lustrecomm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lustrecomm}"
SRC_URI[x86_64_v2_pcp-pmda-lustrecomm.sha256sum] = "a1906ccab44551c0b5bbe78dce67298f466fd9db09e562c2802acab87ee5da34"

URI_x86_64_v2_pcp-pmda-mailq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mailq-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mailq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mailq}"
SRC_URI[x86_64_v2_pcp-pmda-mailq.sha256sum] = "40386314309486f0b7bdba49ba22b331327ef5268173fd35b30c7c8be0d24142"

URI_x86_64_v2_pcp-pmda-memcache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-memcache-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-memcache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-memcache}"
SRC_URI[x86_64_v2_pcp-pmda-memcache.sha256sum] = "fb04096b1c314eacebf90552e1f25d70f10106c95f98a724a4c318e11101d587"

URI_x86_64_v2_pcp-pmda-mic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mic-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mic}"
SRC_URI[x86_64_v2_pcp-pmda-mic.sha256sum] = "291f832244af01e55e7379a5cd715a9a50a42fb1300df7f168e875f18bb4e758"

URI_x86_64_v2_pcp-pmda-mongodb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mongodb-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mongodb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mongodb}"
SRC_URI[x86_64_v2_pcp-pmda-mongodb.sha256sum] = "a7315a88771ca4bb36910582e32db9a73a0f4c6c055890b7d441e66ed1b45dc9"

URI_x86_64_v2_pcp-pmda-mounts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mounts-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mounts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mounts}"
SRC_URI[x86_64_v2_pcp-pmda-mounts.sha256sum] = "3696e4d36ed702a1a72383dc6f42d9476223e15461e5150142cd526c744784ba"

URI_x86_64_v2_pcp-pmda-mssql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mssql-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mssql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mssql}"
SRC_URI[x86_64_v2_pcp-pmda-mssql.sha256sum] = "232c7c115dddee8ac4c1d2543aca576b24f0c4a4679ec473d1fa807b71da8621"

URI_x86_64_v2_pcp-pmda-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mysql-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mysql}"
SRC_URI[x86_64_v2_pcp-pmda-mysql.sha256sum] = "d412c58c9367111621d69065f40923b626eb0b94aae79cc1d15828e6858e3b3d"

URI_x86_64_v2_pcp-pmda-named = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-named-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-named;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-named}"
SRC_URI[x86_64_v2_pcp-pmda-named.sha256sum] = "126858d5a5be1ff629fc8d4eb1e2f5568a4630cc3e224e200e15988ad766f4e6"

URI_x86_64_v2_pcp-pmda-netcheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-netcheck-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-netcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-netcheck}"
SRC_URI[x86_64_v2_pcp-pmda-netcheck.sha256sum] = "751bea7bda441ad990fed3ac05675e414a7c9a007112e4518d9c5bac000f93f8"

URI_x86_64_v2_pcp-pmda-netfilter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-netfilter-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-netfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-netfilter}"
SRC_URI[x86_64_v2_pcp-pmda-netfilter.sha256sum] = "f997ef38cf7784c78a4aeb8d9545c750ea39c858d4e1ad700f34d5ca74cf3038"

URI_x86_64_v2_pcp-pmda-news = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-news-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-news;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-news}"
SRC_URI[x86_64_v2_pcp-pmda-news.sha256sum] = "8d52ccf4365410656d9fb07feac9f9ddba8d5591db5b87b9b404ddf494a08b09"

URI_x86_64_v2_pcp-pmda-nfsclient = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nfsclient-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nfsclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-nfsclient}"
SRC_URI[x86_64_v2_pcp-pmda-nfsclient.sha256sum] = "da8c05486a057898d412f95c94e3d1161d33f5195f6adcc1e3a1ec355a4a1591"

URI_x86_64_v2_pcp-pmda-nginx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nginx-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-nginx}"
SRC_URI[x86_64_v2_pcp-pmda-nginx.sha256sum] = "cd04bcb79e337c2c53e4642ad85784389db8317b65d3db230506563c6f1bd267"

URI_x86_64_v2_pcp-pmda-nvidia-gpu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nvidia-gpu-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nvidia-gpu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-nvidia-gpu}"
SRC_URI[x86_64_v2_pcp-pmda-nvidia-gpu.sha256sum] = "f0607babf3432db7c97bc84c88ec8feb78881b3508abc1b8951e09439ca132dc"

URI_x86_64_v2_pcp-pmda-openmetrics = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-openmetrics-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-openmetrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-openmetrics}"
SRC_URI[x86_64_v2_pcp-pmda-openmetrics.sha256sum] = "ca21fb8a2c6cf733d30d129dd18ea7503f9db6bc3fdf7f9ebd2fe90e96aaadc2"

URI_x86_64_v2_pcp-pmda-opentelemetry = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-opentelemetry-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-opentelemetry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-opentelemetry}"
SRC_URI[x86_64_v2_pcp-pmda-opentelemetry.sha256sum] = "ec8a9cb774d3bccb418d986a05b9cb9cc0b6ac2ccd049f20eeea29ef17cca9c8"

URI_x86_64_v2_pcp-pmda-openvswitch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-openvswitch-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-openvswitch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-openvswitch}"
SRC_URI[x86_64_v2_pcp-pmda-openvswitch.sha256sum] = "c195789aed1891e43adf5adb9bf4f6abb8b60f5f1b55efdae8179b312418a675"

URI_x86_64_v2_pcp-pmda-oracle = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-oracle-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-oracle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-oracle}"
SRC_URI[x86_64_v2_pcp-pmda-oracle.sha256sum] = "90af7e81325d6aae1319867d003859ba4ac8b790846ef4719c67d63047eb063b"

URI_x86_64_v2_pcp-pmda-pdns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-pdns-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-pdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-pdns}"
SRC_URI[x86_64_v2_pcp-pmda-pdns.sha256sum] = "cd7c15292ffafac23427aff0d77dca6f942f3eb42f6b3bf76ee7ead3a91270d7"

URI_x86_64_v2_pcp-pmda-perfevent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-perfevent-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-perfevent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-perfevent}"
SRC_URI[x86_64_v2_pcp-pmda-perfevent.sha256sum] = "977f6043f24cf0167305b5b4ac3f7d20c9661894791e1897d99015da6023a521"

URI_x86_64_v2_pcp-pmda-podman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-podman-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-podman}"
SRC_URI[x86_64_v2_pcp-pmda-podman.sha256sum] = "be579f5f737de1bd0ca0d7492d8c52b85a240fce41d7d164aabde5cf03cd1a18"

URI_x86_64_v2_pcp-pmda-postfix = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-postfix-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-postfix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-postfix}"
SRC_URI[x86_64_v2_pcp-pmda-postfix.sha256sum] = "5d7ea90bb83c752f3d6495aa6d8fa1c62ea1591a3e457316c4ca8b3a3060471c"

URI_x86_64_v2_pcp-pmda-postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-postgresql-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-postgresql}"
SRC_URI[x86_64_v2_pcp-pmda-postgresql.sha256sum] = "1aa744b08a6ee51b68b456a9c03fd22a059b9c3705088e81699069ba506ee2cd"

URI_x86_64_v2_pcp-pmda-rabbitmq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-rabbitmq-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-rabbitmq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-rabbitmq}"
SRC_URI[x86_64_v2_pcp-pmda-rabbitmq.sha256sum] = "1ac1fc3c303525fd862e488c0fef5b653cd411ba1eac38de848436fc27b98242"

URI_x86_64_v2_pcp-pmda-redis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-redis-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-redis}"
SRC_URI[x86_64_v2_pcp-pmda-redis.sha256sum] = "09d1e213f0c3a6843d891f6ed8279805c041b2d7d35ce8a5298464e1b5910ece"

URI_x86_64_v2_pcp-pmda-resctrl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-resctrl-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-resctrl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-resctrl}"
SRC_URI[x86_64_v2_pcp-pmda-resctrl.sha256sum] = "479c075d23b62aaa08dfb441a3d9c6d3d23df6f4735a0e461d8df2573c736a34"

URI_x86_64_v2_pcp-pmda-rocestat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-rocestat-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-rocestat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-rocestat}"
SRC_URI[x86_64_v2_pcp-pmda-rocestat.sha256sum] = "3209774c5128637ae2de176fc6981c3b9dce2703d625069e3aae0e7b8d8209d3"

URI_x86_64_v2_pcp-pmda-roomtemp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-roomtemp-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-roomtemp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-roomtemp}"
SRC_URI[x86_64_v2_pcp-pmda-roomtemp.sha256sum] = "eafcc89f6f7d8e57d9b01c6bf0f4c7abaf0c589240a22e8af09bb3332de56c0a"

URI_x86_64_v2_pcp-pmda-rsyslog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-rsyslog-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-rsyslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-rsyslog}"
SRC_URI[x86_64_v2_pcp-pmda-rsyslog.sha256sum] = "f5af6efda60a27866860081ff0d747a58e44304a357c303270ce1ac42eb04c79"

URI_x86_64_v2_pcp-pmda-samba = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-samba-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-samba}"
SRC_URI[x86_64_v2_pcp-pmda-samba.sha256sum] = "89716044be9dcafa5bfce25190be191da815cc0125848b4447d3fa20eda69c17"

URI_x86_64_v2_pcp-pmda-sendmail = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-sendmail-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-sendmail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-sendmail}"
SRC_URI[x86_64_v2_pcp-pmda-sendmail.sha256sum] = "aeab59cc7debd930ec31b5e58e04f244b475370d8d0baf647fb197d61cb583a3"

URI_x86_64_v2_pcp-pmda-shping = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-shping-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-shping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-shping}"
SRC_URI[x86_64_v2_pcp-pmda-shping.sha256sum] = "9e09f2a06e845df27243d1a8c057516f8da1c0dd27d0df6466da98c227d1113f"

URI_x86_64_v2_pcp-pmda-slurm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-slurm-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-slurm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-slurm}"
SRC_URI[x86_64_v2_pcp-pmda-slurm.sha256sum] = "3c6459d81a56a05ae38e331968a01e759d9c1b88ffc9397a98b12cdfa82053af"

URI_x86_64_v2_pcp-pmda-smart = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-smart-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-smart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-smart}"
SRC_URI[x86_64_v2_pcp-pmda-smart.sha256sum] = "99977ad698d3d5e9207402d2a55794f92cd123506a525fbb4a0c41daedd5b3cd"

URI_x86_64_v2_pcp-pmda-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-snmp-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-snmp}"
SRC_URI[x86_64_v2_pcp-pmda-snmp.sha256sum] = "0ff9277c1dedb748a4f45352908f712440bd500b4134009ca6f781b42cb2050f"

URI_x86_64_v2_pcp-pmda-sockets = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-sockets-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-sockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-sockets}"
SRC_URI[x86_64_v2_pcp-pmda-sockets.sha256sum] = "1a8da50a1ea88ac76c76f588860d62f203fc87177099b602f68fbb528446fe3a"

URI_x86_64_v2_pcp-pmda-statsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-statsd-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-statsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-statsd}"
SRC_URI[x86_64_v2_pcp-pmda-statsd.sha256sum] = "f568341386418b305b574b9d59d198e74e0de8c90225bdb00c33e09f73e6a919"

URI_x86_64_v2_pcp-pmda-summary = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-summary-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-summary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-summary}"
SRC_URI[x86_64_v2_pcp-pmda-summary.sha256sum] = "30f6f107edf4899fe3fd388de0ea099614c328f3fa4f54c57d1e3905fd7df2d5"

URI_x86_64_v2_pcp-pmda-systemd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-systemd-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-systemd}"
SRC_URI[x86_64_v2_pcp-pmda-systemd.sha256sum] = "093435da9c0486c09b8f79c74e686f4f29b0316f6c7be84a1ad6984b43233136"

URI_x86_64_v2_pcp-pmda-trace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-trace-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-trace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-trace}"
SRC_URI[x86_64_v2_pcp-pmda-trace.sha256sum] = "fb6b4171b74cd9c0987ed335e946b4fc09b0c4ff9cf354fe8c97f5bc996a5d20"

URI_x86_64_v2_pcp-pmda-unbound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-unbound-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-unbound}"
SRC_URI[x86_64_v2_pcp-pmda-unbound.sha256sum] = "1d09f01d770d3890db56a767d6ab826b3f5cad9235618bb18ce8a54148002c9e"

URI_x86_64_v2_pcp-pmda-uwsgi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-uwsgi-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-uwsgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-uwsgi}"
SRC_URI[x86_64_v2_pcp-pmda-uwsgi.sha256sum] = "3904715f22b2772bf88cbb47f92e72f6afd2d8118e7cc788ae65ad3e2207e516"

URI_x86_64_v2_pcp-pmda-weblog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-weblog-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-weblog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-weblog}"
SRC_URI[x86_64_v2_pcp-pmda-weblog.sha256sum] = "f8a9f3db8d060821f7bb1bc76d63ca63ad3727db92dddf883a664d9563fe3a56"

URI_x86_64_v2_pcp-pmda-zimbra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-zimbra-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-zimbra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-zimbra}"
SRC_URI[x86_64_v2_pcp-pmda-zimbra.sha256sum] = "f31d7ba189e2d52218578c30f9a2ffdf15975eb0b2709fe1fc9a27481aaeab5e"

URI_x86_64_v2_pcp-pmda-zswap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-zswap-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-zswap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-zswap}"
SRC_URI[x86_64_v2_pcp-pmda-zswap.sha256sum] = "b213dbb443265a268d263166228341abdc7d1c1ce838b210d285d72c7a1e54f0"

URI_x86_64_v2_pcp-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-selinux-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-selinux}"
SRC_URI[x86_64_v2_pcp-selinux.sha256sum] = "abb990ae92ce44a11d7bdceb381f2ca16703ec43212d708f8a71bcc775ca2760"

URI_x86_64_v2_pcp-system-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-system-tools-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-system-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-system-tools}"
SRC_URI[x86_64_v2_pcp-system-tools.sha256sum] = "9ab42b48a21d3e5706c317d207e7bb0d831a76d06117d4b8f090cb2dd7101fd1"

URI_x86_64_v2_pcp-testsuite = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/pcp-testsuite-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-testsuite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-testsuite}"
SRC_URI[x86_64_v2_pcp-testsuite.sha256sum] = "225cc86cbe7bb0fddb8de1f4f7b2cfe8b066daf30b7c72f5a5b1fed90ab1392a"
RPROVIDES:pcp-testsuite:x86_64_v2 = "virtual/perl_Slurm_"

URI_x86_64_v2_pcp-zeroconf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-zeroconf-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-zeroconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-zeroconf}"
SRC_URI[x86_64_v2_pcp-zeroconf.sha256sum] = "665f2fe6cf4c42b4452b63cb0d8ca95dc948de3f39c5b313aff99010380b05ec"

URI_x86_64_v2_perl-PCP-LogImport = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-LogImport-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-LogImport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-LogImport}"
SRC_URI[x86_64_v2_perl-PCP-LogImport.sha256sum] = "ad2bbf55f3c67eb9fb55743101a689616d18cd96fc26a8d54114f94d7c6f2315"

URI_x86_64_v2_perl-PCP-LogSummary = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-LogSummary-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-LogSummary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-LogSummary}"
SRC_URI[x86_64_v2_perl-PCP-LogSummary.sha256sum] = "cebf811473bb31db33123b0163710dc1af6969039e33e3bf8b6a57f458f74840"

URI_x86_64_v2_perl-PCP-MMV = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-MMV-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-MMV;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-MMV}"
SRC_URI[x86_64_v2_perl-PCP-MMV.sha256sum] = "116d552e5270d3a1ccfb7bcda8675ad6bf7b98a5d145986565aed6e6afa1dc36"

URI_x86_64_v2_perl-PCP-PMDA = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-PMDA-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-PMDA;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-PMDA}"
SRC_URI[x86_64_v2_perl-PCP-PMDA.sha256sum] = "436d00bdbb07f8da20329b05ce2a5ea640298da4a68f65027f13dca0eb593e5e"

URI_x86_64_v2_python3-pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pcp-7.1.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pcp}"
SRC_URI[x86_64_v2_python3-pcp.sha256sum] = "85ed3b56ea1586c3e05a722616a603c948437d9bbd08841a7304fd0876bbee22"

URI_aarch64_pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp}"
SRC_URI[aarch64_pcp.sha256sum] = "39c0bae7e5f829809964e3b90696d4005a328aea2fed80e316c0384069b3582c"

URI_aarch64_pcp-conf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-conf-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-conf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-conf}"
SRC_URI[aarch64_pcp-conf.sha256sum] = "b9933e2098437c99ae69b291624cc29b43f89914fc257f0ced8c16524acbb861"

URI_aarch64_pcp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-devel-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-devel}"
SRC_URI[aarch64_pcp-devel.sha256sum] = "3876576f98183d307c94edf758d11763eae63367e0760c770a0c11c93c2c83a4"

URI_aarch64_pcp-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-doc-7.1.5-2.el10.noarch.rpm;name=aarch64_pcp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-doc}"
SRC_URI[aarch64_pcp-doc.sha256sum] = "dc4b0a9749fb3cd2602ccf3dae673f0ae21971258f61f8dd4602d13c88b0adec"

URI_aarch64_pcp-export-pcp2elasticsearch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2elasticsearch-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2elasticsearch;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2elasticsearch}"
SRC_URI[aarch64_pcp-export-pcp2elasticsearch.sha256sum] = "875cc48df6b8c5aa2152af976a23c64b8c8e226953c13c0a2aeb01bb5bc44461"

URI_aarch64_pcp-export-pcp2graphite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2graphite-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2graphite;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2graphite}"
SRC_URI[aarch64_pcp-export-pcp2graphite.sha256sum] = "6cbf150b796877dcc40b9959c181d6f4c8876f5714f0f0a0e993df9f5de1a281"

URI_aarch64_pcp-export-pcp2influxdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2influxdb-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2influxdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2influxdb}"
SRC_URI[aarch64_pcp-export-pcp2influxdb.sha256sum] = "08850d11449d54f8456823ba15ef0fb03d67692b528650fe2d42ca12bd3e60c9"

URI_aarch64_pcp-export-pcp2json = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2json-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2json;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2json}"
SRC_URI[aarch64_pcp-export-pcp2json.sha256sum] = "ed201ecd3b91cec1ee03e1efa66fe80fbfc96f70aac6abad594c147592329e96"

URI_aarch64_pcp-export-pcp2openmetrics = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2openmetrics-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2openmetrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2openmetrics}"
SRC_URI[aarch64_pcp-export-pcp2openmetrics.sha256sum] = "f0896401b718374ec87cef7ec4d3078eddfbf304af69556decd102ba51b80c4d"

URI_aarch64_pcp-export-pcp2opentelemetry = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2opentelemetry-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2opentelemetry;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2opentelemetry}"
SRC_URI[aarch64_pcp-export-pcp2opentelemetry.sha256sum] = "fe42f4508db7e74c8d8274252fd00846e56934c1fb66bbe946d6cfc404610589"

URI_aarch64_pcp-export-pcp2spark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2spark-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2spark;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2spark}"
SRC_URI[aarch64_pcp-export-pcp2spark.sha256sum] = "d66db521257ef889b3eb13f895dfb75844ac5681897d18bade10860bd1bd595f"

URI_aarch64_pcp-export-pcp2xml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2xml-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2xml}"
SRC_URI[aarch64_pcp-export-pcp2xml.sha256sum] = "85a5e45399471ab42e4c28aa24834d1b3a0a0b3edd4c3498e0de4bcca9b7a004"

URI_aarch64_pcp-export-pcp2zabbix = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2zabbix-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2zabbix;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2zabbix}"
SRC_URI[aarch64_pcp-export-pcp2zabbix.sha256sum] = "587a425f687b7ba9ee81ec23e40acc110af2ce8c770e1c6c148102683cf42d30"

URI_aarch64_pcp-export-zabbix-agent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-zabbix-agent-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-export-zabbix-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-zabbix-agent}"
SRC_URI[aarch64_pcp-export-zabbix-agent.sha256sum] = "05e9584f176bd6fb22d010b3dbff85b97ff6ba64e94b0b4e848fe29f0bc13a47"

URI_aarch64_pcp-geolocate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-geolocate-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-geolocate;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-geolocate}"
SRC_URI[aarch64_pcp-geolocate.sha256sum] = "e62171951107f3d4fdefa46286016a4aff10031911d90d6d2b33d25fcf9dc577"

URI_aarch64_pcp-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-gui-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-gui}"
SRC_URI[aarch64_pcp-gui.sha256sum] = "9f70d1b3e455383b7bc3407a11d4066a1da843e9f68981e6876e4b51869c8c4d"

URI_aarch64_pcp-import-benchmarks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-benchmarks-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-import-benchmarks;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-benchmarks}"
SRC_URI[aarch64_pcp-import-benchmarks.sha256sum] = "bc59e52e8b612e5bff7a497dcb56c6bc2a1b7db482a71fe46ec136842aec9824"

URI_aarch64_pcp-import-collectl2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-collectl2pcp-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-import-collectl2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-collectl2pcp}"
SRC_URI[aarch64_pcp-import-collectl2pcp.sha256sum] = "88f90f8ccc21f9b457e4eae2428c28a8c650fee1a8a0d52fc805fce0a1bb34c9"

URI_aarch64_pcp-import-ganglia2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-ganglia2pcp-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-import-ganglia2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-ganglia2pcp}"
SRC_URI[aarch64_pcp-import-ganglia2pcp.sha256sum] = "db215dfc6396018e64c8cba46d6bc7deb080385dd356fd76709551ac471b9d54"

URI_aarch64_pcp-import-iostat2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-iostat2pcp-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-import-iostat2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-iostat2pcp}"
SRC_URI[aarch64_pcp-import-iostat2pcp.sha256sum] = "4dfa44724eb91541eec7e5d968c7a54a17708a241c4ccb1daf44b5113fbec59e"

URI_aarch64_pcp-import-mrtg2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-mrtg2pcp-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-import-mrtg2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-mrtg2pcp}"
SRC_URI[aarch64_pcp-import-mrtg2pcp.sha256sum] = "846cdf6e3071abc9d8c9f10e88b22d987b6e782fe3dc608584792decd8e9e279"

URI_aarch64_pcp-import-pmseries = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-pmseries-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-import-pmseries;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-pmseries}"
SRC_URI[aarch64_pcp-import-pmseries.sha256sum] = "7c84d909e70beceb2bb13e3bd0e81afefec644cdf7be2b7a241d7c6b00a43b5c"

URI_aarch64_pcp-import-sar2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-sar2pcp-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-import-sar2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-sar2pcp}"
SRC_URI[aarch64_pcp-import-sar2pcp.sha256sum] = "7276f081fcf470b6a40bbf8e6443e7b862366ebfcc463cbcdd79f7f6e36f9ff4"

URI_aarch64_pcp-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-libs-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-libs}"
SRC_URI[aarch64_pcp-libs.sha256sum] = "8576fe8e32cc0b69650ad05579f1aba16d2d411c896feb0602a11b241cf733f4"

URI_aarch64_pcp-libs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-libs-devel-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-libs-devel}"
SRC_URI[aarch64_pcp-libs-devel.sha256sum] = "1ac12cfe6a84ee24c4131b4884c5b3f145acf7a8e90153671a57840dc1ac9b3c"

URI_aarch64_pcp-pmda-activemq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-activemq-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-activemq;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-activemq}"
SRC_URI[aarch64_pcp-pmda-activemq.sha256sum] = "e66b58b853ec3fd859c77e98e22e40a75748c9a70978f4ef3ae6db309487b297"

URI_aarch64_pcp-pmda-amdgpu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-amdgpu-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-amdgpu;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-amdgpu}"
SRC_URI[aarch64_pcp-pmda-amdgpu.sha256sum] = "7228dc4f9b2edec68c03ba44ec1bebe06e160e6ad48bc3a321bd5357f9c77c24"

URI_aarch64_pcp-pmda-apache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-apache-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-apache;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-apache}"
SRC_URI[aarch64_pcp-pmda-apache.sha256sum] = "7f559947e54253c101cd881f5df578a5e0c1daf1a98080617f49ab678a5c75ba"

URI_aarch64_pcp-pmda-bash = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bash-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-bash;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bash}"
SRC_URI[aarch64_pcp-pmda-bash.sha256sum] = "4e7847d76a47a9877b592c3769d6bbc988de088ae616640f807d5d9060c90e63"

URI_aarch64_pcp-pmda-bind2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bind2-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-bind2;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bind2}"
SRC_URI[aarch64_pcp-pmda-bind2.sha256sum] = "dab1cffdf51c9bfdf6513c1464db2b7a52cc31cdbae3bf40232370f862ae291c"

URI_aarch64_pcp-pmda-bonding = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bonding-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-bonding;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bonding}"
SRC_URI[aarch64_pcp-pmda-bonding.sha256sum] = "c5c1584c3edda3e51f9cfd6a2bbc5a809e14e18b34624997c429f8914078f88c"

URI_aarch64_pcp-pmda-bpf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bpf-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-bpf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bpf}"
SRC_URI[aarch64_pcp-pmda-bpf.sha256sum] = "32fc20a36c341c8e9ce728ffc02495da0bac2f95c099a9e3a8df81dff78328a8"

URI_aarch64_pcp-pmda-bpftrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bpftrace-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-bpftrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bpftrace}"
SRC_URI[aarch64_pcp-pmda-bpftrace.sha256sum] = "3c96ed92de620bce78c8019f88680aa3ef864d205dd134ae1a782cf41e64b2bc"

URI_aarch64_pcp-pmda-cifs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-cifs-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-cifs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-cifs}"
SRC_URI[aarch64_pcp-pmda-cifs.sha256sum] = "f3b65cc93a11f807ddb4d00234dc1f3422fc940e35d5237336ce188887185c5c"

URI_aarch64_pcp-pmda-cisco = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-cisco-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-cisco;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-cisco}"
SRC_URI[aarch64_pcp-pmda-cisco.sha256sum] = "00d181abd16825583ebda6a7858382fcdfd940fe696f35585a637a4db70928e3"

URI_aarch64_pcp-pmda-dbping = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-dbping-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-dbping;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-dbping}"
SRC_URI[aarch64_pcp-pmda-dbping.sha256sum] = "cf8a8e08bfe95ffd9a8aeb05e5a17f506122bebbf11dfa49cb61bb874bfa1906"

URI_aarch64_pcp-pmda-denki = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-denki-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-denki;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-denki}"
SRC_URI[aarch64_pcp-pmda-denki.sha256sum] = "72c83bcb0b346e02f021f4ceca9d769e37fe7a2e49bc6c4c021d31f5a343cf53"

URI_aarch64_pcp-pmda-dm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-dm-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-dm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-dm}"
SRC_URI[aarch64_pcp-pmda-dm.sha256sum] = "e64686d430e6e9344c5f29cfd8ec5a553ad04bc1177c9da6fb271dc8cae73e36"

URI_aarch64_pcp-pmda-docker = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-docker-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-docker;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-docker}"
SRC_URI[aarch64_pcp-pmda-docker.sha256sum] = "3cdf4cc97eef2effa373f9f9dec735cdfc6ecedf4a4ee0a7bc578bd3787e782e"

URI_aarch64_pcp-pmda-ds389 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-ds389-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-ds389;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-ds389}"
SRC_URI[aarch64_pcp-pmda-ds389.sha256sum] = "aa8e8b7c0ace68d0db706c7fdd1acee62c71674daaf6946cad7c8f882f1486f0"

URI_aarch64_pcp-pmda-ds389log = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-ds389log-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-ds389log;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-ds389log}"
SRC_URI[aarch64_pcp-pmda-ds389log.sha256sum] = "ee7dd133eb0ee8f1fd5acc1bc7949c17e55a0df17ce9237dc87264b2a290a830"

URI_aarch64_pcp-pmda-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-elasticsearch-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-elasticsearch}"
SRC_URI[aarch64_pcp-pmda-elasticsearch.sha256sum] = "9299da76944a3d2c0ccd03cc9ab226cb9156cdcbdf6987ae3659649d8184825f"

URI_aarch64_pcp-pmda-farm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-farm-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-farm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-farm}"
SRC_URI[aarch64_pcp-pmda-farm.sha256sum] = "2d7cc9835b9c107db01ad796bbfa82c3320f0e9a0944252d843a4d6d5e694b58"

URI_aarch64_pcp-pmda-gluster = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gluster-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-gluster;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-gluster}"
SRC_URI[aarch64_pcp-pmda-gluster.sha256sum] = "826a503626ff8784bf8ce5725b6380d5e64adfa54ac155cc6a222b83015cd39c"

URI_aarch64_pcp-pmda-gpfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gpfs-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-gpfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-gpfs}"
SRC_URI[aarch64_pcp-pmda-gpfs.sha256sum] = "c2a3df40991f132d0dc9410bd0d38f0bb9682247a2dd62f0ec2ae491edd3f506"

URI_aarch64_pcp-pmda-gpsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gpsd-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-gpsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-gpsd}"
SRC_URI[aarch64_pcp-pmda-gpsd.sha256sum] = "fbb2d057e84347db40c402a425d1c5999e9d4ec0dee72de0e2d32d58fcdb1dfd"

URI_aarch64_pcp-pmda-hacluster = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-hacluster-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-hacluster;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-hacluster}"
SRC_URI[aarch64_pcp-pmda-hacluster.sha256sum] = "97b2c9dea443813c9e29b268e4565bc8319d14365a18f9792c852f5f3bc25028"

URI_aarch64_pcp-pmda-haproxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-haproxy-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-haproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-haproxy}"
SRC_URI[aarch64_pcp-pmda-haproxy.sha256sum] = "c210e72aa7aa77fe73111effee8a255abc01217eaf18aac6544e31a3f5b54347"

URI_aarch64_pcp-pmda-hdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-hdb-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-hdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-hdb}"
SRC_URI[aarch64_pcp-pmda-hdb.sha256sum] = "ebb043bd7c9c159274d578ff8fcf7475b7c312dc1d53bb347ca41d5bca5b1bc1"

URI_aarch64_pcp-pmda-infiniband = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-infiniband-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-infiniband;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-infiniband}"
SRC_URI[aarch64_pcp-pmda-infiniband.sha256sum] = "e7bd22946320a0959255ef5a0e5758fd371e3362ec43f9ca0e6bf02192b1853a"

URI_aarch64_pcp-pmda-libvirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-libvirt-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-libvirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-libvirt}"
SRC_URI[aarch64_pcp-pmda-libvirt.sha256sum] = "bcb02439baa33c9ca382c9239a28b4cc56623fcf3db8fc47662b181fdcee20fb"

URI_aarch64_pcp-pmda-lio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lio-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-lio;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lio}"
SRC_URI[aarch64_pcp-pmda-lio.sha256sum] = "ec98086a8c39cf407799d23082e3f0ad5774dd67a260724c5ae4b5042fbf1701"

URI_aarch64_pcp-pmda-lmsensors = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lmsensors-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-lmsensors;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lmsensors}"
SRC_URI[aarch64_pcp-pmda-lmsensors.sha256sum] = "91f7f94dc74b52a3d9cca9faf3ab19f267a6362c10d1cb4ddf5a680146627a9a"

URI_aarch64_pcp-pmda-logger = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-logger-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-logger;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-logger}"
SRC_URI[aarch64_pcp-pmda-logger.sha256sum] = "9718b874cede94b3c489662375373fbe3a7d6c66c5d76990fb6d41a691c07386"

URI_aarch64_pcp-pmda-lustre = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lustre-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-lustre;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lustre}"
SRC_URI[aarch64_pcp-pmda-lustre.sha256sum] = "7a1a7e56e6e98b3e926c6edb7a3be6c182da30287d0d49929d6b6a092b7bb46e"

URI_aarch64_pcp-pmda-lustrecomm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lustrecomm-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-lustrecomm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lustrecomm}"
SRC_URI[aarch64_pcp-pmda-lustrecomm.sha256sum] = "de5c9dc31dd309b3d6358d7ab9761a51bd87fc7a8a87a8c991a1fc620e2ec016"

URI_aarch64_pcp-pmda-mailq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mailq-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-mailq;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mailq}"
SRC_URI[aarch64_pcp-pmda-mailq.sha256sum] = "2cfd8479dc1ee07129af075725bf471c47e89c52caeccad8324ca2cc8ef9e129"

URI_aarch64_pcp-pmda-memcache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-memcache-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-memcache;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-memcache}"
SRC_URI[aarch64_pcp-pmda-memcache.sha256sum] = "7747b7a8ed67265edbce58808684487c798ef6ae012757fe722e6b7941a121e9"

URI_aarch64_pcp-pmda-mic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mic-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-mic;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mic}"
SRC_URI[aarch64_pcp-pmda-mic.sha256sum] = "c29cf027f190f9d7d2e1fecfa28d550a04b4ed88cfe502a991b9d9945419f216"

URI_aarch64_pcp-pmda-mongodb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mongodb-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-mongodb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mongodb}"
SRC_URI[aarch64_pcp-pmda-mongodb.sha256sum] = "960e750919691290ef5947b1c267cde297d0e6a9584147fcec303cb8a728ac7f"

URI_aarch64_pcp-pmda-mounts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mounts-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-mounts;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mounts}"
SRC_URI[aarch64_pcp-pmda-mounts.sha256sum] = "ae83920e2913ccf4a5089fd1cc385cb1350acb3468d08ef017c96f17c2c06810"

URI_aarch64_pcp-pmda-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mysql-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mysql}"
SRC_URI[aarch64_pcp-pmda-mysql.sha256sum] = "5a89e4dd13032699d1e6f4f8558c2530b82c9c90f1bf3114cb4924a856997bb1"

URI_aarch64_pcp-pmda-named = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-named-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-named;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-named}"
SRC_URI[aarch64_pcp-pmda-named.sha256sum] = "f141a5674f4e2a4e8b97f8247f902e95a4f0c64124c2f4667a68d3498d421a04"

URI_aarch64_pcp-pmda-netcheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-netcheck-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-netcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-netcheck}"
SRC_URI[aarch64_pcp-pmda-netcheck.sha256sum] = "12b063b575188a129b13d664d3e8395ef468ef2c4f74111af1644a71e9ea94ca"

URI_aarch64_pcp-pmda-netfilter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-netfilter-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-netfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-netfilter}"
SRC_URI[aarch64_pcp-pmda-netfilter.sha256sum] = "b8e4ada9f4cb301b7d13c38eab796227777e0703c8ed9f9b7a60de05130f60b2"

URI_aarch64_pcp-pmda-news = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-news-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-news;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-news}"
SRC_URI[aarch64_pcp-pmda-news.sha256sum] = "82392e004844aa621fda5817fc8eadb1b87b544bf0a7ba2db3c30a6a110066af"

URI_aarch64_pcp-pmda-nfsclient = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nfsclient-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-nfsclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-nfsclient}"
SRC_URI[aarch64_pcp-pmda-nfsclient.sha256sum] = "0d88f89a3d3c7442cd4f86c63268a95816114ca1df1391bb09723ab07a53861e"

URI_aarch64_pcp-pmda-nginx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nginx-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-nginx}"
SRC_URI[aarch64_pcp-pmda-nginx.sha256sum] = "ce5fc3168f4649108a526bec2a8fca01f83a4976262d18d7b5159b29705a2d93"

URI_aarch64_pcp-pmda-nvidia-gpu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nvidia-gpu-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-nvidia-gpu;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-nvidia-gpu}"
SRC_URI[aarch64_pcp-pmda-nvidia-gpu.sha256sum] = "2b392f7fdd3dca7f24143d57f87ba9d1b057005a664d3025fd70e673b9c46933"

URI_aarch64_pcp-pmda-openmetrics = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-openmetrics-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-openmetrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-openmetrics}"
SRC_URI[aarch64_pcp-pmda-openmetrics.sha256sum] = "893b5082698c6bc6e4ed73a7d243a08c1107aa8d6a43876000dce34e75ed358e"

URI_aarch64_pcp-pmda-opentelemetry = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-opentelemetry-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-opentelemetry;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-opentelemetry}"
SRC_URI[aarch64_pcp-pmda-opentelemetry.sha256sum] = "3db9e9d91dee8c6bda8b8dd70c5e2a5877efc91bd0ddc485064758c205416d30"

URI_aarch64_pcp-pmda-openvswitch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-openvswitch-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-openvswitch;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-openvswitch}"
SRC_URI[aarch64_pcp-pmda-openvswitch.sha256sum] = "12e313fb0abef7b555b03e275aa8c86b07f94c978105f5dc3690a8f3b5eac8f3"

URI_aarch64_pcp-pmda-oracle = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-oracle-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-oracle;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-oracle}"
SRC_URI[aarch64_pcp-pmda-oracle.sha256sum] = "18ddfc87581471137892d8a2f15bfe5d4632d95213b41c0e3398e037fe0614d6"

URI_aarch64_pcp-pmda-pdns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-pdns-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-pdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-pdns}"
SRC_URI[aarch64_pcp-pmda-pdns.sha256sum] = "ab1aa416451e51a353fbe523c10c52ef8dcb9fc0421b4d4e1ae148d41ee1e287"

URI_aarch64_pcp-pmda-perfevent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-perfevent-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-perfevent;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-perfevent}"
SRC_URI[aarch64_pcp-pmda-perfevent.sha256sum] = "e598a75dcfe835107b65b401b8cc16aca2723fbf3e828be174f801935a11a0d8"

URI_aarch64_pcp-pmda-podman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-podman-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-podman}"
SRC_URI[aarch64_pcp-pmda-podman.sha256sum] = "609433c79511607c17fc3b62979578b725b1cb45fc4c0e95f7f48296a04c3b07"

URI_aarch64_pcp-pmda-postfix = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-postfix-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-postfix;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-postfix}"
SRC_URI[aarch64_pcp-pmda-postfix.sha256sum] = "8cb712e1c0454dd7ad2675c6ec75187b357cc8b6fe32a8bb594d589a8d8afb26"

URI_aarch64_pcp-pmda-postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-postgresql-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-postgresql}"
SRC_URI[aarch64_pcp-pmda-postgresql.sha256sum] = "5b58a60895f1e92ba6f593d020e97b2a889fd2410c1068754e3f142c5e84011b"

URI_aarch64_pcp-pmda-rabbitmq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-rabbitmq-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-rabbitmq;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-rabbitmq}"
SRC_URI[aarch64_pcp-pmda-rabbitmq.sha256sum] = "ad5ec37581d1c0c5a74081723b8efccd8bdfb480d4b0a043a147d310eccc5b9f"

URI_aarch64_pcp-pmda-redis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-redis-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-redis}"
SRC_URI[aarch64_pcp-pmda-redis.sha256sum] = "3273638a7dc799ecf9a2d96a18a92a48ab6d366441fab2a369b076754fd15635"

URI_aarch64_pcp-pmda-rocestat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-rocestat-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-rocestat;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-rocestat}"
SRC_URI[aarch64_pcp-pmda-rocestat.sha256sum] = "acf6d0e62e7acf1c6b9811daed55619f0576a382d0c1b98c9fcf1b9a771f3130"

URI_aarch64_pcp-pmda-roomtemp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-roomtemp-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-roomtemp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-roomtemp}"
SRC_URI[aarch64_pcp-pmda-roomtemp.sha256sum] = "af2a342e7c4c3978138b31e4aa36038188910cbf1642347491959c2ae612156d"

URI_aarch64_pcp-pmda-rsyslog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-rsyslog-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-rsyslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-rsyslog}"
SRC_URI[aarch64_pcp-pmda-rsyslog.sha256sum] = "416c87ee7c3491e6008a7034d88dc5ab46dc62b4490eb8b25fedbf4af4cf8e89"

URI_aarch64_pcp-pmda-samba = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-samba-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-samba}"
SRC_URI[aarch64_pcp-pmda-samba.sha256sum] = "bb637e3e79872195f2dcd9539838b0db7830537f58b191bb2971dfb1b76a29aa"

URI_aarch64_pcp-pmda-sendmail = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-sendmail-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-sendmail;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-sendmail}"
SRC_URI[aarch64_pcp-pmda-sendmail.sha256sum] = "e68a99ff30c14d8878e0daea94c51068c4b6e7451250b88d3d6141fd10b9a9e7"

URI_aarch64_pcp-pmda-shping = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-shping-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-shping;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-shping}"
SRC_URI[aarch64_pcp-pmda-shping.sha256sum] = "c8feaf4cbf65ae2704bad7b0bfbd3cdad7f18166721442791f3c008f1d143e90"

URI_aarch64_pcp-pmda-slurm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-slurm-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-slurm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-slurm}"
SRC_URI[aarch64_pcp-pmda-slurm.sha256sum] = "a5e15bef2527309a8dff00ab80cdb1194acbc35dea748ef959379b72e4fcb7ff"

URI_aarch64_pcp-pmda-smart = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-smart-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-smart;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-smart}"
SRC_URI[aarch64_pcp-pmda-smart.sha256sum] = "fd1fa066322ff664676df2c5de53b21aab4d1687bb5457c20f015a549cbc5367"

URI_aarch64_pcp-pmda-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-snmp-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-snmp}"
SRC_URI[aarch64_pcp-pmda-snmp.sha256sum] = "d0d83c25d7bd1a1af196a8d7398ebfd663b66e992bfb74a459a65f101a079a9c"

URI_aarch64_pcp-pmda-sockets = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-sockets-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-sockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-sockets}"
SRC_URI[aarch64_pcp-pmda-sockets.sha256sum] = "bbbdc4e24b0327589acca136e8b0ead4a5704d7d16357735f44aaddf9cd720c2"

URI_aarch64_pcp-pmda-statsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-statsd-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-statsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-statsd}"
SRC_URI[aarch64_pcp-pmda-statsd.sha256sum] = "791221a3689f5058aeeef3282da173bc177c31610de5c6b1758a211411c9ed4b"

URI_aarch64_pcp-pmda-summary = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-summary-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-summary;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-summary}"
SRC_URI[aarch64_pcp-pmda-summary.sha256sum] = "18bd6a191f088d12c37fdf489d2e4450bc1ea0ce7f885159dc230f684a613c9a"

URI_aarch64_pcp-pmda-systemd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-systemd-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-systemd}"
SRC_URI[aarch64_pcp-pmda-systemd.sha256sum] = "a6e81e2986e41fdd4af29e254bad1543a6ece73737dfa517eefe936d265c193a"

URI_aarch64_pcp-pmda-trace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-trace-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-trace;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-trace}"
SRC_URI[aarch64_pcp-pmda-trace.sha256sum] = "299d8ca5cec058dc76d13febb6be8468d3d17e88fab9974ee6c8d6d987204879"

URI_aarch64_pcp-pmda-unbound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-unbound-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-unbound}"
SRC_URI[aarch64_pcp-pmda-unbound.sha256sum] = "3e0c0bd49384a820ac43f903003e0f8d0dd0e11a418e0368d87ec762ae5f37af"

URI_aarch64_pcp-pmda-uwsgi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-uwsgi-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-uwsgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-uwsgi}"
SRC_URI[aarch64_pcp-pmda-uwsgi.sha256sum] = "1d6702a6ed9b6ccf67fedf5b1c9402ab9d4ddfae8812a39c0118aec8dcc3a4c6"

URI_aarch64_pcp-pmda-weblog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-weblog-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-weblog;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-weblog}"
SRC_URI[aarch64_pcp-pmda-weblog.sha256sum] = "49b645850b3cbd0eae8aec6d8852d03615f7fefc27a6c87233d7c830e6a79df4"

URI_aarch64_pcp-pmda-zimbra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-zimbra-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-zimbra;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-zimbra}"
SRC_URI[aarch64_pcp-pmda-zimbra.sha256sum] = "52b255893da2f367550d1d9634a4cbcf49126a4e383559f54773dec8d91796c0"

URI_aarch64_pcp-pmda-zswap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-zswap-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-pmda-zswap;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-zswap}"
SRC_URI[aarch64_pcp-pmda-zswap.sha256sum] = "c9eb0f8f5bb3273ed4d5b94a24f9bd83b2c413be754121fd4baed96f39260ccb"

URI_aarch64_pcp-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-selinux-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-selinux}"
SRC_URI[aarch64_pcp-selinux.sha256sum] = "8607facf00deb23c3061068ccb6d33511e873b9451df5fdd91c1e23be06c976c"

URI_aarch64_pcp-system-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-system-tools-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-system-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-system-tools}"
SRC_URI[aarch64_pcp-system-tools.sha256sum] = "895c92a24e3f31ceee380d19d698cfba4dbfddb6f5d30fc66886c10bef59eed8"

URI_aarch64_pcp-testsuite = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/pcp-testsuite-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-testsuite;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-testsuite}"
SRC_URI[aarch64_pcp-testsuite.sha256sum] = "6d03b9484fc2c01fb5ec8a39572e0126cabdab51a515c694894dcc31a983fff6"
RPROVIDES:pcp-testsuite:aarch64 = "virtual/perl_Slurm_"

URI_aarch64_pcp-zeroconf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-zeroconf-7.1.5-2.el10.aarch64.rpm;name=aarch64_pcp-zeroconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-zeroconf}"
SRC_URI[aarch64_pcp-zeroconf.sha256sum] = "454898a6876738f50de58b8b8b96ad3d00522b395678825a0e18016b9c414d32"

URI_aarch64_perl-PCP-LogImport = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-LogImport-7.1.5-2.el10.aarch64.rpm;name=aarch64_perl-PCP-LogImport;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-LogImport}"
SRC_URI[aarch64_perl-PCP-LogImport.sha256sum] = "732bad850230721c99258f5a1d97eb930b32a3520fd6d75adc9de8d5ee16fc7e"

URI_aarch64_perl-PCP-LogSummary = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-LogSummary-7.1.5-2.el10.aarch64.rpm;name=aarch64_perl-PCP-LogSummary;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-LogSummary}"
SRC_URI[aarch64_perl-PCP-LogSummary.sha256sum] = "951abd7d649c0d4e9bdcf354ec6aa58e23dff455bd8ec87aaa7ac64606fbfa49"

URI_aarch64_perl-PCP-MMV = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-MMV-7.1.5-2.el10.aarch64.rpm;name=aarch64_perl-PCP-MMV;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-MMV}"
SRC_URI[aarch64_perl-PCP-MMV.sha256sum] = "9c6d0d6af9b02283ef63c9e74dd80979d88178be13097a4b1c41eafab72a1a16"

URI_aarch64_perl-PCP-PMDA = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-PMDA-7.1.5-2.el10.aarch64.rpm;name=aarch64_perl-PCP-PMDA;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-PMDA}"
SRC_URI[aarch64_perl-PCP-PMDA.sha256sum] = "b47de8c59f14b604f9a8673e74c841fd231e645969221a7a01fee5e2e54648f9"

URI_aarch64_python3-pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pcp-7.1.5-2.el10.aarch64.rpm;name=aarch64_python3-pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pcp}"
SRC_URI[aarch64_python3-pcp.sha256sum] = "2fdaabbe426e146d7cdcff459ea3db593493873f27fef22fffb8d219f64c9278"

RDEPENDS:pcp = " \
 bash \
 diffutils \
 findutils \
 gawk \
 glibc \
 grep \
 hostname \
 libuv \
 openssl-libs \
 pcp-libs \
 pcp-selinux \
 procps-ng \
 readline \
 sed \
 virtual/coreutils \
 which \
 xz \
 zlib-ng-compat \
 zstd \
 "
RDEPENDS:pcp-conf = " \
 "
RDEPENDS:pcp-devel = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 pcp-libs-devel \
 perl-PCP-PMDA \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:pcp-doc = " \
 "
RDEPENDS:pcp-export-pcp2elasticsearch = " \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-export-pcp2graphite = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2influxdb = " \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-export-pcp2json = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2openmetrics = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2opentelemetry = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2spark = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2xml = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2zabbix = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-zabbix-agent = " \
 glibc \
 pcp-libs \
 "
RDEPENDS:pcp-geolocate = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-gui = " \
 bash \
 glibc \
 liberation-sans-fonts \
 libgcc \
 libstdc++ \
 pcp \
 pcp-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:pcp-import-benchmarks = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-import-collectl2pcp = " \
 glibc \
 pcp-libs \
 "
RDEPENDS:pcp-import-ganglia2pcp = " \
 pcp-libs \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-PCP-LogImport \
 perl-POSIX \
 perl-TimeDate \
 perl-interpreter \
 perl-libs \
 perl-vars \
 rrdtool-perl \
 "
RDEPENDS:pcp-import-iostat2pcp = " \
 pcp-libs \
 perl-Getopt-Std \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-import-mrtg2pcp = " \
 pcp-libs \
 perl-PCP-LogImport \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-import-pmseries = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-import-sar2pcp = " \
 pcp-libs \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-XML-TokeParser \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-libs = " \
 cyrus-sasl-lib \
 glibc \
 libuv \
 openssl-libs \
 pcp-conf \
 systemd-libs \
 xz-libs \
 "
RDEPENDS:pcp-libs-devel = " \
 pcp \
 pcp-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pcp-pmda-activemq = " \
 bash \
 pcp \
 pcp-libs \
 perl-Digest-MD5 \
 perl-JSON \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-amdgpu = " \
 bash \
 glibc \
 libdrm \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-apache = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-bash = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-bind2 = " \
 bash \
 pcp \
 pcp-libs \
 perl-File-Slurp \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-XML-LibXML \
 perl-autodie \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-bonding = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-bpf = " \
 bash \
 elfutils-libelf \
 glibc \
 libbpf \
 pcp \
 pcp-libs \
 zlib-ng-compat \
 "
RDEPENDS:pcp-pmda-bpftrace = " \
 bash \
 bpftrace \
 pcp \
 pcp-libs \
 python3 \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-cifs = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-cisco = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-dbping = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBI \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-denki = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-dm = " \
 bash \
 device-mapper-libs \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-docker = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-ds389 = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-ds389log = " \
 bash \
 pcp \
 pcp-libs \
 perl-Date-Manip \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-elasticsearch = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-farm = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 smartmontools \
 "
RDEPENDS:pcp-pmda-gluster = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-gpfs = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-gpsd = " \
 bash \
 pcp \
 pcp-libs \
 perl-JSON \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 "
RDEPENDS:pcp-pmda-hacluster = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-haproxy = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-hdb = " \
 bash \
 pcp \
 pcp-libs \
 python3-packaging \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-infiniband = " \
 bash \
 glibc \
 infiniband-diags \
 libibumad \
 libibverbs \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-libvirt = " \
 bash \
 pcp \
 pcp-libs \
 python3-libvirt \
 python3-lxml \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-lio = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-rtslib \
 "
RDEPENDS:pcp-pmda-lmsensors = " \
 bash \
 lm_sensors \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-logger = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-lustre = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-lustrecomm = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-mailq = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-memcache = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-mic = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-mongodb = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-mounts = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-mssql = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-pyodbc \
 "
RDEPENDS:pcp-pmda-mysql = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBD-MySQL \
 perl-DBI \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-named = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-netcheck = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-netfilter = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-news = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-nfsclient = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-nginx = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-nvidia-gpu = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-openmetrics = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-pmda-opentelemetry = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-pmda-openvswitch = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-oracle = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBI \
 perl-PCP-PMDA \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-pmda-pdns = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 "
RDEPENDS:pcp-pmda-perfevent = " \
 bash \
 glibc \
 libpfm \
 pcp \
 pcp-libs \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-pmda-podman = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-postfix = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 postfix-perl-scripts \
 "
RDEPENDS:pcp-pmda-postgresql = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-psycopg2 \
 "
RDEPENDS:pcp-pmda-rabbitmq = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-redis = " \
 bash \
 pcp \
 pcp-libs \
 perl-Data-Dumper \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-autodie \
 "
RDEPENDS:pcp-pmda-resctrl = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-rocestat = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-roomtemp = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-rsyslog = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-samba = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-sendmail = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-shping = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-slurm = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-smart = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 smartmontools \
 "
RDEPENDS:pcp-pmda-snmp = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-sockets = " \
 bash \
 glibc \
 iproute \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-statsd = " \
 HdrHistogram_c \
 bash \
 chan \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-summary = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-systemd = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 systemd-libs \
 "
RDEPENDS:pcp-pmda-trace = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-unbound = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-uwsgi = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-weblog = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-zimbra = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-zswap = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-selinux = " \
 bash \
 policycoreutils \
 selinux-policy-targeted \
 "
RDEPENDS:pcp-system-tools = " \
 bash \
 glibc \
 ncurses-libs \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-testsuite = " \
 bash \
 bc \
 bzip2 \
 cyrus-sasl-lib \
 gcc \
 glibc \
 gzip \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcp \
 pcp-devel \
 pcp-libs \
 pcp-libs-devel \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 redhat-rpm-config \
 selinux-policy-devel \
 selinux-policy-targeted \
 setools \
 systemd-libs \
 xz-libs \
 "
RDEPENDS:pcp-zeroconf = " \
 bash \
 pcp \
 pcp-doc \
 pcp-libs \
 pcp-pmda-bpf \
 pcp-pmda-dm \
 pcp-pmda-nfsclient \
 pcp-pmda-openmetrics \
 pcp-pmda-opentelemetry \
 pcp-system-tools \
 "
RDEPENDS:perl-PCP-LogImport = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-PCP-LogSummary = " \
 pcp-libs \
 perl-Exporter \
 perl-PCP-LogSummary \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-PCP-MMV = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-PCP-MMV \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-PCP-PMDA = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:python3-pcp = " \
 glibc \
 pcp \
 pcp-libs \
 python3 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/perl_Slurm_"

PROVIDES:append:aarch64 = " rpm/virtual/perl_Slurm_"
