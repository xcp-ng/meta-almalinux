# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Accessor-Grouped"
PV = "0.10014"
PR = "24.el10_3"
PACKAGES = " \
 perl-Class-Accessor-Grouped \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Accessor-Grouped-0.10014-24.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1ce50878e4130ca8cc7676bc7ddb23b9373055f69f659b6441029ff5df7bda3"

URI_x86_64_v2_perl-Class-Accessor-Grouped = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Accessor-Grouped-0.10014-24.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Accessor-Grouped;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Accessor-Grouped}"
SRC_URI[x86_64_v2_perl-Class-Accessor-Grouped.sha256sum] = "978c0c5c803e49c1f784c90f235e0c119761da519b4eaca2dc5ec0f88cbe9d1c"

URI_aarch64_perl-Class-Accessor-Grouped = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Accessor-Grouped-0.10014-24.el10_3.noarch.rpm;name=aarch64_perl-Class-Accessor-Grouped;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Accessor-Grouped}"
SRC_URI[aarch64_perl-Class-Accessor-Grouped.sha256sum] = "a15aaec05f8fb209d97dfeb7dd6bb2ff285f4656a55e27e73586beae234c00b4"

RDEPENDS:perl-Class-Accessor-Grouped = " \
 perl-Carp \
 perl-Module-Runtime \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-mro \
 "
