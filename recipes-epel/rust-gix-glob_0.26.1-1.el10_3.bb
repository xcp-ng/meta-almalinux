# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-glob"
PV = "0.26.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-glob+default-devel \
 rust-gix-glob+document-features-devel \
 rust-gix-glob+serde-devel \
 rust-gix-glob-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-glob-0.26.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5285c3ad87e98b278f2ca2fc91255548aacff05a7d9102a68dc9cc6a5ce60a58"

URI_x86_64_v2_rust-gix-glob+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob+default-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-glob+default-devel}"
SRC_URI[x86_64_v2_rust-gix-glob+default-devel.sha256sum] = "66c703ba1dc9a3145e70013cf82b1b30b0bb7906eb6f1fa936b416ca63612701"

URI_x86_64_v2_rust-gix-glob+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob+document-features-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-glob+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-glob+document-features-devel.sha256sum] = "f1ee8483fda7fbf8070b04c10397b51c6bd7ee09f9b31d8254d793a533204b3a"

URI_x86_64_v2_rust-gix-glob+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob+serde-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-glob+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-glob+serde-devel.sha256sum] = "c4fc30fb3e3d0125a04160d4659e7144fd448c9bff006a2484ef267c636c718c"

URI_x86_64_v2_rust-gix-glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-glob-devel}"
SRC_URI[x86_64_v2_rust-gix-glob-devel.sha256sum] = "79feb35d936a5d417093277f41bd0c12d118eaed4e331a32cfddd09fa0f2e50c"

URI_aarch64_rust-gix-glob+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob+default-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-glob+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-glob+default-devel}"
SRC_URI[aarch64_rust-gix-glob+default-devel.sha256sum] = "b215d0082e2802c4393669b58491c7e33ae07d38a7a1da5b6d460ea8059620d0"

URI_aarch64_rust-gix-glob+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob+document-features-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-glob+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-glob+document-features-devel}"
SRC_URI[aarch64_rust-gix-glob+document-features-devel.sha256sum] = "06c68514ea38358eb4774ee985d935786b5a1a534c1d82885367f86afe9cea98"

URI_aarch64_rust-gix-glob+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob+serde-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-glob+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-glob+serde-devel}"
SRC_URI[aarch64_rust-gix-glob+serde-devel.sha256sum] = "c60bba81f77397458d46a7b316ac3c043000fdfaf376e1767a98830353078065"

URI_aarch64_rust-gix-glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-glob-devel}"
SRC_URI[aarch64_rust-gix-glob-devel.sha256sum] = "1ba934feca6655aea5f0ef61ea3ab26c4dd13af0223866c3020dff1ddf730b61"

RDEPENDS:rust-gix-glob+default-devel = " \
 cargo \
 rust-gix-glob-devel \
 "
RDEPENDS:rust-gix-glob+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-glob-devel \
 "
RDEPENDS:rust-gix-glob+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-bstr+serde-devel \
 rust-gix-glob-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-glob-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-features+default-devel \
 rust-gix-path+default-devel \
 "
