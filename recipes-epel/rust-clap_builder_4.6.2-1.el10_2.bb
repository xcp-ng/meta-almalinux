# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_builder"
PV = "4.6.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-clap_builder+cargo-devel \
 rust-clap_builder+color-devel \
 rust-clap_builder+debug-devel \
 rust-clap_builder+default-devel \
 rust-clap_builder+deprecated-devel \
 rust-clap_builder+env-devel \
 rust-clap_builder+error-context-devel \
 rust-clap_builder+help-devel \
 rust-clap_builder+std-devel \
 rust-clap_builder+string-devel \
 rust-clap_builder+suggestions-devel \
 rust-clap_builder+unicode-devel \
 rust-clap_builder+unstable-doc-devel \
 rust-clap_builder+unstable-ext-devel \
 rust-clap_builder+unstable-styles-devel \
 rust-clap_builder+unstable-v5-devel \
 rust-clap_builder+usage-devel \
 rust-clap_builder+wrap_help-devel \
 rust-clap_builder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_builder-4.6.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c123d33a8ed282a82c308f81bf8de9b34bb7ec95373e8eb3c0380ff519be005a"

URI_x86_64_v2_rust-clap_builder+cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+cargo-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+cargo-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+cargo-devel.sha256sum] = "4ea71fd39454717b013cbb8787712be6f9642306d13ff58c395d238d7bdf65b2"

URI_x86_64_v2_rust-clap_builder+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+color-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+color-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+color-devel.sha256sum] = "514961b3b80aec31f1bf3cd8bedd3d3dfc6216f36fecd8da9c79b208e26cd839"

URI_x86_64_v2_rust-clap_builder+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+debug-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+debug-devel.sha256sum] = "8e7d60715fe54f43969f1db5e79d6872930911bc632bdd3914361e0dad790d92"

URI_x86_64_v2_rust-clap_builder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+default-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+default-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+default-devel.sha256sum] = "1db6024604bd0024101feb4470b262dfb4f75eb31cdddd6884280c14f8e65247"

URI_x86_64_v2_rust-clap_builder+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+deprecated-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+deprecated-devel.sha256sum] = "fc40b03c8d3ef69843db255c41edde1641b256d367ff2e52a4ba5385c7d4aeb6"

URI_x86_64_v2_rust-clap_builder+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+env-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+env-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+env-devel.sha256sum] = "ff8dfd9c69e5436e4641746a8fca5c7a741e16c62a31866b537cbc598bf8de60"

URI_x86_64_v2_rust-clap_builder+error-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+error-context-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+error-context-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+error-context-devel.sha256sum] = "8384261a373e6b9433242f5602c8dd817932172dba85117a54c24ce6e025ccb0"

URI_x86_64_v2_rust-clap_builder+help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+help-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+help-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+help-devel.sha256sum] = "967611f485cb66524af5358eca0a8217ec6595d35a052f1b8fc4a6f9c4202f38"

URI_x86_64_v2_rust-clap_builder+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+std-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+std-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+std-devel.sha256sum] = "d32382c31982debd2ad143d714f2fc1814bf225fbb5b5b0c2d8e998e5f9388d1"

URI_x86_64_v2_rust-clap_builder+string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+string-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+string-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+string-devel.sha256sum] = "d4521904cfa001fc0d03241fe81be1737accd3ef62ac9ce5c4bfe37716239236"

URI_x86_64_v2_rust-clap_builder+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+suggestions-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+suggestions-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+suggestions-devel.sha256sum] = "9acd4981bac7bce5b0484ac76f1b9a789ca688f65aad297cca61c9d5f3ccc95e"

URI_x86_64_v2_rust-clap_builder+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unicode-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unicode-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unicode-devel.sha256sum] = "cd451dfc7e1cc8289043cf9f85dd52e15d3d404d72ddee359d18fb6c3bafa64f"

URI_x86_64_v2_rust-clap_builder+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-doc-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-doc-devel.sha256sum] = "e21c9ae11cb3ebd1eea867a1674bf1a249311968346561683842ecb66e98d5a8"

URI_x86_64_v2_rust-clap_builder+unstable-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-ext-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-ext-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-ext-devel.sha256sum] = "e4c10028bac4327f96b918d35658cc5d703702c6b65e7136c8a4db03c474605f"

URI_x86_64_v2_rust-clap_builder+unstable-styles-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-styles-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-styles-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-styles-devel.sha256sum] = "34f83935951984dac77e1e3d1e3bc143d2f7b6a1bf1e7e6be47da78c043a1b2e"

URI_x86_64_v2_rust-clap_builder+unstable-v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-v5-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-v5-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-v5-devel.sha256sum] = "e21049bc6165137e3791cd171139d58d7449468853d21ccad0c2c07cd36c8510"

URI_x86_64_v2_rust-clap_builder+usage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+usage-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+usage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+usage-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+usage-devel.sha256sum] = "6b8c6b46c32c5be28651ad0477cb09da14ce059507f412ef59a4f58a752092c0"

URI_x86_64_v2_rust-clap_builder+wrap_help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+wrap_help-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+wrap_help-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+wrap_help-devel.sha256sum] = "b4b980cdcb08c360d15b280861c1a4d07e1890b152c4d5a81ff6fdaae0ee0672"

URI_x86_64_v2_rust-clap_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder-devel-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder-devel}"
SRC_URI[x86_64_v2_rust-clap_builder-devel.sha256sum] = "7a3d254fbc8e1f441677e3c8e03a19a1f92f05a84f1a9ea991d5e42b89a1947a"

URI_aarch64_rust-clap_builder+cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+cargo-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+cargo-devel}"
SRC_URI[aarch64_rust-clap_builder+cargo-devel.sha256sum] = "6c91fa48429d425f8042e5d7304d9b29045b4b9db8e109b5dc1f2ac63de6083a"

URI_aarch64_rust-clap_builder+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+color-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+color-devel}"
SRC_URI[aarch64_rust-clap_builder+color-devel.sha256sum] = "7f1a46200e7951e9d3c5250c427280188fb4f5e7a30383a0b6a1b235edb906a7"

URI_aarch64_rust-clap_builder+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+debug-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+debug-devel}"
SRC_URI[aarch64_rust-clap_builder+debug-devel.sha256sum] = "f5ab5d5385320dae8a8eaf35d4ed7c78320e462fffc011843ae2449cdfbed848"

URI_aarch64_rust-clap_builder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+default-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+default-devel}"
SRC_URI[aarch64_rust-clap_builder+default-devel.sha256sum] = "6e2d176b0bdee6445386510e1033b5cf9ead6a20ba0cfc63ae2790aa91fbfcfa"

URI_aarch64_rust-clap_builder+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+deprecated-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+deprecated-devel}"
SRC_URI[aarch64_rust-clap_builder+deprecated-devel.sha256sum] = "817bc5bd861374b7e84402ab677257f1d743b92970f01b37c3117a229b1ee1da"

URI_aarch64_rust-clap_builder+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+env-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+env-devel}"
SRC_URI[aarch64_rust-clap_builder+env-devel.sha256sum] = "d5e7d875c8906cb898672fbe1c865b670a2a0620ca4074d7b710baf0fc34b4a7"

URI_aarch64_rust-clap_builder+error-context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+error-context-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+error-context-devel}"
SRC_URI[aarch64_rust-clap_builder+error-context-devel.sha256sum] = "eb1116665a8b51a053594224e13bb082a0976d1d6625a17c2826ea044dc0ebb5"

URI_aarch64_rust-clap_builder+help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+help-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+help-devel}"
SRC_URI[aarch64_rust-clap_builder+help-devel.sha256sum] = "8aefdf718a1c6b39adfc4097d2c0c497abdd31f51635717e82420f119f2099a2"

URI_aarch64_rust-clap_builder+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+std-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+std-devel}"
SRC_URI[aarch64_rust-clap_builder+std-devel.sha256sum] = "e6fd31adc72c5ff4f8f10a01557e0011e1856ccbb1bcc8a1cb6cab53d8609833"

URI_aarch64_rust-clap_builder+string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+string-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+string-devel}"
SRC_URI[aarch64_rust-clap_builder+string-devel.sha256sum] = "7336c4bc2c9158cd2792bbaaf5c08f495609a82d3033215266ee2c2498084239"

URI_aarch64_rust-clap_builder+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+suggestions-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+suggestions-devel}"
SRC_URI[aarch64_rust-clap_builder+suggestions-devel.sha256sum] = "ecc590bbe21fad662e5310ce05e45fb42d018e05ec4d0086a7ac397a4bf3b1a7"

URI_aarch64_rust-clap_builder+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unicode-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unicode-devel}"
SRC_URI[aarch64_rust-clap_builder+unicode-devel.sha256sum] = "2e47c10ffe46dd385ba219234e5593a9e402f05ed7df5ff5586528c6d3446e46"

URI_aarch64_rust-clap_builder+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-doc-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-doc-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-doc-devel.sha256sum] = "77d9539242149f2843c0a613e3ea1b4f1a7f6cb8339281a01504dec0ee8d4ae3"

URI_aarch64_rust-clap_builder+unstable-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-ext-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-ext-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-ext-devel.sha256sum] = "d3b3fb6f48d7470f1ae358c608f815fd62c8ef58e09f8c28239618ef303fe2cb"

URI_aarch64_rust-clap_builder+unstable-styles-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-styles-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-styles-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-styles-devel.sha256sum] = "4884fd8afdf2240f746caa6fb9821def400f47f468d5c16d5bc56fe1bcd0a8ee"

URI_aarch64_rust-clap_builder+unstable-v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-v5-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-v5-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-v5-devel.sha256sum] = "03c33a62fc9f2bcaf41d7457c6dbd76c859b841cb45075abcbb7e769e3d4fc54"

URI_aarch64_rust-clap_builder+usage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+usage-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+usage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+usage-devel}"
SRC_URI[aarch64_rust-clap_builder+usage-devel.sha256sum] = "645318e3f3674c2f3590d508b42f86f187d41f1a6896e3142e71fae56ba57937"

URI_aarch64_rust-clap_builder+wrap_help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+wrap_help-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+wrap_help-devel}"
SRC_URI[aarch64_rust-clap_builder+wrap_help-devel.sha256sum] = "0194b84b5110dbd0ba9ae78191ad9e94bc7af1c1c92f6bc134cd9e3a3a4cf0c1"

URI_aarch64_rust-clap_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder-devel-4.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-clap_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder-devel}"
SRC_URI[aarch64_rust-clap_builder-devel.sha256sum] = "8b33321cebb8bd320136dcbbc125a1bbfe5dddf46c95cc7a23636563077740d7"

RDEPENDS:rust-clap_builder+cargo-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+debug-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+default-devel = " \
 cargo \
 rust-clap_builder+color-devel \
 rust-clap_builder+error-context-devel \
 rust-clap_builder+help-devel \
 rust-clap_builder+std-devel \
 rust-clap_builder+suggestions-devel \
 rust-clap_builder+usage-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+deprecated-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+env-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+error-context-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+help-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+std-devel = " \
 cargo \
 rust-anstyle+std-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+string-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+suggestions-devel = " \
 cargo \
 rust-clap_builder+error-context-devel \
 rust-clap_builder-devel \
 rust-strsim+default-devel \
 "
RDEPENDS:rust-clap_builder+unicode-devel = " \
 cargo \
 rust-clap_builder-devel \
 rust-unicase+default-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-clap_builder+unstable-doc-devel = " \
 cargo \
 rust-clap_builder+cargo-devel \
 rust-clap_builder+env-devel \
 rust-clap_builder+string-devel \
 rust-clap_builder+unicode-devel \
 rust-clap_builder+unstable-ext-devel \
 rust-clap_builder+wrap_help-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-ext-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-styles-devel = " \
 cargo \
 rust-clap_builder+color-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-v5-devel = " \
 cargo \
 rust-clap_builder+deprecated-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+usage-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+wrap_help-devel = " \
 cargo \
 rust-clap_builder+help-devel \
 rust-clap_builder-devel \
 rust-terminal_size+default-devel \
 "
RDEPENDS:rust-clap_builder-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-clap_lex+default-devel \
 "
