# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klickety"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 klickety \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/klickety-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da1c2239f28ada37e024ce20121e90b6c3190a85af9624312c9f8b4406d6ce07"

URI_x86_64_v2_klickety = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klickety-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klickety;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_klickety}"
SRC_URI[x86_64_v2_klickety.sha256sum] = "e1a6d00df70a3ea2a059bc7fc28b34a58ea2b952acebdfed89d6c50b9fcf5b77"

URI_aarch64_klickety = "${EPEL_MIRROR}/aarch64/Packages/k/klickety-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_klickety;unpack=0"
SRC_URI:append = " ${URI_aarch64_klickety}"
SRC_URI[aarch64_klickety.sha256sum] = "e8a21c763e4a81c62d6854c9eace0e4ceff50a9d0f5fc298c2345f73b3743e17"

RDEPENDS:klickety = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 perl-interpreter \
 perl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
