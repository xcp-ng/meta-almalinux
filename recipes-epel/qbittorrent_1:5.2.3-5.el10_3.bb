# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qbittorrent"
PE = "1"
PV = "5.2.3"
PR = "5.el10_3"
PACKAGES = " \
 qbittorrent \
 qbittorrent-nox \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qbittorrent-5.2.3-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd5c819a3bf85a5e88d8696d152d2f014129c64edda3ea0128297fd528d8cebc"

URI_x86_64_v2_qbittorrent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qbittorrent-5.2.3-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qbittorrent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qbittorrent}"
SRC_URI[x86_64_v2_qbittorrent.sha256sum] = "607c63beff1193762b54b56c2564f4ddd6224453ef95191df2665c5fa22f9b0c"

URI_x86_64_v2_qbittorrent-nox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qbittorrent-nox-5.2.3-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qbittorrent-nox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qbittorrent-nox}"
SRC_URI[x86_64_v2_qbittorrent-nox.sha256sum] = "1d4352f5713de6a5a921bb88f791cac1cd8977bc67dba2e92f4ae8d70c588323"

URI_aarch64_qbittorrent = "${EPEL_MIRROR}/aarch64/Packages/q/qbittorrent-5.2.3-5.el10_3.aarch64.rpm;name=aarch64_qbittorrent;unpack=0"
SRC_URI:append = " ${URI_aarch64_qbittorrent}"
SRC_URI[aarch64_qbittorrent.sha256sum] = "0599d3bde990ac6f9363fc6478558d902d63bc6d848a3a48a8066a45ea5acf78"

URI_aarch64_qbittorrent-nox = "${EPEL_MIRROR}/aarch64/Packages/q/qbittorrent-nox-5.2.3-5.el10_3.aarch64.rpm;name=aarch64_qbittorrent-nox;unpack=0"
SRC_URI:append = " ${URI_aarch64_qbittorrent-nox}"
SRC_URI[aarch64_qbittorrent-nox.sha256sum] = "8df31b7f8332cf23ec58be8026eb4b115f821d4fd98b6c1f6a4c3e5e184a3d09"

RDEPENDS:qbittorrent = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 rb_libtorrent \
 zlib-ng-compat \
 "
RDEPENDS:qbittorrent-nox = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 rb_libtorrent \
 zlib-ng-compat \
 "
