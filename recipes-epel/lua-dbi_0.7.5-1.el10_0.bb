# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-dbi"
PV = "0.7.5"
PR = "1.el10_0"
PACKAGES = " \
 lua-dbi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-dbi-0.7.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce2a960b99ecaee08508902dbcba17bcd191e1735ea91904b976bfb47e4e56cc"

URI_x86_64_v2_lua-dbi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-dbi-0.7.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-dbi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-dbi}"
SRC_URI[x86_64_v2_lua-dbi.sha256sum] = "4909647e13638b36225f13593d34bf817924f3a109d85262acd1e3095f967800"

URI_aarch64_lua-dbi = "${EPEL_MIRROR}/aarch64/Packages/l/lua-dbi-0.7.5-1.el10_0.aarch64.rpm;name=aarch64_lua-dbi;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-dbi}"
SRC_URI[aarch64_lua-dbi.sha256sum] = "76807ff45952e63e6092bdff1f4d9707004b9f5f0380c8c22d9f11c8dfebe6cc"

RDEPENDS:lua-dbi = " \
 glibc \
 libpq \
 lua-libs \
 mariadb-connector-c \
 sqlite-libs \
 "
