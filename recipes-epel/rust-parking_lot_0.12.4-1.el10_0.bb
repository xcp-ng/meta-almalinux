# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-parking_lot"
PV = "0.12.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-parking_lot+arc_lock-devel \
 rust-parking_lot+deadlock_detection-devel \
 rust-parking_lot+default-devel \
 rust-parking_lot+hardware-lock-elision-devel \
 rust-parking_lot+nightly-devel \
 rust-parking_lot+owning_ref-devel \
 rust-parking_lot+send_guard-devel \
 rust-parking_lot+serde-devel \
 rust-parking_lot-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-parking_lot-0.12.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d499de177b0bc12239d2304d9df0b70f4166dbb10e3bb98da7a2fe803bd5b227"

URI_x86_64_v2_rust-parking_lot+arc_lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+arc_lock-devel-0.12.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+arc_lock-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+arc_lock-devel.sha256sum] = "124ce7a8262eacb52029ac25146a132c980704941f02c0308617ac67412501a1"

URI_x86_64_v2_rust-parking_lot+deadlock_detection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+deadlock_detection-devel-0.12.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+deadlock_detection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+deadlock_detection-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+deadlock_detection-devel.sha256sum] = "13be0c6f398b280ab5b6f090be6cc7935240c148f980591050248ba4b6bfe311"

URI_x86_64_v2_rust-parking_lot+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+default-devel-0.12.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+default-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+default-devel.sha256sum] = "c26e9da27e6662d3df1de913aea244429870a48b753f5ef41b2000ee8d85f777"

URI_x86_64_v2_rust-parking_lot+hardware-lock-elision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+hardware-lock-elision-devel-0.12.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+hardware-lock-elision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+hardware-lock-elision-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+hardware-lock-elision-devel.sha256sum] = "0b302eb805201b5839a05745f55c73ebedc4293a80d34bf3761232feee4cef6e"

URI_x86_64_v2_rust-parking_lot+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+nightly-devel-0.12.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+nightly-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+nightly-devel.sha256sum] = "955a3b428cca623ad0e91e75f1fbd1bc55e016028228878ef4f3334580a8706b"

URI_x86_64_v2_rust-parking_lot+owning_ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+owning_ref-devel-0.12.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+owning_ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+owning_ref-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+owning_ref-devel.sha256sum] = "44782114d7b44f7599956067cb765482d29379e88f82868950fa57efba67afe5"

URI_x86_64_v2_rust-parking_lot+send_guard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+send_guard-devel-0.12.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+send_guard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+send_guard-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+send_guard-devel.sha256sum] = "5274128c223f9ac05054f2c2fd33dec7fac4a75b07bb29187a0200013e531ad1"

URI_x86_64_v2_rust-parking_lot+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+serde-devel-0.12.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+serde-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+serde-devel.sha256sum] = "ee7474a3ad6f6ded7ea841ef9fd8e6dbaf8c7323253c9c41485609852709c482"

URI_x86_64_v2_rust-parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot-devel-0.12.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot-devel}"
SRC_URI[x86_64_v2_rust-parking_lot-devel.sha256sum] = "d51547472359f9071958d517dd1ec7ebc9469eb052daf3aea06f158aafa0d967"

URI_aarch64_rust-parking_lot+arc_lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+arc_lock-devel-0.12.4-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+arc_lock-devel}"
SRC_URI[aarch64_rust-parking_lot+arc_lock-devel.sha256sum] = "b19e812131f3c053001efa8187c3d4af10cf48f588eb58250345e8e7578ff632"

URI_aarch64_rust-parking_lot+deadlock_detection-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+deadlock_detection-devel-0.12.4-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot+deadlock_detection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+deadlock_detection-devel}"
SRC_URI[aarch64_rust-parking_lot+deadlock_detection-devel.sha256sum] = "ebe29f7391ad735954b18fe5e51fb0064198d839d2b9157d07d438ad3eb5d5c2"

URI_aarch64_rust-parking_lot+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+default-devel-0.12.4-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+default-devel}"
SRC_URI[aarch64_rust-parking_lot+default-devel.sha256sum] = "0b485bf72e6b6b7bd1401b4323240b1fc1f9e11c16768d697325125d03e33a7d"

URI_aarch64_rust-parking_lot+hardware-lock-elision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+hardware-lock-elision-devel-0.12.4-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot+hardware-lock-elision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+hardware-lock-elision-devel}"
SRC_URI[aarch64_rust-parking_lot+hardware-lock-elision-devel.sha256sum] = "3f1d1c73762d47727f278d38f40ff67bdab603e3802f52e6c112e0a3812633fd"

URI_aarch64_rust-parking_lot+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+nightly-devel-0.12.4-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+nightly-devel}"
SRC_URI[aarch64_rust-parking_lot+nightly-devel.sha256sum] = "8e70010314677d131c95db3f4a09dd2025bbacab1d80e35894bde8b0b11f7ef1"

URI_aarch64_rust-parking_lot+owning_ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+owning_ref-devel-0.12.4-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot+owning_ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+owning_ref-devel}"
SRC_URI[aarch64_rust-parking_lot+owning_ref-devel.sha256sum] = "e70420aa66426125e273269df57fd40163bd51e687a8ab11760d7e79ac743769"

URI_aarch64_rust-parking_lot+send_guard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+send_guard-devel-0.12.4-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot+send_guard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+send_guard-devel}"
SRC_URI[aarch64_rust-parking_lot+send_guard-devel.sha256sum] = "1cf7b1a5f92194a187a87b8223b10f41df6691c00715b8aee60681fa65adca1f"

URI_aarch64_rust-parking_lot+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+serde-devel-0.12.4-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+serde-devel}"
SRC_URI[aarch64_rust-parking_lot+serde-devel.sha256sum] = "ca73eae5e61b44a88d0168aea6d5e5af0a1a175343a70056aefb09a161bdb3b1"

URI_aarch64_rust-parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot-devel-0.12.4-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot-devel}"
SRC_URI[aarch64_rust-parking_lot-devel.sha256sum] = "acc6450233710cb050348d077da0c40776a2120ae2ca40de36d5ecdc73c77f41"

RDEPENDS:rust-parking_lot+arc_lock-devel = " \
 cargo \
 rust-lock_api+arc_lock-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+deadlock_detection-devel = " \
 cargo \
 rust-parking_lot-devel \
 rust-parking_lot_core+deadlock_detection-devel \
 "
RDEPENDS:rust-parking_lot+default-devel = " \
 cargo \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+hardware-lock-elision-devel = " \
 cargo \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+nightly-devel = " \
 cargo \
 rust-lock_api+nightly-devel \
 rust-parking_lot-devel \
 rust-parking_lot_core+nightly-devel \
 "
RDEPENDS:rust-parking_lot+owning_ref-devel = " \
 cargo \
 rust-lock_api+owning_ref-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+send_guard-devel = " \
 cargo \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+serde-devel = " \
 cargo \
 rust-lock_api+serde-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot-devel = " \
 cargo \
 rust \
 rust-lock_api+default-devel \
 rust-parking_lot_core+default-devel \
 "
