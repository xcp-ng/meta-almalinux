# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "partclone"
PV = "0.3.38"
PR = "1.el10_0"
PACKAGES = " \
 partclone \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/partclone-0.3.38-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c7bd2d4973ab4fc008d8ea02e13dfd82b724069a35dc7b24b8c73833dcec071"

URI_x86_64_v2_partclone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/partclone-0.3.38-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_partclone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_partclone}"
SRC_URI[x86_64_v2_partclone.sha256sum] = "dd5076b50a256c74e3a2d0dd09f6cd8bc3177c47bcfc7eafddf94f9883bf7d65"

URI_aarch64_partclone = "${EPEL_MIRROR}/aarch64/Packages/p/partclone-0.3.38-1.el10_0.aarch64.rpm;name=aarch64_partclone;unpack=0"
SRC_URI:append = " ${URI_aarch64_partclone}"
SRC_URI[aarch64_partclone.sha256sum] = "3e2cdcb039c703f7be734ef72b104458e4a9bb5c4f78116d96ab5a7178577609"

RDEPENDS:partclone = " \
 e2fsprogs-libs \
 fuse3-libs \
 glibc \
 libblkid \
 libuuid \
 ncurses-libs \
 ntfs-3g-libs \
 openssl-libs \
 "
