# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-ruby"
PV = "0.23.1"
PR = "2.el10_1"
PACKAGES = " \
 rust-tree-sitter-ruby+default-devel \
 rust-tree-sitter-ruby-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-ruby-0.23.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b05fa15b034f76dfa5d5024a3d0819b93236672e5a4946e7591584b6623a94f3"

URI_x86_64_v2_rust-tree-sitter-ruby+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-ruby+default-devel-0.23.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-ruby+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-ruby+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-ruby+default-devel.sha256sum] = "edaadb3953d42e7428f1cb2b42ee2cf3135de242c4f2bd4ccf5ec8b212eb8c06"

URI_x86_64_v2_rust-tree-sitter-ruby-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-ruby-devel-0.23.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-ruby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-ruby-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-ruby-devel.sha256sum] = "adaa077449e0934131cef284cf46d034839c79d3e3edb341eb4c25b158f30e7b"

URI_aarch64_rust-tree-sitter-ruby+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-ruby+default-devel-0.23.1-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-ruby+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-ruby+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-ruby+default-devel.sha256sum] = "ddf541e2d3c2e79cf43dae354b6ce2ba8a3033e6d05d1f641d04a439f4e3dbfe"

URI_aarch64_rust-tree-sitter-ruby-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-ruby-devel-0.23.1-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-ruby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-ruby-devel}"
SRC_URI[aarch64_rust-tree-sitter-ruby-devel.sha256sum] = "51743b2528d56a788c7fa27612364cd7d70af7b55c64be60f8c9b42dcf22476b"

RDEPENDS:rust-tree-sitter-ruby+default-devel = " \
 cargo \
 rust-tree-sitter-ruby-devel \
 "
RDEPENDS:rust-tree-sitter-ruby-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
