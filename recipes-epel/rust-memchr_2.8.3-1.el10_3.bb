# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memchr"
PV = "2.8.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-memchr+alloc-devel \
 rust-memchr+default-devel \
 rust-memchr+libc-devel \
 rust-memchr+logging-devel \
 rust-memchr+std-devel \
 rust-memchr+use_std-devel \
 rust-memchr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memchr-2.8.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4887c0413b3bc0e3b2ceeb12b84aeabd6a8505ebd09f9eb1464c8e6a0a82461f"

URI_x86_64_v2_rust-memchr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+alloc-devel-2.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+alloc-devel}"
SRC_URI[x86_64_v2_rust-memchr+alloc-devel.sha256sum] = "f8f9c7ef0ab3b6a2a02d6abd16285929921546e0505a5ed6dd198814dceaacf2"

URI_x86_64_v2_rust-memchr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+default-devel-2.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+default-devel}"
SRC_URI[x86_64_v2_rust-memchr+default-devel.sha256sum] = "da5c2832db7041eda60aa62e5c4d7cec49f7040917a9479afd27528580517e95"

URI_x86_64_v2_rust-memchr+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+libc-devel-2.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+libc-devel}"
SRC_URI[x86_64_v2_rust-memchr+libc-devel.sha256sum] = "d96574196ec27f19f1ccdab0cb63080af9e69a91041db611d3aa2ec6960f358b"

URI_x86_64_v2_rust-memchr+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+logging-devel-2.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+logging-devel}"
SRC_URI[x86_64_v2_rust-memchr+logging-devel.sha256sum] = "906b410cb191e92a587fd40eeed0673d8c7e5c7d2272ca821b91a9360b0dd186"

URI_x86_64_v2_rust-memchr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+std-devel-2.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+std-devel}"
SRC_URI[x86_64_v2_rust-memchr+std-devel.sha256sum] = "b2492389f5ba76144ce986deeb88a48313fb93b0f99837ab7feffe4ab01d15e0"

URI_x86_64_v2_rust-memchr+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+use_std-devel-2.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+use_std-devel}"
SRC_URI[x86_64_v2_rust-memchr+use_std-devel.sha256sum] = "92407124c7e4ac5b685cb1ae6056a60ba61c5745e6f545eb3a2fdc2b1d49a360"

URI_x86_64_v2_rust-memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr-devel-2.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr-devel}"
SRC_URI[x86_64_v2_rust-memchr-devel.sha256sum] = "a02312da6f57b6a9650509f44091773ee7a2c41fb13159d501cdfac626708c9a"

URI_aarch64_rust-memchr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+alloc-devel-2.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-memchr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+alloc-devel}"
SRC_URI[aarch64_rust-memchr+alloc-devel.sha256sum] = "3b1197c56146e184f849d49d0b21fd80faaa1edeff1724a9f4d14ebee71341e6"

URI_aarch64_rust-memchr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+default-devel-2.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-memchr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+default-devel}"
SRC_URI[aarch64_rust-memchr+default-devel.sha256sum] = "eaf03637cc8263bad00d82621c75b778b98392924f5da7081b18c317e92c486e"

URI_aarch64_rust-memchr+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+libc-devel-2.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-memchr+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+libc-devel}"
SRC_URI[aarch64_rust-memchr+libc-devel.sha256sum] = "4477e74ae69a8fa47b72b1e42898a664d196186b3c60c9a05b3137d954f4a481"

URI_aarch64_rust-memchr+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+logging-devel-2.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-memchr+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+logging-devel}"
SRC_URI[aarch64_rust-memchr+logging-devel.sha256sum] = "16cf4ce70d8d6ccb428012da5e1759cf9c84f5e7811e49fdce9092d01db2e9e0"

URI_aarch64_rust-memchr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+std-devel-2.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-memchr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+std-devel}"
SRC_URI[aarch64_rust-memchr+std-devel.sha256sum] = "c43a8c5c245d2408cf65f8a100d98491108611f82e8e0bf81b292803964e7f54"

URI_aarch64_rust-memchr+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+use_std-devel-2.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-memchr+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+use_std-devel}"
SRC_URI[aarch64_rust-memchr+use_std-devel.sha256sum] = "8b8dc1c72ca5c785c5d925a9df5a8e7824f96128c81e3aa677d39b4ec3fba89a"

URI_aarch64_rust-memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr-devel-2.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr-devel}"
SRC_URI[aarch64_rust-memchr-devel.sha256sum] = "3954fe7ff8540366b195b3d558c8b0ec5be2167756d3ede0b6aa89abdb5a459d"

RDEPENDS:rust-memchr+alloc-devel = " \
 cargo \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+default-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+libc-devel = " \
 cargo \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+logging-devel = " \
 cargo \
 rust-log+default-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+std-devel = " \
 cargo \
 rust-memchr+alloc-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+use_std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr-devel = " \
 cargo \
 rust \
 "
