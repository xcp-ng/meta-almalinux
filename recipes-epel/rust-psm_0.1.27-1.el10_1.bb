# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-psm"
PV = "0.1.27"
PR = "1.el10_1"
PACKAGES = " \
 rust-psm+default-devel \
 rust-psm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-psm-0.1.27-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "636c7e959e82bac930810b87f70472ba7cb11ba29f8593071f55391689141bda"

URI_x86_64_v2_rust-psm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psm+default-devel-0.1.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psm+default-devel}"
SRC_URI[x86_64_v2_rust-psm+default-devel.sha256sum] = "64c53c7770815e0bc385a73da5e4ac78e022e1e25f02582f4578bb67e155546e"

URI_x86_64_v2_rust-psm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psm-devel-0.1.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psm-devel}"
SRC_URI[x86_64_v2_rust-psm-devel.sha256sum] = "ca3b101afbde080d9973cb48559368925f5ed0e2fbae95e1030646c933217c1a"

URI_aarch64_rust-psm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psm+default-devel-0.1.27-1.el10_1.noarch.rpm;name=aarch64_rust-psm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psm+default-devel}"
SRC_URI[aarch64_rust-psm+default-devel.sha256sum] = "3f7b3045b54a6e91db320f94bb59db665a0c33e03531f19a098e5b6122196d2e"

URI_aarch64_rust-psm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psm-devel-0.1.27-1.el10_1.noarch.rpm;name=aarch64_rust-psm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psm-devel}"
SRC_URI[aarch64_rust-psm-devel.sha256sum] = "a8aac2e7ac798abc0451c876a186694f7c12272e0a2a3e2f4fb42348ca40d8ae"

RDEPENDS:rust-psm+default-devel = " \
 cargo \
 rust-psm-devel \
 "
RDEPENDS:rust-psm-devel = " \
 cargo \
 rust-cc+default-devel \
 "
