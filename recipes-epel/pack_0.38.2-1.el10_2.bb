# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pack"
PV = "0.38.2"
PR = "1.el10_2"
PACKAGES = " \
 pack \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pack-0.38.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b875d17753555601d5789caa5993f48e3bca42098e844bc00b6ff8179ed8bcc9"

URI_x86_64_v2_pack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pack-0.38.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pack}"
SRC_URI[x86_64_v2_pack.sha256sum] = "6898f4af5961d0972b4ef7aa495af0fbbf487e9916d75bb097ba1ed8d5aa5511"

URI_aarch64_pack = "${EPEL_MIRROR}/aarch64/Packages/p/pack-0.38.2-1.el10_2.aarch64.rpm;name=aarch64_pack;unpack=0"
SRC_URI:append = " ${URI_aarch64_pack}"
SRC_URI[aarch64_pack.sha256sum] = "88bfa8cf4fac316aac7fb1bd82bc414733f510c7012a3e62000fe74d2c127bc0"

RDEPENDS:pack = " \
 glibc \
 "
