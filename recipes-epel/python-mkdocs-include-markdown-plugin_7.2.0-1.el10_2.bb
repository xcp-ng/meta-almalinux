# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-include-markdown-plugin"
PV = "7.2.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-mkdocs-include-markdown-plugin \
 python3-mkdocs-include-markdown-plugin+cache \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-include-markdown-plugin-7.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e472b6aa8ab8f812f45f289cfe67d971c1ed0dd212a46d20fa0b2c5f92e4a82"

URI_x86_64_v2_python3-mkdocs-include-markdown-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-include-markdown-plugin-7.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-include-markdown-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-include-markdown-plugin}"
SRC_URI[x86_64_v2_python3-mkdocs-include-markdown-plugin.sha256sum] = "c8853c035c9c8417e3de2e0c29450cd4dbba96dd86dc6ee867bf2e207bc07c9c"

URI_x86_64_v2_python3-mkdocs-include-markdown-plugin+cache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-include-markdown-plugin+cache-7.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-include-markdown-plugin+cache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-include-markdown-plugin+cache}"
SRC_URI[x86_64_v2_python3-mkdocs-include-markdown-plugin+cache.sha256sum] = "df918005addf9d6e142cab78974d08e294dc2c5980eb0959c24d0f332740678f"

URI_aarch64_python3-mkdocs-include-markdown-plugin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-include-markdown-plugin-7.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-mkdocs-include-markdown-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-include-markdown-plugin}"
SRC_URI[aarch64_python3-mkdocs-include-markdown-plugin.sha256sum] = "1a05565a3d63236e15c54290eb8ab14f2c58900c57ce864474b3e5cf256c2665"

URI_aarch64_python3-mkdocs-include-markdown-plugin+cache = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-include-markdown-plugin+cache-7.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-mkdocs-include-markdown-plugin+cache;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-include-markdown-plugin+cache}"
SRC_URI[aarch64_python3-mkdocs-include-markdown-plugin+cache.sha256sum] = "3c2af8d78380833aa204375554976cb6af872c25aee618177037bca277bd4bd8"

RDEPENDS:python3-mkdocs-include-markdown-plugin = " \
 mkdocs \
 python3 \
 python3-wcmatch \
 "
RDEPENDS:python3-mkdocs-include-markdown-plugin+cache = " \
 python3 \
 python3-mkdocs-include-markdown-plugin \
 python3-platformdirs \
 "
