# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memmem"
PV = "0.1.1"
PR = "8.el10_1"
PACKAGES = " \
 rust-memmem+default-devel \
 rust-memmem-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memmem-0.1.1-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b55eaadd625b4b4aeaa367fdee59c9733fe55f33d3490f2d0d16c61d493e7869"

URI_x86_64_v2_rust-memmem+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmem+default-devel-0.1.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmem+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmem+default-devel}"
SRC_URI[x86_64_v2_rust-memmem+default-devel.sha256sum] = "8cfe4e50c9a07c375e349814eb75382850662277e217de656a17f09d964f6394"

URI_x86_64_v2_rust-memmem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmem-devel-0.1.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmem-devel}"
SRC_URI[x86_64_v2_rust-memmem-devel.sha256sum] = "073c114d2891b33d201834205e390dd60654c1f9d5a905ce8d157c7ba9627175"

URI_aarch64_rust-memmem+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmem+default-devel-0.1.1-8.el10_1.noarch.rpm;name=aarch64_rust-memmem+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmem+default-devel}"
SRC_URI[aarch64_rust-memmem+default-devel.sha256sum] = "0bd8850d28c08ea8ecc60b294d665b6c30537adebfe0eaa6ff0142e255a0b92b"

URI_aarch64_rust-memmem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmem-devel-0.1.1-8.el10_1.noarch.rpm;name=aarch64_rust-memmem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmem-devel}"
SRC_URI[aarch64_rust-memmem-devel.sha256sum] = "3f27ef10cda39864dbcae438d0128bb0d86f9538358751f11c1afc9d8ebb8f4d"

RDEPENDS:rust-memmem+default-devel = " \
 cargo \
 rust-memmem-devel \
 "
RDEPENDS:rust-memmem-devel = " \
 cargo \
 "
