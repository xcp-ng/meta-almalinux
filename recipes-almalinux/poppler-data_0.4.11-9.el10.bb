# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "poppler-data"
PV = "0.4.11"
PR = "9.el10"
PACKAGES = " \
 poppler-data \
 poppler-data-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/poppler-data-0.4.11-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "142a78c04b0131925708f423b4d5187ecfcee3b07e8aae7f39a4143cf15717b5"

URI_x86_64_v2_poppler-data = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-data-0.4.11-9.el10.noarch.rpm;name=x86_64_v2_poppler-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-data}"
SRC_URI[x86_64_v2_poppler-data.sha256sum] = "a6048df0dca87ed697faf114059df0b717c36d72dadeeab4870e68e1b60229ea"

URI_x86_64_v2_poppler-data-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-data-devel-0.4.11-9.el10.noarch.rpm;name=x86_64_v2_poppler-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-data-devel}"
SRC_URI[x86_64_v2_poppler-data-devel.sha256sum] = "5699531b44215d79a03321dd2a0cca924fff32485846e4352fa1bb41f576f4be"

URI_aarch64_poppler-data = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-data-0.4.11-9.el10.noarch.rpm;name=aarch64_poppler-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-data}"
SRC_URI[aarch64_poppler-data.sha256sum] = "a6048df0dca87ed697faf114059df0b717c36d72dadeeab4870e68e1b60229ea"

URI_aarch64_poppler-data-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-data-devel-0.4.11-9.el10.noarch.rpm;name=aarch64_poppler-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-data-devel}"
SRC_URI[aarch64_poppler-data-devel.sha256sum] = "5699531b44215d79a03321dd2a0cca924fff32485846e4352fa1bb41f576f4be"

RDEPENDS:poppler-data = " \
 "
RDEPENDS:poppler-data-devel = " \
 pkgconf-pkg-config \
 poppler-data \
 "
