# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-util"
PV = "0.7.19"
PR = "1.el10_2"
PACKAGES = " \
 rust-tokio-util+codec-devel \
 rust-tokio-util+compat-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+full-devel \
 rust-tokio-util+futures-io-devel \
 rust-tokio-util+futures-util-devel \
 rust-tokio-util+hashbrown-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util+io-util-devel \
 rust-tokio-util+join-map-devel \
 rust-tokio-util+libc-devel \
 rust-tokio-util+net-devel \
 rust-tokio-util+rt-devel \
 rust-tokio-util+slab-devel \
 rust-tokio-util+time-devel \
 rust-tokio-util+tracing-devel \
 rust-tokio-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-util-0.7.19-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2517866ce67ee195fc0b61961e0438730560b8a9754ac0d6f003998669007a48"

URI_x86_64_v2_rust-tokio-util+codec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+codec-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+codec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+codec-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+codec-devel.sha256sum] = "2ebde60892fd6c52432aac8c8444ea9a10b4c7ae6d1ca62cab522d1bb24f4339"

URI_x86_64_v2_rust-tokio-util+compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+compat-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+compat-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+compat-devel.sha256sum] = "44898d11375556e08caf6f2d2bbc7e6067cf882320010dc3a8d4f2cbea2204b0"

URI_x86_64_v2_rust-tokio-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+default-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+default-devel.sha256sum] = "032e92131642e58965133cbace6f12041bfbecf740cf24897c7eb54dca893ed6"

URI_x86_64_v2_rust-tokio-util+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+full-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+full-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+full-devel.sha256sum] = "58ec1bda9cf41d193033404d03742306354997307e36dbf5ebb905512308a32b"

URI_x86_64_v2_rust-tokio-util+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+futures-io-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+futures-io-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+futures-io-devel.sha256sum] = "6f05c00aee63db65b9d2e8c97cc237d981ee3713216f48db7ae0afc3ec5dd6a5"

URI_x86_64_v2_rust-tokio-util+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+futures-util-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+futures-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+futures-util-devel.sha256sum] = "bf5abf186709d5bbf311c860873ceacf79f295424e6da5e3a60f8ab9b43b3b68"

URI_x86_64_v2_rust-tokio-util+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+hashbrown-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+hashbrown-devel.sha256sum] = "1e929f8542216217451644f059d745e57dd5016542274a81c05fa88a81b5c220"

URI_x86_64_v2_rust-tokio-util+io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+io-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+io-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+io-devel.sha256sum] = "aa0e4c17c1259f10a5bbb92f2abe83a41e5d9b640bbe5ba70af4c68ef79c3a46"

URI_x86_64_v2_rust-tokio-util+io-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+io-util-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+io-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+io-util-devel.sha256sum] = "80c8ad187575ec4a34d69d30cdc602cceb009f8b92217187cf6b888c334fc936"

URI_x86_64_v2_rust-tokio-util+join-map-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+join-map-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+join-map-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+join-map-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+join-map-devel.sha256sum] = "8e61c2363d1a82b4bdd08576aac785f03844a5b47ba4975db53b5a6524a66c58"

URI_x86_64_v2_rust-tokio-util+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+libc-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+libc-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+libc-devel.sha256sum] = "2c8ab003001e38748befe994490bf2e7bf3db916693a02275db43e086f77503b"

URI_x86_64_v2_rust-tokio-util+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+net-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+net-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+net-devel.sha256sum] = "84c802d11fcb5c8f4b21f5090f9e3b8b336c043ce4e090fd0d98b529004bc993"

URI_x86_64_v2_rust-tokio-util+rt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+rt-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+rt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+rt-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+rt-devel.sha256sum] = "4e2bd1dfb23f26a96bd257e7bcd9f07a7ccb6b35703dd927118df2d38511d1a5"

URI_x86_64_v2_rust-tokio-util+slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+slab-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+slab-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+slab-devel.sha256sum] = "bcb6e8f9122d6df6abdb900a46ba9c75b505c1eede23fe249f0ff2be9104cdc9"

URI_x86_64_v2_rust-tokio-util+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+time-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+time-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+time-devel.sha256sum] = "0e4656810330bcf4e115cd3a0aa30df19f900e59f327982d644637e7c2e08923"

URI_x86_64_v2_rust-tokio-util+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+tracing-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+tracing-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+tracing-devel.sha256sum] = "e2fcdb2b96be7341b05f25e5c27536f7ac87670fadfba78f918656754ef547ba"

URI_x86_64_v2_rust-tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util-devel-0.7.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-util-devel.sha256sum] = "cafc8607469803a0e925732197ae5d97689d2501aa46fb3bfce529706f13075c"

URI_aarch64_rust-tokio-util+codec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+codec-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+codec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+codec-devel}"
SRC_URI[aarch64_rust-tokio-util+codec-devel.sha256sum] = "37d93f5dfd4b39b9b4a26016f1c4fc7dc96d4162475829638f79c231ad8b2f63"

URI_aarch64_rust-tokio-util+compat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+compat-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+compat-devel}"
SRC_URI[aarch64_rust-tokio-util+compat-devel.sha256sum] = "7f0a702dea8f28b8dda622f3a3a831b969ae2c8241ab212dcf657937b4c2fca8"

URI_aarch64_rust-tokio-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+default-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+default-devel}"
SRC_URI[aarch64_rust-tokio-util+default-devel.sha256sum] = "55c2d9aec4dc776e775adbb9f0dc0e3932c020a26ae8502d225039835fa0c99d"

URI_aarch64_rust-tokio-util+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+full-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+full-devel}"
SRC_URI[aarch64_rust-tokio-util+full-devel.sha256sum] = "5fc96ed473630b51633d0c7fc1ef73264a0bf6ec6e635e9081d5510aa337ad3b"

URI_aarch64_rust-tokio-util+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+futures-io-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+futures-io-devel}"
SRC_URI[aarch64_rust-tokio-util+futures-io-devel.sha256sum] = "41f4f9fbc75b2274855ec8ccc8587fa7b360da12d044f532044937de0c15daa2"

URI_aarch64_rust-tokio-util+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+futures-util-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+futures-util-devel}"
SRC_URI[aarch64_rust-tokio-util+futures-util-devel.sha256sum] = "ac20525a81bcb1702abc055f87fc82bf9000874af33c263c9ae197a6d90f8307"

URI_aarch64_rust-tokio-util+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+hashbrown-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+hashbrown-devel}"
SRC_URI[aarch64_rust-tokio-util+hashbrown-devel.sha256sum] = "b8e73fe2992436e298e03f05f503a3290d18c0d67c59df4e2431ed814744e720"

URI_aarch64_rust-tokio-util+io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+io-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+io-devel}"
SRC_URI[aarch64_rust-tokio-util+io-devel.sha256sum] = "e0e38903a8d82efcad52b6db6f27d760b6f5bb62b9e271c320ba4492d2f24fe3"

URI_aarch64_rust-tokio-util+io-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+io-util-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+io-util-devel}"
SRC_URI[aarch64_rust-tokio-util+io-util-devel.sha256sum] = "8ddc976552cd5a7d5ff00dc52fcd36a387d98e06e48de6fe5f3b25198e23e8d8"

URI_aarch64_rust-tokio-util+join-map-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+join-map-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+join-map-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+join-map-devel}"
SRC_URI[aarch64_rust-tokio-util+join-map-devel.sha256sum] = "bcb07d0e23a5b3e8b7c997f98b3c380e4fde313917d0a282ba87dae5cc9a6d07"

URI_aarch64_rust-tokio-util+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+libc-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+libc-devel}"
SRC_URI[aarch64_rust-tokio-util+libc-devel.sha256sum] = "181eec7442474e7b32f31d02b78a07d7b4200ce6e6c5eb2bbb1c41550df010ec"

URI_aarch64_rust-tokio-util+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+net-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+net-devel}"
SRC_URI[aarch64_rust-tokio-util+net-devel.sha256sum] = "2e91aa55ef73e9e76201b9cba2e1695311ef29afc7d73d508832aed14e9f953c"

URI_aarch64_rust-tokio-util+rt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+rt-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+rt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+rt-devel}"
SRC_URI[aarch64_rust-tokio-util+rt-devel.sha256sum] = "0277c99b9c188c95bfb388b22d75c5c4c5eaf091e64d52cc3fe4329cc6f535f4"

URI_aarch64_rust-tokio-util+slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+slab-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+slab-devel}"
SRC_URI[aarch64_rust-tokio-util+slab-devel.sha256sum] = "ab12dbab47e951fdd74f08a609cd520898e0d73cd137635f0672989fb48f19d4"

URI_aarch64_rust-tokio-util+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+time-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+time-devel}"
SRC_URI[aarch64_rust-tokio-util+time-devel.sha256sum] = "dbdef0d4aad70d009b24c771414c482a93c236689c14f6ed373aa71827834750"

URI_aarch64_rust-tokio-util+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+tracing-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+tracing-devel}"
SRC_URI[aarch64_rust-tokio-util+tracing-devel.sha256sum] = "7244a722f5a9f4fb4fe0b5e95cab862931278411b2c8a89582c9bc729f049156"

URI_aarch64_rust-tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util-devel-0.7.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util-devel}"
SRC_URI[aarch64_rust-tokio-util-devel.sha256sum] = "060691d5664883affba06252bf8e4d12edc66c7566590f2457da7de2949a8bd8"

RDEPENDS:rust-tokio-util+codec-devel = " \
 cargo \
 rust-tokio-util+libc-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+compat-devel = " \
 cargo \
 rust-tokio-util+futures-io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+default-devel = " \
 cargo \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+full-devel = " \
 cargo \
 rust-tokio-util+codec-devel \
 rust-tokio-util+compat-devel \
 rust-tokio-util+io-util-devel \
 rust-tokio-util+join-map-devel \
 rust-tokio-util+net-devel \
 rust-tokio-util+rt-devel \
 rust-tokio-util+time-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+futures-util-devel = " \
 cargo \
 rust-futures-util+default-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.15-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+io-devel = " \
 cargo \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+io-util-devel = " \
 cargo \
 rust-tokio+io-util-devel \
 rust-tokio+rt-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+join-map-devel = " \
 cargo \
 rust-tokio-util+hashbrown-devel \
 rust-tokio-util+rt-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+net-devel = " \
 cargo \
 rust-tokio+net-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+rt-devel = " \
 cargo \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio-util+futures-util-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+slab-devel = " \
 cargo \
 rust-slab+default-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+time-devel = " \
 cargo \
 rust-tokio+time-devel \
 rust-tokio-util+slab-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+tracing-devel = " \
 cargo \
 rust-tokio-util-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tokio-util-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-futures-core+default-devel \
 rust-futures-sink+default-devel \
 rust-pin-project-lite+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
