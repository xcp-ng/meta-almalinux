# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ostree"
PV = "2026.2"
PR = "1.el10"
PACKAGES = " \
 ostree \
 ostree-devel \
 ostree-grub2 \
 ostree-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ostree-2026.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7be68c0807371d8ab5d5a546e8a91da94494057c21a8ea3b0d45c7b6c11c8fc1"

URI_x86_64_v2_ostree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ostree-2026.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ostree}"
SRC_URI[x86_64_v2_ostree.sha256sum] = "2f387c58ced7bf0d439ce4fa54ddd244828df51bf07824c7c9699c1c1d41c67f"

URI_x86_64_v2_ostree-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ostree-devel-2026.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_ostree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ostree-devel}"
SRC_URI[x86_64_v2_ostree-devel.sha256sum] = "00014c7e4fabba77d49070ae67fcc9f3ded2899f4be9d2b81a703e5b9c28ea84"

URI_x86_64_v2_ostree-grub2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ostree-grub2-2026.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_ostree-grub2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ostree-grub2}"
SRC_URI[x86_64_v2_ostree-grub2.sha256sum] = "d870f28b854b5ca3594bc8c650a84d27e003df7a06e6a94c86fa79ee9fd70428"

URI_x86_64_v2_ostree-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ostree-libs-2026.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_ostree-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ostree-libs}"
SRC_URI[x86_64_v2_ostree-libs.sha256sum] = "691ef3fc160816a71a5989545bfd3388545e2b8e0b7ed15f5a3361fbe428cf63"

URI_aarch64_ostree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ostree-2026.2-1.el10.aarch64.rpm;name=aarch64_ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_ostree}"
SRC_URI[aarch64_ostree.sha256sum] = "fce6327bc49919c01180f464ef2a9a6ae8f68a1cece95f1bfd001cbe88c2b239"

URI_aarch64_ostree-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ostree-devel-2026.2-1.el10.aarch64.rpm;name=aarch64_ostree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ostree-devel}"
SRC_URI[aarch64_ostree-devel.sha256sum] = "c822e4d86296e6418763b0d0450cb18dd58153aadc9cc3f5d2e66a3ba8ed8c43"

URI_aarch64_ostree-grub2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ostree-grub2-2026.2-1.el10.aarch64.rpm;name=aarch64_ostree-grub2;unpack=0"
SRC_URI:append = " ${URI_aarch64_ostree-grub2}"
SRC_URI[aarch64_ostree-grub2.sha256sum] = "c2c77bcc1d586fd09acf973e15bc0eb9580206749163462702e36dbacb8f6273"

URI_aarch64_ostree-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ostree-libs-2026.2-1.el10.aarch64.rpm;name=aarch64_ostree-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ostree-libs}"
SRC_URI[aarch64_ostree-libs.sha256sum] = "55c9ff6d70c6dcde6c1714d023cc808c46f93495707051e6f2da4f4b719d0a67"

RDEPENDS:ostree = " \
 bash \
 composefs \
 composefs-libs \
 dracut \
 fuse-libs \
 glib2 \
 glibc \
 gnupg2 \
 libarchive \
 libgcc \
 libselinux \
 openssl-libs \
 ostree-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:ostree-devel = " \
 composefs-devel \
 glib2-devel \
 libarchive-devel \
 libcurl-devel \
 libgpg-error-devel \
 libselinux-devel \
 openssl-devel \
 ostree-libs \
 pkgconf-pkg-config \
 systemd-devel \
 virtual/pkgconfig_gpgme__ge_1.8.0 \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:ostree-grub2:x86_64_v2 = " \
 bash \
 grub2-pc \
 ostree \
"
RDEPENDS:ostree-grub2:aarch64 = " \
 bash \
 grub2-efi-aa64 \
 ostree \
"
RDEPENDS:ostree-libs = " \
 composefs-libs \
 glib2 \
 glibc \
 gpgme \
 libarchive \
 libgcc \
 libgpg-error \
 libmount \
 libselinux \
 openssl-libs \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
