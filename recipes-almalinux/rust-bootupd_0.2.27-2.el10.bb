# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bootupd"
PV = "0.2.27"
PR = "2.el10"
PACKAGES = " \
 bootupd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-bootupd-0.2.27-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9de96324056340f6e8c238391ff402dfe03dcc1abf8afd2579030691c6d1c75"

URI_x86_64_v2_bootupd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bootupd-0.2.27-2.el10.x86_64_v2.rpm;name=x86_64_v2_bootupd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bootupd}"
SRC_URI[x86_64_v2_bootupd.sha256sum] = "904e9555cd3a2eb1ef6d0bb592d5838d761edf98eecfcbf6ff5a74fd50064b88"

URI_aarch64_bootupd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bootupd-0.2.27-2.el10.aarch64.rpm;name=aarch64_bootupd;unpack=0"
SRC_URI:append = " ${URI_aarch64_bootupd}"
SRC_URI[aarch64_bootupd.sha256sum] = "bdd040b531a379f69e4757942a0c8812bba1d3dc1e8966e43176f23b275fa100"

RDEPENDS:bootupd = " \
 glibc \
 libgcc \
 openssl-libs \
 systemd \
 "
