# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyperv-daemons"
PV = "0"
PR = "0.50.20220731git.el10"
PACKAGES:x86_64_v2 = " \
 hyperv-daemons \
 hyperv-daemons-license \
 hyperv-tools \
 hypervfcopyd \
 hypervkvpd \
 hypervvssd \
"
PACKAGES:aarch64 = " \
 hyperv-daemons \
 hyperv-daemons-license \
 hyperv-tools \
 hypervkvpd \
 hypervvssd \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyperv-daemons-0-0.50.20220731git.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db669eb3e4fe7b0292eda6e4594353cf217e7fd604420ff20b6024fb1a23e029"

URI_x86_64_v2_hyperv-daemons = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyperv-daemons-0-0.50.20220731git.el10.x86_64_v2.rpm;name=x86_64_v2_hyperv-daemons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyperv-daemons}"
SRC_URI[x86_64_v2_hyperv-daemons.sha256sum] = "503931a6ed22ba387cd58c58bb698a493bb055bdf48114c8e446f54055302397"

URI_x86_64_v2_hyperv-daemons-license = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyperv-daemons-license-0-0.50.20220731git.el10.noarch.rpm;name=x86_64_v2_hyperv-daemons-license;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyperv-daemons-license}"
SRC_URI[x86_64_v2_hyperv-daemons-license.sha256sum] = "ffd60ba3223fbdf8e7b02a8a9f49e7f87a40ed17bc78ae4b3f678198928d21a8"

URI_x86_64_v2_hyperv-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyperv-tools-0-0.50.20220731git.el10.noarch.rpm;name=x86_64_v2_hyperv-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyperv-tools}"
SRC_URI[x86_64_v2_hyperv-tools.sha256sum] = "566cac9fe540aa90e657077824495dba8e2b1963ed45eada81dbfcaf0accab06"

URI_x86_64_v2_hypervfcopyd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hypervfcopyd-0-0.50.20220731git.el10.x86_64_v2.rpm;name=x86_64_v2_hypervfcopyd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypervfcopyd}"
SRC_URI[x86_64_v2_hypervfcopyd.sha256sum] = "4ffdf99339e7cc57bebd24403a7b2c3c74b38ceb707f63022410183827258fb9"

URI_x86_64_v2_hypervkvpd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hypervkvpd-0-0.50.20220731git.el10.x86_64_v2.rpm;name=x86_64_v2_hypervkvpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypervkvpd}"
SRC_URI[x86_64_v2_hypervkvpd.sha256sum] = "5b1d9640e17b9dca3a2e80f65b4b0a9d64b6c4d7bf847624676b8aaa941b2251"

URI_x86_64_v2_hypervvssd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hypervvssd-0-0.50.20220731git.el10.x86_64_v2.rpm;name=x86_64_v2_hypervvssd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypervvssd}"
SRC_URI[x86_64_v2_hypervvssd.sha256sum] = "d72b5f8e3cae951f05cee8cef9e93ff36a06cca58257b371501705e7522e1197"

URI_aarch64_hyperv-daemons = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyperv-daemons-0-0.50.20220731git.el10.aarch64.rpm;name=aarch64_hyperv-daemons;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyperv-daemons}"
SRC_URI[aarch64_hyperv-daemons.sha256sum] = "398e1b40ab59e747c56d9e93fbcae87ec285d18eafb76951f4c490f6f021d9f9"

URI_aarch64_hyperv-daemons-license = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyperv-daemons-license-0-0.50.20220731git.el10.noarch.rpm;name=aarch64_hyperv-daemons-license;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyperv-daemons-license}"
SRC_URI[aarch64_hyperv-daemons-license.sha256sum] = "ffd60ba3223fbdf8e7b02a8a9f49e7f87a40ed17bc78ae4b3f678198928d21a8"

URI_aarch64_hyperv-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyperv-tools-0-0.50.20220731git.el10.noarch.rpm;name=aarch64_hyperv-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyperv-tools}"
SRC_URI[aarch64_hyperv-tools.sha256sum] = "566cac9fe540aa90e657077824495dba8e2b1963ed45eada81dbfcaf0accab06"

URI_aarch64_hypervkvpd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hypervkvpd-0-0.50.20220731git.el10.aarch64.rpm;name=aarch64_hypervkvpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypervkvpd}"
SRC_URI[aarch64_hypervkvpd.sha256sum] = "6366d1d6731cd7c03faff8b4e56e1b8f684c7aad00d089cbae582582919e5dd7"

URI_aarch64_hypervvssd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hypervvssd-0-0.50.20220731git.el10.aarch64.rpm;name=aarch64_hypervvssd;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypervvssd}"
SRC_URI[aarch64_hypervvssd.sha256sum] = "c8c075da38d24c6ec880b06a2ae73010cd14af64b6d88730bbdb31292026cb7d"

RDEPENDS:hyperv-daemons:x86_64_v2 = " \
 hypervfcopyd \
 hypervkvpd \
 hypervvssd \
"
RDEPENDS:hyperv-daemons:aarch64 = " \
 hypervkvpd \
 hypervvssd \
"
RDEPENDS:hyperv-daemons-license = " \
 "
RDEPENDS:hyperv-tools = " \
 python3 \
 "
RDEPENDS:hypervfcopyd = " \
 bash \
 glibc \
 hyperv-daemons-license \
 systemd \
 "
RDEPENDS:hypervkvpd = " \
 bash \
 glibc \
 hyperv-daemons-license \
 systemd \
 "
RDEPENDS:hypervvssd = " \
 bash \
 glibc \
 hyperv-daemons-license \
 systemd \
 "
