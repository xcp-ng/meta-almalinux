# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-imara-diff"
PV = "0.2.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-imara-diff+default-devel \
 rust-gix-imara-diff+unified_diff-devel \
 rust-gix-imara-diff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-imara-diff-0.2.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa1a3b8f70f788c4bae0c297ba5570453720939f23f77f32c0809033bbe3f74a"

URI_x86_64_v2_rust-gix-imara-diff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-imara-diff+default-devel-0.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-imara-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-imara-diff+default-devel}"
SRC_URI[x86_64_v2_rust-gix-imara-diff+default-devel.sha256sum] = "f457b03ec95bcae877e38417c364196cadd91ccc33ae8710863d7a67bddd26f6"

URI_x86_64_v2_rust-gix-imara-diff+unified_diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-imara-diff+unified_diff-devel-0.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-imara-diff+unified_diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-imara-diff+unified_diff-devel}"
SRC_URI[x86_64_v2_rust-gix-imara-diff+unified_diff-devel.sha256sum] = "2f3a0c448727e7eeb03c6c1814904efd10e5888a1cab9ed121449f7d02e81623"

URI_x86_64_v2_rust-gix-imara-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-imara-diff-devel-0.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-imara-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-imara-diff-devel}"
SRC_URI[x86_64_v2_rust-gix-imara-diff-devel.sha256sum] = "ed305452cad2664abaedd75ecda739718850891fb64a1df5c7bae38ba8078a0d"

URI_aarch64_rust-gix-imara-diff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-imara-diff+default-devel-0.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-gix-imara-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-imara-diff+default-devel}"
SRC_URI[aarch64_rust-gix-imara-diff+default-devel.sha256sum] = "d13dd569921e8d710772edfba41dea949d0638c45d0c8d8401d085408d6c626b"

URI_aarch64_rust-gix-imara-diff+unified_diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-imara-diff+unified_diff-devel-0.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-gix-imara-diff+unified_diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-imara-diff+unified_diff-devel}"
SRC_URI[aarch64_rust-gix-imara-diff+unified_diff-devel.sha256sum] = "f851927f7ba076c52c76d196c7733a17015f64f18d8d39bcd8ef009efd76038a"

URI_aarch64_rust-gix-imara-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-imara-diff-devel-0.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-gix-imara-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-imara-diff-devel}"
SRC_URI[aarch64_rust-gix-imara-diff-devel.sha256sum] = "6d8a5c832b632db9d60a231f70d56306a9e4c76d7d868a0a382e95e7c2b0679a"

RDEPENDS:rust-gix-imara-diff+default-devel = " \
 cargo \
 rust-gix-imara-diff-devel \
 "
RDEPENDS:rust-gix-imara-diff+unified_diff-devel = " \
 cargo \
 rust-gix-imara-diff-devel \
 "
RDEPENDS:rust-gix-imara-diff-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~ \
 virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~ \
 virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~ \
 "
