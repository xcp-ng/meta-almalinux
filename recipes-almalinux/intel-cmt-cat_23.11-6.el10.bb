# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-cmt-cat"
PV = "23.11"
PR = "6.el10"
PACKAGES:x86_64_v2 = " \
 intel-cmt-cat \
 intel-cmt-cat-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/intel-cmt-cat-23.11-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d240d7df0f072d4ece40ce50a7cf53a21cd756eb77dc6181b409e2d01a6afd3e"

URI_x86_64_v2_intel-cmt-cat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-cmt-cat-23.11-6.el10.x86_64_v2.rpm;name=x86_64_v2_intel-cmt-cat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-cmt-cat}"
SRC_URI[x86_64_v2_intel-cmt-cat.sha256sum] = "a916257b74ff7039a938f062cf1b5eccd051759f7746441b51e9456db0a34f6e"

URI_x86_64_v2_intel-cmt-cat-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/intel-cmt-cat-devel-23.11-6.el10.x86_64_v2.rpm;name=x86_64_v2_intel-cmt-cat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-cmt-cat-devel}"
SRC_URI[x86_64_v2_intel-cmt-cat-devel.sha256sum] = "463ed6249e773c00ba3efa70c26bcb7f8f38492c22a88df9c268bd8691bf17df"

RDEPENDS:intel-cmt-cat = " \
 bash \
 glibc \
 "
RDEPENDS:intel-cmt-cat-devel = " \
 intel-cmt-cat \
 "
