# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-iai"
PV = "0.1.1"
PR = "10.el10_0"
PACKAGES = " \
 rust-iai+default-devel \
 rust-iai+real_blackbox-devel \
 rust-iai-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-iai-0.1.1-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1605f08559eb07f0c42be9df0a80f62ea5c453468bf04615bbb3907423c7b5f7"

URI_x86_64_v2_rust-iai+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iai+default-devel-0.1.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iai+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iai+default-devel}"
SRC_URI[x86_64_v2_rust-iai+default-devel.sha256sum] = "bc76227900194914333a367a10271acc9e1d5c5a96762ee726f165b0eb336d88"

URI_x86_64_v2_rust-iai+real_blackbox-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iai+real_blackbox-devel-0.1.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iai+real_blackbox-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iai+real_blackbox-devel}"
SRC_URI[x86_64_v2_rust-iai+real_blackbox-devel.sha256sum] = "3c54ea74ebde342a0832621ec22bdd4d3df626bf4b50572a6ddec05654406d5c"

URI_x86_64_v2_rust-iai-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iai-devel-0.1.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iai-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iai-devel}"
SRC_URI[x86_64_v2_rust-iai-devel.sha256sum] = "972ecba5f95e60815f00d92b73fd4f308d794a5d879c230abd27e09c06ad60db"

URI_aarch64_rust-iai+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iai+default-devel-0.1.1-10.el10_0.noarch.rpm;name=aarch64_rust-iai+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iai+default-devel}"
SRC_URI[aarch64_rust-iai+default-devel.sha256sum] = "6e0c7fe0f36dcba3583db1091b173309f8a3cc33601924f49e0aaa9660ae5195"

URI_aarch64_rust-iai+real_blackbox-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iai+real_blackbox-devel-0.1.1-10.el10_0.noarch.rpm;name=aarch64_rust-iai+real_blackbox-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iai+real_blackbox-devel}"
SRC_URI[aarch64_rust-iai+real_blackbox-devel.sha256sum] = "4e0e46dd28638ef0c85d4666c7607c34b8b95a735e8baff844b69525e7f9c5ae"

URI_aarch64_rust-iai-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iai-devel-0.1.1-10.el10_0.noarch.rpm;name=aarch64_rust-iai-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iai-devel}"
SRC_URI[aarch64_rust-iai-devel.sha256sum] = "5cd859ba2b610d6be4e3a2220080b6d8550e6756be2aea3f61c9117b641df0e0"

RDEPENDS:rust-iai+default-devel = " \
 cargo \
 rust-iai-devel \
 "
RDEPENDS:rust-iai+real_blackbox-devel = " \
 cargo \
 rust-iai-devel \
 "
RDEPENDS:rust-iai-devel = " \
 cargo \
 "
