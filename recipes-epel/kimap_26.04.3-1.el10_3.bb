# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kimap"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kimap \
 kimap-devel \
 kimap-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kimap-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bffd59b7f2e550e7bd774f028d17b33b12ab20256b119676dd13d3ddb69e13c6"

URI_x86_64_v2_kimap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimap}"
SRC_URI[x86_64_v2_kimap.sha256sum] = "d42d35d768925749914f1ebb191deb4851ac53905ac855bed06128623beecf87"

URI_x86_64_v2_kimap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimap-devel}"
SRC_URI[x86_64_v2_kimap-devel.sha256sum] = "03f41dfa0eaad008c7c2e84c9cac0e26bca0bfb6f1e04366cf9943736e957f47"

URI_x86_64_v2_kimap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kimap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimap-doc}"
SRC_URI[x86_64_v2_kimap-doc.sha256sum] = "843f0b4cf6d3b1d90a0e0cd4ed7263c43cf5a0fae68c0c717f7956c59e9a5c70"

URI_aarch64_kimap = "${EPEL_MIRROR}/aarch64/Packages/k/kimap-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kimap;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimap}"
SRC_URI[aarch64_kimap.sha256sum] = "83fab3e9fe47d124c5f166ce6c688c8a797696d34bc1bdd8840785c634c03554"

URI_aarch64_kimap-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kimap-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kimap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimap-devel}"
SRC_URI[aarch64_kimap-devel.sha256sum] = "da23e0df8abed1ea4b29bb639ff90c69c8a04e6e8d18341c744f8d7ff2d7ef5b"

URI_aarch64_kimap-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kimap-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kimap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimap-doc}"
SRC_URI[aarch64_kimap-doc.sha256sum] = "05daad71bf52f97dfccc0701cac94d15c3cc0031fc64ca16fbf8780ef9c7885e"

RDEPENDS:kimap = " \
 cyrus-sasl-lib \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kimap-devel = " \
 boost-devel \
 cmake-filesystem \
 cyrus-sasl-devel \
 kf6-kcoreaddons-devel \
 kimap \
 "
RDEPENDS:kimap-doc = " \
 "
