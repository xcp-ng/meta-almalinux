# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-thunderbolt"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-thunderbolt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-thunderbolt-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e81365b23b6dd609db03f12ae07d476528a8039ecc4beae00517b2dcf2a526fe"

URI_x86_64_v2_plasma-thunderbolt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-thunderbolt-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-thunderbolt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-thunderbolt}"
SRC_URI[x86_64_v2_plasma-thunderbolt.sha256sum] = "c4d8dd81820f4cd76a9390a1e50cbc97a858c3c1f69d3359c336d6e7b65b0e78"

URI_aarch64_plasma-thunderbolt = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-thunderbolt-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-thunderbolt;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-thunderbolt}"
SRC_URI[aarch64_plasma-thunderbolt.sha256sum] = "cdd007d33d919ef907eaf0444f79f395bfd76c6309059964250fca648a452b62"

RDEPENDS:plasma-thunderbolt = " \
 bolt \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knotifications \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
