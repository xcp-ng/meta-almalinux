# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-epoch"
PV = "0.9.20"
PR = "1.el10_2"
PACKAGES = " \
 rust-crossbeam-epoch+alloc-devel \
 rust-crossbeam-epoch+default-devel \
 rust-crossbeam-epoch+nightly-devel \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-epoch-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-epoch-0.9.20-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92438badccbb6821498699fe0ada07375f0550f24d519418c18a1ac5980765b9"

URI_x86_64_v2_rust-crossbeam-epoch+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+alloc-devel-0.9.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch+alloc-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+alloc-devel.sha256sum] = "235bbf06d0459f170854bf2744037f2833ee6d5e741e1dfe74fa9b929434c3ed"

URI_x86_64_v2_rust-crossbeam-epoch+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+default-devel-0.9.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+default-devel.sha256sum] = "1fb8fb06b9a496c933d4962aae4b3769d319b9b145a5474b4aca36aa90bb0fe4"

URI_x86_64_v2_rust-crossbeam-epoch+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+nightly-devel-0.9.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch+nightly-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+nightly-devel.sha256sum] = "9211aa574e4f7028700e3ba769078cea200fdd5c4c1fa1ba3c1e7b4cabdad479"

URI_x86_64_v2_rust-crossbeam-epoch+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+std-devel-0.9.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+std-devel.sha256sum] = "a392b026acc8217f374f632d0c0e60a5e3b71990f17ccbd45b0cee897c86eacb"

URI_x86_64_v2_rust-crossbeam-epoch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch-devel-0.9.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch-devel.sha256sum] = "95838bf6149ce430b28088559e34efbc18ceed1927aec53673b7b024cf96f1a9"

URI_aarch64_rust-crossbeam-epoch+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+alloc-devel-0.9.20-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-epoch+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch+alloc-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch+alloc-devel.sha256sum] = "23f66a6d98895c628362fbdb8d1b2b84fd64495637e49b4eced2202c207466d0"

URI_aarch64_rust-crossbeam-epoch+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+default-devel-0.9.20-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-epoch+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch+default-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch+default-devel.sha256sum] = "a44176e4083ecafa11cb8f4f0a4d74a5c9c596fe2ea3e81ca50fa595fbfe792c"

URI_aarch64_rust-crossbeam-epoch+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+nightly-devel-0.9.20-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-epoch+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch+nightly-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch+nightly-devel.sha256sum] = "7b03885e33678e93ff5732580765e1831f120e498f2558b44d26890c171364ff"

URI_aarch64_rust-crossbeam-epoch+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+std-devel-0.9.20-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-epoch+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch+std-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch+std-devel.sha256sum] = "8646a316e2d1cc03bef4e72de9b04044dd90f40b7bd57b824551dbe59dfa7e9a"

URI_aarch64_rust-crossbeam-epoch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch-devel-0.9.20-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-epoch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch-devel.sha256sum] = "934b0c70c6acea1af87598e930ea9e1ed6094322160483776d65da2feae1f38c"

RDEPENDS:rust-crossbeam-epoch+alloc-devel = " \
 cargo \
 rust-crossbeam-epoch-devel \
 "
RDEPENDS:rust-crossbeam-epoch+default-devel = " \
 cargo \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-epoch-devel \
 "
RDEPENDS:rust-crossbeam-epoch+nightly-devel = " \
 cargo \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils+nightly-devel \
 "
RDEPENDS:rust-crossbeam-epoch+std-devel = " \
 cargo \
 rust-crossbeam-epoch+alloc-devel \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-epoch-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
