# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pulp-cli-deb"
PV = "0.4.3"
PR = "3.el10_2"
PACKAGES = " \
 pulp-cli-deb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pulp-cli-deb-0.4.3-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88df360845890fa38f9f4d84956605e4fb904b4570a28f88b22d500644770973"

URI_x86_64_v2_pulp-cli-deb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulp-cli-deb-0.4.3-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pulp-cli-deb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulp-cli-deb}"
SRC_URI[x86_64_v2_pulp-cli-deb.sha256sum] = "ec4c4bd0306639eb1fdf4ce942359837599cba4306b9782251d4af8eb3c3dac9"

URI_aarch64_pulp-cli-deb = "${EPEL_MIRROR}/aarch64/Packages/p/pulp-cli-deb-0.4.3-3.el10_2.noarch.rpm;name=aarch64_pulp-cli-deb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulp-cli-deb}"
SRC_URI[aarch64_pulp-cli-deb.sha256sum] = "bb65fbbb828ee68dfe8d6558a5d09462dfcdcb70de7e6328e9c54b46b400c3f8"

RDEPENDS:pulp-cli-deb = " \
 pulp-cli \
 python3 \
 python3-pulp-glue-deb \
 "
