# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-revel-pathtree"
PV = "0"
PR = "15.20190626git41257a1.el10_0"
PACKAGES = " \
 golang-github-revel-pathtree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-revel-pathtree-0-15.20190626git41257a1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed295f2dc7cfb41995b614803f247120faaf610d9897ec4530211862bcc107de"

URI_aarch64_golang-github-revel-pathtree-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-revel-pathtree-devel-0-15.20190626git41257a1.el10_0.noarch.rpm;name=aarch64_golang-github-revel-pathtree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-revel-pathtree-devel}"
SRC_URI[aarch64_golang-github-revel-pathtree-devel.sha256sum] = "601f9db087473e3b83011f41718c536c2731b23b3a00c9512af18988c0e423ec"

RDEPENDS:golang-github-revel-pathtree-devel = " \
 go-filesystem \
 "
