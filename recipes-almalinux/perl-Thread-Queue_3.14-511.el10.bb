# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Thread-Queue"
PV = "3.14"
PR = "511.el10"
PACKAGES = " \
 perl-Thread-Queue \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Thread-Queue-3.14-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9c5da5c4b6877ce9e121008fb4d5ce4ad63d8761ff80ab38ee875dc6daefdce"

URI_x86_64_v2_perl-Thread-Queue = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Thread-Queue-3.14-511.el10.noarch.rpm;name=x86_64_v2_perl-Thread-Queue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Thread-Queue}"
SRC_URI[x86_64_v2_perl-Thread-Queue.sha256sum] = "d797fbefb163376189a49252c6cb0f7a53f6a66d31c5fece7e6039fa36d6b703"

URI_aarch64_perl-Thread-Queue = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Thread-Queue-3.14-511.el10.noarch.rpm;name=aarch64_perl-Thread-Queue;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Thread-Queue}"
SRC_URI[aarch64_perl-Thread-Queue.sha256sum] = "d797fbefb163376189a49252c6cb0f7a53f6a66d31c5fece7e6039fa36d6b703"

RDEPENDS:perl-Thread-Queue = " \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-threads-shared \
 "
