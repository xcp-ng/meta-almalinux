# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-syndication"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-syndication \
 kf6-syndication-devel \
 kf6-syndication-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-syndication-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8bc9208010d1eac63310096d5a3bebdf2418ee39c78b869d788d57d465a87388"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syndication;unpack=0"
SRC_URI[x86_64_v2_kf6-syndication.sha256sum] = "71367613889161eac5321a8cb3e09882849538c163d1b4a9faa9545b9d34ca50"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syndication-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-syndication-devel.sha256sum] = "034c6dff4c80c567a93be9851c81bb563ee418df248f95173957088d36efe8a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syndication-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-syndication-doc.sha256sum] = "04707f90755900e1fdf6609681b2dad9a51f73a7645598207dba11094ac7b525"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-syndication;unpack=0"
SRC_URI[aarch64_kf6-syndication.sha256sum] = "5f84ac7df1c2486b17b1b25b630f6851e0f1a0390fe80a62b790c0daf559a2d4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-syndication-devel;unpack=0"
SRC_URI[aarch64_kf6-syndication-devel.sha256sum] = "e239a4453f72befaf82909f2d9b3e5ef042ee293e1e97556cc832e9fa40aed1d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-syndication-doc;unpack=0"
SRC_URI[aarch64_kf6-syndication-doc.sha256sum] = "6efca4d474226d82d944d808f2feb545b6bf9cfebb7d9f43c4a8e4656549c3d7"

RDEPENDS:kf6-syndication = " \
 glibc \
 kf6-filesystem \
 kf6-kcodecs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-syndication-devel = " \
 cmake-filesystem \
 kf6-syndication \
 "
RDEPENDS:kf6-syndication-doc = " \
 "
