# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-th-abstraction"
PV = "0.5.0.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-th-abstraction \
 ghc-th-abstraction-devel \
 ghc-th-abstraction-doc \
 ghc-th-abstraction-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-th-abstraction-0.5.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "237c6c6ba859222da47f2c69360027c2342d6c642b0844f3016639946266732d"

URI_x86_64_v2_ghc-th-abstraction = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-abstraction-0.5.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-abstraction;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-abstraction}"
SRC_URI[x86_64_v2_ghc-th-abstraction.sha256sum] = "724e1167b31f39ba493c2e59120e882f28a7e13f734292f16e271e6c67e02fdd"

URI_x86_64_v2_ghc-th-abstraction-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-abstraction-devel-0.5.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-abstraction-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-abstraction-devel}"
SRC_URI[x86_64_v2_ghc-th-abstraction-devel.sha256sum] = "08370ad3d7c41aae77daf163a4ffeeae974bc1ee822f1f63a6fa4b110f34ed04"

URI_x86_64_v2_ghc-th-abstraction-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-abstraction-doc-0.5.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-th-abstraction-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-abstraction-doc}"
SRC_URI[x86_64_v2_ghc-th-abstraction-doc.sha256sum] = "8cbf4c2ef90110b5c31a255355cf9654308a6ee4d11c5354ec22d0586f590c3d"

URI_x86_64_v2_ghc-th-abstraction-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-abstraction-prof-0.5.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-abstraction-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-abstraction-prof}"
SRC_URI[x86_64_v2_ghc-th-abstraction-prof.sha256sum] = "bc7576b877933bc10d4fed9b39d0312c6d9ec19438cdbce48826dfb9303410e4"

URI_aarch64_ghc-th-abstraction = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-abstraction-0.5.0.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-th-abstraction;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-abstraction}"
SRC_URI[aarch64_ghc-th-abstraction.sha256sum] = "1ffd1263f6ef32ce9e40890a6cfa317f802c91def76ff5ad1ca1736095e81a9b"

URI_aarch64_ghc-th-abstraction-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-abstraction-devel-0.5.0.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-th-abstraction-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-abstraction-devel}"
SRC_URI[aarch64_ghc-th-abstraction-devel.sha256sum] = "b93551a2a189f7e591445321caf88ade0dc97179d8c2e31a7328f7d1d094c350"

URI_aarch64_ghc-th-abstraction-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-abstraction-doc-0.5.0.0-1.el10_0.noarch.rpm;name=aarch64_ghc-th-abstraction-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-abstraction-doc}"
SRC_URI[aarch64_ghc-th-abstraction-doc.sha256sum] = "b7348eea72158e96624040545ec6d8c5bc40f1de5c43c2500f3df7b3f9f299e0"

URI_aarch64_ghc-th-abstraction-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-abstraction-prof-0.5.0.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-th-abstraction-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-abstraction-prof}"
SRC_URI[aarch64_ghc-th-abstraction-prof.sha256sum] = "c7552487422c65a4c0e69894348b84ed982854581a3e87a3d9d8e5da812ab230"

RDEPENDS:ghc-th-abstraction = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-th-abstraction-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-template-haskell-devel \
 ghc-th-abstraction \
 "
RDEPENDS:ghc-th-abstraction-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-th-abstraction-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-template-haskell-prof \
 ghc-th-abstraction-devel \
 "
