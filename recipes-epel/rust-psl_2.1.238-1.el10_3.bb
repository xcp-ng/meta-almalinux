# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-psl"
PV = "2.1.238"
PR = "1.el10_3"
PACKAGES = " \
 rust-psl+default-devel \
 rust-psl+helpers-devel \
 rust-psl-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-psl-2.1.238-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d59ee2a001212ec3070e301ee7b20eba22cfdd8d16ae21f8eb2728815eaa0afa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl+default-devel-2.1.238-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-psl+default-devel.sha256sum] = "6cb667296e6a1a97f0526919c41d91cab569a9cc37ad7fc8fcbf9555c1720670"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl+helpers-devel-2.1.238-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl+helpers-devel;unpack=0"
SRC_URI[x86_64_v2_rust-psl+helpers-devel.sha256sum] = "acf5fef7e957a5b003096564c2a80036bc1b2326a1c2f52555f46727ca8895e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl-devel-2.1.238-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-psl-devel.sha256sum] = "39f205a25e14b6810e0c80c6c49b45aaf53d669e34c51db6d7b9ff119ec44e97"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-psl+default-devel-2.1.238-1.el10_3.noarch.rpm;name=aarch64_rust-psl+default-devel;unpack=0"
SRC_URI[aarch64_rust-psl+default-devel.sha256sum] = "efa7bbc7ac7cbe2a7e1e6be0b6bea5ab1d9304dce2fde228d5b90e799175188a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-psl+helpers-devel-2.1.238-1.el10_3.noarch.rpm;name=aarch64_rust-psl+helpers-devel;unpack=0"
SRC_URI[aarch64_rust-psl+helpers-devel.sha256sum] = "bcab63f1cdc977fa3cd59b5b8dc7f381fdd11fac746694d9c933763db978a08f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-psl-devel-2.1.238-1.el10_3.noarch.rpm;name=aarch64_rust-psl-devel;unpack=0"
SRC_URI[aarch64_rust-psl-devel.sha256sum] = "b386a50d55f998dfbf1a886c288eb0aee452aaa3a324fe7e80a3d61b664fc50c"

RDEPENDS:rust-psl+default-devel = " \
 cargo \
 rust-psl+helpers-devel \
 rust-psl-devel \
 "
RDEPENDS:rust-psl+helpers-devel = " \
 cargo \
 rust-psl-devel \
 "
RDEPENDS:rust-psl-devel = " \
 cargo \
 rust-psl-types+default-devel \
 "
