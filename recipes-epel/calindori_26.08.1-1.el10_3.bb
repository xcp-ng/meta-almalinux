# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "calindori"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 calindori \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/calindori-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bfb80fcd5a88d10953e0dde98f6e7fb28caeca26af61ff2983c88f2abc43d577"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calindori-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calindori;unpack=0"
SRC_URI[x86_64_v2_calindori.sha256sum] = "e6ef60776b06191b01811ecf6ccfa53c6c20bf954b1df43111dde39bc5641c54"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/calindori-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_calindori;unpack=0"
SRC_URI[aarch64_calindori.sha256sum] = "590cb6abc867f3f4dd7decc9529a417e196c073ab9dcc02cc07b9a0d1b7839da"

RDEPENDS:calindori = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-knotifications \
 kf6-kpeople \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
