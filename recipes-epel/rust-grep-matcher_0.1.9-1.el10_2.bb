# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-matcher"
PV = "0.1.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-grep-matcher+default-devel \
 rust-grep-matcher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-matcher-0.1.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94edb91e6c47c0383eed8a4a9311c67b10e0777a15dc0d2be89cb154692eb73e"

URI_x86_64_v2_rust-grep-matcher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-matcher+default-devel-0.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-matcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-matcher+default-devel}"
SRC_URI[x86_64_v2_rust-grep-matcher+default-devel.sha256sum] = "7eedde5e12a1ec1a2fd3250523ab00b0f0bec07750a80182b6c6f652e68d82d9"

URI_x86_64_v2_rust-grep-matcher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-matcher-devel-0.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-matcher-devel}"
SRC_URI[x86_64_v2_rust-grep-matcher-devel.sha256sum] = "d7abcd764baef9bccf299bcf52381ebcef96e7d8d8ea654ec47649286dbb8f34"

URI_aarch64_rust-grep-matcher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-matcher+default-devel-0.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-grep-matcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-matcher+default-devel}"
SRC_URI[aarch64_rust-grep-matcher+default-devel.sha256sum] = "dfab9029c991e11a47905246f01ca1a216cb5134f84fd673f1f14a3d4e403eee"

URI_aarch64_rust-grep-matcher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-matcher-devel-0.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-grep-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-matcher-devel}"
SRC_URI[aarch64_rust-grep-matcher-devel.sha256sum] = "095863df685de618e46683ad88194607f1b38521803c924debe33ede05d280a0"

RDEPENDS:rust-grep-matcher+default-devel = " \
 cargo \
 rust-grep-matcher-devel \
 "
RDEPENDS:rust-grep-matcher-devel = " \
 cargo \
 rust-memchr+default-devel \
 "
