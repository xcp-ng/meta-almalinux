# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdbusaddons"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kdbusaddons \
 kf6-kdbusaddons-devel \
 kf6-kdbusaddons-doc \
 kf6-kdbusaddons-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdbusaddons-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84267509b2eebcdac9498aead277e43de21f4e774de7ab368023df99e85bb195"

URI_x86_64_v2_kf6-kdbusaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdbusaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons}"
SRC_URI[x86_64_v2_kf6-kdbusaddons.sha256sum] = "128d45c4f93cfbc4b94676879b32948e0f3df76d00ec827ac958f20e984ad864"

URI_x86_64_v2_kf6-kdbusaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdbusaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons-devel}"
SRC_URI[x86_64_v2_kf6-kdbusaddons-devel.sha256sum] = "039d9506f2b6c1fda2ef65e9ce39b94c122f97011dc49022201d3157f7fc5ada"

URI_x86_64_v2_kf6-kdbusaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdbusaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons-doc}"
SRC_URI[x86_64_v2_kf6-kdbusaddons-doc.sha256sum] = "59ec4549af9fbde044a4545419cb3ccdbe7c6f39ebd84e1e9b53d8fa00bfd80c"

URI_x86_64_v2_kf6-kdbusaddons-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdbusaddons-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons-html}"
SRC_URI[x86_64_v2_kf6-kdbusaddons-html.sha256sum] = "9247298b8ce0cbf01748b6211121a28889f6f7d341f5e8b39f9407ce874ae54a"

URI_aarch64_kf6-kdbusaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kdbusaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons}"
SRC_URI[aarch64_kf6-kdbusaddons.sha256sum] = "5b23fae29bfb242255e94691d8f081cca2031813272c5d860ca0914bfad39999"

URI_aarch64_kf6-kdbusaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kdbusaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons-devel}"
SRC_URI[aarch64_kf6-kdbusaddons-devel.sha256sum] = "164e113e199c79dbfb4d80ec9826352ad930f6c3d1660fc6416a0ac99e5028b5"

URI_aarch64_kf6-kdbusaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kdbusaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons-doc}"
SRC_URI[aarch64_kf6-kdbusaddons-doc.sha256sum] = "29ab510d690dc9be206464689304d9ea644510cdcb458b5323a41243f2e3f79e"

URI_aarch64_kf6-kdbusaddons-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kdbusaddons-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons-html}"
SRC_URI[aarch64_kf6-kdbusaddons-html.sha256sum] = "d4eb22748f4d344bf8ed85a9260f2f045eaaeabec16918be9065a8262d9edf95"

RDEPENDS:kf6-kdbusaddons = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kdbusaddons-devel = " \
 cmake-filesystem \
 kf6-kdbusaddons \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdbusaddons-doc = " \
 "
RDEPENDS:kf6-kdbusaddons-html = " \
 "
