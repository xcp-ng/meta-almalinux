# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-widestring"
PV = "1.2.1"
PR = "3.el10_1"
PACKAGES = " \
 rust-widestring+alloc-devel \
 rust-widestring+default-devel \
 rust-widestring+std-devel \
 rust-widestring-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-widestring-1.2.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "264cbdb67d7e419d53bb630aaf5a60ed32bbe6802db8c5b439b834c17e0140c5"

URI_x86_64_v2_rust-widestring+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-widestring+alloc-devel-1.2.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-widestring+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-widestring+alloc-devel}"
SRC_URI[x86_64_v2_rust-widestring+alloc-devel.sha256sum] = "eece212da7afa7b8e89568c3dc8db965b8a168bc7423d6c654eed69ae6840830"

URI_x86_64_v2_rust-widestring+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-widestring+default-devel-1.2.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-widestring+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-widestring+default-devel}"
SRC_URI[x86_64_v2_rust-widestring+default-devel.sha256sum] = "b6639a082f7b81fc2b716f136db92e63ebbc065dbc3401405504de73902ddb56"

URI_x86_64_v2_rust-widestring+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-widestring+std-devel-1.2.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-widestring+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-widestring+std-devel}"
SRC_URI[x86_64_v2_rust-widestring+std-devel.sha256sum] = "af076bdfaf7f2eeda24cf704d45a0ebd444c02af7964a41fed370fa470075106"

URI_x86_64_v2_rust-widestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-widestring-devel-1.2.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-widestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-widestring-devel}"
SRC_URI[x86_64_v2_rust-widestring-devel.sha256sum] = "a23efe6373552f319357176b8d04ba74541eafb26ec6c22aa0aa51a9e6f41f7d"

URI_aarch64_rust-widestring+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-widestring+alloc-devel-1.2.1-3.el10_1.noarch.rpm;name=aarch64_rust-widestring+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-widestring+alloc-devel}"
SRC_URI[aarch64_rust-widestring+alloc-devel.sha256sum] = "4e5e6d8d82775303be273e22643c96425ccc0bdb67c62aead032b2658cab39a7"

URI_aarch64_rust-widestring+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-widestring+default-devel-1.2.1-3.el10_1.noarch.rpm;name=aarch64_rust-widestring+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-widestring+default-devel}"
SRC_URI[aarch64_rust-widestring+default-devel.sha256sum] = "a861e4220e38187d9c07c3dba8c6200d49a0b1f679fdb32b23ae62dfc1864e8e"

URI_aarch64_rust-widestring+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-widestring+std-devel-1.2.1-3.el10_1.noarch.rpm;name=aarch64_rust-widestring+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-widestring+std-devel}"
SRC_URI[aarch64_rust-widestring+std-devel.sha256sum] = "a040a8d1693725e01245ca5a82cd59b52ddb9128e593f58b64b35c81de8c9170"

URI_aarch64_rust-widestring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-widestring-devel-1.2.1-3.el10_1.noarch.rpm;name=aarch64_rust-widestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-widestring-devel}"
SRC_URI[aarch64_rust-widestring-devel.sha256sum] = "7167d12a134a7a66c31f96fe640ccef2131e23df1e00fabed01880da6f495055"

RDEPENDS:rust-widestring+alloc-devel = " \
 cargo \
 rust-widestring-devel \
 "
RDEPENDS:rust-widestring+default-devel = " \
 cargo \
 rust-widestring+std-devel \
 rust-widestring-devel \
 "
RDEPENDS:rust-widestring+std-devel = " \
 cargo \
 rust-widestring+alloc-devel \
 rust-widestring-devel \
 "
RDEPENDS:rust-widestring-devel = " \
 cargo \
 rust \
 "
