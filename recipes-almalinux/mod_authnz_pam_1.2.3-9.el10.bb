# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_authnz_pam"
PV = "1.2.3"
PR = "9.el10"
PACKAGES = " \
 mod_authnz_pam \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_authnz_pam-1.2.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e4f6e911d664cf5beff46c1ce83ac28f2b52f0872ad272c118aa4ae7efbca81"

URI_x86_64_v2_mod_authnz_pam = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_authnz_pam-1.2.3-9.el10.x86_64_v2.rpm;name=x86_64_v2_mod_authnz_pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_authnz_pam}"
SRC_URI[x86_64_v2_mod_authnz_pam.sha256sum] = "bc9a5ca210a3b9bf38ef84e66bb69d53a3ca93b73090095a2cc5abc91f32decb"

URI_aarch64_mod_authnz_pam = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_authnz_pam-1.2.3-9.el10.aarch64.rpm;name=aarch64_mod_authnz_pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_authnz_pam}"
SRC_URI[aarch64_mod_authnz_pam.sha256sum] = "4423f86a06d12fb83143172a44802640e3d263928a730954d325a80e1547352d"

RDEPENDS:mod_authnz_pam = " \
 glibc \
 httpd-core \
 pam \
 pam-libs \
 "
