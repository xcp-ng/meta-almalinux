# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-astropy-iers-data"
PV = "0.2026.7.6.1.1.20"
PR = "1.el10_2"
PACKAGES = " \
 python3-astropy-iers-data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-astropy-iers-data-0.2026.7.6.1.1.20-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0de67c84d503af271b5441f1dc5befee7dcd8ca461cccf457ccf78801a03488"

URI_x86_64_v2_python3-astropy-iers-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-astropy-iers-data-0.2026.7.6.1.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-astropy-iers-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-astropy-iers-data}"
SRC_URI[x86_64_v2_python3-astropy-iers-data.sha256sum] = "b9eed54dfe9192c9a288272c04b28167a2364c8cfaac22c621b939cf32e59e3f"

URI_aarch64_python3-astropy-iers-data = "${EPEL_MIRROR}/aarch64/Packages/p/python3-astropy-iers-data-0.2026.7.6.1.1.20-1.el10_2.noarch.rpm;name=aarch64_python3-astropy-iers-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-astropy-iers-data}"
SRC_URI[aarch64_python3-astropy-iers-data.sha256sum] = "5776070feb997ec48f07f88d645b578b3bb2d7c9fbfbb13528906cac40c0208d"

RDEPENDS:python3-astropy-iers-data = " \
 python3 \
 "
