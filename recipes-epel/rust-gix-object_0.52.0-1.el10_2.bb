# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-object"
PV = "0.52.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-object+default-devel \
 rust-gix-object+document-features-devel \
 rust-gix-object+serde-devel \
 rust-gix-object+verbose-object-parsing-errors-devel \
 rust-gix-object-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-object-0.52.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bdff844a8d3e0d74ff4d08f66794d92e5d8e8752f810cf634266b8195bc85c4"

URI_x86_64_v2_rust-gix-object+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+default-devel-0.52.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+default-devel}"
SRC_URI[x86_64_v2_rust-gix-object+default-devel.sha256sum] = "ca2f24f3d69c283937d4f40363b8c7df154c31d7c74166f491d9baeeadefd631"

URI_x86_64_v2_rust-gix-object+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+document-features-devel-0.52.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-object+document-features-devel.sha256sum] = "e3bee07d4a1258dd421feda26f61be0fbf30eed290f622bf95e5b49dda355eae"

URI_x86_64_v2_rust-gix-object+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+serde-devel-0.52.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-object+serde-devel.sha256sum] = "9936d74166920d88f286f2094651fdbd22f5ba4ee7811839e36421d65d05c718"

URI_x86_64_v2_rust-gix-object+verbose-object-parsing-errors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+verbose-object-parsing-errors-devel-0.52.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+verbose-object-parsing-errors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+verbose-object-parsing-errors-devel}"
SRC_URI[x86_64_v2_rust-gix-object+verbose-object-parsing-errors-devel.sha256sum] = "0650af8d3ebee4c948399c2aadac844aa98ea77ae2681b84dca9ec3870306035"

URI_x86_64_v2_rust-gix-object-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object-devel-0.52.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object-devel}"
SRC_URI[x86_64_v2_rust-gix-object-devel.sha256sum] = "359d1f5071954e4855aa10523dc12660169c76a0892e364661296cd0333fc6da"

URI_aarch64_rust-gix-object+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+default-devel-0.52.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+default-devel}"
SRC_URI[aarch64_rust-gix-object+default-devel.sha256sum] = "57b3a5087b84200a3ed5cc7e885d61b795ced2cb2f1bb06d10bb5b5273233564"

URI_aarch64_rust-gix-object+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+document-features-devel-0.52.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-object+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+document-features-devel}"
SRC_URI[aarch64_rust-gix-object+document-features-devel.sha256sum] = "71824098524e5239c518615b471d5a31dfd4ad712dee5bafdf849492d7cbda7d"

URI_aarch64_rust-gix-object+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+serde-devel-0.52.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-object+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+serde-devel}"
SRC_URI[aarch64_rust-gix-object+serde-devel.sha256sum] = "a7997fd6218092d7f367a256ed84129f22785e2db5e09a873fc440dcdffaa1b9"

URI_aarch64_rust-gix-object+verbose-object-parsing-errors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+verbose-object-parsing-errors-devel-0.52.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-object+verbose-object-parsing-errors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+verbose-object-parsing-errors-devel}"
SRC_URI[aarch64_rust-gix-object+verbose-object-parsing-errors-devel.sha256sum] = "a72ef9214002d53aa14571ecd38aa3cb2afe7499cf4a20a362ddeef81586c478"

URI_aarch64_rust-gix-object-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object-devel-0.52.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-object-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object-devel}"
SRC_URI[aarch64_rust-gix-object-devel.sha256sum] = "31857406bc9ca7770b24d0f663811f1b782742e6225312cabfda0fc854471767"

RDEPENDS:rust-gix-object+default-devel = " \
 cargo \
 rust-gix-object-devel \
 "
RDEPENDS:rust-gix-object+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-object-devel \
 "
RDEPENDS:rust-gix-object+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-actor+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-object-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-smallvec+serde-devel \
 "
RDEPENDS:rust-gix-object+verbose-object-parsing-errors-devel = " \
 cargo \
 rust-gix-object-devel \
 rust-winnow+std-devel \
 "
RDEPENDS:rust-gix-object-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-actor+default-devel \
 rust-gix-date+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-path+default-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-itoa+default-devel \
 rust-smallvec+default-devel \
 rust-smallvec+write-devel \
 rust-thiserror+default-devel \
 rust-winnow+default-devel \
 rust-winnow+simd-devel \
 "
