# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clru"
PV = "0.6.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-clru+default-devel \
 rust-clru-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clru-0.6.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fdfcd1792654aa00d49a8a56310e2a055ad00e3966d49ccc9282615a9a0a5b2"

URI_x86_64_v2_rust-clru+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clru+default-devel-0.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clru+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clru+default-devel}"
SRC_URI[x86_64_v2_rust-clru+default-devel.sha256sum] = "057fc0f134437a656bfaa7cc239061df9281f9394cbbd954f494c3fb78c42dc3"

URI_x86_64_v2_rust-clru-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clru-devel-0.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clru-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clru-devel}"
SRC_URI[x86_64_v2_rust-clru-devel.sha256sum] = "694d553f12ca75780319ce4389cd49b1f27053989b7c6a4e5d557ac515b913f6"

URI_aarch64_rust-clru+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clru+default-devel-0.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clru+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clru+default-devel}"
SRC_URI[aarch64_rust-clru+default-devel.sha256sum] = "68df84173cf56e732a1fb899e0e81817f60e2ea691a2e3040420ca654f14d7f4"

URI_aarch64_rust-clru-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clru-devel-0.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clru-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clru-devel}"
SRC_URI[aarch64_rust-clru-devel.sha256sum] = "ae81727165198212ababda2ad0096172047cbadf69b9a3c9d778a129c6a48d08"

RDEPENDS:rust-clru+default-devel = " \
 cargo \
 rust-clru-devel \
 "
RDEPENDS:rust-clru-devel = " \
 cargo \
 rust-hashbrown+default-devel \
 "
