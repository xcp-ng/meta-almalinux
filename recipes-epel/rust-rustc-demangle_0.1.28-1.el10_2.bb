# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustc-demangle"
PV = "0.1.28"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustc-demangle+default-devel \
 rust-rustc-demangle+std-devel \
 rust-rustc-demangle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustc-demangle-0.1.28-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3d924544baca8eae04e1ba6376a2978cd8856e7c68b327b4871e779cd603afd"

URI_x86_64_v2_rust-rustc-demangle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-demangle+default-devel-0.1.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-demangle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-demangle+default-devel}"
SRC_URI[x86_64_v2_rust-rustc-demangle+default-devel.sha256sum] = "1875612a00d508fbe7c497fb59fd7fbfa9a8e70ebf3a388549a691a20b1fc32f"

URI_x86_64_v2_rust-rustc-demangle+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-demangle+std-devel-0.1.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-demangle+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-demangle+std-devel}"
SRC_URI[x86_64_v2_rust-rustc-demangle+std-devel.sha256sum] = "d4c77bcc84f6b3b64a1cf0870e7f9871059fe3cffc7958bd82d5315103b70fe5"

URI_x86_64_v2_rust-rustc-demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-demangle-devel-0.1.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-demangle-devel}"
SRC_URI[x86_64_v2_rust-rustc-demangle-devel.sha256sum] = "bdf8534f3f1170a4fcc3f08ec7bd3d0f5b0a44bfa3f10c16e8153dfc48554b1d"

URI_aarch64_rust-rustc-demangle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-demangle+default-devel-0.1.28-1.el10_2.noarch.rpm;name=aarch64_rust-rustc-demangle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-demangle+default-devel}"
SRC_URI[aarch64_rust-rustc-demangle+default-devel.sha256sum] = "7ae90228f9a155d05f6894e9f48723775a62a5ec581d3d2bdb85442eea8d5e32"

URI_aarch64_rust-rustc-demangle+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-demangle+std-devel-0.1.28-1.el10_2.noarch.rpm;name=aarch64_rust-rustc-demangle+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-demangle+std-devel}"
SRC_URI[aarch64_rust-rustc-demangle+std-devel.sha256sum] = "0faf4c7ec98cf48dd5f090afb2fd3f11084290632d700b407ba4d9ff09db1dc6"

URI_aarch64_rust-rustc-demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-demangle-devel-0.1.28-1.el10_2.noarch.rpm;name=aarch64_rust-rustc-demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-demangle-devel}"
SRC_URI[aarch64_rust-rustc-demangle-devel.sha256sum] = "ebcd5d5b0681423d144b9f2a145e872c9bd1a129870f2b4141ecd31da9725a75"

RDEPENDS:rust-rustc-demangle+default-devel = " \
 cargo \
 rust-rustc-demangle-devel \
 "
RDEPENDS:rust-rustc-demangle+std-devel = " \
 cargo \
 rust-rustc-demangle-devel \
 "
RDEPENDS:rust-rustc-demangle-devel = " \
 cargo \
 "
