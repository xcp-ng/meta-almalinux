# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oneapi-level-zero"
PV = "1.28.6"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 oneapi-level-zero \
 oneapi-level-zero-devel \
 oneapi-level-zero-zello_world \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/o/oneapi-level-zero-1.28.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53cc783c2180e377e7afbe144c1521a8f3d15cb2ed26409af63465c405cc2a8b"

URI_x86_64_v2_oneapi-level-zero = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oneapi-level-zero-1.28.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oneapi-level-zero;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oneapi-level-zero}"
SRC_URI[x86_64_v2_oneapi-level-zero.sha256sum] = "43594a81418179ba91a79b4e05474d216ed93ef730a13b21e11bf70da69f8d6d"

URI_x86_64_v2_oneapi-level-zero-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oneapi-level-zero-devel-1.28.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oneapi-level-zero-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oneapi-level-zero-devel}"
SRC_URI[x86_64_v2_oneapi-level-zero-devel.sha256sum] = "b6bfec0bc1bfeb3d4d4fd93122722c48932b6b7602f4e97af362c5e995865ec5"

URI_x86_64_v2_oneapi-level-zero-zello_world = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oneapi-level-zero-zello_world-1.28.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oneapi-level-zero-zello_world;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oneapi-level-zero-zello_world}"
SRC_URI[x86_64_v2_oneapi-level-zero-zello_world.sha256sum] = "9bf2aed1fda7b9b41664bc24436c85e49283d7dd97f4ccdf4f46082e1a7ba612"

RDEPENDS:oneapi-level-zero = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:oneapi-level-zero-devel = " \
 oneapi-level-zero \
 oneapi-level-zero-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:oneapi-level-zero-zello_world = " \
 glibc \
 libgcc \
 libstdc++ \
 oneapi-level-zero \
 "
