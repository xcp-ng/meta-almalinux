# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-smi"
PV = "7.1.1"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 rocm-smi \
 rocm-smi-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-smi-7.1.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6a5c65f2f1ab6c8a9480f84796f38b5156b3642bf8e8a263f94f6d517ee0b5c"

URI_x86_64_v2_rocm-smi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-smi-7.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-smi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-smi}"
SRC_URI[x86_64_v2_rocm-smi.sha256sum] = "4cc76917e98867508eeba5a0e1a2141916a0c3310ad9c0b5fa56f1a0c131a49e"

URI_x86_64_v2_rocm-smi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-smi-devel-7.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-smi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-smi-devel}"
SRC_URI[x86_64_v2_rocm-smi-devel.sha256sum] = "43a6607f5b81c2a7417143cf9ce271e14754a10bae96d7d9128751152e9ce9ce"

RDEPENDS:rocm-smi = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:rocm-smi-devel = " \
 cmake-filesystem \
 libdrm-devel \
 rocm-smi \
 "
