# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-string-cases"
PV = "0.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-string-cases+default-devel \
 rust-string-cases-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-string-cases-0.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ce2fe679a9f89ccb458cee5a934f49a7e77ae75cd5897c08186087ff90cfd30"

URI_x86_64_v2_rust-string-cases+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string-cases+default-devel-0.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string-cases+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string-cases+default-devel}"
SRC_URI[x86_64_v2_rust-string-cases+default-devel.sha256sum] = "41aaba8493c487caab57767be0da542bbb74bbcc50352056a621de76d622583c"

URI_x86_64_v2_rust-string-cases-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string-cases-devel-0.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string-cases-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string-cases-devel}"
SRC_URI[x86_64_v2_rust-string-cases-devel.sha256sum] = "01057b10fc41cdb20b362d5ef0f523e1ab3f854b3f0ac4dd62f23cca7d1ac611"

URI_aarch64_rust-string-cases+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string-cases+default-devel-0.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-string-cases+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string-cases+default-devel}"
SRC_URI[aarch64_rust-string-cases+default-devel.sha256sum] = "f49bc9c4de3e802ca331649b14c8dba853380f5532ebe707e8b19e2dbdde1e12"

URI_aarch64_rust-string-cases-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string-cases-devel-0.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-string-cases-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string-cases-devel}"
SRC_URI[aarch64_rust-string-cases-devel.sha256sum] = "bb5d5e942a04ed033e560022edfa6bd32b88919fbaaeb3fcc19c9cd18b704406"

RDEPENDS:rust-string-cases+default-devel = " \
 cargo \
 rust-string-cases-devel \
 "
RDEPENDS:rust-string-cases-devel = " \
 cargo \
 "
