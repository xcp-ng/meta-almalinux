# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proptest"
PV = "1.7.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-proptest+alloc-devel \
 rust-proptest+atomic64bit-devel \
 rust-proptest+attr-macro-devel \
 rust-proptest+bit-set-devel \
 rust-proptest+default-code-coverage-devel \
 rust-proptest+default-devel \
 rust-proptest+fork-devel \
 rust-proptest+handle-panics-devel \
 rust-proptest+lazy_static-devel \
 rust-proptest+no_std-devel \
 rust-proptest+proptest-macro-devel \
 rust-proptest+regex-syntax-devel \
 rust-proptest+rusty-fork-devel \
 rust-proptest+std-devel \
 rust-proptest+tempfile-devel \
 rust-proptest+timeout-devel \
 rust-proptest+unstable-devel \
 rust-proptest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proptest-1.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48c913d8ca098bb58302d1dbc3bfdb37500525ac460c5c8e429968d644cff152"

URI_x86_64_v2_rust-proptest+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+alloc-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+alloc-devel}"
SRC_URI[x86_64_v2_rust-proptest+alloc-devel.sha256sum] = "0a0d1474bd35f1283ff66d0dfda2f0fd5bcf5ff1e713e341ed1802e66fc13e1d"

URI_x86_64_v2_rust-proptest+atomic64bit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+atomic64bit-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+atomic64bit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+atomic64bit-devel}"
SRC_URI[x86_64_v2_rust-proptest+atomic64bit-devel.sha256sum] = "77a4e416a216c68850e71d21248acc7ac3aa4196992bd9d9b787d2b8a371284f"

URI_x86_64_v2_rust-proptest+attr-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+attr-macro-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+attr-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+attr-macro-devel}"
SRC_URI[x86_64_v2_rust-proptest+attr-macro-devel.sha256sum] = "a772a346c2a07446032875c30b28620092f61a3cf1e45f35d542d77041639100"

URI_x86_64_v2_rust-proptest+bit-set-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+bit-set-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+bit-set-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+bit-set-devel}"
SRC_URI[x86_64_v2_rust-proptest+bit-set-devel.sha256sum] = "9bd8e8a2346cb4bcc46d3d7b8bcffd8a41af3aaa748c6a6dd828a2b49d800671"

URI_x86_64_v2_rust-proptest+default-code-coverage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+default-code-coverage-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+default-code-coverage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+default-code-coverage-devel}"
SRC_URI[x86_64_v2_rust-proptest+default-code-coverage-devel.sha256sum] = "e3e1b0bd0c3fa263eba7a759a4f3a9f0fdb99bad47ff9f3c5cc055f1bcb186aa"

URI_x86_64_v2_rust-proptest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+default-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+default-devel}"
SRC_URI[x86_64_v2_rust-proptest+default-devel.sha256sum] = "39788ab89c601d8d983b1a2f5e0792b2c1550e9cfd79364f9efd4c0457b510ba"

URI_x86_64_v2_rust-proptest+fork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+fork-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+fork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+fork-devel}"
SRC_URI[x86_64_v2_rust-proptest+fork-devel.sha256sum] = "5af059c8471f67f9f6abc633818a68c85108e67d03548c7e5edc4959c83f2f43"

URI_x86_64_v2_rust-proptest+handle-panics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+handle-panics-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+handle-panics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+handle-panics-devel}"
SRC_URI[x86_64_v2_rust-proptest+handle-panics-devel.sha256sum] = "e92094d1a84074fb8bc7a12b43b69a8c66643a0c25975600962b8a211f8cb257"

URI_x86_64_v2_rust-proptest+lazy_static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+lazy_static-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+lazy_static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+lazy_static-devel}"
SRC_URI[x86_64_v2_rust-proptest+lazy_static-devel.sha256sum] = "5f687941fdd25747680212c8a9f6d0e833debc1e09957a00effe1c1553258111"

URI_x86_64_v2_rust-proptest+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+no_std-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+no_std-devel}"
SRC_URI[x86_64_v2_rust-proptest+no_std-devel.sha256sum] = "629b2d8457b208726f4d3c423ad6d08daa4105c5711d4328d984a212a1f3fbfe"

URI_x86_64_v2_rust-proptest+proptest-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+proptest-macro-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+proptest-macro-devel}"
SRC_URI[x86_64_v2_rust-proptest+proptest-macro-devel.sha256sum] = "46ed8e7f1a0330bc7ba9d44c00788a79f61c4c3bf1c32e59f99fb5d0ec9b70b4"

URI_x86_64_v2_rust-proptest+regex-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+regex-syntax-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+regex-syntax-devel}"
SRC_URI[x86_64_v2_rust-proptest+regex-syntax-devel.sha256sum] = "92915f2899a6905895013391e3224596ccee9e8100f5b26b7ec1a0b95ae2a653"

URI_x86_64_v2_rust-proptest+rusty-fork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+rusty-fork-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+rusty-fork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+rusty-fork-devel}"
SRC_URI[x86_64_v2_rust-proptest+rusty-fork-devel.sha256sum] = "c4f5b568d07f5f2bf719c333e0d42f07f11d4e4bfce27892924eb14dd040e61e"

URI_x86_64_v2_rust-proptest+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+std-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+std-devel}"
SRC_URI[x86_64_v2_rust-proptest+std-devel.sha256sum] = "fe9c026821efd670ca4715cb66dcb8aeea517a3caef6d7474f947f2b0d1f257a"

URI_x86_64_v2_rust-proptest+tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+tempfile-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+tempfile-devel}"
SRC_URI[x86_64_v2_rust-proptest+tempfile-devel.sha256sum] = "645ce81e016f05dbde27c8c944b23882717da7256718a7b391c90700d0d00418"

URI_x86_64_v2_rust-proptest+timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+timeout-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+timeout-devel}"
SRC_URI[x86_64_v2_rust-proptest+timeout-devel.sha256sum] = "6d913c18aaf9e7528c6f23c93f376020316ccef5820ecbe0de9c2d6f201800a1"

URI_x86_64_v2_rust-proptest+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+unstable-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+unstable-devel}"
SRC_URI[x86_64_v2_rust-proptest+unstable-devel.sha256sum] = "5f5ddc8c54717c849c209c968aa10a86e8f225d9194a739f9ea1cf81e6c5ddea"

URI_x86_64_v2_rust-proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-devel-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-devel}"
SRC_URI[x86_64_v2_rust-proptest-devel.sha256sum] = "a97be069404504d260aa62f1fe38508526a2904111ecd45a570b2b44ed715455"

URI_aarch64_rust-proptest+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+alloc-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+alloc-devel}"
SRC_URI[aarch64_rust-proptest+alloc-devel.sha256sum] = "18384e91c9b9c3cea136a6e3e64723a97c99e61167c4149484b3612b2d936005"

URI_aarch64_rust-proptest+atomic64bit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+atomic64bit-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+atomic64bit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+atomic64bit-devel}"
SRC_URI[aarch64_rust-proptest+atomic64bit-devel.sha256sum] = "6a75875b42f9e03b6a56e129c9dd2a0297480442e9e262159194c01dcde86161"

URI_aarch64_rust-proptest+attr-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+attr-macro-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+attr-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+attr-macro-devel}"
SRC_URI[aarch64_rust-proptest+attr-macro-devel.sha256sum] = "4c75b147a350bd911acaf1ad5b26916b53b72a01ff2c3a5f914f68c5f0b7ede5"

URI_aarch64_rust-proptest+bit-set-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+bit-set-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+bit-set-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+bit-set-devel}"
SRC_URI[aarch64_rust-proptest+bit-set-devel.sha256sum] = "ba67767e325c0c5de44cf4b456d069d56a81c6e9fecf74d18fb4901a6989a9ef"

URI_aarch64_rust-proptest+default-code-coverage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+default-code-coverage-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+default-code-coverage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+default-code-coverage-devel}"
SRC_URI[aarch64_rust-proptest+default-code-coverage-devel.sha256sum] = "a3067a3ce2cfa12282e904f970e72e33503abe34290b83a84662a31946772f7b"

URI_aarch64_rust-proptest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+default-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+default-devel}"
SRC_URI[aarch64_rust-proptest+default-devel.sha256sum] = "89759b7d302688e8946db8d065de6b9242b24076a065ef60e848ab972a337b75"

URI_aarch64_rust-proptest+fork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+fork-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+fork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+fork-devel}"
SRC_URI[aarch64_rust-proptest+fork-devel.sha256sum] = "04ced1fdf007dbf5291fb2482ee856385395137785432de0fe3f46228b9e06b4"

URI_aarch64_rust-proptest+handle-panics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+handle-panics-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+handle-panics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+handle-panics-devel}"
SRC_URI[aarch64_rust-proptest+handle-panics-devel.sha256sum] = "a643463370621c03d70153f29d2c4a4226870edfe96f18b14ca515571959220e"

URI_aarch64_rust-proptest+lazy_static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+lazy_static-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+lazy_static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+lazy_static-devel}"
SRC_URI[aarch64_rust-proptest+lazy_static-devel.sha256sum] = "da83c6ff88597c23e2f08ea2278facedaff76bcd3ba0d67975dbb9bc40e65cc8"

URI_aarch64_rust-proptest+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+no_std-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+no_std-devel}"
SRC_URI[aarch64_rust-proptest+no_std-devel.sha256sum] = "cac7ad0b9c1c0a3d54fc581c33b4be1514bd4d36cf7fd01ac2b716c1dc91ef21"

URI_aarch64_rust-proptest+proptest-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+proptest-macro-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+proptest-macro-devel}"
SRC_URI[aarch64_rust-proptest+proptest-macro-devel.sha256sum] = "c4b2d64ff658eadcceeec2fc64fb5a64a8cb91a05da8d5e1a95242303e4a0813"

URI_aarch64_rust-proptest+regex-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+regex-syntax-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+regex-syntax-devel}"
SRC_URI[aarch64_rust-proptest+regex-syntax-devel.sha256sum] = "43883fe2450dc0602efed1109b3251becb312c1584127dd06cda8922fb0d42ad"

URI_aarch64_rust-proptest+rusty-fork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+rusty-fork-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+rusty-fork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+rusty-fork-devel}"
SRC_URI[aarch64_rust-proptest+rusty-fork-devel.sha256sum] = "cb8150ccf1e9c761c6e2624a3965168a4d22989f4702f526572617e36508b866"

URI_aarch64_rust-proptest+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+std-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+std-devel}"
SRC_URI[aarch64_rust-proptest+std-devel.sha256sum] = "71233dd7e545997f121dd2c95fb82b53a0c17b81d0449c79dbea40b7136a262d"

URI_aarch64_rust-proptest+tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+tempfile-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+tempfile-devel}"
SRC_URI[aarch64_rust-proptest+tempfile-devel.sha256sum] = "8df0c72def964b8102e61fa1165bbbcd366f980da786d5290fe065cbc5a902f4"

URI_aarch64_rust-proptest+timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+timeout-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+timeout-devel}"
SRC_URI[aarch64_rust-proptest+timeout-devel.sha256sum] = "83d34fe5757ea95206327b6b58f5a4c9e32c3025347832d4a499d7d218d6d242"

URI_aarch64_rust-proptest+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+unstable-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+unstable-devel}"
SRC_URI[aarch64_rust-proptest+unstable-devel.sha256sum] = "a4ab7e8520b3c1817faddfaa730fa811c1244b6ba642a0f2eef0c0e8c10cfb7c"

URI_aarch64_rust-proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-devel-1.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-devel}"
SRC_URI[aarch64_rust-proptest-devel.sha256sum] = "0a061fd07da26d1bd6f1cdf46958111a1bda7c8d133c87cb69e8de26c8a8a849"

RDEPENDS:rust-proptest+alloc-devel = " \
 cargo \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+atomic64bit-devel = " \
 cargo \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+attr-macro-devel = " \
 cargo \
 rust-proptest+proptest-macro-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+bit-set-devel = " \
 cargo \
 rust-bit-set+default-devel \
 rust-bit-vec+default-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+default-code-coverage-devel = " \
 cargo \
 rust-proptest+bit-set-devel \
 rust-proptest+fork-devel \
 rust-proptest+std-devel \
 rust-proptest+timeout-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+default-devel = " \
 cargo \
 rust-proptest+bit-set-devel \
 rust-proptest+fork-devel \
 rust-proptest+std-devel \
 rust-proptest+timeout-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+fork-devel = " \
 cargo \
 rust-proptest+rusty-fork-devel \
 rust-proptest+std-devel \
 rust-proptest+tempfile-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+handle-panics-devel = " \
 cargo \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+lazy_static-devel = " \
 cargo \
 rust-lazy_static+default-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+no_std-devel = " \
 cargo \
 rust-num-traits+libm-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+proptest-macro-devel = " \
 cargo \
 rust-proptest-devel \
 rust-proptest-macro+default-devel \
 "
RDEPENDS:rust-proptest+regex-syntax-devel = " \
 cargo \
 rust-proptest-devel \
 rust-regex-syntax+default-devel \
 "
RDEPENDS:rust-proptest+rusty-fork-devel = " \
 cargo \
 rust-proptest-devel \
 rust-rusty-fork-devel \
 "
RDEPENDS:rust-proptest+std-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-proptest+lazy_static-devel \
 rust-proptest+regex-syntax-devel \
 rust-proptest-devel \
 rust-rand+os_rng-devel \
 rust-rand+std-devel \
 "
RDEPENDS:rust-proptest+tempfile-devel = " \
 cargo \
 rust-proptest-devel \
 rust-tempfile+default-devel \
 "
RDEPENDS:rust-proptest+timeout-devel = " \
 cargo \
 rust-proptest+fork-devel \
 rust-proptest-devel \
 rust-rusty-fork+timeout-devel \
 rust-rusty-fork-devel \
 "
RDEPENDS:rust-proptest+unstable-devel = " \
 cargo \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-num-traits-devel \
 rust-rand+alloc-devel \
 rust-rand-devel \
 rust-rand_chacha-devel \
 rust-rand_xorshift+default-devel \
 rust-unarray+default-devel \
 "
