# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-credential-libsecret"
PV = "0.4.14"
PR = "1.el10_1"
PACKAGES = " \
 rust-cargo-credential-libsecret+default-devel \
 rust-cargo-credential-libsecret-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-credential-libsecret-0.4.14-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4079d3157399a7c7e1cbbccf5ea37a7670e3c3cc369267613a1ca886f2a737d"

URI_x86_64_v2_rust-cargo-credential-libsecret+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-credential-libsecret+default-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-credential-libsecret+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-credential-libsecret+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-credential-libsecret+default-devel.sha256sum] = "13b236728afa3918b5841f8b9ab9444c9de250ad696fb4fe0db4d3d35b0bf9bf"

URI_x86_64_v2_rust-cargo-credential-libsecret-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-credential-libsecret-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-credential-libsecret-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-credential-libsecret-devel}"
SRC_URI[x86_64_v2_rust-cargo-credential-libsecret-devel.sha256sum] = "b2a95972bbb47e49dea7456068ee2e3274a956dc15a0dd469a8eebb33e67106d"

URI_aarch64_rust-cargo-credential-libsecret+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-credential-libsecret+default-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-cargo-credential-libsecret+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-credential-libsecret+default-devel}"
SRC_URI[aarch64_rust-cargo-credential-libsecret+default-devel.sha256sum] = "1b41617c591e330f53fdb6dac4335ab9d407e10a1287ea8fac0bf2f8cfa0cc99"

URI_aarch64_rust-cargo-credential-libsecret-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-credential-libsecret-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-cargo-credential-libsecret-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-credential-libsecret-devel}"
SRC_URI[aarch64_rust-cargo-credential-libsecret-devel.sha256sum] = "19e02d94769ac356284d891a44bca9cea8246d5a4b9bd261b33267841061191b"

RDEPENDS:rust-cargo-credential-libsecret+default-devel = " \
 cargo \
 rust-cargo-credential-libsecret-devel \
 "
RDEPENDS:rust-cargo-credential-libsecret-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-cargo-credential+default-devel \
 rust-libloading+default-devel \
 "
