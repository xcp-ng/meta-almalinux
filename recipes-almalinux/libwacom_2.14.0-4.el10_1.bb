# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libwacom"
PV = "2.14.0"
PR = "4.el10_1"
PACKAGES = " \
 libwacom \
 libwacom-data \
 libwacom-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libwacom-2.14.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b694c1c3fed05cd4d77f569fac7c71f2ce75c2af09528dc4e77eefc289f778f1"

URI_x86_64_v2_libwacom = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwacom-2.14.0-4.el10_1.x86_64_v2.rpm;name=x86_64_v2_libwacom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwacom}"
SRC_URI[x86_64_v2_libwacom.sha256sum] = "6d53f8d1a81937a1b72d0f562d4610fc2d6f599dbe985ff5bb501aef6cba4ee7"

URI_x86_64_v2_libwacom-data = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwacom-data-2.14.0-4.el10_1.noarch.rpm;name=x86_64_v2_libwacom-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwacom-data}"
SRC_URI[x86_64_v2_libwacom-data.sha256sum] = "79ddba3fcfdbc52fd29302dae77ee9fc29ba12ad5bde8844c53705fe84b5213e"

URI_x86_64_v2_libwacom-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwacom-devel-2.14.0-4.el10_1.x86_64_v2.rpm;name=x86_64_v2_libwacom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwacom-devel}"
SRC_URI[x86_64_v2_libwacom-devel.sha256sum] = "e8af1d807b9a25d1a3d0602c5cd777ae4a0960ba97cc39dc8d2b8eef52d78452"

URI_aarch64_libwacom = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwacom-2.14.0-4.el10_1.aarch64.rpm;name=aarch64_libwacom;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwacom}"
SRC_URI[aarch64_libwacom.sha256sum] = "f29943c96e32256b9a27dcfdd0a5bc69c70eb17ed5457e6e4b4376079e7a7186"

URI_aarch64_libwacom-data = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwacom-data-2.14.0-4.el10_1.noarch.rpm;name=aarch64_libwacom-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwacom-data}"
SRC_URI[aarch64_libwacom-data.sha256sum] = "79ddba3fcfdbc52fd29302dae77ee9fc29ba12ad5bde8844c53705fe84b5213e"

URI_aarch64_libwacom-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwacom-devel-2.14.0-4.el10_1.aarch64.rpm;name=aarch64_libwacom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwacom-devel}"
SRC_URI[aarch64_libwacom-devel.sha256sum] = "7473b45aa1cc76ac023ae8c7a1b6d4b681a7703989ed81a9889e8a90e9c5cacc"

RDEPENDS:libwacom = " \
 glib2 \
 glibc \
 libevdev \
 libgudev \
 libwacom-data \
 python3 \
 "
RDEPENDS:libwacom-data = " \
 "
RDEPENDS:libwacom-devel = " \
 glib2-devel \
 libevdev-devel \
 libgudev-devel \
 libwacom \
 pkgconf-pkg-config \
 "
