# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpkpass"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kpkpass \
 kpkpass-devel \
 kpkpass-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpkpass-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "644af0daf5de6cae9597e2f37398211f2a210847e8bf7845c539161040549faf"

URI_x86_64_v2_kpkpass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpkpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpkpass}"
SRC_URI[x86_64_v2_kpkpass.sha256sum] = "838e914a92faf1061315718a3e8eee8064a6603bbd74f8dddff4fa57be130ca4"

URI_x86_64_v2_kpkpass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpkpass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpkpass-devel}"
SRC_URI[x86_64_v2_kpkpass-devel.sha256sum] = "b0fc32ca733ef31363b3f74b4ab8033c7dfacd64a170e154a73f5e41eed333d1"

URI_x86_64_v2_kpkpass-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kpkpass-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpkpass-doc}"
SRC_URI[x86_64_v2_kpkpass-doc.sha256sum] = "0a24304b326397527eb53ff81664b66d48fec518193b78fc62c86cd92ad66a1c"

URI_aarch64_kpkpass = "${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kpkpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpkpass}"
SRC_URI[aarch64_kpkpass.sha256sum] = "7f4e9c4a4c36b223c8c1595afbe5811cdf97cf9bad275dd5e887ca444edee669"

URI_aarch64_kpkpass-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kpkpass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpkpass-devel}"
SRC_URI[aarch64_kpkpass-devel.sha256sum] = "49bf1206b9d05b5119bdbcb7d7b9d568177567b3d8742192ea2d55902e2bfcb4"

URI_aarch64_kpkpass-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kpkpass-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpkpass-doc}"
SRC_URI[aarch64_kpkpass-doc.sha256sum] = "2db9718b36632694463edcceb93fbeb56b524f6a11483bf03d3b491ce8c2e26b"

RDEPENDS:kpkpass = " \
 glibc \
 kf6-karchive \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kpkpass-devel = " \
 cmake-filesystem \
 kf6-karchive-devel \
 kpkpass \
 "
RDEPENDS:kpkpass-doc = " \
 "
