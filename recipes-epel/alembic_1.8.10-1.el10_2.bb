# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alembic"
PV = "1.8.10"
PR = "1.el10_2"
PACKAGES = " \
 alembic \
 alembic-devel \
 alembic-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/alembic-1.8.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f454e01b63ec2cae9412ac38422b52e47eb5cad5aadc544f2c1aa75551ed98d3"

URI_x86_64_v2_alembic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alembic-1.8.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alembic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alembic}"
SRC_URI[x86_64_v2_alembic.sha256sum] = "0745e3c9c0ec76687894d07a92f80efccbb9e23fc556b9f1aef88d38316ef99d"

URI_x86_64_v2_alembic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alembic-devel-1.8.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alembic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alembic-devel}"
SRC_URI[x86_64_v2_alembic-devel.sha256sum] = "40995df0bfd0740fd5a461e45b5390c7d1a2a06e8177808536152a0ebe76a8c9"

URI_x86_64_v2_alembic-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alembic-libs-1.8.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alembic-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alembic-libs}"
SRC_URI[x86_64_v2_alembic-libs.sha256sum] = "28d4d75c98797ae711a3d2411ef8a63ba017aa202058641302cdcf8f9b47930d"

URI_aarch64_alembic = "${EPEL_MIRROR}/aarch64/Packages/a/alembic-1.8.10-1.el10_2.aarch64.rpm;name=aarch64_alembic;unpack=0"
SRC_URI:append = " ${URI_aarch64_alembic}"
SRC_URI[aarch64_alembic.sha256sum] = "e5a630b79c6c54a73d31692b97d59f9d3a6d1b68f98af38a0924a2b376f6cf1e"

URI_aarch64_alembic-devel = "${EPEL_MIRROR}/aarch64/Packages/a/alembic-devel-1.8.10-1.el10_2.aarch64.rpm;name=aarch64_alembic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_alembic-devel}"
SRC_URI[aarch64_alembic-devel.sha256sum] = "2e0e31548c624c66559f3bebb9e859c148e702ce45a41dd3a193c6ae0c20ca4a"

URI_aarch64_alembic-libs = "${EPEL_MIRROR}/aarch64/Packages/a/alembic-libs-1.8.10-1.el10_2.aarch64.rpm;name=aarch64_alembic-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_alembic-libs}"
SRC_URI[aarch64_alembic-libs.sha256sum] = "9905e5456b5c3aee79a199c0e151ba603e70634e236e01fba685d519d051f49f"

RDEPENDS:alembic = " \
 alembic-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:alembic-devel = " \
 alembic-libs \
 cmake \
 cmake-filesystem \
 imath-devel \
 "
RDEPENDS:alembic-libs = " \
 glibc \
 hdf5 \
 imath \
 libgcc \
 libstdc++ \
 "
