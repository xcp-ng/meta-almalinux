# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ron0.7"
PV = "0.7.1"
PR = "5.el10_0"
PACKAGES = " \
 rust-ron0.7+default-devel \
 rust-ron0.7+indexmap-devel \
 rust-ron0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ron0.7-0.7.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55c1eefd0116d5727d56405428515b5c16512dfedb0082072680fd0afe046fff"

URI_x86_64_v2_rust-ron0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron0.7+default-devel-0.7.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron0.7+default-devel}"
SRC_URI[x86_64_v2_rust-ron0.7+default-devel.sha256sum] = "5fd44c36206ea6c4c69f3f54de431969a7885be80e9b76c041b878209bdad919"

URI_x86_64_v2_rust-ron0.7+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron0.7+indexmap-devel-0.7.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron0.7+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron0.7+indexmap-devel}"
SRC_URI[x86_64_v2_rust-ron0.7+indexmap-devel.sha256sum] = "75c12cef530bdd5d9cb4373665b7523abbc09c4a7156f118da3c994deef4d3ee"

URI_x86_64_v2_rust-ron0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron0.7-devel-0.7.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron0.7-devel}"
SRC_URI[x86_64_v2_rust-ron0.7-devel.sha256sum] = "be1cfbf8b891c697c2e5b7dd33ef2f158d11998d8736320c426b2b75b5ce8d9e"

URI_aarch64_rust-ron0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron0.7+default-devel-0.7.1-5.el10_0.noarch.rpm;name=aarch64_rust-ron0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron0.7+default-devel}"
SRC_URI[aarch64_rust-ron0.7+default-devel.sha256sum] = "8bbdc3a02dab6a07d62c63923bc96a332ee13c8bd45508a174eb540b516555e8"

URI_aarch64_rust-ron0.7+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron0.7+indexmap-devel-0.7.1-5.el10_0.noarch.rpm;name=aarch64_rust-ron0.7+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron0.7+indexmap-devel}"
SRC_URI[aarch64_rust-ron0.7+indexmap-devel.sha256sum] = "c6d557f0fb533638c0ccc126e1b9870b008b2504f19de4878851f11b4315db59"

URI_aarch64_rust-ron0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron0.7-devel-0.7.1-5.el10_0.noarch.rpm;name=aarch64_rust-ron0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron0.7-devel}"
SRC_URI[aarch64_rust-ron0.7-devel.sha256sum] = "63ec683be178f458fa40ae60d01ad3fd35a41c7452b511840f6754225129121e"

RDEPENDS:rust-ron0.7+default-devel = " \
 cargo \
 rust-ron0.7-devel \
 "
RDEPENDS:rust-ron0.7+indexmap-devel = " \
 cargo \
 rust-indexmap1+default-devel \
 rust-indexmap1+serde-1-devel \
 rust-ron0.7-devel \
 "
RDEPENDS:rust-ron0.7-devel = " \
 cargo \
 rust-base64_0.13+default-devel \
 rust-bitflags1+default-devel \
 rust-serde+default-devel \
 rust-serde+serde_derive-devel \
 "
