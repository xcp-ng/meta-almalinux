# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mpvqt"
PV = "1.0.1"
PR = "1.el10_0"
PACKAGES = " \
 mpvqt \
 mpvqt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mpvqt-1.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16a8f21f6404717a17a56d7f68aa1584fcde03dcedc71f3315d8338a977f8e2b"

URI_x86_64_v2_mpvqt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mpvqt-1.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mpvqt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpvqt}"
SRC_URI[x86_64_v2_mpvqt.sha256sum] = "efc33e748db46b4c71436fa469fe6b2a69bfcbd36d9be76c42e16916271b4580"

URI_x86_64_v2_mpvqt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mpvqt-devel-1.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mpvqt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpvqt-devel}"
SRC_URI[x86_64_v2_mpvqt-devel.sha256sum] = "a9c362324e2a56b6391b8ec4bb13560a065afdfe33b414250a989e8efd423f87"

URI_aarch64_mpvqt = "${EPEL_MIRROR}/aarch64/Packages/m/mpvqt-1.0.1-1.el10_0.aarch64.rpm;name=aarch64_mpvqt;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpvqt}"
SRC_URI[aarch64_mpvqt.sha256sum] = "3875d142655c4e6972aecb19090e211a3098622fe4b680ddeb904c9571bbd4a1"

URI_aarch64_mpvqt-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mpvqt-devel-1.0.1-1.el10_0.aarch64.rpm;name=aarch64_mpvqt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpvqt-devel}"
SRC_URI[aarch64_mpvqt-devel.sha256sum] = "5c33a57dd6f1f47f770c8accdc38089195a68ab50712c8debde9333c9043ceee"

RDEPENDS:mpvqt = " \
 glibc \
 libstdc++ \
 mpv-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:mpvqt-devel = " \
 cmake-filesystem \
 mpv-devel \
 mpvqt \
 qt6-qtdeclarative-devel \
 "
