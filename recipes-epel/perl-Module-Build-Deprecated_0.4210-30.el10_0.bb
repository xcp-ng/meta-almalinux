# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Build-Deprecated"
PV = "0.4210"
PR = "30.el10_0"
PACKAGES = " \
 perl-Module-Build-Deprecated \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Build-Deprecated-0.4210-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b76dcddb6f8a5a8d297671082a3fc1fd8623589bba12b088f55a53165e82a44"

URI_x86_64_v2_perl-Module-Build-Deprecated = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Build-Deprecated-0.4210-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Build-Deprecated;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Build-Deprecated}"
SRC_URI[x86_64_v2_perl-Module-Build-Deprecated.sha256sum] = "367be7a84d80957247b9cdeec0c6904b3d0044d2e7f51885b2f5e278a1ed526e"

URI_aarch64_perl-Module-Build-Deprecated = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Build-Deprecated-0.4210-30.el10_0.noarch.rpm;name=aarch64_perl-Module-Build-Deprecated;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Build-Deprecated}"
SRC_URI[aarch64_perl-Module-Build-Deprecated.sha256sum] = "8674867aa89b01b32155a2c447700806990e9d483318bc9a5dec276c9e0f382b"

RDEPENDS:perl-Module-Build-Deprecated = " \
 perl-CPAN-Meta-YAML \
 perl-Module-Metadata \
 perl-base \
 perl-libs \
 perl-parent \
 perl-version \
 "
