# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "volume_key"
PV = "0.3.12"
PR = "24.el10"
PACKAGES = " \
 python3-volume_key \
 volume_key \
 volume_key-devel \
 volume_key-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/volume_key-0.3.12-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28cb16b8a0951770d0bb13cb4e262d2a766d289c205b9b269090f752d2145922"

URI_x86_64_v2_python3-volume_key = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-volume_key-0.3.12-24.el10.x86_64_v2.rpm;name=x86_64_v2_python3-volume_key;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-volume_key}"
SRC_URI[x86_64_v2_python3-volume_key.sha256sum] = "2fa3d38c45815508eba9358ee7b0405a9aba0e49f3c5d2cec9bdb2235f188cce"

URI_x86_64_v2_volume_key = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/volume_key-0.3.12-24.el10.x86_64_v2.rpm;name=x86_64_v2_volume_key;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volume_key}"
SRC_URI[x86_64_v2_volume_key.sha256sum] = "423fcae18833b5823959fea3ca5a460ab934913b12b83fd8dd983ed09ae65dc5"

URI_x86_64_v2_volume_key-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/volume_key-devel-0.3.12-24.el10.x86_64_v2.rpm;name=x86_64_v2_volume_key-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volume_key-devel}"
SRC_URI[x86_64_v2_volume_key-devel.sha256sum] = "d07e8886d5e05b53c73dff1df8b5aaa40032618adcfc43d022732ace8d6eefb2"

URI_x86_64_v2_volume_key-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/volume_key-libs-0.3.12-24.el10.x86_64_v2.rpm;name=x86_64_v2_volume_key-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volume_key-libs}"
SRC_URI[x86_64_v2_volume_key-libs.sha256sum] = "f7dd562c6e48f1eaa980e1e603038022c9d6e508cbcaf2da79a99e1ccfda4637"

URI_aarch64_python3-volume_key = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-volume_key-0.3.12-24.el10.aarch64.rpm;name=aarch64_python3-volume_key;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-volume_key}"
SRC_URI[aarch64_python3-volume_key.sha256sum] = "bb2ceda888644c66369529cf11fd4b33bd2f7f417b84a7f059ed2ece904b7051"

URI_aarch64_volume_key = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/volume_key-0.3.12-24.el10.aarch64.rpm;name=aarch64_volume_key;unpack=0"
SRC_URI:append = " ${URI_aarch64_volume_key}"
SRC_URI[aarch64_volume_key.sha256sum] = "cc9659fa6d4b5f470ce63abd56d0894bc85a7420f9e5872a12a830d737299b0e"

URI_aarch64_volume_key-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/volume_key-devel-0.3.12-24.el10.aarch64.rpm;name=aarch64_volume_key-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_volume_key-devel}"
SRC_URI[aarch64_volume_key-devel.sha256sum] = "8f81f0c301c5b323e419f7b8eae410decb194ae0edffa067bae19be796b0579d"

URI_aarch64_volume_key-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/volume_key-libs-0.3.12-24.el10.aarch64.rpm;name=aarch64_volume_key-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_volume_key-libs}"
SRC_URI[aarch64_volume_key-libs.sha256sum] = "dc31d4c0a4d4fbda6bf651d7cab4cd2d462022f7a14cb069fae4abd3f78776bb"

RDEPENDS:python3-volume_key = " \
 cryptsetup-libs \
 glib2 \
 glibc \
 gpgme \
 libblkid \
 nspr \
 nss \
 nss-util \
 python3 \
 volume_key-libs \
 "
RDEPENDS:volume_key = " \
 glib2 \
 glibc \
 nspr \
 nss \
 volume_key-libs \
 "
RDEPENDS:volume_key-devel = " \
 volume_key-libs \
 "
RDEPENDS:volume_key-libs = " \
 cryptsetup-libs \
 glib2 \
 glibc \
 gnupg2 \
 gpgme \
 libblkid \
 nspr \
 nss \
 nss-util \
 "
