# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ctags"
PV = "6.1.0"
PR = "1.el10_0"
PACKAGES = " \
 ctags \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/ctags-6.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d169e5a06365df92704148b31d3e74795b4910122a07ac5b57712579c8dcb28"

URI_x86_64_v2_ctags = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ctags-6.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ctags;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ctags}"
SRC_URI[x86_64_v2_ctags.sha256sum] = "0b287fb3c554acfad961e7d3c150fda4a607f45e2aaecc7b071b1559aa561cb7"

URI_aarch64_ctags = "${EPEL_MIRROR}/aarch64/Packages/c/ctags-6.1.0-1.el10_0.aarch64.rpm;name=aarch64_ctags;unpack=0"
SRC_URI:append = " ${URI_aarch64_ctags}"
SRC_URI[aarch64_ctags.sha256sum] = "b6142a5bdffddd218bf35b53bae200e918142f18a3e9105b5719e4f0cc9deebd"

RDEPENDS:ctags = " \
 glibc \
 jansson \
 libseccomp \
 libxml2 \
 libyaml \
 "
