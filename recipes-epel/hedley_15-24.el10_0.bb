# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hedley"
PV = "15"
PR = "24.el10_0"
PACKAGES = " \
 hedley-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/h/hedley-15-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e11657415733af39c56c8167784156b190032a929ff7f64fef74fc94fb420dd6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hedley-devel-15-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_hedley-devel;unpack=0"
SRC_URI[x86_64_v2_hedley-devel.sha256sum] = "d7ada182597651156ab4ff3d1d049d5bd945629bf3438cfb495e503810f5c896"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hedley-devel-15-24.el10_0.noarch.rpm;name=aarch64_hedley-devel;unpack=0"
SRC_URI[aarch64_hedley-devel.sha256sum] = "a6afa1d0194dc574cc57b8e4af52d695d725887bc24cc2992be5213f4bb4e3a7"

RDEPENDS:hedley-devel = " \
 "
