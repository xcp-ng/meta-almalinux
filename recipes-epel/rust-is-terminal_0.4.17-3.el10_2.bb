# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-is-terminal"
PV = "0.4.17"
PR = "3.el10_2"
PACKAGES = " \
 rust-is-terminal+default-devel \
 rust-is-terminal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-is-terminal-0.4.17-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72f9465c11be5852b190e038f888041e15355d23497242db944402fff8b67073"

URI_x86_64_v2_rust-is-terminal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-terminal+default-devel-0.4.17-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-terminal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is-terminal+default-devel}"
SRC_URI[x86_64_v2_rust-is-terminal+default-devel.sha256sum] = "44f9537e24cbebf1c22b94543b90719f128d875e95b8a67a70efc47d802fb9fe"

URI_x86_64_v2_rust-is-terminal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-terminal-devel-0.4.17-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is-terminal-devel}"
SRC_URI[x86_64_v2_rust-is-terminal-devel.sha256sum] = "e8ee25713658e9fb233c4bc3326da3555369c762cf21ec6afae2435f097b24dd"

URI_aarch64_rust-is-terminal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is-terminal+default-devel-0.4.17-3.el10_2.noarch.rpm;name=aarch64_rust-is-terminal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is-terminal+default-devel}"
SRC_URI[aarch64_rust-is-terminal+default-devel.sha256sum] = "875ef7c815cf3238649c252107232fe336f27f06dc1baa2e0e1c0a953c066f5e"

URI_aarch64_rust-is-terminal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is-terminal-devel-0.4.17-3.el10_2.noarch.rpm;name=aarch64_rust-is-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is-terminal-devel}"
SRC_URI[aarch64_rust-is-terminal-devel.sha256sum] = "69691b72ddbca644b8932d5ae54dd977100a989fa7b7a7868cbf48b3757fbbe2"

RDEPENDS:rust-is-terminal+default-devel = " \
 cargo \
 rust-is-terminal-devel \
 "
RDEPENDS:rust-is-terminal-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
