# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-config2"
PV = "0.1.43"
PR = "1.el10_2"
PACKAGES = " \
 rust-cargo-config2+default-devel \
 rust-cargo-config2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-config2-0.1.43-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a10073961d468b28e13df7ceea4fb2cc78bb391472fc38cde60c2e8174cfa917"

URI_x86_64_v2_rust-cargo-config2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-config2+default-devel-0.1.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-config2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-config2+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-config2+default-devel.sha256sum] = "d93d75a86b8cd0d40490f6f585b5818e01f92e4dd9a1be511304ea5d91972da7"

URI_x86_64_v2_rust-cargo-config2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-config2-devel-0.1.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-config2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-config2-devel}"
SRC_URI[x86_64_v2_rust-cargo-config2-devel.sha256sum] = "b01c0947cdec9a09d67d8fb1dd388e292dc5a428aa79a0e8d58e4682719fcc06"

URI_aarch64_rust-cargo-config2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-config2+default-devel-0.1.43-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-config2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-config2+default-devel}"
SRC_URI[aarch64_rust-cargo-config2+default-devel.sha256sum] = "d02672a8d278133a15902cb0343ec5e910de47bcf23a7043b4202262a3a32596"

URI_aarch64_rust-cargo-config2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-config2-devel-0.1.43-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-config2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-config2-devel}"
SRC_URI[aarch64_rust-cargo-config2-devel.sha256sum] = "7a65ab92519b567ee52f9e227cf8094047a0cc9ae596e89691ebf74822c74435"

RDEPENDS:rust-cargo-config2+default-devel = " \
 cargo \
 rust-cargo-config2-devel \
 "
RDEPENDS:rust-cargo-config2-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-toml+parse-devel \
 rust-toml+serde-devel \
 rust-toml-devel \
 "
