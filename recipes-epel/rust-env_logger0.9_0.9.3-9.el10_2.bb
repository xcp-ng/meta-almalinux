# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_logger0.9"
PV = "0.9.3"
PR = "9.el10_2"
PACKAGES = " \
 rust-env_logger0.9+atty-devel \
 rust-env_logger0.9+default-devel \
 rust-env_logger0.9+humantime-devel \
 rust-env_logger0.9+regex-devel \
 rust-env_logger0.9+termcolor-devel \
 rust-env_logger0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_logger0.9-0.9.3-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4b534aa8652afdf93eaf542f788c2749468dccde5e4388e5e5c9412678d3c7a"

URI_x86_64_v2_rust-env_logger0.9+atty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+atty-devel-0.9.3-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+atty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+atty-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+atty-devel.sha256sum] = "30b3291e4de731c5385e97e8b9e21339be1a66809b12bd436c4183443bb07b5d"

URI_x86_64_v2_rust-env_logger0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+default-devel-0.9.3-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+default-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+default-devel.sha256sum] = "58edcf9db8a26a3bef93248df16010ce851faa2db1a1197a5ef14510e4e90f28"

URI_x86_64_v2_rust-env_logger0.9+humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+humantime-devel-0.9.3-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+humantime-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+humantime-devel.sha256sum] = "aa17cbba9856b1e5ac963243d6b9620dbe4f0b029256ad53d57d004f99e6dd2a"

URI_x86_64_v2_rust-env_logger0.9+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+regex-devel-0.9.3-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+regex-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+regex-devel.sha256sum] = "6c27ce7af8779f729a4e7eeb63252df4a8d084612b2a7dce00a7deccee8515e9"

URI_x86_64_v2_rust-env_logger0.9+termcolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+termcolor-devel-0.9.3-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+termcolor-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+termcolor-devel.sha256sum] = "955f3aabada528d8310595dc308e07d955b28413d7f18cbbbe1b0a1deaccbfe9"

URI_x86_64_v2_rust-env_logger0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9-devel-0.9.3-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9-devel.sha256sum] = "793db2aa1c937bfd11b632e336ebf54425bebea41f5ee661724caf9c7b2a5c81"
RPROVIDES:rust-env_logger0.9-devel:x86_64_v2 = "virtual/crate_env_logger__ge_0.6.1"

URI_aarch64_rust-env_logger0.9+atty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+atty-devel-0.9.3-9.el10_2.noarch.rpm;name=aarch64_rust-env_logger0.9+atty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+atty-devel}"
SRC_URI[aarch64_rust-env_logger0.9+atty-devel.sha256sum] = "4cf89337d05cffc8ad1d0fc33fec9c5436697bead47a847642882bed4c5dcdfd"

URI_aarch64_rust-env_logger0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+default-devel-0.9.3-9.el10_2.noarch.rpm;name=aarch64_rust-env_logger0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+default-devel}"
SRC_URI[aarch64_rust-env_logger0.9+default-devel.sha256sum] = "a903393fdb03d0a037ec1c9ae05c2586bd3887cd7f330eb8422438c7d518d151"

URI_aarch64_rust-env_logger0.9+humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+humantime-devel-0.9.3-9.el10_2.noarch.rpm;name=aarch64_rust-env_logger0.9+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+humantime-devel}"
SRC_URI[aarch64_rust-env_logger0.9+humantime-devel.sha256sum] = "10507367b369e3148dcb9d856f1fb57f5711c283700727db586a21b4e33454be"

URI_aarch64_rust-env_logger0.9+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+regex-devel-0.9.3-9.el10_2.noarch.rpm;name=aarch64_rust-env_logger0.9+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+regex-devel}"
SRC_URI[aarch64_rust-env_logger0.9+regex-devel.sha256sum] = "d7ae9a8d00bf089668a04ff2f912121fc9074a582602ccc7daf18f37232f0e7b"

URI_aarch64_rust-env_logger0.9+termcolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+termcolor-devel-0.9.3-9.el10_2.noarch.rpm;name=aarch64_rust-env_logger0.9+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+termcolor-devel}"
SRC_URI[aarch64_rust-env_logger0.9+termcolor-devel.sha256sum] = "f45a63b0fce00aa2f9ccad8bf2193e6cd2cb2bada8f24c0fb35a7fff32f274d7"

URI_aarch64_rust-env_logger0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9-devel-0.9.3-9.el10_2.noarch.rpm;name=aarch64_rust-env_logger0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9-devel}"
SRC_URI[aarch64_rust-env_logger0.9-devel.sha256sum] = "9385e26bda7548cbf91b7fcf6ae816690ae4b292298ff489ffc740a7b27a3c40"
RPROVIDES:rust-env_logger0.9-devel:aarch64 = "virtual/crate_env_logger__ge_0.6.1"

RDEPENDS:rust-env_logger0.9+atty-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 "
RDEPENDS:rust-env_logger0.9+default-devel = " \
 cargo \
 rust-env_logger0.9+atty-devel \
 rust-env_logger0.9+humantime-devel \
 rust-env_logger0.9+regex-devel \
 rust-env_logger0.9+termcolor-devel \
 rust-env_logger0.9-devel \
 "
RDEPENDS:rust-env_logger0.9+humantime-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 rust-humantime+default-devel \
 "
RDEPENDS:rust-env_logger0.9+regex-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-env_logger0.9+termcolor-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 rust-termcolor+default-devel \
 "
RDEPENDS:rust-env_logger0.9-devel = " \
 cargo \
 rust-log+default-devel \
 rust-log+std-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_env_logger__ge_0.6.1"

PROVIDES:append:aarch64 = " rpm/virtual/crate_env_logger__ge_0.6.1"
