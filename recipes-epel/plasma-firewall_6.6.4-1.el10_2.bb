# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-firewall"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-firewall \
 plasma-firewall-firewalld \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-firewall-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd77d39bdaf7414222827a95ca9f3ec15770aadb13a7593586d2f4f71bd10c22"

URI_x86_64_v2_plasma-firewall = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-firewall-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-firewall;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-firewall}"
SRC_URI[x86_64_v2_plasma-firewall.sha256sum] = "7f5efeaf4eb8ff4cd90624f976ec758bb02d3f894952f2c8f5386e54b7ab9960"

URI_x86_64_v2_plasma-firewall-firewalld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-firewall-firewalld-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-firewall-firewalld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-firewall-firewalld}"
SRC_URI[x86_64_v2_plasma-firewall-firewalld.sha256sum] = "3be0ce08b8446a2c1c3c2ba051e925ad3e55fe2f18edca0cc839e8b86413c342"

URI_aarch64_plasma-firewall = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-firewall-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-firewall;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-firewall}"
SRC_URI[aarch64_plasma-firewall.sha256sum] = "a619b98dbd1805c6aea56e0410ebb4f19345e2e897b788556f676e232bb4d6e2"

URI_aarch64_plasma-firewall-firewalld = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-firewall-firewalld-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-firewall-firewalld;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-firewall-firewalld}"
SRC_URI[aarch64_plasma-firewall-firewalld.sha256sum] = "12658c61848122d83013b65443c2fcecafce5a1c675a3240707524df358eef6c"

RDEPENDS:plasma-firewall = " \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 plasma-firewall-firewalld \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-firewall-firewalld = " \
 firewalld \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 plasma-firewall \
 qt6-qtbase \
 "
