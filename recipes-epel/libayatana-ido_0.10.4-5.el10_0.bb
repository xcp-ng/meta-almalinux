# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libayatana-ido"
PV = "0.10.4"
PR = "5.el10_0"
PACKAGES = " \
 libayatana-ido-gtk3 \
 libayatana-ido-gtk3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libayatana-ido-0.10.4-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebe4422628599e3613da58b5ae8920fafbf76c0d81fd4f3169bafd6034717dba"

URI_x86_64_v2_libayatana-ido-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-ido-gtk3-0.10.4-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-ido-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libayatana-ido-gtk3}"
SRC_URI[x86_64_v2_libayatana-ido-gtk3.sha256sum] = "40396e50a17bcbd87a7face8fea2cf0b0ba0e813ab34a6e8d884ba2ca648c452"

URI_x86_64_v2_libayatana-ido-gtk3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-ido-gtk3-devel-0.10.4-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-ido-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libayatana-ido-gtk3-devel}"
SRC_URI[x86_64_v2_libayatana-ido-gtk3-devel.sha256sum] = "60ea8ea5a1c162861e3f41c2c3c0cc50ff34f2bef996210803e661d4d180f8ba"

URI_aarch64_libayatana-ido-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/l/libayatana-ido-gtk3-0.10.4-5.el10_0.aarch64.rpm;name=aarch64_libayatana-ido-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libayatana-ido-gtk3}"
SRC_URI[aarch64_libayatana-ido-gtk3.sha256sum] = "49946574f8d0526ab69c9e30afee9af014008b574dae5b8a9347838cdd44e913"

URI_aarch64_libayatana-ido-gtk3-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libayatana-ido-gtk3-devel-0.10.4-5.el10_0.aarch64.rpm;name=aarch64_libayatana-ido-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libayatana-ido-gtk3-devel}"
SRC_URI[aarch64_libayatana-ido-gtk3-devel.sha256sum] = "b55b743d58602e3fa29cdd615ff227bd4a9e976979dfff8af8b7d410e04414da"

RDEPENDS:libayatana-ido-gtk3 = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 pango \
 "
RDEPENDS:libayatana-ido-gtk3-devel = " \
 glib2-devel \
 gtk3-devel \
 libayatana-ido-gtk3 \
 pkgconf-pkg-config \
 "
