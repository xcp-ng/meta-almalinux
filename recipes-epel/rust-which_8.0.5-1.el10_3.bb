# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-which"
PV = "8.0.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-which+default-devel \
 rust-which+real-sys-devel \
 rust-which+regex-devel \
 rust-which+tracing-devel \
 rust-which-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-which-8.0.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcb1317b02ebeaa4bb230e42b008a5046c3534c8168f81f360dc1b3307d5ae07"

URI_x86_64_v2_rust-which+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+default-devel-8.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+default-devel}"
SRC_URI[x86_64_v2_rust-which+default-devel.sha256sum] = "a16d661118e0ea8afbc1df43dea2a6de23a6f0d3f46331961acec7d6ae9feaaa"

URI_x86_64_v2_rust-which+real-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+real-sys-devel-8.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+real-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+real-sys-devel}"
SRC_URI[x86_64_v2_rust-which+real-sys-devel.sha256sum] = "c58d59315b82e473e714504dbdb1f3eda2a9c95aa09cd3ba532090cf02f8ac29"

URI_x86_64_v2_rust-which+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+regex-devel-8.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+regex-devel}"
SRC_URI[x86_64_v2_rust-which+regex-devel.sha256sum] = "d24f52c7225fd3b9bba866f7dffc870acd889df648b1013ccd8a0c3cbf0fba0e"

URI_x86_64_v2_rust-which+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+tracing-devel-8.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+tracing-devel}"
SRC_URI[x86_64_v2_rust-which+tracing-devel.sha256sum] = "2f1a51f880c3c5708f895eb45c176bd1213d0897734a937dca900682706a606d"

URI_x86_64_v2_rust-which-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which-devel-8.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which-devel}"
SRC_URI[x86_64_v2_rust-which-devel.sha256sum] = "f994f18b9e9c5457ddbdea14a159a1e0125d32bf0ba25109c6b6a666036ea950"

URI_aarch64_rust-which+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+default-devel-8.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-which+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+default-devel}"
SRC_URI[aarch64_rust-which+default-devel.sha256sum] = "995c783b12f3b698a1c6be5d27c937222903fe9110f668647e20aacffd7a9385"

URI_aarch64_rust-which+real-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+real-sys-devel-8.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-which+real-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+real-sys-devel}"
SRC_URI[aarch64_rust-which+real-sys-devel.sha256sum] = "8bcdeb506d58b8c908682a145744d736384dc27e50ff1317e710817b833916c7"

URI_aarch64_rust-which+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+regex-devel-8.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-which+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+regex-devel}"
SRC_URI[aarch64_rust-which+regex-devel.sha256sum] = "3a6a28a6e309c10f38459aa839410d747a250cbf1f9c86b9c24178af3daa7050"

URI_aarch64_rust-which+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+tracing-devel-8.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-which+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+tracing-devel}"
SRC_URI[aarch64_rust-which+tracing-devel.sha256sum] = "565e6cc12ae2d7e97892ea0988b7873c3275306db4049c91a0f38a29d3100a2b"

URI_aarch64_rust-which-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which-devel-8.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-which-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which-devel}"
SRC_URI[aarch64_rust-which-devel.sha256sum] = "9a37284cda50b90488641abc35cc317c5c2110794077bdb44c679190c1f4ac9f"

RDEPENDS:rust-which+default-devel = " \
 cargo \
 rust-which+real-sys-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+real-sys-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+regex-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+tracing-devel = " \
 cargo \
 rust-tracing-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which-devel = " \
 cargo \
 rust \
 "
