# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-html2text"
PV = "0.6.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-html2text+ansi_colours-devel \
 rust-html2text+backtrace-devel \
 rust-html2text+default-devel \
 rust-html2text+html_trace-devel \
 rust-html2text+html_trace_bt-devel \
 rust-html2text-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-html2text-0.6.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cd1173ed1b36f967e177d1b773c4c3a978ea413ac1f825ab4ffd39b6a521921"

URI_x86_64_v2_rust-html2text+ansi_colours-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html2text+ansi_colours-devel-0.6.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html2text+ansi_colours-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html2text+ansi_colours-devel}"
SRC_URI[x86_64_v2_rust-html2text+ansi_colours-devel.sha256sum] = "588671f4d0f3b776584a056306ffa27444e6ecd0d0af389595f4cfeb06eceb96"

URI_x86_64_v2_rust-html2text+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html2text+backtrace-devel-0.6.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html2text+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html2text+backtrace-devel}"
SRC_URI[x86_64_v2_rust-html2text+backtrace-devel.sha256sum] = "97b8c20764eb5942420c85b688a7c0828b3151c374e4e37839a43a46b2b5091b"

URI_x86_64_v2_rust-html2text+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html2text+default-devel-0.6.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html2text+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html2text+default-devel}"
SRC_URI[x86_64_v2_rust-html2text+default-devel.sha256sum] = "337f7ccee5f15b0bee6dffaa7203bf2ffefcda90d1c74eaad117554cb7fd6700"

URI_x86_64_v2_rust-html2text+html_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html2text+html_trace-devel-0.6.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html2text+html_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html2text+html_trace-devel}"
SRC_URI[x86_64_v2_rust-html2text+html_trace-devel.sha256sum] = "ca867dd82702fab7a938144c07fc2c1cfd9424a75a7ac5a458e77a294e4f4ba4"

URI_x86_64_v2_rust-html2text+html_trace_bt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html2text+html_trace_bt-devel-0.6.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html2text+html_trace_bt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html2text+html_trace_bt-devel}"
SRC_URI[x86_64_v2_rust-html2text+html_trace_bt-devel.sha256sum] = "57dc76617c822d6bdedd4d3c2016b50e163e684b8a172ebea8792613f9586e4a"

URI_x86_64_v2_rust-html2text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html2text-devel-0.6.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html2text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html2text-devel}"
SRC_URI[x86_64_v2_rust-html2text-devel.sha256sum] = "c4867a49abeede4d246a004cc064cbf5c82ba8008b54bad8b3dbecb3af626a76"

URI_aarch64_rust-html2text+ansi_colours-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html2text+ansi_colours-devel-0.6.0-4.el10_0.noarch.rpm;name=aarch64_rust-html2text+ansi_colours-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html2text+ansi_colours-devel}"
SRC_URI[aarch64_rust-html2text+ansi_colours-devel.sha256sum] = "870e2bb98a9d457c43f324006a1e4fd25247f4392b4455739e1f1b264c769853"

URI_aarch64_rust-html2text+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html2text+backtrace-devel-0.6.0-4.el10_0.noarch.rpm;name=aarch64_rust-html2text+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html2text+backtrace-devel}"
SRC_URI[aarch64_rust-html2text+backtrace-devel.sha256sum] = "292a1d24167c5e644c6972d05be90083d3aa6788c2ede47b2d1f1b5a4a310267"

URI_aarch64_rust-html2text+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html2text+default-devel-0.6.0-4.el10_0.noarch.rpm;name=aarch64_rust-html2text+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html2text+default-devel}"
SRC_URI[aarch64_rust-html2text+default-devel.sha256sum] = "c1289d7f5a59e4c452f7b0e95f470392eafb0a55f6eba57b5f67c55b3d59ede4"

URI_aarch64_rust-html2text+html_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html2text+html_trace-devel-0.6.0-4.el10_0.noarch.rpm;name=aarch64_rust-html2text+html_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html2text+html_trace-devel}"
SRC_URI[aarch64_rust-html2text+html_trace-devel.sha256sum] = "8bb04ddfc67d525ac6607cbefd54350a96b1628a1bd23c5e74dbcb2d90fa7638"

URI_aarch64_rust-html2text+html_trace_bt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html2text+html_trace_bt-devel-0.6.0-4.el10_0.noarch.rpm;name=aarch64_rust-html2text+html_trace_bt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html2text+html_trace_bt-devel}"
SRC_URI[aarch64_rust-html2text+html_trace_bt-devel.sha256sum] = "f98fc9bdfad8889190f1cf7e29186107f1e0791ad598278dd7e9c8774012a614"

URI_aarch64_rust-html2text-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html2text-devel-0.6.0-4.el10_0.noarch.rpm;name=aarch64_rust-html2text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html2text-devel}"
SRC_URI[aarch64_rust-html2text-devel.sha256sum] = "c2bb2849f1051c6d6ea029eebf1fa8359ac9112212e091c1faf8c9fe034de1b5"

RDEPENDS:rust-html2text+ansi_colours-devel = " \
 cargo \
 rust-html2text-devel \
 "
RDEPENDS:rust-html2text+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-html2text-devel \
 "
RDEPENDS:rust-html2text+default-devel = " \
 cargo \
 rust-html2text-devel \
 "
RDEPENDS:rust-html2text+html_trace-devel = " \
 cargo \
 rust-html2text-devel \
 "
RDEPENDS:rust-html2text+html_trace_bt-devel = " \
 cargo \
 rust-html2text+backtrace-devel \
 rust-html2text-devel \
 "
RDEPENDS:rust-html2text-devel = " \
 cargo \
 rust \
 rust-html5ever0.26+default-devel \
 rust-markup5ever0.11+default-devel \
 rust-tendril+default-devel \
 rust-unicode-width0.1+default-devel \
 rust-xml5ever0.17+default-devel \
 "
