# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "powertop"
PV = "2.15"
PR = "8.el10"
PACKAGES = " \
 powertop \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/powertop-2.15-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2f7dd02ce2c54c655337fee03d1361b0348d7f1bfe39ef2f025b7903deb2695"

URI_x86_64_v2_powertop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/powertop-2.15-8.el10.x86_64_v2.rpm;name=x86_64_v2_powertop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_powertop}"
SRC_URI[x86_64_v2_powertop.sha256sum] = "172d43c5169f8845b04f434e216567363e7e6837167396552d398e0875210785"

URI_aarch64_powertop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/powertop-2.15-8.el10.aarch64.rpm;name=aarch64_powertop;unpack=0"
SRC_URI:append = " ${URI_aarch64_powertop}"
SRC_URI[aarch64_powertop.sha256sum] = "7bcbb7a2bf1d3178adf85c4a2d9e72cb9fad8900036186b6f653b52891cecec1"

RDEPENDS:powertop = " \
 bash \
 glibc \
 libgcc \
 libnl3 \
 libstdc++ \
 ncurses-libs \
 pciutils-libs \
 systemd \
 virtual/coreutils \
 "
