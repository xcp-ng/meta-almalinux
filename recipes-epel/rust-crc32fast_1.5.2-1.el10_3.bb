# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crc32fast"
PV = "1.5.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-crc32fast+default-devel \
 rust-crc32fast+nightly-devel \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crc32fast-1.5.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1840244a89f13cbbd81edd014e5c092c79c911baf299716ecd1cbc09ca6b9c17"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast+default-devel-1.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crc32fast+default-devel.sha256sum] = "ea8ce333c3bbcac6fb701a02e05af914b638a0200d29897a545fe292b1b617b1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast+nightly-devel-1.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast+nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crc32fast+nightly-devel.sha256sum] = "4109d4c66db622b9b08f76de638fe14f8c4feed06e37443b4827d1d707a22d7d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast+std-devel-1.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crc32fast+std-devel.sha256sum] = "2f67af7f3b453f25b61647ef8a4add2604151c753caca16718905171e6d89ad6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast-devel-1.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crc32fast-devel.sha256sum] = "28df0875cfa3c2d23f6095b317360add0c1f80557a9a601a08a75fdc712d7b62"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast+default-devel-1.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-crc32fast+default-devel;unpack=0"
SRC_URI[aarch64_rust-crc32fast+default-devel.sha256sum] = "5efa38e0eb2c280d75e4be3b0e283d0cb259dd568aa8e74200a32422828f26f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast+nightly-devel-1.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-crc32fast+nightly-devel;unpack=0"
SRC_URI[aarch64_rust-crc32fast+nightly-devel.sha256sum] = "c92e4e2751b94711ac678555739ff34daebc7bfd417aab663a5e0d7ae008910a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast+std-devel-1.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-crc32fast+std-devel;unpack=0"
SRC_URI[aarch64_rust-crc32fast+std-devel.sha256sum] = "986bb5f169b58391930b5de20176a170d008a6d682897b02c1e369a90a8ec706"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast-devel-1.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-crc32fast-devel;unpack=0"
SRC_URI[aarch64_rust-crc32fast-devel.sha256sum] = "10fc085d443b71a58d89b98ba5f425d4887b86b240cf4181b3895e3a0b9b92e4"

RDEPENDS:rust-crc32fast+default-devel = " \
 cargo \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 "
RDEPENDS:rust-crc32fast+nightly-devel = " \
 cargo \
 rust-crc32fast-devel \
 "
RDEPENDS:rust-crc32fast+std-devel = " \
 cargo \
 rust-crc32fast-devel \
 "
RDEPENDS:rust-crc32fast-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "
