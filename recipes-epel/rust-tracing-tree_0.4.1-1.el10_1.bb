# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-tree"
PV = "0.4.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-tracing-tree+default-devel \
 rust-tracing-tree+time-devel \
 rust-tracing-tree+tracing-log-devel \
 rust-tracing-tree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-tree-0.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "921f880cdd98ab0c4376d1c16448f6713d35afbfad9b6b6bbfdae3641693d237"

URI_x86_64_v2_rust-tracing-tree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-tree+default-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-tree+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-tree+default-devel.sha256sum] = "790eedb8962c7dfcafb16a4e66e7229f10aaedd2a169fe2fc7392d3c734956ee"

URI_x86_64_v2_rust-tracing-tree+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-tree+time-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-tree+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-tree+time-devel}"
SRC_URI[x86_64_v2_rust-tracing-tree+time-devel.sha256sum] = "2c8bb2965f0dbe3c798037d973dece8805880becd8d50f7bfa10a47408a53a9c"

URI_x86_64_v2_rust-tracing-tree+tracing-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-tree+tracing-log-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-tree+tracing-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-tree+tracing-log-devel}"
SRC_URI[x86_64_v2_rust-tracing-tree+tracing-log-devel.sha256sum] = "fd49559c3d43049fdfc4f462d8e9fa75f49970e5c88e15138597b6e4cd94b6b0"

URI_x86_64_v2_rust-tracing-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-tree-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-tree-devel}"
SRC_URI[x86_64_v2_rust-tracing-tree-devel.sha256sum] = "29373bd998c37efae8b6bdf7453ba9f63dfb92405fce96de6e9c32da317fe70a"

URI_aarch64_rust-tracing-tree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-tree+default-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-tree+default-devel}"
SRC_URI[aarch64_rust-tracing-tree+default-devel.sha256sum] = "0f8aac859cb62639b10407fd3795c7c39aeae984e035338ab57506b87b7227d4"

URI_aarch64_rust-tracing-tree+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-tree+time-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-tree+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-tree+time-devel}"
SRC_URI[aarch64_rust-tracing-tree+time-devel.sha256sum] = "f6374e17c9e44e55dd4ac34ec34f4fa53fd63443833652d99f88ea1040c80f6a"

URI_aarch64_rust-tracing-tree+tracing-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-tree+tracing-log-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-tree+tracing-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-tree+tracing-log-devel}"
SRC_URI[aarch64_rust-tracing-tree+tracing-log-devel.sha256sum] = "9e390423d89b39877ab6d2f0f3ad50052f5c0885982fd4ad6e97dc223fad9d29"

URI_aarch64_rust-tracing-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-tree-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-tree-devel}"
SRC_URI[aarch64_rust-tracing-tree-devel.sha256sum] = "f0a32f08d6425f8e0921cafe45a2039645b80d66281fd4fe7642645cd50c0ae6"

RDEPENDS:rust-tracing-tree+default-devel = " \
 cargo \
 rust-tracing-tree+tracing-log-devel \
 rust-tracing-tree-devel \
 "
RDEPENDS:rust-tracing-tree+time-devel = " \
 cargo \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 rust-tracing-tree-devel \
 "
RDEPENDS:rust-tracing-tree+tracing-log-devel = " \
 cargo \
 rust-tracing-log+log-tracer-devel \
 rust-tracing-log+std-devel \
 rust-tracing-log-devel \
 rust-tracing-tree-devel \
 "
RDEPENDS:rust-tracing-tree-devel = " \
 cargo \
 rust \
 rust-nu-ansi-term+default-devel \
 rust-tracing-core+default-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+registry-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber-devel \
 "
