# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-mi"
PV = "0.20080630"
PR = "33.el10"
PACKAGES = " \
 hunspell-mi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-mi-0.20080630-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01af81bd6bf5ad76bbba50b05b538e02341022ff7391ff5e10671a1a1b532792"

URI_x86_64_v2_hunspell-mi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-mi-0.20080630-33.el10.noarch.rpm;name=x86_64_v2_hunspell-mi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-mi}"
SRC_URI[x86_64_v2_hunspell-mi.sha256sum] = "c65bcaf07d5c92f3d294582fd5af86a3652ebbb6991103f4a3e662c982f22dee"

URI_aarch64_hunspell-mi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-mi-0.20080630-33.el10.noarch.rpm;name=aarch64_hunspell-mi;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-mi}"
SRC_URI[aarch64_hunspell-mi.sha256sum] = "c65bcaf07d5c92f3d294582fd5af86a3652ebbb6991103f4a3e662c982f22dee"

RDEPENDS:hunspell-mi = " \
 hunspell-filesystem \
 "
