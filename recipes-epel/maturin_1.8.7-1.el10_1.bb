# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maturin"
PV = "1.8.7"
PR = "1.el10_1"
PACKAGES = " \
 maturin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/maturin-1.8.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdd8c04f05ef5955678154470d4f1a24be11b2053e32852669db66a04f4c310b"

URI_x86_64_v2_maturin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maturin-1.8.7-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_maturin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maturin}"
SRC_URI[x86_64_v2_maturin.sha256sum] = "fe472861b49cd0626d6bf2f1ecbda52212cb78f04b7702cd76aa15a593f41d28"

URI_aarch64_maturin = "${EPEL_MIRROR}/aarch64/Packages/m/maturin-1.8.7-1.el10_1.aarch64.rpm;name=aarch64_maturin;unpack=0"
SRC_URI:append = " ${URI_aarch64_maturin}"
SRC_URI[aarch64_maturin.sha256sum] = "70e66701127bce1ba178bab1415ccf950bec62d921e4a09bd656adfb9e253c65"

RDEPENDS:maturin = " \
 bzip2-libs \
 cargo \
 glibc \
 libgcc \
 libzstd \
 python3 \
 "
