# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ply"
PV = "3.11"
PR = "25.el10"
PACKAGES = " \
 python3-ply \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-ply-3.11-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e95c02169137b128c3c5e696809e5041f4e4bf97c2f7cb266d98b0b78e47723"

URI_x86_64_v2_python3-ply = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-ply-3.11-25.el10.noarch.rpm;name=x86_64_v2_python3-ply;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ply}"
SRC_URI[x86_64_v2_python3-ply.sha256sum] = "61025082f63457b66205a4894e078296c117ab4d0878dcc3b8ab0bdc54cda23a"

URI_aarch64_python3-ply = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-ply-3.11-25.el10.noarch.rpm;name=aarch64_python3-ply;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ply}"
SRC_URI[aarch64_python3-ply.sha256sum] = "61025082f63457b66205a4894e078296c117ab4d0878dcc3b8ab0bdc54cda23a"

RDEPENDS:python3-ply = " \
 python3 \
 "
