# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtwebchannel"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtwebchannel \
 qt5-qtwebchannel-devel \
 qt5-qtwebchannel-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtwebchannel-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a075f8b5dcd5ce4060fa8f0d157e5cf416e9d5ec112bf87c7dba7ebf1e8bd429"

URI_x86_64_v2_qt5-qtwebchannel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebchannel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebchannel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebchannel}"
SRC_URI[x86_64_v2_qt5-qtwebchannel.sha256sum] = "4f649a23bf0740e2afd578ad12b7baef9646e34459863c98fa52f9b6ec0e92eb"

URI_x86_64_v2_qt5-qtwebchannel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebchannel-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebchannel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebchannel-devel}"
SRC_URI[x86_64_v2_qt5-qtwebchannel-devel.sha256sum] = "007edc35563e34415024d1d7f2d161250ebdfdddfbd36c26e507bffb576017d4"

URI_x86_64_v2_qt5-qtwebchannel-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebchannel-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebchannel-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebchannel-examples}"
SRC_URI[x86_64_v2_qt5-qtwebchannel-examples.sha256sum] = "b3025dc66c32948ad5691f8e77d1dded503b8d8e625fcff57e4c4b1574c741c7"

URI_aarch64_qt5-qtwebchannel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebchannel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtwebchannel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebchannel}"
SRC_URI[aarch64_qt5-qtwebchannel.sha256sum] = "9cadc914abfd18dc8d1857153d1f1e1546df2f3eea536c270031dbd791dc5bde"

URI_aarch64_qt5-qtwebchannel-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebchannel-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtwebchannel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebchannel-devel}"
SRC_URI[aarch64_qt5-qtwebchannel-devel.sha256sum] = "fc923f6f3ea55c450d62b99b5e04bc578d79c908dc170b8fe0da0a5d2bb6aaa3"

URI_aarch64_qt5-qtwebchannel-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebchannel-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtwebchannel-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebchannel-examples}"
SRC_URI[aarch64_qt5-qtwebchannel-examples.sha256sum] = "91ef0b3c10c77ea1b548725248c1846a8ade5b2f449a7164fde089f60e64d927"

RDEPENDS:qt5-qtwebchannel = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtwebchannel-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtwebchannel \
 "
RDEPENDS:qt5-qtwebchannel-examples = " \
 glibc \
 libstdc++ \
 nodejs \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtwebchannel \
 qt5-qtwebsockets \
 "
