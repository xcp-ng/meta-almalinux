# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTML-StripScripts"
PV = "1.06"
PR = "26.el10_0"
PACKAGES = " \
 perl-HTML-StripScripts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTML-StripScripts-1.06-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb0c1ec7f88972ec44c6549084ed30b4ca553fcb7fb29f35bcf2b0a2a0667b97"

URI_x86_64_v2_perl-HTML-StripScripts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTML-StripScripts-1.06-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTML-StripScripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTML-StripScripts}"
SRC_URI[x86_64_v2_perl-HTML-StripScripts.sha256sum] = "fd0d4a7006172fb01c5f87b13ad4ffc06a3108dfd04b9ea284fd6aa52fdf17a1"

URI_aarch64_perl-HTML-StripScripts = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTML-StripScripts-1.06-26.el10_0.noarch.rpm;name=aarch64_perl-HTML-StripScripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTML-StripScripts}"
SRC_URI[aarch64_perl-HTML-StripScripts.sha256sum] = "a5a8fb47cc7b22e5f16b2eebceb4903d0ffda9118814aceb4982177526646af8"

RDEPENDS:perl-HTML-StripScripts = " \
 perl-libs \
 perl-vars \
 "
