# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keychecker"
PV = "1.0"
PR = "24.el10_3"
PACKAGES = " \
 keychecker \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/keychecker-1.0-24.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f413e5681689f52c3cff07f45caef19165bdc4b08efd377e895baa13d35538f6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keychecker-1.0-24.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_keychecker;unpack=0"
SRC_URI[x86_64_v2_keychecker.sha256sum] = "64efa74088333af1c40f1b9dbda24d49e086ab7d223b9b0396d8927329a2af0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/keychecker-1.0-24.el10_3.noarch.rpm;name=aarch64_keychecker;unpack=0"
SRC_URI[aarch64_keychecker.sha256sum] = "4f96bcc3c03d882e8993bf647cf6bead74d2675c37aa0fd07f096fa51b17a682"

RDEPENDS:keychecker = " \
 python3 \
 python3-rpm \
 "
