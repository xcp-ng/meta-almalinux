# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bpfmon"
PV = "2.53"
PR = "1.el10_0"
PACKAGES = " \
 bpfmon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bpfmon-2.53-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95e22ca92aeb185db2137af47913f141f900948a25068a97916231b78fd9981a"

URI_x86_64_v2_bpfmon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bpfmon-2.53-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bpfmon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bpfmon}"
SRC_URI[x86_64_v2_bpfmon.sha256sum] = "df51cb4a87b61d88b1e82def0b406e27ac8a27532ba23cf3354e5e21ebdc252b"

URI_aarch64_bpfmon = "${EPEL_MIRROR}/aarch64/Packages/b/bpfmon-2.53-1.el10_0.aarch64.rpm;name=aarch64_bpfmon;unpack=0"
SRC_URI:append = " ${URI_aarch64_bpfmon}"
SRC_URI[aarch64_bpfmon.sha256sum] = "eede585a28285f650b9955b98023f47790fbc650b165bddceb6c72784fc1b506"

RDEPENDS:bpfmon = " \
 glibc \
 libpcap \
 yascreen \
 "
