# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hiprand"
PV = "7.1.0"
PR = "5.el10_2"
PACKAGES:x86_64_v2 = " \
 hiprand \
 hiprand-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hiprand-7.1.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25b6afc1d3008372a783d66f7fba7a0e31c9fb9b7c6678b9e03033263ac1ce07"

URI_x86_64_v2_hiprand = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hiprand-7.1.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hiprand;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hiprand}"
SRC_URI[x86_64_v2_hiprand.sha256sum] = "c934af68e8bde479ab92eb68c55e1425828a51311589f5bfe115120af999a42f"

URI_x86_64_v2_hiprand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hiprand-devel-7.1.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hiprand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hiprand-devel}"
SRC_URI[x86_64_v2_hiprand-devel.sha256sum] = "85da0acc8c0d90f5a21c1c5cc5cb223cf11b2367fe55ada65cbd29854ac9d591"

RDEPENDS:hiprand = " \
 glibc \
 libstdc++ \
 rocrand \
 "
RDEPENDS:hiprand-devel = " \
 cmake-filesystem \
 hiprand \
 rocrand-devel \
 "
