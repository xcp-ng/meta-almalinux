# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-b3sum"
PV = "1.8.2"
PR = "3.el10_1"
PACKAGES = " \
 b3sum \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-b3sum-1.8.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "618ae6ffb38487bbe108cc019ea17c8b04ee03d2c28c94ee873b92a70c081944"

URI_x86_64_v2_b3sum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/b3sum-1.8.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_b3sum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_b3sum}"
SRC_URI[x86_64_v2_b3sum.sha256sum] = "358e2e357007fa4d2958e732cec7b09d85f1e9438c2c5659cfb8d3b14ab1b8f8"

URI_aarch64_b3sum = "${EPEL_MIRROR}/aarch64/Packages/b/b3sum-1.8.2-3.el10_1.aarch64.rpm;name=aarch64_b3sum;unpack=0"
SRC_URI:append = " ${URI_aarch64_b3sum}"
SRC_URI[aarch64_b3sum.sha256sum] = "30ebaa9b769378f8c77ebf648516fe222475f0c55d6996be359eaca73788a468"

RDEPENDS:b3sum = " \
 glibc \
 libgcc \
 "
