# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rpassword"
PV = "7.5.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-rpassword+default-devel \
 rust-rpassword-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rpassword-7.5.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f255165532e61c181d5277f642f1fdb3574c0b4d5257c7a460c86c43bf28f3b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpassword+default-devel-7.5.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpassword+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rpassword+default-devel.sha256sum] = "aa08c3ff7383208da36675b42028fd57ae1014925843d669c855b89a6a5c7b11"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpassword-devel-7.5.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpassword-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rpassword-devel.sha256sum] = "16f277d337ef5cc37861a3a23064e44cfd85390bea0af374846887f5290602f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rpassword+default-devel-7.5.4-1.el10_2.noarch.rpm;name=aarch64_rust-rpassword+default-devel;unpack=0"
SRC_URI[aarch64_rust-rpassword+default-devel.sha256sum] = "8e8642d7d23a7c344e767526ae12e51c08c660dde42c91a8f2cefbc3a13c23e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rpassword-devel-7.5.4-1.el10_2.noarch.rpm;name=aarch64_rust-rpassword-devel;unpack=0"
SRC_URI[aarch64_rust-rpassword-devel.sha256sum] = "f373b0e09588959fe0fc8c2075126f2f30f36fcdc52247ce6c99bfcf11804e91"

RDEPENDS:rust-rpassword+default-devel = " \
 cargo \
 rust-rpassword-devel \
 "
RDEPENDS:rust-rpassword-devel = " \
 bash \
 cargo \
 rust \
 rust-libc+default-devel \
 rust-rtoolbox+default-devel \
 "
