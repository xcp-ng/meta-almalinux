# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cpubits"
PV = "0.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-cpubits+default-devel \
 rust-cpubits-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cpubits-0.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d705bcc0c767a750d6225394afb5943ef0eaf60e8a40fb45b9ab29ef84202a8"

URI_x86_64_v2_rust-cpubits+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpubits+default-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpubits+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpubits+default-devel}"
SRC_URI[x86_64_v2_rust-cpubits+default-devel.sha256sum] = "a33cd37c4d656f3aa2f23cd9b23a98177f6a8c5408d361570b8f6341a0e51fd6"

URI_x86_64_v2_rust-cpubits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpubits-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpubits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpubits-devel}"
SRC_URI[x86_64_v2_rust-cpubits-devel.sha256sum] = "a4829837435e143414a7d77f548a7be879d1e49af1183e4de278575f985afef4"

URI_aarch64_rust-cpubits+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpubits+default-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-cpubits+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpubits+default-devel}"
SRC_URI[aarch64_rust-cpubits+default-devel.sha256sum] = "90bd43cbec977fcbaf27cf0dbb8667200e9213d4bff4c60998428e6df602dad9"

URI_aarch64_rust-cpubits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpubits-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-cpubits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpubits-devel}"
SRC_URI[aarch64_rust-cpubits-devel.sha256sum] = "87fa69af48c211968107b92e713a0608008c0381eaa19384f2b72c069b46323e"

RDEPENDS:rust-cpubits+default-devel = " \
 cargo \
 rust-cpubits-devel \
 "
RDEPENDS:rust-cpubits-devel = " \
 cargo \
 rust \
 "
