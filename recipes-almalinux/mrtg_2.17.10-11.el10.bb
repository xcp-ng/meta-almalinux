# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mrtg"
PV = "2.17.10"
PR = "11.el10"
PACKAGES = " \
 mrtg \
 mrtg-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mrtg-2.17.10-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c5a60e174be3a4b6a51af461aefdee38aa930ebfe9fccba7a70a3dc979ece17"

URI_x86_64_v2_mrtg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mrtg-2.17.10-11.el10.x86_64_v2.rpm;name=x86_64_v2_mrtg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrtg}"
SRC_URI[x86_64_v2_mrtg.sha256sum] = "ff6fca30b42789db4e2e80e5bca93bd05ca517cbfc96a6ebc42a93c7c5d94906"

URI_x86_64_v2_mrtg-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mrtg-selinux-2.17.10-11.el10.noarch.rpm;name=x86_64_v2_mrtg-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrtg-selinux}"
SRC_URI[x86_64_v2_mrtg-selinux.sha256sum] = "66d9f246f6a897796b271ad7072e8466ab02219ab3e7fbd8f40d55ebfba088c9"

URI_aarch64_mrtg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mrtg-2.17.10-11.el10.aarch64.rpm;name=aarch64_mrtg;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrtg}"
SRC_URI[aarch64_mrtg.sha256sum] = "1e8be51221a30a264805ad00bb0f6256ec2f25640b3188a98f336480dcbc8c55"

URI_aarch64_mrtg-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mrtg-selinux-2.17.10-11.el10.noarch.rpm;name=aarch64_mrtg-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrtg-selinux}"
SRC_URI[aarch64_mrtg-selinux.sha256sum] = "66d9f246f6a897796b271ad7072e8466ab02219ab3e7fbd8f40d55ebfba088c9"

RDEPENDS:mrtg = " \
 bash \
 gd \
 glibc \
 mrtg \
 mrtg-selinux \
 perl-CGI \
 perl-Carp \
 perl-Exporter \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IO \
 perl-IO-Socket-INET6 \
 perl-Math-BigInt \
 perl-POSIX \
 perl-Pod-Usage \
 perl-SNMP_Session \
 perl-Socket \
 perl-Socket6 \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-locale \
 perl-vars \
 systemd \
 "
RDEPENDS:mrtg-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
