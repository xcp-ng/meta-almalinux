# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rclone"
PV = "1.74.0"
PR = "2.el10_1"
PACKAGES = " \
 rclone \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rclone-1.74.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edcd2ea8be154e9b6f64e2aee677380b2ea80f8761f7102892d37b68384212b5"

URI_x86_64_v2_rclone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rclone-1.74.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rclone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rclone}"
SRC_URI[x86_64_v2_rclone.sha256sum] = "f43c6f2e7ef5475b41f84c363584d219e979debb8b695be641a4f7f54943d90f"

URI_aarch64_rclone = "${EPEL_MIRROR}/aarch64/Packages/r/rclone-1.74.0-2.el10_1.aarch64.rpm;name=aarch64_rclone;unpack=0"
SRC_URI:append = " ${URI_aarch64_rclone}"
SRC_URI[aarch64_rclone.sha256sum] = "fa328b95a3f79a4f5f63b68d39b00534c10d7ad83358f9da73945ada12459795"

RDEPENDS:rclone = " \
 glibc \
 "
