# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tcpreplay"
PV = "4.5.2"
PR = "1.el10_2"
PACKAGES = " \
 tcpreplay \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tcpreplay-4.5.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6b7676b55a2a77bff23d098ff990849f0b3500a63449e846facd0b105d99726"

URI_x86_64_v2_tcpreplay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcpreplay-4.5.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcpreplay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tcpreplay}"
SRC_URI[x86_64_v2_tcpreplay.sha256sum] = "9ac309d1693c5cd48d9035499b96410d4ed13102c5746287668c51584ba24659"

URI_aarch64_tcpreplay = "${EPEL_MIRROR}/aarch64/Packages/t/tcpreplay-4.5.2-1.el10_2.aarch64.rpm;name=aarch64_tcpreplay;unpack=0"
SRC_URI:append = " ${URI_aarch64_tcpreplay}"
SRC_URI[aarch64_tcpreplay.sha256sum] = "3ed9867b0f8be9b305da0d2391847b8f736df510de0942304f034366ec14d358"

RDEPENDS:tcpreplay = " \
 glibc \
 libpcap \
 tcpdump \
 "
