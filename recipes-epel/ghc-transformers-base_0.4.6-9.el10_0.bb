# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-transformers-base"
PV = "0.4.6"
PR = "9.el10_0"
PACKAGES = " \
 ghc-transformers-base \
 ghc-transformers-base-devel \
 ghc-transformers-base-doc \
 ghc-transformers-base-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-transformers-base-0.4.6-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84418198dca57bddada6621fc5aeaafc3dd485766966fcad50859d58a43dc6b5"

URI_x86_64_v2_ghc-transformers-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-transformers-base-0.4.6-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-transformers-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-transformers-base}"
SRC_URI[x86_64_v2_ghc-transformers-base.sha256sum] = "13aa00a140500d5e2f48faf6345107108372c2b2deca855e846a70c53bc3cc72"

URI_x86_64_v2_ghc-transformers-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-transformers-base-devel-0.4.6-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-transformers-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-transformers-base-devel}"
SRC_URI[x86_64_v2_ghc-transformers-base-devel.sha256sum] = "89034bf1bb5b1254fa278cb0740d635ed5983dbc84644a0db0cda18ba9551dcf"

URI_x86_64_v2_ghc-transformers-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-transformers-base-doc-0.4.6-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-transformers-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-transformers-base-doc}"
SRC_URI[x86_64_v2_ghc-transformers-base-doc.sha256sum] = "32e088388ce77580c279da5e97214fbed5dd3bbb902152467d5d5eda2e6c50b4"

URI_x86_64_v2_ghc-transformers-base-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-transformers-base-prof-0.4.6-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-transformers-base-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-transformers-base-prof}"
SRC_URI[x86_64_v2_ghc-transformers-base-prof.sha256sum] = "1ba3d8e122d5c6bd129c3f0043886a1506cc095040ad95acddb83c840d3216a0"

URI_aarch64_ghc-transformers-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-transformers-base-0.4.6-9.el10_0.aarch64.rpm;name=aarch64_ghc-transformers-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-transformers-base}"
SRC_URI[aarch64_ghc-transformers-base.sha256sum] = "e97fba08a66ac002ac59833d9b20c1556fd3c0e5d9c8f37958dd62a1109de2da"

URI_aarch64_ghc-transformers-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-transformers-base-devel-0.4.6-9.el10_0.aarch64.rpm;name=aarch64_ghc-transformers-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-transformers-base-devel}"
SRC_URI[aarch64_ghc-transformers-base-devel.sha256sum] = "ffebe8d521b14e19b6f1cca79bfb42c0203bde17ec48383d5c7b7d3746316cfc"

URI_aarch64_ghc-transformers-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-transformers-base-doc-0.4.6-9.el10_0.noarch.rpm;name=aarch64_ghc-transformers-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-transformers-base-doc}"
SRC_URI[aarch64_ghc-transformers-base-doc.sha256sum] = "c125c608bfe90326e96761f98508c88d5d7c973ca6b83f36516d1854bb18b55d"

URI_aarch64_ghc-transformers-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-transformers-base-prof-0.4.6-9.el10_0.aarch64.rpm;name=aarch64_ghc-transformers-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-transformers-base-prof}"
SRC_URI[aarch64_ghc-transformers-base-prof.sha256sum] = "8765424958916b880fb7065705d28521daf3cbbfc6ff6c5c5a962d4281edf74d"

RDEPENDS:ghc-transformers-base = " \
 ghc-array \
 ghc-base \
 ghc-base-orphans \
 ghc-ghc-bignum \
 ghc-stm \
 ghc-transformers \
 ghc-transformers-compat \
 glibc \
 gmp \
 "
RDEPENDS:ghc-transformers-base-devel = " \
 ghc-base-devel \
 ghc-base-orphans-devel \
 ghc-compiler \
 ghc-stm-devel \
 ghc-transformers-base \
 ghc-transformers-compat-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-transformers-base-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-transformers-base-prof = " \
 ghc-base-orphans-prof \
 ghc-base-prof \
 ghc-stm-prof \
 ghc-transformers-base-devel \
 ghc-transformers-compat-prof \
 ghc-transformers-prof \
 "
