# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-handlebars"
PV = "6.4.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-handlebars+default-devel \
 rust-handlebars+dir_source-devel \
 rust-handlebars+heck-devel \
 rust-handlebars+no_logging-devel \
 rust-handlebars+preserve_json_order-devel \
 rust-handlebars+string_helpers-devel \
 rust-handlebars+walkdir-devel \
 rust-handlebars-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-handlebars-6.4.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df723c4ee71a7e4562a6edb2c535b066854f637a268db2c13aefdf7fbbe986df"

URI_x86_64_v2_rust-handlebars+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-handlebars+default-devel-6.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-handlebars+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-handlebars+default-devel}"
SRC_URI[x86_64_v2_rust-handlebars+default-devel.sha256sum] = "ec38b197a7aaaacb9535dbe8ac0bf1da26c8ddb6cc239fb9f558a9eef94246e5"

URI_x86_64_v2_rust-handlebars+dir_source-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-handlebars+dir_source-devel-6.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-handlebars+dir_source-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-handlebars+dir_source-devel}"
SRC_URI[x86_64_v2_rust-handlebars+dir_source-devel.sha256sum] = "e729742989a699cd8ab4b22461f853b9197beb50635800582c6a8af627509acb"

URI_x86_64_v2_rust-handlebars+heck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-handlebars+heck-devel-6.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-handlebars+heck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-handlebars+heck-devel}"
SRC_URI[x86_64_v2_rust-handlebars+heck-devel.sha256sum] = "d224520e9b2380dc592ed0a477552a3e5612d71a4cd9fe04c4910ac3c5ab40cd"

URI_x86_64_v2_rust-handlebars+no_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-handlebars+no_logging-devel-6.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-handlebars+no_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-handlebars+no_logging-devel}"
SRC_URI[x86_64_v2_rust-handlebars+no_logging-devel.sha256sum] = "ff14117232a0ebe7a05db19585ed0d1396087d1619e7a533e8787d2379581a09"

URI_x86_64_v2_rust-handlebars+preserve_json_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-handlebars+preserve_json_order-devel-6.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-handlebars+preserve_json_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-handlebars+preserve_json_order-devel}"
SRC_URI[x86_64_v2_rust-handlebars+preserve_json_order-devel.sha256sum] = "99e96b6246d0ef68dd72e7816a808bcff78b26b830db3a0d69c4e6da91534a72"

URI_x86_64_v2_rust-handlebars+string_helpers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-handlebars+string_helpers-devel-6.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-handlebars+string_helpers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-handlebars+string_helpers-devel}"
SRC_URI[x86_64_v2_rust-handlebars+string_helpers-devel.sha256sum] = "1cd74cf6bc7ff59689ca44633a37e63bd854437d22b136977cbde8bcc36f30da"

URI_x86_64_v2_rust-handlebars+walkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-handlebars+walkdir-devel-6.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-handlebars+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-handlebars+walkdir-devel}"
SRC_URI[x86_64_v2_rust-handlebars+walkdir-devel.sha256sum] = "c6cb0cbd41bfa40e557d6141ef44b4a02b60effef652a5ca9cb0bd0cd20924ed"

URI_x86_64_v2_rust-handlebars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-handlebars-devel-6.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-handlebars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-handlebars-devel}"
SRC_URI[x86_64_v2_rust-handlebars-devel.sha256sum] = "2a10e489f48e5ed05d33251ec54e837f0b1ac9ae10db59893cd4a1e7314520f0"

URI_aarch64_rust-handlebars+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-handlebars+default-devel-6.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-handlebars+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-handlebars+default-devel}"
SRC_URI[aarch64_rust-handlebars+default-devel.sha256sum] = "5419659cec7f72e91b0daca4146c10f303f345d1401b7f5a1c7eb64db322a080"

URI_aarch64_rust-handlebars+dir_source-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-handlebars+dir_source-devel-6.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-handlebars+dir_source-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-handlebars+dir_source-devel}"
SRC_URI[aarch64_rust-handlebars+dir_source-devel.sha256sum] = "ad417e4e06843a64c6fed83d2bdcee051811784b0f2a14f64a7123e4b4f4dd8c"

URI_aarch64_rust-handlebars+heck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-handlebars+heck-devel-6.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-handlebars+heck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-handlebars+heck-devel}"
SRC_URI[aarch64_rust-handlebars+heck-devel.sha256sum] = "e99b605deb7212b7c5e776d1ec267d8ac5f89f460191cd11a0ccf6b5cec3f299"

URI_aarch64_rust-handlebars+no_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-handlebars+no_logging-devel-6.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-handlebars+no_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-handlebars+no_logging-devel}"
SRC_URI[aarch64_rust-handlebars+no_logging-devel.sha256sum] = "6a4a21a7a797599c70d7c274181b97c41024008e766f90a485d9781a53f661aa"

URI_aarch64_rust-handlebars+preserve_json_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-handlebars+preserve_json_order-devel-6.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-handlebars+preserve_json_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-handlebars+preserve_json_order-devel}"
SRC_URI[aarch64_rust-handlebars+preserve_json_order-devel.sha256sum] = "6af957a811255296c75b74a518a6aa481aba64313b5895d13d332d242a0e8af8"

URI_aarch64_rust-handlebars+string_helpers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-handlebars+string_helpers-devel-6.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-handlebars+string_helpers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-handlebars+string_helpers-devel}"
SRC_URI[aarch64_rust-handlebars+string_helpers-devel.sha256sum] = "640e3b614dcb7beeb44bdf9da87621b02d64e37260266292c33ffb0c041d83da"

URI_aarch64_rust-handlebars+walkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-handlebars+walkdir-devel-6.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-handlebars+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-handlebars+walkdir-devel}"
SRC_URI[aarch64_rust-handlebars+walkdir-devel.sha256sum] = "de48e5b36e08f25e820fc2dfe7edb5a1a94d2106655153f7a03556d06c615278"

URI_aarch64_rust-handlebars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-handlebars-devel-6.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-handlebars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-handlebars-devel}"
SRC_URI[aarch64_rust-handlebars-devel.sha256sum] = "eea651dab96e5dc1e090922680b87698411accc526e6439085d607270fc449be"

RDEPENDS:rust-handlebars+default-devel = " \
 cargo \
 rust-handlebars+preserve_json_order-devel \
 rust-handlebars-devel \
 "
RDEPENDS:rust-handlebars+dir_source-devel = " \
 cargo \
 rust-handlebars+walkdir-devel \
 rust-handlebars-devel \
 "
RDEPENDS:rust-handlebars+heck-devel = " \
 cargo \
 rust-handlebars-devel \
 rust-heck+default-devel \
 "
RDEPENDS:rust-handlebars+no_logging-devel = " \
 cargo \
 rust-handlebars-devel \
 "
RDEPENDS:rust-handlebars+preserve_json_order-devel = " \
 cargo \
 rust-handlebars-devel \
 rust-serde_json+preserve_order-devel \
 "
RDEPENDS:rust-handlebars+string_helpers-devel = " \
 cargo \
 rust-handlebars+heck-devel \
 rust-handlebars-devel \
 "
RDEPENDS:rust-handlebars+walkdir-devel = " \
 cargo \
 rust-handlebars-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-handlebars-devel = " \
 bash \
 cargo \
 rust \
 rust-derive_builder+default-devel \
 rust-log+default-devel \
 rust-num-order+default-devel \
 rust-pest+default-devel \
 rust-pest_derive+default-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 "
