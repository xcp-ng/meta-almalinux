# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rrdtool"
PV = "1.8.0"
PR = "21.el10_2"
PACKAGES = " \
 python3-rrdtool \
 rrdtool \
 rrdtool-devel \
 rrdtool-doc \
 rrdtool-lua \
 rrdtool-perl \
 rrdtool-ruby \
 rrdtool-tcl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rrdtool-1.8.0-21.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36cead5af26146beb368d86e3bbe1d10c1660b1869b619117e8406488729ad10"

URI_x86_64_v2_python3-rrdtool = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-rrdtool-1.8.0-21.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-rrdtool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rrdtool}"
SRC_URI[x86_64_v2_python3-rrdtool.sha256sum] = "5e03e733fe39744caf9a799c71e1a675d3bf987db59b3161932826f0c73b2a75"

URI_x86_64_v2_rrdtool = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rrdtool-1.8.0-21.el10_2.x86_64_v2.rpm;name=x86_64_v2_rrdtool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool}"
SRC_URI[x86_64_v2_rrdtool.sha256sum] = "cb237cc54d7397373ad57ea7da45da7dfe44c0b82efef9e489a92e513752993e"

URI_x86_64_v2_rrdtool-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-devel-1.8.0-21.el10_2.x86_64_v2.rpm;name=x86_64_v2_rrdtool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-devel}"
SRC_URI[x86_64_v2_rrdtool-devel.sha256sum] = "1d66a398b7aabc6cdf6880911655b2594ebd3a02c834b8a4395635221bbf6c84"

URI_x86_64_v2_rrdtool-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-doc-1.8.0-21.el10_2.x86_64_v2.rpm;name=x86_64_v2_rrdtool-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-doc}"
SRC_URI[x86_64_v2_rrdtool-doc.sha256sum] = "bef4210de46c5fe6ed29df157f26bac5074b105224b3d367a10cd820201e0a13"

URI_x86_64_v2_rrdtool-lua = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-lua-1.8.0-21.el10_2.x86_64_v2.rpm;name=x86_64_v2_rrdtool-lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-lua}"
SRC_URI[x86_64_v2_rrdtool-lua.sha256sum] = "900bda05ec98c361c62a9202d7353b8b37acc38edc8596e85d2607df01db302a"

URI_x86_64_v2_rrdtool-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rrdtool-perl-1.8.0-21.el10_2.x86_64_v2.rpm;name=x86_64_v2_rrdtool-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-perl}"
SRC_URI[x86_64_v2_rrdtool-perl.sha256sum] = "7b830fa8121ddc7ab63039ff8ccb264eb5ebb18b140defd426502379141fba1e"

URI_x86_64_v2_rrdtool-ruby = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-ruby-1.8.0-21.el10_2.x86_64_v2.rpm;name=x86_64_v2_rrdtool-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-ruby}"
SRC_URI[x86_64_v2_rrdtool-ruby.sha256sum] = "1e65a6feb72445b12ff4981df04f9fdb486681377864c491124129a5ed78a44d"

URI_x86_64_v2_rrdtool-tcl = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-tcl-1.8.0-21.el10_2.x86_64_v2.rpm;name=x86_64_v2_rrdtool-tcl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-tcl}"
SRC_URI[x86_64_v2_rrdtool-tcl.sha256sum] = "233ecbf178aad841c60267964be06ddd2d421a0ad39213daf68eaa27e3636ee2"

URI_aarch64_python3-rrdtool = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-rrdtool-1.8.0-21.el10_2.aarch64.rpm;name=aarch64_python3-rrdtool;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rrdtool}"
SRC_URI[aarch64_python3-rrdtool.sha256sum] = "18e4945909c21ef4ecef722f6476d0c5fbca6281299a0b7575d352499ad4c47b"

URI_aarch64_rrdtool = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rrdtool-1.8.0-21.el10_2.aarch64.rpm;name=aarch64_rrdtool;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool}"
SRC_URI[aarch64_rrdtool.sha256sum] = "dc34edc145b57c2fcdb875d6691b7ebe0f550942764f3501be6dc21a874ffb39"

URI_aarch64_rrdtool-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-devel-1.8.0-21.el10_2.aarch64.rpm;name=aarch64_rrdtool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-devel}"
SRC_URI[aarch64_rrdtool-devel.sha256sum] = "5ded161e80d912cf12697e75e0eaf7b47ba5a785cb2b5093aa0ad271f9044a74"

URI_aarch64_rrdtool-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-doc-1.8.0-21.el10_2.aarch64.rpm;name=aarch64_rrdtool-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-doc}"
SRC_URI[aarch64_rrdtool-doc.sha256sum] = "9c72dc23caa2c0e93590749676414fa66541de34e50ef202d614c3b31cb8274c"

URI_aarch64_rrdtool-lua = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-lua-1.8.0-21.el10_2.aarch64.rpm;name=aarch64_rrdtool-lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-lua}"
SRC_URI[aarch64_rrdtool-lua.sha256sum] = "d3ebd11fa83777052383b522e07d8297372b7fdef9db54cc6d8ea089e4d131f5"

URI_aarch64_rrdtool-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rrdtool-perl-1.8.0-21.el10_2.aarch64.rpm;name=aarch64_rrdtool-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-perl}"
SRC_URI[aarch64_rrdtool-perl.sha256sum] = "39c8d5a85607a7e58ae707b963a6cf6a34e4815afcacd8d8eb6a2f543f288b3d"

URI_aarch64_rrdtool-ruby = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-ruby-1.8.0-21.el10_2.aarch64.rpm;name=aarch64_rrdtool-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-ruby}"
SRC_URI[aarch64_rrdtool-ruby.sha256sum] = "91b91358a77b1c15bfcff6d9c8cb77653891e3898cad8518f51cb73526d8fd0c"

URI_aarch64_rrdtool-tcl = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-tcl-1.8.0-21.el10_2.aarch64.rpm;name=aarch64_rrdtool-tcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-tcl}"
SRC_URI[aarch64_rrdtool-tcl.sha256sum] = "a36f7bb52dd09315117cab8b5980b020ea45843dd65bf55103deddeccfefefb6"

RDEPENDS:python3-rrdtool = " \
 glibc \
 python3 \
 rrdtool \
 "
RDEPENDS:rrdtool = " \
 bash \
 cairo \
 dejavu-sans-mono-fonts \
 glib2 \
 glibc \
 harfbuzz \
 libpng \
 libxml2 \
 pango \
 systemd \
 "
RDEPENDS:rrdtool-devel = " \
 pkgconf-pkg-config \
 rrdtool \
 "
RDEPENDS:rrdtool-doc = " \
 "
RDEPENDS:rrdtool-lua = " \
 cairo \
 glib2 \
 glibc \
 harfbuzz \
 libpng \
 libxml2 \
 lua-libs \
 pango \
 rrdtool \
 "
RDEPENDS:rrdtool-perl = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Fcntl \
 perl-IO \
 perl-IPC-Open3 \
 perl-libs \
 perl-vars \
 rrdtool \
 "
RDEPENDS:rrdtool-ruby = " \
 glibc \
 rrdtool \
 ruby-libs \
 "
RDEPENDS:rrdtool-tcl = " \
 glibc \
 rrdtool \
 tcl \
 "
