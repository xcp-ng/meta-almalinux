# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strum_macros0.27"
PV = "0.27.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-strum_macros0.27+default-devel \
 rust-strum_macros0.27-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strum_macros0.27-0.27.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb5c690c6c35e639d40e05c610dd7736ea8fe946722bb8d1a4293b6e700a3e58"

URI_x86_64_v2_rust-strum_macros0.27+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum_macros0.27+default-devel-0.27.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum_macros0.27+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum_macros0.27+default-devel}"
SRC_URI[x86_64_v2_rust-strum_macros0.27+default-devel.sha256sum] = "d5c0d38f47afe2937e26ab88ab86f6b16241ee9f9adf313c7557afc9e5c7d780"

URI_x86_64_v2_rust-strum_macros0.27-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum_macros0.27-devel-0.27.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum_macros0.27-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum_macros0.27-devel}"
SRC_URI[x86_64_v2_rust-strum_macros0.27-devel.sha256sum] = "a089cc2682e2d8706a217edb529c4a2dcace7bb4cda7b3b1621a5754f7402429"

URI_aarch64_rust-strum_macros0.27+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum_macros0.27+default-devel-0.27.2-1.el10_3.noarch.rpm;name=aarch64_rust-strum_macros0.27+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum_macros0.27+default-devel}"
SRC_URI[aarch64_rust-strum_macros0.27+default-devel.sha256sum] = "d60b8a7c769241229bb1e2ac699ec355f399547402257752fa39fa45cec8cf75"

URI_aarch64_rust-strum_macros0.27-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum_macros0.27-devel-0.27.2-1.el10_3.noarch.rpm;name=aarch64_rust-strum_macros0.27-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum_macros0.27-devel}"
SRC_URI[aarch64_rust-strum_macros0.27-devel.sha256sum] = "1f94fde3fb2a0dab7d0f4792da7699cef5d9cd3550781cfb8ea6f82d26ec00ff"

RDEPENDS:rust-strum_macros0.27+default-devel = " \
 cargo \
 rust-strum_macros0.27-devel \
 "
RDEPENDS:rust-strum_macros0.27-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+parsing-devel \
 "
