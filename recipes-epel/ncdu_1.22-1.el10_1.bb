# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ncdu"
PV = "1.22"
PR = "1.el10_1"
PACKAGES = " \
 ncdu \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ncdu-1.22-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4880d9e77fd86a5051cae933ea2179bafc766fa54034dcda51adc584412cb299"

URI_x86_64_v2_ncdu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ncdu-1.22-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ncdu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncdu}"
SRC_URI[x86_64_v2_ncdu.sha256sum] = "3d961f2aa15c27811323fac00e4ab9bd534c81925a475718e0dbc19d6ffbb2b5"

URI_aarch64_ncdu = "${EPEL_MIRROR}/aarch64/Packages/n/ncdu-1.22-1.el10_1.aarch64.rpm;name=aarch64_ncdu;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncdu}"
SRC_URI[aarch64_ncdu.sha256sum] = "fbb23ea36f00c46b96cb9f3bb3779bdbbf12bd6d850cf27a7b2b6bd9dcb79bcd"

RDEPENDS:ncdu = " \
 glibc \
 ncurses-libs \
 "
