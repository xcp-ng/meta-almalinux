# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-time"
PV = "0.3.47"
PR = "1.el10_2"
PACKAGES = " \
 rust-time+alloc-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+large-dates-devel \
 rust-time+local-offset-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 rust-time+quickcheck-devel \
 rust-time+rand-devel \
 rust-time+rand08-devel \
 rust-time+rand09-devel \
 rust-time+serde-devel \
 rust-time+serde-human-readable-devel \
 rust-time+serde-well-known-devel \
 rust-time+std-devel \
 rust-time-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-time-0.3.47-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ac288f92dd3f1583f826a28afe11bb9b66db7412e4689cfa36b3ae467623056"

URI_x86_64_v2_rust-time+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+alloc-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+alloc-devel}"
SRC_URI[x86_64_v2_rust-time+alloc-devel.sha256sum] = "9e3b979649d97ea05555e0153c04729727c6baa7f3575336ca1bf3b3ea614e57"

URI_x86_64_v2_rust-time+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+default-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+default-devel}"
SRC_URI[x86_64_v2_rust-time+default-devel.sha256sum] = "1c6fecbe3165188c9034a8500a6fec73b20280a837eab53717acb52b3dfcd594"

URI_x86_64_v2_rust-time+formatting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+formatting-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+formatting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+formatting-devel}"
SRC_URI[x86_64_v2_rust-time+formatting-devel.sha256sum] = "12fe2c1d0dc07b6d5ef2e59f7439c07aa3453ed3829ce9a5dc05ce9b3608042c"

URI_x86_64_v2_rust-time+large-dates-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+large-dates-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+large-dates-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+large-dates-devel}"
SRC_URI[x86_64_v2_rust-time+large-dates-devel.sha256sum] = "acc11261d74dc509e128c0215a5aaee3fae5b95d77005820dd22333bc573202d"

URI_x86_64_v2_rust-time+local-offset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+local-offset-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+local-offset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+local-offset-devel}"
SRC_URI[x86_64_v2_rust-time+local-offset-devel.sha256sum] = "6c0203c6f0b019306a295325d9024117c77f439cd61b01034c3f0514f5be4b70"

URI_x86_64_v2_rust-time+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+macros-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+macros-devel}"
SRC_URI[x86_64_v2_rust-time+macros-devel.sha256sum] = "9f1aa6cd0ba4e37776e904808ccc5750ff2aaf70ee73827dec4b8b8e485cd66b"

URI_x86_64_v2_rust-time+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+parsing-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+parsing-devel}"
SRC_URI[x86_64_v2_rust-time+parsing-devel.sha256sum] = "25fbbbc6418431170895fa2918736c89b110aeb807a5146431d188b32f171cf9"

URI_x86_64_v2_rust-time+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+quickcheck-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-time+quickcheck-devel.sha256sum] = "e1cdf6ebee0945174b7dbcbdf33b3749077b75194c37de6532de1cb26ac9bf99"

URI_x86_64_v2_rust-time+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+rand-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+rand-devel}"
SRC_URI[x86_64_v2_rust-time+rand-devel.sha256sum] = "bcf16a91b6952712b4b62e501f4452f558ef5b19e782ca73ac5332eab61ce858"

URI_x86_64_v2_rust-time+rand08-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+rand08-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+rand08-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+rand08-devel}"
SRC_URI[x86_64_v2_rust-time+rand08-devel.sha256sum] = "2c55c6d2eaeace5798503f448de9c64c8fe902ef9b699dc590b0157238e02e4d"

URI_x86_64_v2_rust-time+rand09-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+rand09-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+rand09-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+rand09-devel}"
SRC_URI[x86_64_v2_rust-time+rand09-devel.sha256sum] = "600bd66395dd39b1f880058eceb8802c0f3da2b764788ce13cdcc274bc958ae2"

URI_x86_64_v2_rust-time+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+serde-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+serde-devel}"
SRC_URI[x86_64_v2_rust-time+serde-devel.sha256sum] = "5fb6af57f755767806303c092b5c6bb60dafef9fd9d81f4d7d4a6a3b55ecbf61"

URI_x86_64_v2_rust-time+serde-human-readable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+serde-human-readable-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+serde-human-readable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+serde-human-readable-devel}"
SRC_URI[x86_64_v2_rust-time+serde-human-readable-devel.sha256sum] = "6f3c42ea1cd4d5a482eb468ac2ee7e05db100b06e4bcbbd305bf46b3d4195e20"

URI_x86_64_v2_rust-time+serde-well-known-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+serde-well-known-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+serde-well-known-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+serde-well-known-devel}"
SRC_URI[x86_64_v2_rust-time+serde-well-known-devel.sha256sum] = "84095f84cd8af9318a493157b566c748da9a681a6e1e1f0cf8382c67440efbaf"

URI_x86_64_v2_rust-time+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+std-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+std-devel}"
SRC_URI[x86_64_v2_rust-time+std-devel.sha256sum] = "a8ff4eba920801fd8ae920e28bfef1990a6bf77474d821bc113b3c6c6a7abed1"

URI_x86_64_v2_rust-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-devel-0.3.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-devel}"
SRC_URI[x86_64_v2_rust-time-devel.sha256sum] = "021eecb6305add5268a77cce7b239a4afffe4714157cd98f5dac879dadd54248"

URI_aarch64_rust-time+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+alloc-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+alloc-devel}"
SRC_URI[aarch64_rust-time+alloc-devel.sha256sum] = "25d40da1b5b4887ff928feafe4fe061f421bd9b150ba24ecc9a8d2642458e7f3"

URI_aarch64_rust-time+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+default-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+default-devel}"
SRC_URI[aarch64_rust-time+default-devel.sha256sum] = "268d17cc719c86037c10c3ffd5fbe355df23268509dab481fe83ad167fde7b70"

URI_aarch64_rust-time+formatting-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+formatting-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+formatting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+formatting-devel}"
SRC_URI[aarch64_rust-time+formatting-devel.sha256sum] = "8cb6bde7097833f8d4f358ebcb05a01d8da60d7ac489aa779851bd69bddc545b"

URI_aarch64_rust-time+large-dates-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+large-dates-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+large-dates-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+large-dates-devel}"
SRC_URI[aarch64_rust-time+large-dates-devel.sha256sum] = "c661200594acd3cd81e7ff00287f1f7b7186796360ca55a49e6f1347380305fe"

URI_aarch64_rust-time+local-offset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+local-offset-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+local-offset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+local-offset-devel}"
SRC_URI[aarch64_rust-time+local-offset-devel.sha256sum] = "30a4ab309912a4d5d73e71985beaa6b51829ced0af4aad8727536e2634d8fbcb"

URI_aarch64_rust-time+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+macros-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+macros-devel}"
SRC_URI[aarch64_rust-time+macros-devel.sha256sum] = "3708bd86278c643600a424eafb13bfb6b63a1a1f254c6652963f62aed8e4135a"

URI_aarch64_rust-time+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+parsing-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+parsing-devel}"
SRC_URI[aarch64_rust-time+parsing-devel.sha256sum] = "58b59724e7bda53e11517d7534d42103ccd6ee292f2afd119861c165f671ea9c"

URI_aarch64_rust-time+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+quickcheck-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+quickcheck-devel}"
SRC_URI[aarch64_rust-time+quickcheck-devel.sha256sum] = "a3216cd57e878fc117d065270e6c81aca9ee76696cf791993bfabaf8d7cf1dfa"

URI_aarch64_rust-time+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+rand-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+rand-devel}"
SRC_URI[aarch64_rust-time+rand-devel.sha256sum] = "cb9295334f2e1ccfa426ab804bc471dec5220de1f25edc9380b674e73f31dfb5"

URI_aarch64_rust-time+rand08-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+rand08-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+rand08-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+rand08-devel}"
SRC_URI[aarch64_rust-time+rand08-devel.sha256sum] = "ccaa1decbe0761878eb917744383252d784a072f5b4b2755cf9ecda820de052b"

URI_aarch64_rust-time+rand09-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+rand09-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+rand09-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+rand09-devel}"
SRC_URI[aarch64_rust-time+rand09-devel.sha256sum] = "3c905d7e835601f4fde0c1e33537830cc3e74a6174c34580c7417f1ba8d9ba30"

URI_aarch64_rust-time+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+serde-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+serde-devel}"
SRC_URI[aarch64_rust-time+serde-devel.sha256sum] = "8f1a2c0d55abe70f43991f2c9fdad16f295ce3515fefb01c5076b0ac319ab9f8"

URI_aarch64_rust-time+serde-human-readable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+serde-human-readable-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+serde-human-readable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+serde-human-readable-devel}"
SRC_URI[aarch64_rust-time+serde-human-readable-devel.sha256sum] = "b7904c8f229ff5590e3ea50da4bc11d294830fb21db8b74cd841028fbdbbce03"

URI_aarch64_rust-time+serde-well-known-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+serde-well-known-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+serde-well-known-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+serde-well-known-devel}"
SRC_URI[aarch64_rust-time+serde-well-known-devel.sha256sum] = "ee896273fe9bb208432eea2185eaf906cfcabdf93cec0d4d74b33a8b1ca72108"

URI_aarch64_rust-time+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+std-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+std-devel}"
SRC_URI[aarch64_rust-time+std-devel.sha256sum] = "c24d0d55df32f6c240124d74c40b06656c235de34489ee17812ce494bb1da5d6"

URI_aarch64_rust-time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-devel-0.3.47-1.el10_2.noarch.rpm;name=aarch64_rust-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-devel}"
SRC_URI[aarch64_rust-time-devel.sha256sum] = "077fd5287f13fa88b63802c4b134f95a854058eb74e367f965e1161bf2d2a9cc"

RDEPENDS:rust-time+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+default-devel = " \
 cargo \
 rust-time+std-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+formatting-devel = " \
 cargo \
 rust-itoa+default-devel \
 rust-time+std-devel \
 rust-time-devel \
 rust-time-macros+default-devel \
 rust-time-macros+formatting-devel \
 "
RDEPENDS:rust-time+large-dates-devel = " \
 cargo \
 rust-time-core+large-dates-devel \
 rust-time-devel \
 rust-time-macros+default-devel \
 rust-time-macros+large-dates-devel \
 "
RDEPENDS:rust-time+local-offset-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-num_threads+default-devel \
 rust-time+std-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+macros-devel = " \
 cargo \
 rust-time-devel \
 rust-time-macros+default-devel \
 "
RDEPENDS:rust-time+parsing-devel = " \
 cargo \
 rust-time-devel \
 rust-time-macros+default-devel \
 rust-time-macros+parsing-devel \
 "
RDEPENDS:rust-time+quickcheck-devel = " \
 cargo \
 rust-deranged+quickcheck-devel \
 rust-quickcheck-devel \
 rust-time+alloc-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+rand-devel = " \
 cargo \
 rust-time+rand08-devel \
 rust-time+rand09-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+rand08-devel = " \
 cargo \
 rust-deranged+rand08-devel \
 rust-rand0.8-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+rand09-devel = " \
 cargo \
 rust-deranged+rand09-devel \
 rust-rand0.9-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+serde-devel = " \
 cargo \
 rust-deranged+serde-devel \
 rust-serde_core-devel \
 rust-time-devel \
 rust-time-macros+default-devel \
 rust-time-macros+serde-devel \
 "
RDEPENDS:rust-time+serde-human-readable-devel = " \
 cargo \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time+serde-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+serde-well-known-devel = " \
 cargo \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time+serde-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+std-devel = " \
 cargo \
 rust-time+alloc-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time-devel = " \
 cargo \
 rust \
 rust-deranged+default-devel \
 rust-deranged+powerfmt-devel \
 rust-num-conv+default-devel \
 rust-powerfmt-devel \
 rust-time-core+default-devel \
 "
