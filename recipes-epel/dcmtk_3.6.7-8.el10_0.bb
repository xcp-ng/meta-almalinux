# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dcmtk"
PV = "3.6.7"
PR = "8.el10_0"
PACKAGES = " \
 dcmtk \
 dcmtk-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dcmtk-3.6.7-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7aa77e4d059b949390c0a0e9669dc497446a6cbe2083c05d9c2056af0fdbbcc7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dcmtk-3.6.7-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dcmtk;unpack=0"
SRC_URI[x86_64_v2_dcmtk.sha256sum] = "7226aee8c89d98d72a1eb091520ec0f87d0d6c9c55da765b7698ec24e1a6fc7d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dcmtk-devel-3.6.7-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dcmtk-devel;unpack=0"
SRC_URI[x86_64_v2_dcmtk-devel.sha256sum] = "7f1add632015d3e556db8895af622d822b1ab330881ccb7e8169a906b7654000"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dcmtk-3.6.7-8.el10_0.aarch64.rpm;name=aarch64_dcmtk;unpack=0"
SRC_URI[aarch64_dcmtk.sha256sum] = "78cda87a4a13a03372df161b4791b98683b06c320e18a837a1f9e57fd3c96b0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dcmtk-devel-3.6.7-8.el10_0.aarch64.rpm;name=aarch64_dcmtk-devel;unpack=0"
SRC_URI[aarch64_dcmtk-devel.sha256sum] = "bac24189830c0dd4c2294a0e7a26588597d4b99cb18fd1446be47859910c9cfb"

RDEPENDS:dcmtk = " \
 glibc \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 libxml2 \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dcmtk-devel = " \
 cmake-filesystem \
 dcmtk \
 libpng-devel \
 libtiff-devel \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
