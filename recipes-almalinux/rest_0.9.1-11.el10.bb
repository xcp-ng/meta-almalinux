# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rest"
PV = "0.9.1"
PR = "11.el10"
PACKAGES = " \
 rest \
 rest-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rest-0.9.1-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7be74dafe2883123060ec52ef7cdeda74a83e43f511be25cb79046a33ed48ce0"

URI_x86_64_v2_rest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rest-0.9.1-11.el10.x86_64_v2.rpm;name=x86_64_v2_rest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rest}"
SRC_URI[x86_64_v2_rest.sha256sum] = "92cc24a3cccd0d3fc6c6370e2cc692c34c0d9f0a6ca3a32aa516b248c937b8ed"

URI_x86_64_v2_rest-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rest-devel-0.9.1-11.el10.x86_64_v2.rpm;name=x86_64_v2_rest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rest-devel}"
SRC_URI[x86_64_v2_rest-devel.sha256sum] = "128953eccd7d7dba37b184b1e3b63425668b2740d6a4138ac8a086693c3b0a94"

URI_aarch64_rest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rest-0.9.1-11.el10.aarch64.rpm;name=aarch64_rest;unpack=0"
SRC_URI:append = " ${URI_aarch64_rest}"
SRC_URI[aarch64_rest.sha256sum] = "1f2eb51f7b3ac869e8492ec2a8bda7d5964a9318e335d07d03b7d40b50ffe077"

URI_aarch64_rest-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rest-devel-0.9.1-11.el10.aarch64.rpm;name=aarch64_rest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rest-devel}"
SRC_URI[aarch64_rest-devel.sha256sum] = "91cf8ddd4062688e5e90030ced67fc9c212d60cd28abc1abe772ab990f82a868"

RDEPENDS:rest = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 libsoup3 \
 libxml2 \
 "
RDEPENDS:rest-devel = " \
 glib2-devel \
 json-glib-devel \
 libsoup3-devel \
 libxml2-devel \
 pkgconf-pkg-config \
 rest \
 rest-devel \
 "
