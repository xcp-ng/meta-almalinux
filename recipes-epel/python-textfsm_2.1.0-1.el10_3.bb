# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-textfsm"
PV = "2.1.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-textfsm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-textfsm-2.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0854fdd9a9e59d5b22a16eda71812823b15806e24679b6a57441dde2e8f326b0"

URI_x86_64_v2_python3-textfsm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-textfsm-2.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-textfsm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-textfsm}"
SRC_URI[x86_64_v2_python3-textfsm.sha256sum] = "879c10bdb4cc266bfe2fc04110a6226d3c05b8266ad1c672e413e7c74066da01"

URI_aarch64_python3-textfsm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-textfsm-2.1.0-1.el10_3.noarch.rpm;name=aarch64_python3-textfsm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-textfsm}"
SRC_URI[aarch64_python3-textfsm.sha256sum] = "93fdde7acfb58205cc5db8e5d5bb77031f4efaf590c65d65c566d17ff0fc9253"

RDEPENDS:python3-textfsm = " \
 python3 \
 "
