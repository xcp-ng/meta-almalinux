# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-attica"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-attica \
 kf6-attica-devel \
 kf6-attica-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-attica-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5085ff04e1c11677ec52220117251756436c985a737f4f124717560bf819e1af"

URI_x86_64_v2_kf6-attica = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-attica;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica}"
SRC_URI[x86_64_v2_kf6-attica.sha256sum] = "5d2502d966ec9830c3e317682da53c874d78332ae293d5a2ca5de55f23ac5edb"

URI_x86_64_v2_kf6-attica-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-attica-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica-devel}"
SRC_URI[x86_64_v2_kf6-attica-devel.sha256sum] = "4f52f2a0b457ee3c412853489586ba000344780a5ef3c4f10e2fbfb74dd8228b"

URI_x86_64_v2_kf6-attica-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-attica-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica-doc}"
SRC_URI[x86_64_v2_kf6-attica-doc.sha256sum] = "1b01a1ab4a84b25fe7f6d572de2976667ac742d1e78e56291dad4bfdcaa9ae03"

URI_aarch64_kf6-attica = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-attica;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica}"
SRC_URI[aarch64_kf6-attica.sha256sum] = "77bfe3a50885c31225f24a15f338cfa471ba30367c58ed2bc420ae4415ab1611"

URI_aarch64_kf6-attica-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-attica-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica-devel}"
SRC_URI[aarch64_kf6-attica-devel.sha256sum] = "1df5449452d95c54d970c2eadfdbfa70d8fb3992afc62f4b0d06073513eb7c36"

URI_aarch64_kf6-attica-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-attica-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica-doc}"
SRC_URI[aarch64_kf6-attica-doc.sha256sum] = "4803217fbd5389c79d391aa94591f956813fddeb1e60561fbee4875f6a8e49a1"

RDEPENDS:kf6-attica = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-attica-devel = " \
 cmake-filesystem \
 kf6-attica \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-attica-doc = " \
 "
