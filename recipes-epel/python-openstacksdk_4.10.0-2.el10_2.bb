# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openstacksdk"
PV = "4.10.0"
PR = "2.el10_2"
PACKAGES = " \
 python3-openstacksdk \
 python3-openstacksdk-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openstacksdk-4.10.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c59184135e465bf2d38002e4572da8d601d256f4fe6dd7b4a96e735a62bf314e"

URI_x86_64_v2_python3-openstacksdk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openstacksdk-4.10.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openstacksdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openstacksdk}"
SRC_URI[x86_64_v2_python3-openstacksdk.sha256sum] = "ecb8d583b5ad4aa4878453c5d5fc6a020552574172c3944e0b42ba92b6223795"

URI_x86_64_v2_python3-openstacksdk-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openstacksdk-tests-4.10.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openstacksdk-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openstacksdk-tests}"
SRC_URI[x86_64_v2_python3-openstacksdk-tests.sha256sum] = "4ba934f39aa01fcab8612ed00926a0f7065c2e954f199b64697dc5be511b79fe"

URI_aarch64_python3-openstacksdk = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openstacksdk-4.10.0-2.el10_2.noarch.rpm;name=aarch64_python3-openstacksdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openstacksdk}"
SRC_URI[aarch64_python3-openstacksdk.sha256sum] = "aeb3f46b39764f8ac6f598eac1d13be75cbd3228551570d3ff6857b137d3fe4f"

URI_aarch64_python3-openstacksdk-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openstacksdk-tests-4.10.0-2.el10_2.noarch.rpm;name=aarch64_python3-openstacksdk-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openstacksdk-tests}"
SRC_URI[aarch64_python3-openstacksdk-tests.sha256sum] = "986b7fa50be7b09f74a938522e8efdd6dc77ace75be1e7e9672ee153a36ffbd5"

RDEPENDS:python3-openstacksdk = " \
 python3 \
 python3-cryptography \
 python3-decorator \
 python3-dogpile-cache \
 python3-iso8601 \
 python3-jmespath \
 python3-jsonpatch \
 python3-keystoneauth1 \
 python3-os-service-types \
 python3-pbr \
 python3-platformdirs \
 python3-psutil \
 python3-pyyaml \
 python3-requestsexceptions \
 python3-typing-extensions \
 "
RDEPENDS:python3-openstacksdk-tests = " \
 bash \
 python3 \
 python3-openstacksdk \
 "
