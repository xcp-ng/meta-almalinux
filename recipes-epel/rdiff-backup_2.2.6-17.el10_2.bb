# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rdiff-backup"
PV = "2.2.6"
PR = "17.el10_2"
PACKAGES = " \
 rdiff-backup \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rdiff-backup-2.2.6-17.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "72a5048da3da003d377be105582bc280441ac0e63291cb28cc5889c78d855db0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rdiff-backup-2.2.6-17.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rdiff-backup;unpack=0"
SRC_URI[x86_64_v2_rdiff-backup.sha256sum] = "1c7c9d38c88715f3cdb8bb26bf9fd3859dd5ef471dc0373b9a94baa3fdd90875"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rdiff-backup-2.2.6-17.el10_2.aarch64.rpm;name=aarch64_rdiff-backup;unpack=0"
SRC_URI[aarch64_rdiff-backup.sha256sum] = "b7314a1ffee8795700be1f02dd4f45bc3eaa9326fe1db6779195b96adf832d64"

RDEPENDS:rdiff-backup = " \
 glibc \
 librsync \
 python3 \
 python3-pyyaml \
 "
