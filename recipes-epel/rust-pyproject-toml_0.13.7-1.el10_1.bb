# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyproject-toml"
PV = "0.13.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-pyproject-toml+default-devel \
 rust-pyproject-toml+glob-devel \
 rust-pyproject-toml+pep639-glob-devel \
 rust-pyproject-toml+tracing-devel \
 rust-pyproject-toml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyproject-toml-0.13.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bffd6a4fafa983956545b53cfc55de1da4d6935b8436fedcbe3a0beb0e6e9a46"

URI_x86_64_v2_rust-pyproject-toml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml+default-devel-0.13.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml+default-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml+default-devel.sha256sum] = "4682736e93f2b30e26ea8e97d72b5db3d0305ee181b04c84a8ce23d7d62c897f"

URI_x86_64_v2_rust-pyproject-toml+glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml+glob-devel-0.13.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml+glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml+glob-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml+glob-devel.sha256sum] = "f93b0537c1c7283e2f99c082a322828e5deb8840705cde7b13c19f7faeb17c11"

URI_x86_64_v2_rust-pyproject-toml+pep639-glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml+pep639-glob-devel-0.13.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml+pep639-glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml+pep639-glob-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml+pep639-glob-devel.sha256sum] = "2a19c25ea3b2e6ccb97d1c0826c0585f31220995e12c8180290e83b2785998a4"

URI_x86_64_v2_rust-pyproject-toml+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml+tracing-devel-0.13.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml+tracing-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml+tracing-devel.sha256sum] = "80ece74a951da53b0a7be93c1e6d26dd0ab1396fec867cc52ab80f42789fb9d0"

URI_x86_64_v2_rust-pyproject-toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml-devel-0.13.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml-devel.sha256sum] = "d932e5da277559ce54c8251d0c83913b516b9e5e84dfa4bae5eac4d1626c59a7"

URI_aarch64_rust-pyproject-toml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml+default-devel-0.13.7-1.el10_1.noarch.rpm;name=aarch64_rust-pyproject-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml+default-devel}"
SRC_URI[aarch64_rust-pyproject-toml+default-devel.sha256sum] = "be0a3424e8aa552837ce0754301159a30649b54660af64a41e507bcd529e5025"

URI_aarch64_rust-pyproject-toml+glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml+glob-devel-0.13.7-1.el10_1.noarch.rpm;name=aarch64_rust-pyproject-toml+glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml+glob-devel}"
SRC_URI[aarch64_rust-pyproject-toml+glob-devel.sha256sum] = "2a7815ef207704ffee4bee067f460026baa199a15fcf5e5b61255e0b1f3ddf1a"

URI_aarch64_rust-pyproject-toml+pep639-glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml+pep639-glob-devel-0.13.7-1.el10_1.noarch.rpm;name=aarch64_rust-pyproject-toml+pep639-glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml+pep639-glob-devel}"
SRC_URI[aarch64_rust-pyproject-toml+pep639-glob-devel.sha256sum] = "9ce60627675961a143bbb931c45b56174ad25358d4a813f95f32355a6d127594"

URI_aarch64_rust-pyproject-toml+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml+tracing-devel-0.13.7-1.el10_1.noarch.rpm;name=aarch64_rust-pyproject-toml+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml+tracing-devel}"
SRC_URI[aarch64_rust-pyproject-toml+tracing-devel.sha256sum] = "f462e2e4e9d6d734f9a2105e0b705fa3264e60d99add714d563ab02c16908c38"

URI_aarch64_rust-pyproject-toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml-devel-0.13.7-1.el10_1.noarch.rpm;name=aarch64_rust-pyproject-toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml-devel}"
SRC_URI[aarch64_rust-pyproject-toml-devel.sha256sum] = "7a7869811f007bf5654eb5578ef2791f1b45751f9c41241e1be0208e0e9ebc9c"

RDEPENDS:rust-pyproject-toml+default-devel = " \
 cargo \
 rust-pyproject-toml-devel \
 "
RDEPENDS:rust-pyproject-toml+glob-devel = " \
 cargo \
 rust-glob+default-devel \
 rust-pyproject-toml-devel \
 "
RDEPENDS:rust-pyproject-toml+pep639-glob-devel = " \
 cargo \
 rust-pyproject-toml+glob-devel \
 rust-pyproject-toml-devel \
 "
RDEPENDS:rust-pyproject-toml+tracing-devel = " \
 cargo \
 rust-pep440_rs+tracing-devel \
 rust-pep508_rs+tracing-devel \
 rust-pyproject-toml-devel \
 "
RDEPENDS:rust-pyproject-toml-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-indexmap+serde-devel \
 rust-pep440_rs+default-devel \
 rust-pep508_rs+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-thiserror+default-devel \
 rust-toml+parse-devel \
 rust-toml+serde-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 "
