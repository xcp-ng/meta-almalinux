# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksanecore"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 ksanecore \
 ksanecore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksanecore-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7988d029e3aa5ca60ebbe41a63af4a7fe9612f14ea43bbbadb3179208fcab9b"

URI_x86_64_v2_ksanecore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksanecore-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksanecore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksanecore}"
SRC_URI[x86_64_v2_ksanecore.sha256sum] = "cca67ab90300fc5acb0f4eb0bdbc8dbc7a23dd8612bd6cb1d0603223830acffb"

URI_x86_64_v2_ksanecore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksanecore-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksanecore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksanecore-devel}"
SRC_URI[x86_64_v2_ksanecore-devel.sha256sum] = "fa754626f3fb362503019310ee2a5d6a7bf20fbfbe2138877e7670b4f41b5dd4"

URI_aarch64_ksanecore = "${EPEL_MIRROR}/aarch64/Packages/k/ksanecore-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ksanecore;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksanecore}"
SRC_URI[aarch64_ksanecore.sha256sum] = "e9f3eec1fdf29211546e264dae497a722c782a4e90830416a930e639c3bdd759"

URI_aarch64_ksanecore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ksanecore-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ksanecore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksanecore-devel}"
SRC_URI[aarch64_ksanecore-devel.sha256sum] = "340f5c338d2742f9821c71fbb90e9822ad77b763b3259322479263b4df320f8b"

RDEPENDS:ksanecore = " \
 glibc \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 sane-backends-libs \
 "
RDEPENDS:ksanecore-devel = " \
 cmake-filesystem \
 ksanecore \
 qt6-qtbase-devel \
 "
