# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zstd-sys"
PV = "2.0.15"
PR = "1.el10_1"
PACKAGES = " \
 rust-zstd-sys+bindgen-devel \
 rust-zstd-sys+debug-devel \
 rust-zstd-sys+default-devel \
 rust-zstd-sys+experimental-devel \
 rust-zstd-sys+fat-lto-devel \
 rust-zstd-sys+legacy-devel \
 rust-zstd-sys+no_asm-devel \
 rust-zstd-sys+non-cargo-devel \
 rust-zstd-sys+pkg-config-devel \
 rust-zstd-sys+seekable-devel \
 rust-zstd-sys+std-devel \
 rust-zstd-sys+thin-devel \
 rust-zstd-sys+thin-lto-devel \
 rust-zstd-sys+zdict_builder-devel \
 rust-zstd-sys+zstdmt-devel \
 rust-zstd-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zstd-sys-2.0.15-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "740af9321827068e3bdaf5c6f076110614e15b670162184e5ac912a2cbb61fdc"

URI_x86_64_v2_rust-zstd-sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+bindgen-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+bindgen-devel.sha256sum] = "f94bc2dc6ea002a1b77a5e4d6279e289f36e2f7feeb8c974205ede2f1b49f1b5"

URI_x86_64_v2_rust-zstd-sys+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+debug-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+debug-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+debug-devel.sha256sum] = "4cfac0001a87f3d3a76b353037246528032f88c949aa79293a1fc1d8587b4d75"

URI_x86_64_v2_rust-zstd-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+default-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+default-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+default-devel.sha256sum] = "2e5494116a3e577606d3e8cb44f90f0d7e037e3a956097d18e8a13a511b775d7"

URI_x86_64_v2_rust-zstd-sys+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+experimental-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+experimental-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+experimental-devel.sha256sum] = "48086bb0ea9ea2722ffac6559721d6bf48b8bb83041cd3a7c952b213b9ed9ef9"

URI_x86_64_v2_rust-zstd-sys+fat-lto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+fat-lto-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+fat-lto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+fat-lto-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+fat-lto-devel.sha256sum] = "5290f2447a6d5b471bf71b9a57090176d86ed745f7826d8c200b4c1dc748cf47"

URI_x86_64_v2_rust-zstd-sys+legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+legacy-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+legacy-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+legacy-devel.sha256sum] = "9b7a7dcdba550bbfd10d64d0ac53ea1f9d69bfadcc093a6c0518707db67277bd"

URI_x86_64_v2_rust-zstd-sys+no_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+no_asm-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+no_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+no_asm-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+no_asm-devel.sha256sum] = "9a2c572f08d614ed1dd987f5832975d9912da7d0cc59fd681d10ad2f41312926"

URI_x86_64_v2_rust-zstd-sys+non-cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+non-cargo-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+non-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+non-cargo-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+non-cargo-devel.sha256sum] = "d726e5bd470916f8f9900ed97da325ef93386522f357e4a6147dd0b58abb0674"

URI_x86_64_v2_rust-zstd-sys+pkg-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+pkg-config-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+pkg-config-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+pkg-config-devel.sha256sum] = "5bb5c02d3ecba768ef5c4024635153e3ca1ddcadf8a7b8294e9a499fa1141472"

URI_x86_64_v2_rust-zstd-sys+seekable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+seekable-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+seekable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+seekable-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+seekable-devel.sha256sum] = "673f967c6f1f592d6a57e08805eb422357aab7acdea5312c10687978ae2b50d4"

URI_x86_64_v2_rust-zstd-sys+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+std-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+std-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+std-devel.sha256sum] = "32891858c41677777f5c9d09cc31e567a7c1d0f836471045a3722a32c709fe36"

URI_x86_64_v2_rust-zstd-sys+thin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+thin-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+thin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+thin-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+thin-devel.sha256sum] = "7933e7ac9e0f1f52f4ce3aa6be8ab30fd625705467efe20e4fb4cf7bd075b17f"

URI_x86_64_v2_rust-zstd-sys+thin-lto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+thin-lto-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+thin-lto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+thin-lto-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+thin-lto-devel.sha256sum] = "0df535d08240e2cd8f12146bc3a4921573a6cbdfd0ad65902606430d3cb0df20"

URI_x86_64_v2_rust-zstd-sys+zdict_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+zdict_builder-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+zdict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+zdict_builder-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+zdict_builder-devel.sha256sum] = "9876d7599f797aef94d1ec3147eb7819ba2d2c46924b7a5b483cad338f0fa25a"

URI_x86_64_v2_rust-zstd-sys+zstdmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+zstdmt-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+zstdmt-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+zstdmt-devel.sha256sum] = "c7735483f7c415cfba0e31d6f8d65858b08de0bfeeee4fcdddbabc2465eaf705"

URI_x86_64_v2_rust-zstd-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys-devel-2.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys-devel.sha256sum] = "45fe328f20c8290e0fbb0337989e79690284a44681d036439f3380192d618fd9"

URI_aarch64_rust-zstd-sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+bindgen-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+bindgen-devel}"
SRC_URI[aarch64_rust-zstd-sys+bindgen-devel.sha256sum] = "28b7f1000a1384c175f3b6e1edbdd7ba100da556e4abccf2ff8b476c3b4cebb0"

URI_aarch64_rust-zstd-sys+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+debug-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+debug-devel}"
SRC_URI[aarch64_rust-zstd-sys+debug-devel.sha256sum] = "39f40a6d28ea7af75afa7365373d9d1b50872b99bcfeecd5ef8c9e126a18fd8c"

URI_aarch64_rust-zstd-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+default-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+default-devel}"
SRC_URI[aarch64_rust-zstd-sys+default-devel.sha256sum] = "cec3398b3cbfc1f0e810c4dfe8f7be60b2456e45754d5022aaf8ac9b33aca374"

URI_aarch64_rust-zstd-sys+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+experimental-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+experimental-devel}"
SRC_URI[aarch64_rust-zstd-sys+experimental-devel.sha256sum] = "ea1085a4649454a82f015f07aa4f030cb44bee6a2f26561c703a1308bfee37d4"

URI_aarch64_rust-zstd-sys+fat-lto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+fat-lto-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+fat-lto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+fat-lto-devel}"
SRC_URI[aarch64_rust-zstd-sys+fat-lto-devel.sha256sum] = "fd427d01a17544c2b3884b835ae207be3b190697125fdc2439b222263cfb969d"

URI_aarch64_rust-zstd-sys+legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+legacy-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+legacy-devel}"
SRC_URI[aarch64_rust-zstd-sys+legacy-devel.sha256sum] = "59593c0021fbe05eb75279dfe6e075d6d0c56c3832e2aaae5ec744f6c1f0b48d"

URI_aarch64_rust-zstd-sys+no_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+no_asm-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+no_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+no_asm-devel}"
SRC_URI[aarch64_rust-zstd-sys+no_asm-devel.sha256sum] = "92c131216b222c75d355afb091938f466a27112a9ecfc36d82711d28aae61032"

URI_aarch64_rust-zstd-sys+non-cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+non-cargo-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+non-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+non-cargo-devel}"
SRC_URI[aarch64_rust-zstd-sys+non-cargo-devel.sha256sum] = "f097ebddad2380c0d7c62b5b0831c8b271d22cd9cf914a24fea20cc2cc7c6294"

URI_aarch64_rust-zstd-sys+pkg-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+pkg-config-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+pkg-config-devel}"
SRC_URI[aarch64_rust-zstd-sys+pkg-config-devel.sha256sum] = "8c70f1e919c7e446a82cc776bada5fd81d41c38fa8f0dea2ea30e89eae33b099"

URI_aarch64_rust-zstd-sys+seekable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+seekable-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+seekable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+seekable-devel}"
SRC_URI[aarch64_rust-zstd-sys+seekable-devel.sha256sum] = "26986ef579e3e020810df00324b02d6b379d38341fb5e20b022e8dba79d88852"

URI_aarch64_rust-zstd-sys+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+std-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+std-devel}"
SRC_URI[aarch64_rust-zstd-sys+std-devel.sha256sum] = "6434e542b13beab3d1724cb8d2cf01dfc7e2db561665c40fce01c444eabd4a2d"

URI_aarch64_rust-zstd-sys+thin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+thin-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+thin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+thin-devel}"
SRC_URI[aarch64_rust-zstd-sys+thin-devel.sha256sum] = "cb04b38b8b9bfcd2c1bf89da4054c6726e44f44fb6f09665a065120228e326f4"

URI_aarch64_rust-zstd-sys+thin-lto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+thin-lto-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+thin-lto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+thin-lto-devel}"
SRC_URI[aarch64_rust-zstd-sys+thin-lto-devel.sha256sum] = "407ed91f2c9171919ff3f67ed3d4efe0cbc4290b74c66b7dc40ca235323550d4"

URI_aarch64_rust-zstd-sys+zdict_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+zdict_builder-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+zdict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+zdict_builder-devel}"
SRC_URI[aarch64_rust-zstd-sys+zdict_builder-devel.sha256sum] = "c69bbf6550d55fd3c8ef3608a49ae326c9f47f6d0a5ab3268e825828c20c7ce9"

URI_aarch64_rust-zstd-sys+zstdmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+zstdmt-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+zstdmt-devel}"
SRC_URI[aarch64_rust-zstd-sys+zstdmt-devel.sha256sum] = "1aa5b823ee0b019f096d8a4281426c1dc4c6a1088f5f2a9cbc38f4d3a3b73b78"

URI_aarch64_rust-zstd-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys-devel-2.0.15-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys-devel}"
SRC_URI[aarch64_rust-zstd-sys-devel.sha256sum] = "5f03b467bdacad6c48588d62d0f24c49f77f80674e43fd93a075141469b4f212"

RDEPENDS:rust-zstd-sys+bindgen-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+debug-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+default-devel = " \
 cargo \
 rust-zstd-sys+bindgen-devel \
 rust-zstd-sys+legacy-devel \
 rust-zstd-sys+zdict_builder-devel \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+experimental-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+fat-lto-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+legacy-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+no_asm-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+non-cargo-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+pkg-config-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+seekable-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+std-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+thin-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+thin-lto-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+zdict_builder-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+zstdmt-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys-devel = " \
 cargo \
 libzstd-devel \
 rust \
 rust-bindgen+runtime-devel \
 rust-bindgen+which-rustfmt-devel \
 rust-bindgen-devel \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-pkg-config+default-devel \
 "
