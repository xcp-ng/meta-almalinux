# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-SubCalls"
PV = "1.10"
PR = "17.el10_0"
PACKAGES = " \
 perl-Test-SubCalls \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Test-SubCalls-1.10-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ec36e45f5e2298812afec326091a9d7a127cd57828205c77450950f58d36a949"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-SubCalls-1.10-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-SubCalls;unpack=0"
SRC_URI[x86_64_v2_perl-Test-SubCalls.sha256sum] = "36181c961d600292c0f864524936a6718044ef526eeb51ea56b6fc8883ac233e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-SubCalls-1.10-17.el10_0.noarch.rpm;name=aarch64_perl-Test-SubCalls;unpack=0"
SRC_URI[aarch64_perl-Test-SubCalls.sha256sum] = "a3c3f372f3a645de298ef70120efbfb06006762361c083b30e91439cc542ba8b"

RDEPENDS:perl-Test-SubCalls = " \
 perl-Exporter \
 perl-Hook-LexWrap \
 perl-PathTools \
 perl-Test-Simple \
 perl-libs \
 perl-vars \
 "
