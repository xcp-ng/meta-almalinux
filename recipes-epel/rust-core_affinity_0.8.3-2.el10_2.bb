# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-core_affinity"
PV = "0.8.3"
PR = "2.el10_2"
PACKAGES = " \
 rust-core_affinity+default-devel \
 rust-core_affinity-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-core_affinity-0.8.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c9d77bf4ca3d4785d072258453c9cfbf3ce26deb6111a8366ee4b685b49c0200"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-core_affinity+default-devel-0.8.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-core_affinity+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-core_affinity+default-devel.sha256sum] = "3d6b5a6cd143b936aaca013a95bdfa0741ee581d8d1c42387504829545d56e9f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-core_affinity-devel-0.8.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-core_affinity-devel;unpack=0"
SRC_URI[x86_64_v2_rust-core_affinity-devel.sha256sum] = "196303399ee15b9215c675ceb5e0dae0c0be31221a0ba840e0c2137137908809"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-core_affinity+default-devel-0.8.3-2.el10_2.noarch.rpm;name=aarch64_rust-core_affinity+default-devel;unpack=0"
SRC_URI[aarch64_rust-core_affinity+default-devel.sha256sum] = "b0a210366260d8834f9ce125afa3e4b0da15ba53566feed2762eab92643f3339"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-core_affinity-devel-0.8.3-2.el10_2.noarch.rpm;name=aarch64_rust-core_affinity-devel;unpack=0"
SRC_URI[aarch64_rust-core_affinity-devel.sha256sum] = "c43c2b95af722bdbb23a9fe6caba6e60857481191819d63e25dc9d39a4dbda44"

RDEPENDS:rust-core_affinity+default-devel = " \
 cargo \
 rust-core_affinity-devel \
 "
RDEPENDS:rust-core_affinity-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-num_cpus+default-devel \
 "
