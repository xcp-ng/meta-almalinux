# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "signon-kwallet-extension"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 signon-kwallet-extension \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/signon-kwallet-extension-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5cbacbf8b3d59387a2efdf5243995f9ec9324dcf8e3d16ca2b807433d167cfd"

URI_x86_64_v2_signon-kwallet-extension = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-kwallet-extension-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signon-kwallet-extension;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signon-kwallet-extension}"
SRC_URI[x86_64_v2_signon-kwallet-extension.sha256sum] = "eceff18eb1742e45db0d19b96768cb783dba3a4fd2e6aa9f46d63a322dfacb3e"

URI_aarch64_signon-kwallet-extension = "${EPEL_MIRROR}/aarch64/Packages/s/signon-kwallet-extension-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_signon-kwallet-extension;unpack=0"
SRC_URI:append = " ${URI_aarch64_signon-kwallet-extension}"
SRC_URI[aarch64_signon-kwallet-extension.sha256sum] = "f13cfb2b196c67500f6f7ad04cee1bb94ac38d86abf7cf90c1e9e8eb809f1eaf"

RDEPENDS:signon-kwallet-extension = " \
 glibc \
 kf6-kwallet-libs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 signon \
 "
