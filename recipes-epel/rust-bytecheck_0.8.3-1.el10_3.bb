# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytecheck"
PV = "0.8.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-bytecheck+default-devel \
 rust-bytecheck+simdutf8-devel \
 rust-bytecheck+uuid-1-devel \
 rust-bytecheck-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytecheck-0.8.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdf823ada134cf26180fd001d5d60bef6b687fd9f061b7c969d8926dbcd8e7da"

URI_x86_64_v2_rust-bytecheck+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck+default-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck+default-devel}"
SRC_URI[x86_64_v2_rust-bytecheck+default-devel.sha256sum] = "c92a9444be4d0e58feb3211363447a28f7a0038dbf6296a7a832c2c0d093a7be"

URI_x86_64_v2_rust-bytecheck+simdutf8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck+simdutf8-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck+simdutf8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck+simdutf8-devel}"
SRC_URI[x86_64_v2_rust-bytecheck+simdutf8-devel.sha256sum] = "efab734a7935d7172cdff1c7595d20d7f0645caf3cdfaf958c26f57bf95498cc"

URI_x86_64_v2_rust-bytecheck+uuid-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck+uuid-1-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck+uuid-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck+uuid-1-devel}"
SRC_URI[x86_64_v2_rust-bytecheck+uuid-1-devel.sha256sum] = "45344e9f016b8bdf0975050cf66586f98d71a0cb95f1d13000f6161fb9d99d47"

URI_x86_64_v2_rust-bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck-devel}"
SRC_URI[x86_64_v2_rust-bytecheck-devel.sha256sum] = "bb0bc9121402ca8e104b70cf01122e0a5bbe61ad686de5879240e091ac5f5708"

URI_aarch64_rust-bytecheck+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck+default-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-bytecheck+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck+default-devel}"
SRC_URI[aarch64_rust-bytecheck+default-devel.sha256sum] = "6f39c62f78f12ff864fced6d8ed3b91769d63323726989de6ec7408f516bd951"

URI_aarch64_rust-bytecheck+simdutf8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck+simdutf8-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-bytecheck+simdutf8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck+simdutf8-devel}"
SRC_URI[aarch64_rust-bytecheck+simdutf8-devel.sha256sum] = "0bdca47ef673667c25c913fe36c4861789a9783d2bd197542b13244bffb5e48e"

URI_aarch64_rust-bytecheck+uuid-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck+uuid-1-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-bytecheck+uuid-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck+uuid-1-devel}"
SRC_URI[aarch64_rust-bytecheck+uuid-1-devel.sha256sum] = "a863e5c5fb1ab91660b705b5bad69bd492a12365922d3ca6012c79c1b6b96404"

URI_aarch64_rust-bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck-devel}"
SRC_URI[aarch64_rust-bytecheck-devel.sha256sum] = "9628188a754207a4c91ba1d9a2e62718dad19f2eee47025a6b74f7e9478098e9"

RDEPENDS:rust-bytecheck+default-devel = " \
 cargo \
 rust-bytecheck+simdutf8-devel \
 rust-bytecheck-devel \
 "
RDEPENDS:rust-bytecheck+simdutf8-devel = " \
 cargo \
 rust-bytecheck-devel \
 rust-simdutf8-devel \
 "
RDEPENDS:rust-bytecheck+uuid-1-devel = " \
 cargo \
 rust-bytecheck-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-bytecheck-devel = " \
 cargo \
 rust \
 rust-bytecheck_derive-devel \
 rust-ptr_meta-devel \
 rust-rancor-devel \
 "
