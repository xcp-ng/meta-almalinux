# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-psl"
PV = "2.1.223"
PR = "1.el10_2"
PACKAGES = " \
 rust-psl+default-devel \
 rust-psl+helpers-devel \
 rust-psl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-psl-2.1.223-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "840d7c385c7b58dd78fc00dddaec0d2b4446f5ec49891d4bb114d8829b52113d"

URI_x86_64_v2_rust-psl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl+default-devel-2.1.223-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psl+default-devel}"
SRC_URI[x86_64_v2_rust-psl+default-devel.sha256sum] = "f292282c9b3664cc337d65aaf830525141d32f19f82000d1c07eb59d116742da"

URI_x86_64_v2_rust-psl+helpers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl+helpers-devel-2.1.223-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl+helpers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psl+helpers-devel}"
SRC_URI[x86_64_v2_rust-psl+helpers-devel.sha256sum] = "d070631d3d9ac137f3436fca10c30ff58719c202949f935f8af69e4cfab507bc"

URI_x86_64_v2_rust-psl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl-devel-2.1.223-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psl-devel}"
SRC_URI[x86_64_v2_rust-psl-devel.sha256sum] = "61d674bbb8bd70bf621094c230f72aaac2d5d530aea028f452330939906c175d"

URI_aarch64_rust-psl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psl+default-devel-2.1.223-1.el10_2.noarch.rpm;name=aarch64_rust-psl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psl+default-devel}"
SRC_URI[aarch64_rust-psl+default-devel.sha256sum] = "0972bf1e2634ead2b3d431d13229520b917e0be4bf460fefc4191e06d13699a8"

URI_aarch64_rust-psl+helpers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psl+helpers-devel-2.1.223-1.el10_2.noarch.rpm;name=aarch64_rust-psl+helpers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psl+helpers-devel}"
SRC_URI[aarch64_rust-psl+helpers-devel.sha256sum] = "7c9ea99d67d971cd610386b72d45813ca6e57297d9a8b715671bfe2244b06dca"

URI_aarch64_rust-psl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psl-devel-2.1.223-1.el10_2.noarch.rpm;name=aarch64_rust-psl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psl-devel}"
SRC_URI[aarch64_rust-psl-devel.sha256sum] = "1e8a49b0adeb7812d41549d9791a2bd9c6e63d51bf58c1bb7904a2a522b18335"

RDEPENDS:rust-psl+default-devel = " \
 cargo \
 rust-psl+helpers-devel \
 rust-psl-devel \
 "
RDEPENDS:rust-psl+helpers-devel = " \
 cargo \
 rust-psl-devel \
 "
RDEPENDS:rust-psl-devel = " \
 cargo \
 rust-psl-types+default-devel \
 "
