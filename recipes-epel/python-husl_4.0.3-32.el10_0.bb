# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-husl"
PV = "4.0.3"
PR = "32.el10_0"
PACKAGES = " \
 python3-husl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-husl-4.0.3-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c5e75a591b72cd8fafa91464cdd3c1e2f44095179435dabee04221871a1b0a5"

URI_x86_64_v2_python3-husl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-husl-4.0.3-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-husl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-husl}"
SRC_URI[x86_64_v2_python3-husl.sha256sum] = "49c21c8bccdf1366b75f28f0e5b417352de19620a6b4d765c8e2f908113f341d"

URI_aarch64_python3-husl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-husl-4.0.3-32.el10_0.noarch.rpm;name=aarch64_python3-husl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-husl}"
SRC_URI[aarch64_python3-husl.sha256sum] = "94a29ae6b3ee57c199f26e6923e9c6d223300ecb5315318ffef62cd40c7bcb28"

RDEPENDS:python3-husl = " \
 python3 \
 "
