# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unrar-free"
PV = "0.3.1"
PR = "2.el10_1"
PACKAGES = " \
 unrar \
 unrar-free \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/unrar-free-0.3.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98d411d59b10d98f348dfd1b7d1c010c5846a156a43af343eefe7932f66144f9"

URI_x86_64_v2_unrar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unrar-0.3.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unrar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unrar}"
SRC_URI[x86_64_v2_unrar.sha256sum] = "d4120fb7daacba29a917518002e60756be6f2603a6264332e40189d2c5def467"

URI_x86_64_v2_unrar-free = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unrar-free-0.3.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unrar-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unrar-free}"
SRC_URI[x86_64_v2_unrar-free.sha256sum] = "7e37f56be445bf4889d18b90b5e1a46c9fc0a6afdf4dce3a728c0250218087af"

URI_aarch64_unrar = "${EPEL_MIRROR}/aarch64/Packages/u/unrar-0.3.1-2.el10_1.aarch64.rpm;name=aarch64_unrar;unpack=0"
SRC_URI:append = " ${URI_aarch64_unrar}"
SRC_URI[aarch64_unrar.sha256sum] = "fe2d61835df6878c13235adf512f0b648d1d971cc7ee0c0971687c93a3548ca1"

URI_aarch64_unrar-free = "${EPEL_MIRROR}/aarch64/Packages/u/unrar-free-0.3.1-2.el10_1.aarch64.rpm;name=aarch64_unrar-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_unrar-free}"
SRC_URI[aarch64_unrar-free.sha256sum] = "1b9b71f1b2ca2afa38cb477a3c5ff437d669cc9ac01853df8313a38417c89977"

RDEPENDS:unrar = " \
 unrar-free \
 "
RDEPENDS:unrar-free = " \
 glibc \
 libarchive \
 "
