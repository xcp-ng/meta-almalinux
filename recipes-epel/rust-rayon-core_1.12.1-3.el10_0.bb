# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rayon-core"
PV = "1.12.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-rayon-core+default-devel \
 rust-rayon-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rayon-core-1.12.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fca234112242f1a777f2414039eb8850de10400eb7d4dcfea83d7b5cf6e0488"

URI_x86_64_v2_rust-rayon-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rayon-core+default-devel-1.12.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rayon-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rayon-core+default-devel}"
SRC_URI[x86_64_v2_rust-rayon-core+default-devel.sha256sum] = "bf46eb5329363f63d5a00548877f4a6d2847742184997b1b5869ee0449ab0040"

URI_x86_64_v2_rust-rayon-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rayon-core-devel-1.12.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rayon-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rayon-core-devel}"
SRC_URI[x86_64_v2_rust-rayon-core-devel.sha256sum] = "2b827d5c06d4a74c5dc92a2c2625d44594a03e04b05ad3448f4478bc36d89f6d"

URI_aarch64_rust-rayon-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rayon-core+default-devel-1.12.1-3.el10_0.noarch.rpm;name=aarch64_rust-rayon-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rayon-core+default-devel}"
SRC_URI[aarch64_rust-rayon-core+default-devel.sha256sum] = "99b957d0f2f9806e5ea44805a41e32d325fddfacf8484d3813878d3a8aac99be"

URI_aarch64_rust-rayon-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rayon-core-devel-1.12.1-3.el10_0.noarch.rpm;name=aarch64_rust-rayon-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rayon-core-devel}"
SRC_URI[aarch64_rust-rayon-core-devel.sha256sum] = "c72af53bf446e3a35559a967cdd61552d9b682cd00b190c0b04448205dba8322"

RDEPENDS:rust-rayon-core+default-devel = " \
 cargo \
 rust-rayon-core-devel \
 "
RDEPENDS:rust-rayon-core-devel = " \
 cargo \
 rust \
 rust-crossbeam-deque+default-devel \
 rust-crossbeam-utils+default-devel \
 "
