# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libjodycode"
PV = "3.1.1"
PR = "2.el10_1"
PACKAGES = " \
 libjodycode \
 libjodycode-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libjodycode-3.1.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b4f9791a448189b7cee179b9a53f31b223ec38159e812d4deba77e3f0f1ed98"

URI_x86_64_v2_libjodycode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjodycode-3.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjodycode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjodycode}"
SRC_URI[x86_64_v2_libjodycode.sha256sum] = "7416ae8e30237c06cf8fa5f43fce1bedf05bb8583cce20b2e205d126d58bde1c"

URI_x86_64_v2_libjodycode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjodycode-devel-3.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjodycode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjodycode-devel}"
SRC_URI[x86_64_v2_libjodycode-devel.sha256sum] = "7f108c39bb3930925bbbd5f6242fef785aa4d66c9c32057eb7815494413a5f5e"

URI_aarch64_libjodycode = "${EPEL_MIRROR}/aarch64/Packages/l/libjodycode-3.1.1-2.el10_1.aarch64.rpm;name=aarch64_libjodycode;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjodycode}"
SRC_URI[aarch64_libjodycode.sha256sum] = "e75294ce7d03b12642a73ae6d015c691ca32b396ada62c7131003c2460de0413"

URI_aarch64_libjodycode-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libjodycode-devel-3.1.1-2.el10_1.aarch64.rpm;name=aarch64_libjodycode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjodycode-devel}"
SRC_URI[aarch64_libjodycode-devel.sha256sum] = "782e6514ba2e7c93519e122a65f41ef4e065473cb3018313daf243a9c86d7694"

RDEPENDS:libjodycode = " \
 glibc \
 "
RDEPENDS:libjodycode-devel = " \
 libjodycode \
 "
