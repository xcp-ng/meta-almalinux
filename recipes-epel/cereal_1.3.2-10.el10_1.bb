# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cereal"
PV = "1.3.2"
PR = "10.el10_1"
PACKAGES = " \
 cereal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cereal-1.3.2-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b79cd0d9770df3c7ede5eccfb3cf6e2153683312cecce6c032904decbeb4b39e"

URI_x86_64_v2_cereal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cereal-devel-1.3.2-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cereal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cereal-devel}"
SRC_URI[x86_64_v2_cereal-devel.sha256sum] = "7740ae02f8be90eea0100438c81019b8706ebb49993915cbcecd8b868297ea78"

URI_aarch64_cereal-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cereal-devel-1.3.2-10.el10_1.aarch64.rpm;name=aarch64_cereal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cereal-devel}"
SRC_URI[aarch64_cereal-devel.sha256sum] = "218edd7ee721a9a799fb2b6db52187d27c42c2cb04dc39d48f619b407750c8d1"

RDEPENDS:cereal-devel = " \
 cmake-filesystem \
 "
