# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scroll"
PV = "0.12.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-scroll+default-devel \
 rust-scroll+derive-devel \
 rust-scroll+std-devel \
 rust-scroll-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scroll-0.12.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2908f11b8efad9ba3fe15752c82fa8a104386c9fcd44b0f81b73e486fa7d62c8"

URI_x86_64_v2_rust-scroll+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll+default-devel-0.12.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll+default-devel}"
SRC_URI[x86_64_v2_rust-scroll+default-devel.sha256sum] = "7ef7599fc2bc75e13327c234e2ab8d5e03ce591d5509a8b11f0d55d73de10be6"

URI_x86_64_v2_rust-scroll+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll+derive-devel-0.12.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll+derive-devel}"
SRC_URI[x86_64_v2_rust-scroll+derive-devel.sha256sum] = "38e9daf2f90a8704c42dc695504e9120a81f159944d303f63f07e5227279c395"

URI_x86_64_v2_rust-scroll+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll+std-devel-0.12.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll+std-devel}"
SRC_URI[x86_64_v2_rust-scroll+std-devel.sha256sum] = "0bd63977ddca33bcae8d43e4d400cfcc622622ad63f0a206f286b3e95f09ba89"

URI_x86_64_v2_rust-scroll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll-devel-0.12.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll-devel}"
SRC_URI[x86_64_v2_rust-scroll-devel.sha256sum] = "dfe51215314ab97cdc9aa7410ad24f3b494c27d397636ccc31eceea4df5bcccf"

URI_aarch64_rust-scroll+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll+default-devel-0.12.0-2.el10_0.noarch.rpm;name=aarch64_rust-scroll+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll+default-devel}"
SRC_URI[aarch64_rust-scroll+default-devel.sha256sum] = "9bb4a4dc2b5178527e001bc01ca24b107d094f9ed762ef1e357f5e9a1fdeb542"

URI_aarch64_rust-scroll+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll+derive-devel-0.12.0-2.el10_0.noarch.rpm;name=aarch64_rust-scroll+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll+derive-devel}"
SRC_URI[aarch64_rust-scroll+derive-devel.sha256sum] = "782798edcf94bc94b223a42235f27ddb26ed87fd88fe259de07f879813d00853"

URI_aarch64_rust-scroll+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll+std-devel-0.12.0-2.el10_0.noarch.rpm;name=aarch64_rust-scroll+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll+std-devel}"
SRC_URI[aarch64_rust-scroll+std-devel.sha256sum] = "ecf083619a21e8f51fa7722b2b518187d2ad4f1ba6c052ce2421dcb9aee62042"

URI_aarch64_rust-scroll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll-devel-0.12.0-2.el10_0.noarch.rpm;name=aarch64_rust-scroll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll-devel}"
SRC_URI[aarch64_rust-scroll-devel.sha256sum] = "acb6f5272a6806be55c0dfb60836814d8fb1a5c6685fdf85c9a8eb79abfd371c"

RDEPENDS:rust-scroll+default-devel = " \
 cargo \
 rust-scroll+std-devel \
 rust-scroll-devel \
 "
RDEPENDS:rust-scroll+derive-devel = " \
 cargo \
 rust-scroll-devel \
 rust-scroll_derive+default-devel \
 "
RDEPENDS:rust-scroll+std-devel = " \
 cargo \
 rust-scroll-devel \
 "
RDEPENDS:rust-scroll-devel = " \
 cargo \
 rust \
 "
