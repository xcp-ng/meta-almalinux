# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-b4"
PV = "0.14.3"
PR = "2.el10_3"
PACKAGES = " \
 b4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-b4-0.14.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90e0d15121dea7a35b8a983451cf479109603c055647fb43ac3b130705d678c3"

URI_x86_64_v2_b4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/b4-0.14.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_b4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_b4}"
SRC_URI[x86_64_v2_b4.sha256sum] = "22a4c979588b5ed806dde3d900d1d156b812e5ac034f32afe027b345427b24ea"

URI_aarch64_b4 = "${EPEL_MIRROR}/aarch64/Packages/b/b4-0.14.3-2.el10_3.noarch.rpm;name=aarch64_b4;unpack=0"
SRC_URI:append = " ${URI_aarch64_b4}"
SRC_URI[aarch64_b4.sha256sum] = "5f00b029251a337328eb7611d04e198ccd9c3d30f1f6b5566945518c8a4d8316"

RDEPENDS:b4 = " \
 git-filter-repo \
 patatt \
 python3 \
 python3-dkimpy \
 python3-requests \
 "
