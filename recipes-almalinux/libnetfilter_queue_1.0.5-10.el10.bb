# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnetfilter_queue"
PV = "1.0.5"
PR = "10.el10"
PACKAGES = " \
 libnetfilter_queue \
 libnetfilter_queue-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libnetfilter_queue-1.0.5-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1060574605abbc34c8dcfdd7778e2e5d2bd3d76d73fc69a8588ad0ae71ec5dc1"

URI_x86_64_v2_libnetfilter_queue = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnetfilter_queue-1.0.5-10.el10.x86_64_v2.rpm;name=x86_64_v2_libnetfilter_queue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnetfilter_queue}"
SRC_URI[x86_64_v2_libnetfilter_queue.sha256sum] = "e7964e2df37a94f34a2cc971cd75646f267b70b09027a1631aab6c1eee3686e6"

URI_x86_64_v2_libnetfilter_queue-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnetfilter_queue-devel-1.0.5-10.el10.x86_64_v2.rpm;name=x86_64_v2_libnetfilter_queue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnetfilter_queue-devel}"
SRC_URI[x86_64_v2_libnetfilter_queue-devel.sha256sum] = "c42f2cbf8f0f487bcc5933a0f647da63c25b276ab504e3f413d92cf81773d296"

URI_aarch64_libnetfilter_queue = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnetfilter_queue-1.0.5-10.el10.aarch64.rpm;name=aarch64_libnetfilter_queue;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnetfilter_queue}"
SRC_URI[aarch64_libnetfilter_queue.sha256sum] = "4b27d3e285532d12c985b12575ddbec3500f347c86eddb4692318e9c89d09f6d"

URI_aarch64_libnetfilter_queue-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnetfilter_queue-devel-1.0.5-10.el10.aarch64.rpm;name=aarch64_libnetfilter_queue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnetfilter_queue-devel}"
SRC_URI[aarch64_libnetfilter_queue-devel.sha256sum] = "cea5d89494cd08cac54bc62d4b56879a481cab9f98a66ee5f8a4a44dd4977f30"

RDEPENDS:libnetfilter_queue = " \
 glibc \
 libmnl \
 libnfnetlink \
 "
RDEPENDS:libnetfilter_queue-devel = " \
 kernel-headers \
 libnetfilter_queue \
 libnfnetlink-devel \
 pkgconf-pkg-config \
 "
