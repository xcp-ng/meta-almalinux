# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-filetime"
PV = "0.2.29"
PR = "1.el10_3"
PACKAGES = " \
 rust-filetime+default-devel \
 rust-filetime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-filetime-0.2.29-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f20cf3d403c748b14094413cc46f644203f44f17f34867e85d93204d4e45633d"

URI_x86_64_v2_rust-filetime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-filetime+default-devel-0.2.29-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-filetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-filetime+default-devel}"
SRC_URI[x86_64_v2_rust-filetime+default-devel.sha256sum] = "9af41f40b08bdccc67229b7a5e9600d79dd16b12dba4c4a508825af84dcc84bf"

URI_x86_64_v2_rust-filetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-filetime-devel-0.2.29-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-filetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-filetime-devel}"
SRC_URI[x86_64_v2_rust-filetime-devel.sha256sum] = "5f6c4e51e0c7c7f9fffc0152ab100bdfd89771f683cb5077813cbc68c9f10295"

URI_aarch64_rust-filetime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-filetime+default-devel-0.2.29-1.el10_3.noarch.rpm;name=aarch64_rust-filetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-filetime+default-devel}"
SRC_URI[aarch64_rust-filetime+default-devel.sha256sum] = "5b66df5d2a0cda14d93baaa7ebb17a8b980376382689800fa2500d7956e98f43"

URI_aarch64_rust-filetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-filetime-devel-0.2.29-1.el10_3.noarch.rpm;name=aarch64_rust-filetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-filetime-devel}"
SRC_URI[aarch64_rust-filetime-devel.sha256sum] = "08e5ffc713550893c12f4656580fe0bce670e1bacd709184f6867b8ecaa613b7"

RDEPENDS:rust-filetime+default-devel = " \
 cargo \
 rust-filetime-devel \
 "
RDEPENDS:rust-filetime-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 "
