# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-byteable"
PV = "0.1.1"
PR = "42.el10_0"
PACKAGES = " \
 ghc-byteable \
 ghc-byteable-devel \
 ghc-byteable-doc \
 ghc-byteable-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-byteable-0.1.1-42.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "795212b99df558a008b8de7db099a3aad2aa6d01646d1af5f811554bda65d10b"

URI_x86_64_v2_ghc-byteable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-byteable-0.1.1-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-byteable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-byteable}"
SRC_URI[x86_64_v2_ghc-byteable.sha256sum] = "a98909f51b69f67d732a20c7bd075697393bef880c13e2eae0a66fc72e30a5fd"

URI_x86_64_v2_ghc-byteable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-byteable-devel-0.1.1-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-byteable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-byteable-devel}"
SRC_URI[x86_64_v2_ghc-byteable-devel.sha256sum] = "b3f3fba845c2265ff01db688b386ad21fa57da89d6c489b152e1e3fca1fcffe2"

URI_x86_64_v2_ghc-byteable-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-byteable-doc-0.1.1-42.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-byteable-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-byteable-doc}"
SRC_URI[x86_64_v2_ghc-byteable-doc.sha256sum] = "44e3a359acd60d8503ea0321ea30499c6c0829239aab31895ce95b70783b498e"

URI_x86_64_v2_ghc-byteable-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-byteable-prof-0.1.1-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-byteable-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-byteable-prof}"
SRC_URI[x86_64_v2_ghc-byteable-prof.sha256sum] = "6090f9245aa80a95655f55ea206ed5384b6f8ed5ea5785755036357b29f05da5"

URI_aarch64_ghc-byteable = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-byteable-0.1.1-42.el10_0.aarch64.rpm;name=aarch64_ghc-byteable;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-byteable}"
SRC_URI[aarch64_ghc-byteable.sha256sum] = "68ffb5b743b593de93d377f74e25042e66710b0424ffe92e7ebdc7ae5d57951d"

URI_aarch64_ghc-byteable-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-byteable-devel-0.1.1-42.el10_0.aarch64.rpm;name=aarch64_ghc-byteable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-byteable-devel}"
SRC_URI[aarch64_ghc-byteable-devel.sha256sum] = "7673f90f5697c36e6f67cb3d5690b2d1f7c2c421ea5eb7f121369ac3b0bfb3da"

URI_aarch64_ghc-byteable-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-byteable-doc-0.1.1-42.el10_0.noarch.rpm;name=aarch64_ghc-byteable-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-byteable-doc}"
SRC_URI[aarch64_ghc-byteable-doc.sha256sum] = "e4373a705cbc24453a1198dbca763ab2e668b5fcabd04950e1120ba3e85612a1"

URI_aarch64_ghc-byteable-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-byteable-prof-0.1.1-42.el10_0.aarch64.rpm;name=aarch64_ghc-byteable-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-byteable-prof}"
SRC_URI[aarch64_ghc-byteable-prof.sha256sum] = "2745230194e5d377a68cde35469bc9c5dbe12acf184505849f3f17f0463494d1"

RDEPENDS:ghc-byteable = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-byteable-devel = " \
 ghc-base-devel \
 ghc-byteable \
 ghc-bytestring-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-byteable-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-byteable-prof = " \
 ghc-base-prof \
 ghc-byteable-devel \
 ghc-bytestring-prof \
 "
