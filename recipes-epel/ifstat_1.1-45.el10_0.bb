# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ifstat"
PV = "1.1"
PR = "45.el10_0"
PACKAGES = " \
 ifstat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ifstat-1.1-45.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "998a0d16445dd7def7796055dad8c75ba9cbcdf46e8ea8c513a8fbfad85675ca"

URI_x86_64_v2_ifstat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ifstat-1.1-45.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ifstat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ifstat}"
SRC_URI[x86_64_v2_ifstat.sha256sum] = "153c8d84ee7c18520e15ced3108e01959b1d5c4306d61d49ad7ef193c1faa19a"

URI_aarch64_ifstat = "${EPEL_MIRROR}/aarch64/Packages/i/ifstat-1.1-45.el10_0.aarch64.rpm;name=aarch64_ifstat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ifstat}"
SRC_URI[aarch64_ifstat.sha256sum] = "b0ac812f2aee8b682422001b46fa0f193f476840c913581dbcbc8b529afa3e58"

RDEPENDS:ifstat = " \
 glibc \
 net-snmp-libs \
 "
