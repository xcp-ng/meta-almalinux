# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-brotli-decompressor"
PV = "5.0.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-brotli-decompressor+alloc-stdlib-devel \
 rust-brotli-decompressor+default-devel \
 rust-brotli-decompressor+disable-timer-devel \
 rust-brotli-decompressor+ffi-api-devel \
 rust-brotli-decompressor+pass-through-ffi-panics-devel \
 rust-brotli-decompressor+seccomp-devel \
 rust-brotli-decompressor+std-devel \
 rust-brotli-decompressor+unsafe-devel \
 rust-brotli-decompressor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-brotli-decompressor-5.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdd185e85ad657aec34cc0c05a41c4b2cf993fcf1f26ac78f96916ce8e6088ab"

URI_x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+alloc-stdlib-devel-5.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel.sha256sum] = "097f5177273ff8fb548264b53534ada87de135e6a74e271a660fdd03e4673997"

URI_x86_64_v2_rust-brotli-decompressor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+default-devel-5.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+default-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+default-devel.sha256sum] = "e5d666ca9ab9c68bfb582b197fd60fcb72feb86a17c6d18acc4e31b5191a0fe1"

URI_x86_64_v2_rust-brotli-decompressor+disable-timer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+disable-timer-devel-5.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+disable-timer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+disable-timer-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+disable-timer-devel.sha256sum] = "d77eb23001615d0c7c6757959364414e169c78ff26ab0db938bfcc99ce6fedd0"

URI_x86_64_v2_rust-brotli-decompressor+ffi-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+ffi-api-devel-5.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+ffi-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+ffi-api-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+ffi-api-devel.sha256sum] = "9ed4768df03d5834100c7e4a32141d96eda7eb5c9c115d8867db67cc3317d7a7"

URI_x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+pass-through-ffi-panics-devel-5.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel.sha256sum] = "6238c0a0376d8486dc5e1084ab1f973764a444927d295ffa1101544b5e491360"

URI_x86_64_v2_rust-brotli-decompressor+seccomp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+seccomp-devel-5.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+seccomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+seccomp-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+seccomp-devel.sha256sum] = "88d84a97db3420f6fe76193ca10353a8b07893078eaa4a0d4e5a659b98400ed2"

URI_x86_64_v2_rust-brotli-decompressor+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+std-devel-5.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+std-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+std-devel.sha256sum] = "c49fe8dc68cc37a3bfa17dbee676743da2a7caea02c23d3e7f3d9929b2102e3f"

URI_x86_64_v2_rust-brotli-decompressor+unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+unsafe-devel-5.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+unsafe-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+unsafe-devel.sha256sum] = "d6d79a6b6ea5dadbd39fb1dfb084494c110a5deb13ba1c1102d24ff2cb9f5729"

URI_x86_64_v2_rust-brotli-decompressor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor-devel-5.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor-devel.sha256sum] = "d4c21c850baffb2a78a2a73b53b61107b4b75282ddf5a425c7b18bf62d8d7581"

URI_aarch64_rust-brotli-decompressor+alloc-stdlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+alloc-stdlib-devel-5.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+alloc-stdlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+alloc-stdlib-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+alloc-stdlib-devel.sha256sum] = "a05742098b5db6f4227f2594cc11c01c1d4a8077c22006dabfca8a19a9e5662e"

URI_aarch64_rust-brotli-decompressor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+default-devel-5.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+default-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+default-devel.sha256sum] = "afa4184143aeb020b3d3e22aa4b6368d458cd2b679f9122835634415b7d901d1"

URI_aarch64_rust-brotli-decompressor+disable-timer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+disable-timer-devel-5.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+disable-timer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+disable-timer-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+disable-timer-devel.sha256sum] = "97a053417a77b5b1c17d36c2bfef6f4763fc928acb1cc716cec48915e305fdec"

URI_aarch64_rust-brotli-decompressor+ffi-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+ffi-api-devel-5.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+ffi-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+ffi-api-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+ffi-api-devel.sha256sum] = "8220d2dae8a17279f3d2f0511835b5661f8a78f50e3bbf3032c161bb3dabf578"

URI_aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+pass-through-ffi-panics-devel-5.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel.sha256sum] = "0b438d733de737ad6a9587b158e7d312ec12de064bedafc627ff52a3e8cd51c9"

URI_aarch64_rust-brotli-decompressor+seccomp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+seccomp-devel-5.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+seccomp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+seccomp-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+seccomp-devel.sha256sum] = "af49a5e428c92881aae964e02f2ab5143cebbc1905d5f96c44c4c770861158c8"

URI_aarch64_rust-brotli-decompressor+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+std-devel-5.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+std-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+std-devel.sha256sum] = "88ff78f7af16872a61615235f7280940daf4a6dac94a3c55849da195fe54d149"

URI_aarch64_rust-brotli-decompressor+unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+unsafe-devel-5.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+unsafe-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+unsafe-devel.sha256sum] = "9b788adadd38cc09e8188093aa0e4568078ffbc770a8deeca74d8ec01516d076"

URI_aarch64_rust-brotli-decompressor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor-devel-5.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor-devel}"
SRC_URI[aarch64_rust-brotli-decompressor-devel.sha256sum] = "f93fbcf3b875330ca3574356899aba831d7268ae9c992742903b734a979b3272"

RDEPENDS:rust-brotli-decompressor+alloc-stdlib-devel = " \
 cargo \
 rust-alloc-stdlib+default-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+default-devel = " \
 cargo \
 rust-brotli-decompressor+std-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+disable-timer-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+ffi-api-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+pass-through-ffi-panics-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+seccomp-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+std-devel = " \
 cargo \
 rust-brotli-decompressor+alloc-stdlib-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+unsafe-devel = " \
 cargo \
 rust-alloc-no-stdlib+unsafe-devel \
 rust-alloc-stdlib+default-devel \
 rust-alloc-stdlib+unsafe-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor-devel = " \
 cargo \
 rust-alloc-no-stdlib+default-devel \
 "
