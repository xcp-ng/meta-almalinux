# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Glib"
PV = "1.3294"
PR = "5.el10_0"
PACKAGES = " \
 perl-Glib \
 perl-Glib-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Glib-1.3294-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e4c7d856de392675336b7355285e2ffdd9c827265d682d6ff10311afd7d8da3e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Glib-1.3294-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Glib;unpack=0"
SRC_URI[x86_64_v2_perl-Glib.sha256sum] = "400b588fa49d9e40f050e499ca210c9b6b18aa7140bb98544ba731bed4e0c4f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Glib-devel-1.3294-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Glib-devel;unpack=0"
SRC_URI[x86_64_v2_perl-Glib-devel.sha256sum] = "f85fa17877943cda139a9268a900b608ac1476a3fa05f85320753d1336f10136"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Glib-1.3294-5.el10_0.aarch64.rpm;name=aarch64_perl-Glib;unpack=0"
SRC_URI[aarch64_perl-Glib.sha256sum] = "93a0d19eadaeb28b2c6e725b0be45d5d28108eeb6ef20233937143589d5f3dcb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Glib-devel-1.3294-5.el10_0.aarch64.rpm;name=aarch64_perl-Glib-devel;unpack=0"
SRC_URI[aarch64_perl-Glib-devel.sha256sum] = "bc0ccd06113511d019b78b3deb89030ca97c5206562d59e60b4088485bbefe17"

RDEPENDS:perl-Glib = " \
 glib2 \
 glibc \
 perl-Carp \
 perl-Data-Dumper \
 perl-DynaLoader \
 perl-Exporter \
 perl-Glib \
 perl-IO \
 perl-POSIX \
 perl-PathTools \
 perl-Storable \
 perl-base \
 perl-constant \
 perl-libs \
 perl-overload \
 perl-vars \
 "
RDEPENDS:perl-Glib-devel = " \
 perl-Carp \
 perl-ExtUtils-MakeMaker \
 perl-Glib \
 perl-PathTools \
 perl-libs \
 "
