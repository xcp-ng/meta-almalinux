# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-gorilla-schema"
PV = "1.2.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-gorilla-schema-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-gorilla-schema-1.2.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe01433610f2cd1673a6399021a0714191aa4ce44ce8f20506575d10c794d233"

URI_x86_64_v2_golang-github-gorilla-schema-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-gorilla-schema-devel-1.2.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-gorilla-schema-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-gorilla-schema-devel}"
SRC_URI[x86_64_v2_golang-github-gorilla-schema-devel.sha256sum] = "79f588692bb5f6e200640a4524d0192a5c9a1d28e33745fe27a9af8c439dbede"

URI_aarch64_golang-github-gorilla-schema-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-gorilla-schema-devel-1.2.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-gorilla-schema-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-gorilla-schema-devel}"
SRC_URI[aarch64_golang-github-gorilla-schema-devel.sha256sum] = "e9f99b55316eae59eea92095a778fbcac3482dc18d7d84accbd69115495268d0"

RDEPENDS:golang-github-gorilla-schema-devel = " \
 go-filesystem \
 "
