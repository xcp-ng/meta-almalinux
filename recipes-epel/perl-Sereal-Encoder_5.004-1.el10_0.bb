# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sereal-Encoder"
PV = "5.004"
PR = "1.el10_0"
PACKAGES = " \
 perl-Sereal-Encoder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sereal-Encoder-5.004-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8c3f130382b553350e55fee13458f17ed87dac5e00c90c3ac4cc0f481ba1354"

URI_x86_64_v2_perl-Sereal-Encoder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sereal-Encoder-5.004-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sereal-Encoder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sereal-Encoder}"
SRC_URI[x86_64_v2_perl-Sereal-Encoder.sha256sum] = "5de1d582da4d54fdcc5f465d8228ae1dad9917137ad29ab8de83f4085b9dce0c"

URI_aarch64_perl-Sereal-Encoder = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sereal-Encoder-5.004-1.el10_0.aarch64.rpm;name=aarch64_perl-Sereal-Encoder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sereal-Encoder}"
SRC_URI[aarch64_perl-Sereal-Encoder.sha256sum] = "bc6b1fc7da5330f165b8c23e8cc24ec62c5511f214089ea981a462eeb72401be"

RDEPENDS:perl-Sereal-Encoder = " \
 csnappy \
 glibc \
 libzstd \
 miniz \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
