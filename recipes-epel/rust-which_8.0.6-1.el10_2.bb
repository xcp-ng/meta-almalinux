# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-which"
PV = "8.0.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-which+default-devel \
 rust-which+real-sys-devel \
 rust-which+regex-devel \
 rust-which+tracing-devel \
 rust-which-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-which-8.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2e931b32361032eae21c4f4a73c8699e58dd67580fcc846dccd21810c49e0710"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+default-devel-8.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-which+default-devel.sha256sum] = "c81ee73c2dcd8ef9b4de747dff19d8a29b5ecb19876434c0e1b54b676fb071b4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+real-sys-devel-8.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+real-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-which+real-sys-devel.sha256sum] = "363b9d0f9639ac3f229fc3d528631af7bc6dfab742da4eb38df450a51e3f3a38"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+regex-devel-8.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+regex-devel;unpack=0"
SRC_URI[x86_64_v2_rust-which+regex-devel.sha256sum] = "33c1e520bc8881f23733ebfc62b2c73db869254a317f87975eb48e43754fc387"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+tracing-devel-8.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+tracing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-which+tracing-devel.sha256sum] = "9bab1dd5f719b4acd5829c8d6f922fdc264dd1c6cfcee8c8645a661e97a4f5f7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which-devel-8.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which-devel;unpack=0"
SRC_URI[x86_64_v2_rust-which-devel.sha256sum] = "ea6f484dcf721d663a277eb889dc2967fd3386846b4f61708154a91b50364c63"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-which+default-devel-8.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-which+default-devel;unpack=0"
SRC_URI[aarch64_rust-which+default-devel.sha256sum] = "13d7566610f0cd37e4e820ea287db0ff08caa0b099b349f0c9388b94336d9b68"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-which+real-sys-devel-8.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-which+real-sys-devel;unpack=0"
SRC_URI[aarch64_rust-which+real-sys-devel.sha256sum] = "15366c96c2d5e28a9fe9565deb99327cb25e3583f51e8ea991ea71bd8b198fbe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-which+regex-devel-8.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-which+regex-devel;unpack=0"
SRC_URI[aarch64_rust-which+regex-devel.sha256sum] = "cec3071722d08897b97c1bc342a50622b3c2ef2c74d1ce5eb62c6e52835a6066"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-which+tracing-devel-8.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-which+tracing-devel;unpack=0"
SRC_URI[aarch64_rust-which+tracing-devel.sha256sum] = "13f038e721f6f18449dd0321cd76cabbd1429ecaee2d30d6a717e1eeb9946524"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-which-devel-8.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-which-devel;unpack=0"
SRC_URI[aarch64_rust-which-devel.sha256sum] = "b5648244d99d74e8bad6162c87cbefd5a2a2a3f04d83b11f003eac7c826a537d"

RDEPENDS:rust-which+default-devel = " \
 cargo \
 rust-which+real-sys-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+real-sys-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+regex-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+tracing-devel = " \
 cargo \
 rust-tracing-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which-devel = " \
 cargo \
 rust \
 "
