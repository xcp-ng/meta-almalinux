# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "objfw"
PV = "1.5.2"
PR = "1.el10_1"
PACKAGES = " \
 libobjfw \
 libobjfw-devel \
 libobjfwhid \
 libobjfwhid-devel \
 libobjfwrt \
 libobjfwrt-devel \
 libobjfwtls \
 libobjfwtls-devel \
 objfw \
 objfw-doc \
 ofarc \
 ofdns \
 ofgctester \
 ofhash \
 ofhttp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/objfw-1.5.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59fe51e6121295fba2ef23785789296ef2a748c88d7a2f88a87bcfdb626e871b"

URI_x86_64_v2_libobjfw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfw-1.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfw}"
SRC_URI[x86_64_v2_libobjfw.sha256sum] = "82d38c64f930c0120c5f52056b6bf4578401a3eed597d232dc23dedb5baa62de"

URI_x86_64_v2_libobjfw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfw-devel-1.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfw-devel}"
SRC_URI[x86_64_v2_libobjfw-devel.sha256sum] = "612b2f290afb4530d4e38723a84010a6d91dfa92046bb8d10caa2efdad21011d"

URI_x86_64_v2_libobjfwhid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwhid-1.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwhid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwhid}"
SRC_URI[x86_64_v2_libobjfwhid.sha256sum] = "c864b8cf7bb0d7808f30d5d85f25d3714fb70ec59f4ff8e01d97e0b85b978967"

URI_x86_64_v2_libobjfwhid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwhid-devel-1.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwhid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwhid-devel}"
SRC_URI[x86_64_v2_libobjfwhid-devel.sha256sum] = "118f20d35957a8de73dfb3fe2ae818a9f65b949409d236b511f956f2005fd495"

URI_x86_64_v2_libobjfwrt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwrt-1.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwrt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwrt}"
SRC_URI[x86_64_v2_libobjfwrt.sha256sum] = "d0ceeac20e70cfdf60fc9b1b1e22f074bff9b8cfef8beeb59a46f7351a2a923e"

URI_x86_64_v2_libobjfwrt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwrt-devel-1.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwrt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwrt-devel}"
SRC_URI[x86_64_v2_libobjfwrt-devel.sha256sum] = "8b737de18ad14598fb7c8dde72fb80bfd4af90dd01859611dde43d80f6039067"

URI_x86_64_v2_libobjfwtls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwtls-1.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwtls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwtls}"
SRC_URI[x86_64_v2_libobjfwtls.sha256sum] = "60eec7006700349932da1bbe1393c16a515767d50f1dbda6a2bf2aedd06b1f9b"

URI_x86_64_v2_libobjfwtls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwtls-devel-1.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwtls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwtls-devel}"
SRC_URI[x86_64_v2_libobjfwtls-devel.sha256sum] = "1d1d8ccba5641c517a4a2e60aaba5546dd3526dd293997b8cb63c7cf8f0c2068"

URI_x86_64_v2_objfw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/objfw-1.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_objfw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_objfw}"
SRC_URI[x86_64_v2_objfw.sha256sum] = "5c35ff8c59c03a5a8a7caf4f6f706f42fc1cc1bff9cbe3c68a3489f8257770e7"

URI_x86_64_v2_objfw-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/objfw-doc-1.5.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_objfw-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_objfw-doc}"
SRC_URI[x86_64_v2_objfw-doc.sha256sum] = "d20c8d91f2c3b781b013ded30fa76ba5639e66cfe361ac59627241bc8518cb92"

URI_x86_64_v2_ofarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofarc-1.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofarc}"
SRC_URI[x86_64_v2_ofarc.sha256sum] = "7b765d4dcfce9b5eab178b653ef169965dd7ee1b848101afa9e13d30680ddb12"

URI_x86_64_v2_ofdns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofdns-1.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofdns}"
SRC_URI[x86_64_v2_ofdns.sha256sum] = "b40eef2ec72bda92e8d2858f86208c9ee17e73b8bf7fc96c0dd851f312fce2e7"

URI_x86_64_v2_ofgctester = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofgctester-1.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofgctester;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofgctester}"
SRC_URI[x86_64_v2_ofgctester.sha256sum] = "4f300df59cc1cd6a83c2da41ccac15d9ee6406773358c888a466c40647c18c5f"

URI_x86_64_v2_ofhash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofhash-1.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofhash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofhash}"
SRC_URI[x86_64_v2_ofhash.sha256sum] = "f49254ada6efd9ab1810ad234423613dbb44073e486b5d97185c70f829cd9672"

URI_x86_64_v2_ofhttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofhttp-1.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofhttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofhttp}"
SRC_URI[x86_64_v2_ofhttp.sha256sum] = "3d134b50b06a59b64a613550c84bc3fbffc37d49b02fe8207a3b6e79ca0b646c"

URI_aarch64_libobjfw = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfw-1.5.2-1.el10_1.aarch64.rpm;name=aarch64_libobjfw;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfw}"
SRC_URI[aarch64_libobjfw.sha256sum] = "8941c064500711c979102575ca80015109b2f06ce0240bde313f9d8e9e0893a7"

URI_aarch64_libobjfw-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfw-devel-1.5.2-1.el10_1.aarch64.rpm;name=aarch64_libobjfw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfw-devel}"
SRC_URI[aarch64_libobjfw-devel.sha256sum] = "7e50b12dffd30f2d732dd16ed724499b736981a3352eadc52608966492fc3def"

URI_aarch64_libobjfwhid = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwhid-1.5.2-1.el10_1.aarch64.rpm;name=aarch64_libobjfwhid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwhid}"
SRC_URI[aarch64_libobjfwhid.sha256sum] = "fb2d90e91420aff035dc36ba25790cd7fe0fff66784b9f4fcc0d00a8bfe8039b"

URI_aarch64_libobjfwhid-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwhid-devel-1.5.2-1.el10_1.aarch64.rpm;name=aarch64_libobjfwhid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwhid-devel}"
SRC_URI[aarch64_libobjfwhid-devel.sha256sum] = "052b7fcbefd5a48ed628cc53afcf3c0b8d8a5872212f4c7f381be48146147089"

URI_aarch64_libobjfwrt = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwrt-1.5.2-1.el10_1.aarch64.rpm;name=aarch64_libobjfwrt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwrt}"
SRC_URI[aarch64_libobjfwrt.sha256sum] = "b2dd494e23b79dbc934454ccb5a21a1ecabe63b8bee582d626b48f268875138d"

URI_aarch64_libobjfwrt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwrt-devel-1.5.2-1.el10_1.aarch64.rpm;name=aarch64_libobjfwrt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwrt-devel}"
SRC_URI[aarch64_libobjfwrt-devel.sha256sum] = "203b23cc99f1b563c93f7bd6cf14edd7f300904472482f8ff856763225a72e9b"

URI_aarch64_libobjfwtls = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwtls-1.5.2-1.el10_1.aarch64.rpm;name=aarch64_libobjfwtls;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwtls}"
SRC_URI[aarch64_libobjfwtls.sha256sum] = "4222160de7ed271efc916f0b1b21248c91f46d16de9a649eac4534e68623f4e6"

URI_aarch64_libobjfwtls-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwtls-devel-1.5.2-1.el10_1.aarch64.rpm;name=aarch64_libobjfwtls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwtls-devel}"
SRC_URI[aarch64_libobjfwtls-devel.sha256sum] = "9fbcfd52dcdc8dfa6b963260248d3bf85dc84966cc3166deb78be449e8ff50c3"

URI_aarch64_objfw = "${EPEL_MIRROR}/aarch64/Packages/o/objfw-1.5.2-1.el10_1.aarch64.rpm;name=aarch64_objfw;unpack=0"
SRC_URI:append = " ${URI_aarch64_objfw}"
SRC_URI[aarch64_objfw.sha256sum] = "cb733a1525420eb01766c465e09cb0cdbfb890b168b62fddc167c8a66714a4a3"

URI_aarch64_objfw-doc = "${EPEL_MIRROR}/aarch64/Packages/o/objfw-doc-1.5.2-1.el10_1.noarch.rpm;name=aarch64_objfw-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_objfw-doc}"
SRC_URI[aarch64_objfw-doc.sha256sum] = "b56f82feaaaac563b34d4da0f3c0a95e2bc8607d8ce00244fb7d5a88a23eaeec"

URI_aarch64_ofarc = "${EPEL_MIRROR}/aarch64/Packages/o/ofarc-1.5.2-1.el10_1.aarch64.rpm;name=aarch64_ofarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofarc}"
SRC_URI[aarch64_ofarc.sha256sum] = "b79a99e86e231ddfc69babb756baefe420459ce0908f1b309ef16e5316107262"

URI_aarch64_ofdns = "${EPEL_MIRROR}/aarch64/Packages/o/ofdns-1.5.2-1.el10_1.aarch64.rpm;name=aarch64_ofdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofdns}"
SRC_URI[aarch64_ofdns.sha256sum] = "e7a4c8cf8d28ff18a84c33d68cb8d7fb7e0233077c71212cf56b4e19ffb3e0b9"

URI_aarch64_ofgctester = "${EPEL_MIRROR}/aarch64/Packages/o/ofgctester-1.5.2-1.el10_1.aarch64.rpm;name=aarch64_ofgctester;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofgctester}"
SRC_URI[aarch64_ofgctester.sha256sum] = "8c0a8109622ebd60f425c5cb34172283c42ec8070166c4c892748c9d45ef23cd"

URI_aarch64_ofhash = "${EPEL_MIRROR}/aarch64/Packages/o/ofhash-1.5.2-1.el10_1.aarch64.rpm;name=aarch64_ofhash;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofhash}"
SRC_URI[aarch64_ofhash.sha256sum] = "d76bf89470194f9829ebb6f1d29e32485efa25ccceb6ce36e076c3652a334dae"

URI_aarch64_ofhttp = "${EPEL_MIRROR}/aarch64/Packages/o/ofhttp-1.5.2-1.el10_1.aarch64.rpm;name=aarch64_ofhttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofhttp}"
SRC_URI[aarch64_ofhttp.sha256sum] = "216e56fa8e5c6814ad6a060c1dc1dca258ef26c453653306a4ff459f562e7b69"

RDEPENDS:libobjfw = " \
 glibc \
 libgcc \
 libobjfwrt \
 "
RDEPENDS:libobjfw-devel = " \
 bash \
 clang \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwrt-devel \
 lksctp-tools-devel \
 "
RDEPENDS:libobjfwhid = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 "
RDEPENDS:libobjfwhid-devel = " \
 libobjfw-devel \
 libobjfwhid \
 libobjfwrt-devel \
 "
RDEPENDS:libobjfwrt = " \
 glibc \
 libgcc \
 "
RDEPENDS:libobjfwrt-devel = " \
 libobjfwrt \
 "
RDEPENDS:libobjfwtls = " \
 glibc \
 gnutls \
 libgcc \
 libobjfw \
 libobjfwrt \
 "
RDEPENDS:libobjfwtls-devel = " \
 libobjfw-devel \
 libobjfwrt-devel \
 libobjfwtls \
 "
RDEPENDS:objfw = " \
 libobjfw \
 libobjfw-devel \
 libobjfwhid \
 libobjfwhid-devel \
 libobjfwrt \
 libobjfwrt-devel \
 libobjfwtls \
 libobjfwtls-devel \
 ofarc \
 ofdns \
 ofgctester \
 ofhash \
 ofhttp \
 "
RDEPENDS:objfw-doc = " \
 "
RDEPENDS:ofarc = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwtls \
 "
RDEPENDS:ofdns = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 "
RDEPENDS:ofgctester = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwhid \
 libobjfwrt \
 "
RDEPENDS:ofhash = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwtls \
 "
RDEPENDS:ofhttp = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwtls \
 "
