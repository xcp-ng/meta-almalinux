# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dogtag-pki"
PV = "11.9.0"
PR = "5.el10_2.alma.1"
PACKAGES = " \
 idm-pki-acme \
 idm-pki-base \
 idm-pki-ca \
 idm-pki-java \
 idm-pki-kra \
 idm-pki-server \
 idm-pki-tools \
 python3-idm-pki \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dogtag-pki-11.9.0-5.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7d5e8d7d57783530a45721478e28c2f2b0ab8fe8891089092b3781fbf5594000"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-acme-11.9.0-5.el10_2.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-acme;unpack=0"
SRC_URI[x86_64_v2_idm-pki-acme.sha256sum] = "b5bef02548113c0fa533f73999506eb0f9f5ed8060cc5870f5a024cfe04b38f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-base-11.9.0-5.el10_2.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-base;unpack=0"
SRC_URI[x86_64_v2_idm-pki-base.sha256sum] = "582d387b6396d8e4e698857b48390f3d102d7ac512738e3cc874874c5c912711"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-ca-11.9.0-5.el10_2.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-ca;unpack=0"
SRC_URI[x86_64_v2_idm-pki-ca.sha256sum] = "222cd95d6a7904a983de39241895dd9acb151c45c8a7491e9550adc37bd65352"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-java-11.9.0-5.el10_2.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-java;unpack=0"
SRC_URI[x86_64_v2_idm-pki-java.sha256sum] = "0cdf052ebc4a0c8e950bbeca80d0f2c7c6760d139c66043c04ced088658411e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-kra-11.9.0-5.el10_2.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-kra;unpack=0"
SRC_URI[x86_64_v2_idm-pki-kra.sha256sum] = "e5fda389acc85e9115f766d485557babdcf49b10683904f1114a8015fcfe0ae7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-server-11.9.0-5.el10_2.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-server;unpack=0"
SRC_URI[x86_64_v2_idm-pki-server.sha256sum] = "b0f00e34f7b8789bf4cf070694a5cd3513616af2667ab61700b8c68820ad419c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-tools-11.9.0-5.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_idm-pki-tools;unpack=0"
SRC_URI[x86_64_v2_idm-pki-tools.sha256sum] = "c930dc771ef74f2c50d34f36762feea38608261e6d88143f9382831c3a4a6c48"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-idm-pki-11.9.0-5.el10_2.alma.1.noarch.rpm;name=x86_64_v2_python3-idm-pki;unpack=0"
SRC_URI[x86_64_v2_python3-idm-pki.sha256sum] = "df55263895dce79bb1709226dd320f18f208f120a85e935cfa2ab9bc787fdda0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-acme-11.9.0-5.el10_2.alma.1.noarch.rpm;name=aarch64_idm-pki-acme;unpack=0"
SRC_URI[aarch64_idm-pki-acme.sha256sum] = "b5bef02548113c0fa533f73999506eb0f9f5ed8060cc5870f5a024cfe04b38f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-base-11.9.0-5.el10_2.alma.1.noarch.rpm;name=aarch64_idm-pki-base;unpack=0"
SRC_URI[aarch64_idm-pki-base.sha256sum] = "582d387b6396d8e4e698857b48390f3d102d7ac512738e3cc874874c5c912711"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-ca-11.9.0-5.el10_2.alma.1.noarch.rpm;name=aarch64_idm-pki-ca;unpack=0"
SRC_URI[aarch64_idm-pki-ca.sha256sum] = "222cd95d6a7904a983de39241895dd9acb151c45c8a7491e9550adc37bd65352"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-java-11.9.0-5.el10_2.alma.1.noarch.rpm;name=aarch64_idm-pki-java;unpack=0"
SRC_URI[aarch64_idm-pki-java.sha256sum] = "0cdf052ebc4a0c8e950bbeca80d0f2c7c6760d139c66043c04ced088658411e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-kra-11.9.0-5.el10_2.alma.1.noarch.rpm;name=aarch64_idm-pki-kra;unpack=0"
SRC_URI[aarch64_idm-pki-kra.sha256sum] = "e5fda389acc85e9115f766d485557babdcf49b10683904f1114a8015fcfe0ae7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-server-11.9.0-5.el10_2.alma.1.noarch.rpm;name=aarch64_idm-pki-server;unpack=0"
SRC_URI[aarch64_idm-pki-server.sha256sum] = "b0f00e34f7b8789bf4cf070694a5cd3513616af2667ab61700b8c68820ad419c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-tools-11.9.0-5.el10_2.alma.1.aarch64.rpm;name=aarch64_idm-pki-tools;unpack=0"
SRC_URI[aarch64_idm-pki-tools.sha256sum] = "5c75378835fa515066c83de8a1959beb73b79fea10f3d3caf7dbd8170329cddd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-idm-pki-11.9.0-5.el10_2.alma.1.noarch.rpm;name=aarch64_python3-idm-pki;unpack=0"
SRC_URI[aarch64_python3-idm-pki.sha256sum] = "df55263895dce79bb1709226dd320f18f208f120a85e935cfa2ab9bc787fdda0"

RDEPENDS:idm-pki-acme = " \
 bash \
 idm-pki-server \
 "
RDEPENDS:idm-pki-base = " \
 bash \
 nss \
 python3-idm-pki \
 "
RDEPENDS:idm-pki-ca = " \
 bash \
 idm-pki-server \
 systemd \
 "
RDEPENDS:idm-pki-java = " \
 apache-commons-cli \
 apache-commons-codec \
 apache-commons-io \
 apache-commons-lang3 \
 apache-commons-logging \
 apache-commons-net \
 httpcomponents-client \
 idm-jss \
 idm-ldapjdk \
 idm-pki-base \
 java-21-openjdk-headless \
 slf4j \
 slf4j-jdk14 \
 "
RDEPENDS:idm-pki-kra = " \
 bash \
 idm-pki-server \
 systemd \
 "
RDEPENDS:idm-pki-server = " \
 bash \
 hostname \
 idm-jss-tomcat \
 idm-pki-tools \
 ipa-healthcheck-core \
 java-21-openjdk-headless \
 keyutils \
 openldap-clients \
 openssl \
 policycoreutils \
 policycoreutils-python-utils \
 procps-ng \
 python3 \
 python3-libselinux \
 python3-lxml \
 python3-policycoreutils \
 selinux-policy-targeted \
 shadow-utils \
 systemd \
 tomcat9 \
 unzip \
 "
RDEPENDS:idm-pki-tools = " \
 bash \
 file \
 glibc \
 idm-pki-java \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 nss-tools \
 openldap \
 openldap-clients \
 openssl \
 p11-kit-trust \
 "
RDEPENDS:python3-idm-pki = " \
 idm-pki-base \
 python3 \
 python3-cryptography \
 python3-ldap \
 python3-lxml \
 python3-requests \
 python3-six \
 "
