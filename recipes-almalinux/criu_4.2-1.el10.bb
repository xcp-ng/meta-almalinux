# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "criu"
PV = "4.2"
PR = "1.el10"
PACKAGES = " \
 crit \
 criu \
 criu-devel \
 criu-libs \
 python3-criu \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/criu-4.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "183c3653ffad7a320879863c314e9e7f965b5f744d00896e2ec7dfb03a84ba9d"

URI_x86_64_v2_crit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crit-4.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_crit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crit}"
SRC_URI[x86_64_v2_crit.sha256sum] = "07167ce6974b55ff8ad7e86d1857dd48b02e2e90d080964b448ea7526bf6dd79"

URI_x86_64_v2_criu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/criu-4.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_criu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_criu}"
SRC_URI[x86_64_v2_criu.sha256sum] = "2b141e71610e9c227c0b2d0d2c07198d5828a5a2f6c88eaaea628de560443504"

URI_x86_64_v2_criu-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/criu-devel-4.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_criu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_criu-devel}"
SRC_URI[x86_64_v2_criu-devel.sha256sum] = "4304bc4f6a68cd991ba474ef42bcd47fd5edd13e7514cfeb3b7aaadca98bccfc"

URI_x86_64_v2_criu-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/criu-libs-4.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_criu-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_criu-libs}"
SRC_URI[x86_64_v2_criu-libs.sha256sum] = "62fde3ea1243ae87e2c1c9d7db4a227780cd3ecc0352d69d5e9e041da0d7f599"

URI_x86_64_v2_python3-criu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-criu-4.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-criu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-criu}"
SRC_URI[x86_64_v2_python3-criu.sha256sum] = "9a298411bffa2434d471749b347febbe57dc7cf601317af9d4cb1785db0fbbb8"

URI_aarch64_crit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crit-4.2-1.el10.aarch64.rpm;name=aarch64_crit;unpack=0"
SRC_URI:append = " ${URI_aarch64_crit}"
SRC_URI[aarch64_crit.sha256sum] = "07fec46039a16493789f7b95b629f29df6c10661ca3ca2c28658367ab1cad9a1"

URI_aarch64_criu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/criu-4.2-1.el10.aarch64.rpm;name=aarch64_criu;unpack=0"
SRC_URI:append = " ${URI_aarch64_criu}"
SRC_URI[aarch64_criu.sha256sum] = "3c42376d9e83cfbec626551bec67058bfb9dc583ee73862205fbde8c283fbdb9"

URI_aarch64_criu-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/criu-devel-4.2-1.el10.aarch64.rpm;name=aarch64_criu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_criu-devel}"
SRC_URI[aarch64_criu-devel.sha256sum] = "428f618950d6543029c39f13818caa21a8a96ff403c1c0c68856930130326ab2"

URI_aarch64_criu-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/criu-libs-4.2-1.el10.aarch64.rpm;name=aarch64_criu-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_criu-libs}"
SRC_URI[aarch64_criu-libs.sha256sum] = "e61e08553acc39d6a7cefffa77b97e0eea86ed8e3d8581fc0c4172e3a66546c0"

URI_aarch64_python3-criu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-criu-4.2-1.el10.aarch64.rpm;name=aarch64_python3-criu;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-criu}"
SRC_URI[aarch64_python3-criu.sha256sum] = "9bb8691d1c87c6332752c72b8bc80b977e1d8f4446b37727f5a0ed1c6a22a632"

RDEPENDS:crit = " \
 python3 \
 python3-criu \
 "
RDEPENDS:criu = " \
 bash \
 glibc \
 gnutls \
 libgcc \
 libnet \
 libnl3 \
 libselinux \
 libuuid \
 nftables \
 protobuf-c \
 "
RDEPENDS:criu-devel = " \
 criu \
 criu-libs \
 pkgconf-pkg-config \
 protobuf-c-devel \
 "
RDEPENDS:criu-libs = " \
 criu \
 glibc \
 protobuf-c \
 "
RDEPENDS:python3-criu = " \
 python3 \
 python3-protobuf \
 "
