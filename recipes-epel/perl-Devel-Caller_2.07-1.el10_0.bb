# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-Caller"
PV = "2.07"
PR = "1.el10_0"
PACKAGES = " \
 perl-Devel-Caller \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-Caller-2.07-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6953cac7c4979646b9c1b6cce4e489f161d1e380fa1993c09962c8e30effdf88"

URI_x86_64_v2_perl-Devel-Caller = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-Caller-2.07-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Devel-Caller;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-Caller}"
SRC_URI[x86_64_v2_perl-Devel-Caller.sha256sum] = "2076fc7b8eb7482efcb7ab009b1b4222842c9d45c1346b594ee4984d36ab7288"

URI_aarch64_perl-Devel-Caller = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-Caller-2.07-1.el10_0.aarch64.rpm;name=aarch64_perl-Devel-Caller;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-Caller}"
SRC_URI[aarch64_perl-Devel-Caller.sha256sum] = "9def8eb15accbff9232bf4b0c00141f0d456adee64f7c77d52fd62cc90b31ee2"

RDEPENDS:perl-Devel-Caller = " \
 glibc \
 perl-B \
 perl-Exporter \
 perl-PadWalker \
 perl-base \
 perl-libs \
 "
