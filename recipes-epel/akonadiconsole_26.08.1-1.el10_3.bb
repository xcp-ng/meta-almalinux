# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadiconsole"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 akonadiconsole \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/akonadiconsole-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bb4ad72cc6c9150ae3032ada140646a021dc27254303de4ea9feedac1f67ace9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadiconsole-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadiconsole;unpack=0"
SRC_URI[x86_64_v2_akonadiconsole.sha256sum] = "5d3a404f68d832d80e54d395acb5e89286992a0f0e39bf07a9660a96fdd7ccdf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadiconsole-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_akonadiconsole;unpack=0"
SRC_URI[aarch64_akonadiconsole.sha256sum] = "e3838b194502939d006f06fe3e80603e414d7404b4c2df8d2b96f09d83a0efa2"

RDEPENDS:akonadiconsole = " \
 akonadi-calendar-tools \
 akonadi-contacts \
 akonadi-search \
 akonadi-server \
 calendarsupport \
 glibc \
 kf6-kcalendarcore \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kmime \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdepim \
 libstdc++ \
 messagelib \
 qt6-qtbase \
 qt6-qtbase-gui \
 xapian-core-libs \
 "
