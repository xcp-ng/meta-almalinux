# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwayland"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kwayland \
 kwayland-devel \
 kwayland-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwayland-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cf66c3e385372a740557b5f433168b16698718092c15911a60184bbaaa535cd"

URI_x86_64_v2_kwayland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwayland}"
SRC_URI[x86_64_v2_kwayland.sha256sum] = "cf0c69df99667cc01c68bb4e827ec9b9c142aa526b5a45edab15eee57223a732"

URI_x86_64_v2_kwayland-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwayland-devel}"
SRC_URI[x86_64_v2_kwayland-devel.sha256sum] = "9219777eb4d205d064e0c4d3c926d03b3f8d42349b3c464c3dc4207c51365d7b"

URI_x86_64_v2_kwayland-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-doc-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kwayland-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwayland-doc}"
SRC_URI[x86_64_v2_kwayland-doc.sha256sum] = "5c818f98606b414d15bc59c4b22dcd399d2bc7397e99323035ee7620fa658b89"

URI_aarch64_kwayland = "${EPEL_MIRROR}/aarch64/Packages/k/kwayland-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kwayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwayland}"
SRC_URI[aarch64_kwayland.sha256sum] = "884c3383b7fd74879634dcea76a80f7fd113fba5d43d205327ee5f976a7ec8ea"

URI_aarch64_kwayland-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kwayland-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kwayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwayland-devel}"
SRC_URI[aarch64_kwayland-devel.sha256sum] = "f48283dfee0dde664bdcb88e2faaed4b80c7d6ebff833504a37b61da86a29163"

URI_aarch64_kwayland-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kwayland-doc-6.3.6-1.el10_0.noarch.rpm;name=aarch64_kwayland-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwayland-doc}"
SRC_URI[aarch64_kwayland-doc.sha256sum] = "a4206421e034c91ca4cc43d2a137aa22be5ff1565672f64bc067a7d36b13826f"

RDEPENDS:kwayland = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwayland \
 "
RDEPENDS:kwayland-devel = " \
 cmake-filesystem \
 kwayland \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kwayland-doc = " \
 "
