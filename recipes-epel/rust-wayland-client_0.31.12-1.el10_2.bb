# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-client"
PV = "0.31.12"
PR = "1.el10_2"
PACKAGES = " \
 rust-wayland-client+default-devel \
 rust-wayland-client+log-devel \
 rust-wayland-client-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-client-0.31.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69151390c712eb0d4967f1a85f046c12e361a35ee4517dbce9889de5b94b5c23"

URI_x86_64_v2_rust-wayland-client+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+default-devel-0.31.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-client+default-devel.sha256sum] = "d4cfc9e716af0892b7ed5b81e1c5f057300b3564d92af4dc106b1f3a075c8eb0"

URI_x86_64_v2_rust-wayland-client+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+log-devel-0.31.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client+log-devel}"
SRC_URI[x86_64_v2_rust-wayland-client+log-devel.sha256sum] = "795da20f0dca0575aa77babe5208a74538c1ffc121f84d97415f20421d32488d"

URI_x86_64_v2_rust-wayland-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client-devel-0.31.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client-devel}"
SRC_URI[x86_64_v2_rust-wayland-client-devel.sha256sum] = "c8964f444c8b12b903d27fcb8dfb7a638a9d1d2a1b2ae34afd7062f928d8d127"

URI_aarch64_rust-wayland-client+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+default-devel-0.31.12-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-client+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client+default-devel}"
SRC_URI[aarch64_rust-wayland-client+default-devel.sha256sum] = "363b8c340e5565b0527ef4daadaff63e5f0e02a788ea25bea851d0c919ff22aa"

URI_aarch64_rust-wayland-client+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+log-devel-0.31.12-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-client+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client+log-devel}"
SRC_URI[aarch64_rust-wayland-client+log-devel.sha256sum] = "c8ff7d54a50b8c93a51ec911ac275045e9fafabe6df81d93721e706463724eca"

URI_aarch64_rust-wayland-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client-devel-0.31.12-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client-devel}"
SRC_URI[aarch64_rust-wayland-client-devel.sha256sum] = "95280c6345b0dad881dc2d7183be08e34a8722c4a547bd71f06a45359f34a97d"

RDEPENDS:rust-wayland-client+default-devel = " \
 cargo \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
