# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tikv-jemallocator"
PV = "0.6.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-tikv-jemallocator+alloc_trait-devel \
 rust-tikv-jemallocator+background_threads-devel \
 rust-tikv-jemallocator+background_threads_runtime_support-devel \
 rust-tikv-jemallocator+debug-devel \
 rust-tikv-jemallocator+default-devel \
 rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel \
 rust-tikv-jemallocator+profiling-devel \
 rust-tikv-jemallocator+stats-devel \
 rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemallocator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tikv-jemallocator-0.6.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c06987d549d5728f64f92579a7083bea0bf677b96c5fb90e17f79ab5d5cff2d"

URI_x86_64_v2_rust-tikv-jemallocator+alloc_trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+alloc_trait-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+alloc_trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+alloc_trait-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+alloc_trait-devel.sha256sum] = "91965fa85387bcd7f5b9e1fd7a02a91d5df7325b1228c99f22d3800ea96f6907"

URI_x86_64_v2_rust-tikv-jemallocator+background_threads-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+background_threads-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+background_threads-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+background_threads-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+background_threads-devel.sha256sum] = "a5dc6da45e34d44146efe7957f2694d6f84ae9b0df25c2c33cca4c6f11d4c6c8"

URI_x86_64_v2_rust-tikv-jemallocator+background_threads_runtime_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+background_threads_runtime_support-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+background_threads_runtime_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+background_threads_runtime_support-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+background_threads_runtime_support-devel.sha256sum] = "e0315c34f6538a9724dded0590708f78a0b004a98f65e278e1e5add46edd9c36"

URI_x86_64_v2_rust-tikv-jemallocator+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+debug-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+debug-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+debug-devel.sha256sum] = "e4e23e4d9f83641be192e2202d5d3100f066d75ca177ba420039b7e17e07cb63"

URI_x86_64_v2_rust-tikv-jemallocator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+default-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+default-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+default-devel.sha256sum] = "7ebb161f17a17149afb0043d08719fc81ff56508c5f1f9709860b9d1f541df1f"

URI_x86_64_v2_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel.sha256sum] = "06fe3280daf5556737dfe04bd60cdf33781b0f9f573c5924c4fc6a0031b1a13c"

URI_x86_64_v2_rust-tikv-jemallocator+profiling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+profiling-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+profiling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+profiling-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+profiling-devel.sha256sum] = "0b262479a98a452c6a70782eb8205a142017d6e0f12b5ef549ed171178d0e3b0"

URI_x86_64_v2_rust-tikv-jemallocator+stats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+stats-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+stats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+stats-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+stats-devel.sha256sum] = "456feaafb974325a022a8c3cd7744ed84b2a1c5a7a28e39bf55432fc19a3fa15"

URI_x86_64_v2_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel.sha256sum] = "a583c5e98a3bfc09bba8a27fe9cc7b48a5274a7dc8aa7d134902e0b6ff72c6c7"

URI_x86_64_v2_rust-tikv-jemallocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator-devel.sha256sum] = "f7a07a8a4529f7f8c4ad5562648abc9afafe19a03bca53eb062c08c812989062"

URI_aarch64_rust-tikv-jemallocator+alloc_trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+alloc_trait-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemallocator+alloc_trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+alloc_trait-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+alloc_trait-devel.sha256sum] = "ed3bc253360dd19d977eb4dc229cdc1bce070ec2f07339e1d0e5d82441acb5e4"

URI_aarch64_rust-tikv-jemallocator+background_threads-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+background_threads-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemallocator+background_threads-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+background_threads-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+background_threads-devel.sha256sum] = "11af678a14b2d0cd28d034bce46af5cc2b52516eaf0bf001c17d62d1d352bdf2"

URI_aarch64_rust-tikv-jemallocator+background_threads_runtime_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+background_threads_runtime_support-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemallocator+background_threads_runtime_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+background_threads_runtime_support-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+background_threads_runtime_support-devel.sha256sum] = "017e307bf0716aa1a35229e2ef7084d5db49327c503ac439a42fd49affa338d2"

URI_aarch64_rust-tikv-jemallocator+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+debug-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemallocator+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+debug-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+debug-devel.sha256sum] = "b3985a986157a8ed3ed6039c0269d33d7cdecb3c083377ab22a0bab919148109"

URI_aarch64_rust-tikv-jemallocator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+default-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemallocator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+default-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+default-devel.sha256sum] = "b76bacd71866d8761b549dd5c7190e03cffe9cec9c08b23197c8b5d0e27d0137"

URI_aarch64_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel.sha256sum] = "915225634296504ff47f23ccf4daf7aaef9d1f76ed260146ec6f5a392192bf05"

URI_aarch64_rust-tikv-jemallocator+profiling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+profiling-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemallocator+profiling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+profiling-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+profiling-devel.sha256sum] = "544e7902826dc10da19d61473a67a3f18a6c59e9e9edfca1eb85a94d78f61503"

URI_aarch64_rust-tikv-jemallocator+stats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+stats-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemallocator+stats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+stats-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+stats-devel.sha256sum] = "11f9a44d2672bb61267e0a660552c01cda7f3c2ccf210c6c0eb7f5a9599c01ae"

URI_aarch64_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel.sha256sum] = "f0e5e7770ac18221d1cc165e619e7586fbddb92ba61a82ad4aa936d4bea0a0ff"

URI_aarch64_rust-tikv-jemallocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemallocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator-devel.sha256sum] = "6d0e7904e1c4fbb85fe24e561a78ca7d66f8f204eaff861442c433b4d8d78595"

RDEPENDS:rust-tikv-jemallocator+alloc_trait-devel = " \
 cargo \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+background_threads-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+background_threads-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+background_threads_runtime_support-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+background_threads_runtime_support-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+debug-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+debug-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+default-devel = " \
 cargo \
 rust-tikv-jemallocator+background_threads_runtime_support-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel \
 rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+profiling-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+profiling-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+stats-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+stats-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator-devel = " \
 cargo \
 rust-libc-devel \
 rust-tikv-jemalloc-sys-devel \
 "
