# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs24"
PE = "1"
PV = "24.18.0"
PR = "3.el10_2"
PACKAGES = " \
 nodejs24 \
 nodejs24-devel \
 nodejs24-docs \
 nodejs24-full-i18n \
 nodejs24-libs \
 nodejs24-npm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs24-24.18.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de9866f6f04a105509d6934616fb18e0d9d0c1f223cd14564109fa7c39a61f3f"

URI_x86_64_v2_nodejs24 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-24.18.0-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs24;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24}"
SRC_URI[x86_64_v2_nodejs24.sha256sum] = "dcbf23b84d7a0cbf8c5618e3dc399ce5ebf450f1e94b6ce673f27e0f65f8b071"
RPROVIDES:nodejs24:x86_64_v2 = "virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

URI_x86_64_v2_nodejs24-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-devel-24.18.0-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs24-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-devel}"
SRC_URI[x86_64_v2_nodejs24-devel.sha256sum] = "c81e848dad8b6863dbedbfba91123ef63b4cbeedbfaecb8b42cc625d251191ee"

URI_x86_64_v2_nodejs24-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-docs-24.18.0-3.el10_2.noarch.rpm;name=x86_64_v2_nodejs24-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-docs}"
SRC_URI[x86_64_v2_nodejs24-docs.sha256sum] = "89066bd3e4a424f6060b375e6c02c05394b0753a9457c3f2bea0b8ca3a7ef097"

URI_x86_64_v2_nodejs24-full-i18n = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-full-i18n-24.18.0-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs24-full-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-full-i18n}"
SRC_URI[x86_64_v2_nodejs24-full-i18n.sha256sum] = "70ab798a204dae3e8ac5ecedbd3b4b659d4566cb57d92c0d9022ebf7e7a3af97"

URI_x86_64_v2_nodejs24-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-libs-24.18.0-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs24-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-libs}"
SRC_URI[x86_64_v2_nodejs24-libs.sha256sum] = "d167e8b6b601e32fde15a69674e118a2ea4da06fbbbedfef74fb9655ae1ed774"

URI_x86_64_v2_nodejs24-npm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-npm-11.16.0-1.24.18.0.3.el10_2.noarch.rpm;name=x86_64_v2_nodejs24-npm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-npm}"
SRC_URI[x86_64_v2_nodejs24-npm.sha256sum] = "a0d67f6698a66c5d36c8a723a620bfc3e7512941af628d160a75f70e47142745"

URI_aarch64_nodejs24 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-24.18.0-3.el10_2.aarch64.rpm;name=aarch64_nodejs24;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24}"
SRC_URI[aarch64_nodejs24.sha256sum] = "376cc4807f2207404fcfd9273af15c8094ac4c4ac04616820b61ea7f532aa74b"
RPROVIDES:nodejs24:aarch64 = "virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

URI_aarch64_nodejs24-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-devel-24.18.0-3.el10_2.aarch64.rpm;name=aarch64_nodejs24-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-devel}"
SRC_URI[aarch64_nodejs24-devel.sha256sum] = "e96797f8f5ce7e4ab0a03eb87833691e51e961873fd368fcb7482a41449114c8"

URI_aarch64_nodejs24-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-docs-24.18.0-3.el10_2.noarch.rpm;name=aarch64_nodejs24-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-docs}"
SRC_URI[aarch64_nodejs24-docs.sha256sum] = "89066bd3e4a424f6060b375e6c02c05394b0753a9457c3f2bea0b8ca3a7ef097"

URI_aarch64_nodejs24-full-i18n = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-full-i18n-24.18.0-3.el10_2.aarch64.rpm;name=aarch64_nodejs24-full-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-full-i18n}"
SRC_URI[aarch64_nodejs24-full-i18n.sha256sum] = "bb07bb11ff61d830c8ed6af44b2fb146238014a0921639797a4642aa55526d84"

URI_aarch64_nodejs24-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-libs-24.18.0-3.el10_2.aarch64.rpm;name=aarch64_nodejs24-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-libs}"
SRC_URI[aarch64_nodejs24-libs.sha256sum] = "e4a0231960c2ea96881f4a06986fcdfc5b9dc14e3d2ff95904cfd314176270f6"

URI_aarch64_nodejs24-npm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-npm-11.16.0-1.24.18.0.3.el10_2.noarch.rpm;name=aarch64_nodejs24-npm;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-npm}"
SRC_URI[aarch64_nodejs24-npm.sha256sum] = "a0d67f6698a66c5d36c8a723a620bfc3e7512941af628d160a75f70e47142745"

RDEPENDS:nodejs24 = " \
 ca-certificates \
 glibc \
 nodejs24-libs \
 "
RDEPENDS:nodejs24-devel = " \
 brotli-devel \
 libuv-devel \
 nodejs-packaging \
 nodejs24 \
 nodejs24-libs \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:nodejs24-docs = " \
 nodejs24 \
 "
RDEPENDS:nodejs24-full-i18n = " \
 nodejs24 \
 "
RDEPENDS:nodejs24-libs = " \
 c-ares \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 libuv \
 openssl-libs \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:nodejs24-npm = " \
 bash \
 nodejs24 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/nodejs_engine_ rpm/virtual/nodejs_engine__ge_0.8.0"

PROVIDES:append:aarch64 = " rpm/virtual/nodejs_engine_ rpm/virtual/nodejs_engine__ge_0.8.0"
