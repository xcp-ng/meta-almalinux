# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tower-test"
PV = "0.4.0"
PR = "12.el10_3"
PACKAGES = " \
 rust-tower-test+default-devel \
 rust-tower-test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tower-test-0.4.0-12.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd5d18458387800130a4f3ab5fbf99bdf2acf217f2478b81c1ccf9ee9a995996"

URI_x86_64_v2_rust-tower-test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-test+default-devel-0.4.0-12.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-test+default-devel}"
SRC_URI[x86_64_v2_rust-tower-test+default-devel.sha256sum] = "58c9236596cec14ff62c0e9316442cddb2e1d4786c98f4958a6f4b5f9f2aaf4b"

URI_x86_64_v2_rust-tower-test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-test-devel-0.4.0-12.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-test-devel}"
SRC_URI[x86_64_v2_rust-tower-test-devel.sha256sum] = "078e2343bf89e5fb5fbaf42ced014c093866d1cc8f30f84f9db97debc738dd6f"

URI_aarch64_rust-tower-test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-test+default-devel-0.4.0-12.el10_3.noarch.rpm;name=aarch64_rust-tower-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-test+default-devel}"
SRC_URI[aarch64_rust-tower-test+default-devel.sha256sum] = "53d6bdcd13b85b2cc9a68002255b7e70d1243e83296f4248245d8279422b3b2b"

URI_aarch64_rust-tower-test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-test-devel-0.4.0-12.el10_3.noarch.rpm;name=aarch64_rust-tower-test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-test-devel}"
SRC_URI[aarch64_rust-tower-test-devel.sha256sum] = "e425d4e684bfee7ed03f302bf99a19dae0301a7ddea0553df14ddda1ce1b7ead"

RDEPENDS:rust-tower-test+default-devel = " \
 cargo \
 rust-tower-test-devel \
 "
RDEPENDS:rust-tower-test-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-pin-project+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tokio-test+default-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
