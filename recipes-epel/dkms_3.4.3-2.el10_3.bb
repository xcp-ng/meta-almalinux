# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dkms"
PV = "3.4.3"
PR = "2.el10_3"
PACKAGES = " \
 dkms \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dkms-3.4.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3990a6703ca9d15ddf335ccfe2dcc96e1657be5224d7f099bb6f3746196a54fd"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - dkms: (kernel-64k-devel-matched if kernel-64k-core)
# - dkms: (kernel-rt-debug-devel if kernel-rt-debug-core)
# - dkms: (kernel-rt-devel if kernel-rt-core)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - dkms: (kernel-rt-debug-devel if kernel-rt-debug-core)
# - dkms: (kernel-rt-devel if kernel-rt-core)

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dkms-3.4.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dkms;unpack=0"
SRC_URI[x86_64_v2_dkms.sha256sum] = "48dc606aa2c1e5aff8b84d3e8646e0fb11eb346bdb78d0ae8132cd7225eaa1a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dkms-3.4.3-2.el10_3.noarch.rpm;name=aarch64_dkms;unpack=0"
SRC_URI[aarch64_dkms.sha256sum] = "31e88015c597d9e385201957674e0c9b88dab344c70f8888580a60f114de0c3b"

RDEPENDS:dkms:x86_64_v2 = " \
 bash \
 cpio \
 elfutils-libelf-devel \
 file \
 findutils \
 gawk \
 gcc \
 grep \
 gzip \
 kernel-debug-devel-matched \
 kernel-devel-matched \
 kmod \
 make \
 patch \
 sed \
 tar \
 virtual/coreutils \
 which \
"
RDEPENDS:dkms:aarch64 = " \
 bash \
 cpio \
 elfutils-libelf-devel \
 file \
 findutils \
 gawk \
 gcc \
 grep \
 gzip \
 kernel-64k-devel-matched \
 kernel-debug-devel-matched \
 kernel-devel-matched \
 kmod \
 make \
 patch \
 sed \
 tar \
 virtual/coreutils \
 which \
"
