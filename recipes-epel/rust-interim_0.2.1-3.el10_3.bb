# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-interim"
PV = "0.2.1"
PR = "3.el10_3"
PACKAGES = " \
 rust-interim+chrono_0_4-devel \
 rust-interim+default-devel \
 rust-interim+jiff_0_2-devel \
 rust-interim+std-devel \
 rust-interim+time_0_3-devel \
 rust-interim-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-interim-0.2.1-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f68edda2885f94f8b91157c6736e2dc9b8a37ea1f6f06f76bcbe1ad3f96fd5f"

URI_x86_64_v2_rust-interim+chrono_0_4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-interim+chrono_0_4-devel-0.2.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-interim+chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-interim+chrono_0_4-devel}"
SRC_URI[x86_64_v2_rust-interim+chrono_0_4-devel.sha256sum] = "8a8a4e1577a468a1f19fbe17c279845549eed7d38a77662075ae8d8fc97219cb"

URI_x86_64_v2_rust-interim+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-interim+default-devel-0.2.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-interim+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-interim+default-devel}"
SRC_URI[x86_64_v2_rust-interim+default-devel.sha256sum] = "0b83b6e7eaa5f233d8abef3725fe0ad1ac46280daa19f468233debd698852844"

URI_x86_64_v2_rust-interim+jiff_0_2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-interim+jiff_0_2-devel-0.2.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-interim+jiff_0_2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-interim+jiff_0_2-devel}"
SRC_URI[x86_64_v2_rust-interim+jiff_0_2-devel.sha256sum] = "b4759e0bea295684aa6ac0e0ab3af4cddb9ed2106ff230b850ed9d9beca754a4"

URI_x86_64_v2_rust-interim+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-interim+std-devel-0.2.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-interim+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-interim+std-devel}"
SRC_URI[x86_64_v2_rust-interim+std-devel.sha256sum] = "f4694399d8d6ab35c65ac519199678521ec461290a4f2221c093647eea7a61f6"

URI_x86_64_v2_rust-interim+time_0_3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-interim+time_0_3-devel-0.2.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-interim+time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-interim+time_0_3-devel}"
SRC_URI[x86_64_v2_rust-interim+time_0_3-devel.sha256sum] = "99ec4e6e26b1a04f1f8fb470118b508685d35ed57a78e44310f05336131389fa"

URI_x86_64_v2_rust-interim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-interim-devel-0.2.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-interim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-interim-devel}"
SRC_URI[x86_64_v2_rust-interim-devel.sha256sum] = "2366a59d7e151fc6eec6d92d8cfcafda9914eff1f76e55b0a15aa1c7791404cd"

URI_aarch64_rust-interim+chrono_0_4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-interim+chrono_0_4-devel-0.2.1-3.el10_3.noarch.rpm;name=aarch64_rust-interim+chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-interim+chrono_0_4-devel}"
SRC_URI[aarch64_rust-interim+chrono_0_4-devel.sha256sum] = "237977c74fa573de5fa6be10730a2ab0f1889ac4921d2f4fc05c6b60f42379ef"

URI_aarch64_rust-interim+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-interim+default-devel-0.2.1-3.el10_3.noarch.rpm;name=aarch64_rust-interim+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-interim+default-devel}"
SRC_URI[aarch64_rust-interim+default-devel.sha256sum] = "a52c10425889c1d219cb0dea177379b6b65207e088427017e48e9340e23ee647"

URI_aarch64_rust-interim+jiff_0_2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-interim+jiff_0_2-devel-0.2.1-3.el10_3.noarch.rpm;name=aarch64_rust-interim+jiff_0_2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-interim+jiff_0_2-devel}"
SRC_URI[aarch64_rust-interim+jiff_0_2-devel.sha256sum] = "b5bdffc2eae3e9636a3d565109c46dba414425f55e4d700d980af9c03ab42c60"

URI_aarch64_rust-interim+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-interim+std-devel-0.2.1-3.el10_3.noarch.rpm;name=aarch64_rust-interim+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-interim+std-devel}"
SRC_URI[aarch64_rust-interim+std-devel.sha256sum] = "ddc5bf9b5093e24ef92701bbb6edeee3fe9576b56e77dd5c7fbaebd7ed6c9616"

URI_aarch64_rust-interim+time_0_3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-interim+time_0_3-devel-0.2.1-3.el10_3.noarch.rpm;name=aarch64_rust-interim+time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-interim+time_0_3-devel}"
SRC_URI[aarch64_rust-interim+time_0_3-devel.sha256sum] = "cbfab6eeadd9257577ba4738f3f4ddb5778de4303673289846b17a54301f1284"

URI_aarch64_rust-interim-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-interim-devel-0.2.1-3.el10_3.noarch.rpm;name=aarch64_rust-interim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-interim-devel}"
SRC_URI[aarch64_rust-interim-devel.sha256sum] = "3b4374c309b777d25b7eb6d82c8117ed8f0df066b1b4aa8430ee4300ac3cd745"

RDEPENDS:rust-interim+chrono_0_4-devel = " \
 cargo \
 rust-chrono-devel \
 rust-interim-devel \
 "
RDEPENDS:rust-interim+default-devel = " \
 cargo \
 rust-interim+std-devel \
 rust-interim-devel \
 "
RDEPENDS:rust-interim+jiff_0_2-devel = " \
 cargo \
 rust-interim-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-interim+std-devel = " \
 cargo \
 rust-interim-devel \
 "
RDEPENDS:rust-interim+time_0_3-devel = " \
 cargo \
 rust-interim-devel \
 rust-time-devel \
 "
RDEPENDS:rust-interim-devel = " \
 cargo \
 rust \
 rust-logos+default-devel \
 "
