# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cairo-GObject"
PV = "1.005"
PR = "22.el10_0"
PACKAGES = " \
 perl-Cairo-GObject \
 perl-Cairo-GObject-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Cairo-GObject-1.005-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "504110895da5201d2c28de414af8e43c416ca3139d88d4a7994125276846d9cd"

URI_x86_64_v2_perl-Cairo-GObject = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cairo-GObject-1.005-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Cairo-GObject;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cairo-GObject}"
SRC_URI[x86_64_v2_perl-Cairo-GObject.sha256sum] = "df0e4c44deca26308e5ddcc07d574c80804cfa4c3c9c7e32eb47e8e5db47516a"

URI_x86_64_v2_perl-Cairo-GObject-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cairo-GObject-tests-1.005-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Cairo-GObject-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cairo-GObject-tests}"
SRC_URI[x86_64_v2_perl-Cairo-GObject-tests.sha256sum] = "92a5bf2c6d63e5d8b18c0695c24c76f28d973775d6cc84bc4982d049c6eb92d9"

URI_aarch64_perl-Cairo-GObject = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cairo-GObject-1.005-22.el10_0.aarch64.rpm;name=aarch64_perl-Cairo-GObject;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cairo-GObject}"
SRC_URI[aarch64_perl-Cairo-GObject.sha256sum] = "a5ffb6749edb288b5bd38d737a6ea9080c140877b9f76c8f8df3248e7a618c1e"

URI_aarch64_perl-Cairo-GObject-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cairo-GObject-tests-1.005-22.el10_0.noarch.rpm;name=aarch64_perl-Cairo-GObject-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cairo-GObject-tests}"
SRC_URI[aarch64_perl-Cairo-GObject-tests.sha256sum] = "1505c763cdb83134dcfbb0e9b86c30cd7836120b3d3e3a5908ff876aa380c560"

RDEPENDS:perl-Cairo-GObject = " \
 cairo \
 cairo-gobject \
 glib2 \
 glibc \
 perl-Cairo \
 perl-Glib \
 perl-libs \
 "
RDEPENDS:perl-Cairo-GObject-tests = " \
 bash \
 perl-Cairo-GObject \
 perl-Glib \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
