# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-scitokens"
PV = "1.9.7"
PR = "1.el10_3"
PACKAGES = " \
 python3-scitokens \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-scitokens-1.9.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a3102383ae1c551f005b45e9e21985cd2152575d48e8ffdfb23300707077947"

URI_x86_64_v2_python3-scitokens = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-scitokens-1.9.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-scitokens;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-scitokens}"
SRC_URI[x86_64_v2_python3-scitokens.sha256sum] = "cfd23327d0936ec8de0ba18e2ab929dd0df8988243bd031ea7d9ba09babecc78"

URI_aarch64_python3-scitokens = "${EPEL_MIRROR}/aarch64/Packages/p/python3-scitokens-1.9.7-1.el10_3.noarch.rpm;name=aarch64_python3-scitokens;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-scitokens}"
SRC_URI[aarch64_python3-scitokens.sha256sum] = "deca867420a91ac0d72e23826605789e7d12b9a1736567cbe889dd282f157ac0"

RDEPENDS:python3-scitokens = " \
 python3 \
 python3-cryptography \
 python3-jwt \
 python3-requests \
 "
