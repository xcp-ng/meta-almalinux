# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_collator_data"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_collator_data+default-devel \
 rust-icu_collator_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_collator_data-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1db9ab5ca3262125b4c54526ccb18338cb0b171e5042fd9d7e35295e2bba351e"

URI_x86_64_v2_rust-icu_collator_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator_data+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_collator_data+default-devel.sha256sum] = "f54df48b3c955f3ea758e1c3bd39be2ec4f052506d7c2f98d7f34315bcb91d59"

URI_x86_64_v2_rust-icu_collator_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator_data-devel}"
SRC_URI[x86_64_v2_rust-icu_collator_data-devel.sha256sum] = "8de36f5aa74cda2f518adac460bd01d907824650b648f88f273c5ff66a6778ac"

URI_aarch64_rust-icu_collator_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator_data+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_collator_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator_data+default-devel}"
SRC_URI[aarch64_rust-icu_collator_data+default-devel.sha256sum] = "6165d2d5d3776571a7395ef3fd14004e4bb44391691efa5afee16042d209b93c"

URI_aarch64_rust-icu_collator_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_collator_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator_data-devel}"
SRC_URI[aarch64_rust-icu_collator_data-devel.sha256sum] = "6a4a758e0f77f91d41743f8673b6d2f33216068e352707a64e0b703b9a6f8a14"

RDEPENDS:rust-icu_collator_data+default-devel = " \
 cargo \
 rust-icu_collator_data-devel \
 "
RDEPENDS:rust-icu_collator_data-devel = " \
 cargo \
 rust \
 "
