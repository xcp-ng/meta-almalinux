# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsepol"
PV = "3.9"
PR = "1.el10"
PACKAGES = " \
 libsepol \
 libsepol-devel \
 libsepol-static \
 libsepol-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libsepol-3.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d78a3e1e88d3159cd3be148ee4e65b0e0ad44ea45967d8802208c25e0071550b"

URI_x86_64_v2_libsepol = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsepol-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol}"
SRC_URI[x86_64_v2_libsepol.sha256sum] = "38d4bccb0aef5ff35251cd8ed52791cba7108ced90b74d84808e3147c214a352"

URI_x86_64_v2_libsepol-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsepol-devel-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol-devel}"
SRC_URI[x86_64_v2_libsepol-devel.sha256sum] = "fedd5feb64021c97927a4301ebd02dd653e3421408baf056bef69a7c256dc61d"

URI_x86_64_v2_libsepol-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsepol-static-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol-static}"
SRC_URI[x86_64_v2_libsepol-static.sha256sum] = "0ad5951603b30405f04a553ce7d5489144a69e60eb689208a9ee33c4c84dd22e"

URI_x86_64_v2_libsepol-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsepol-utils-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol-utils}"
SRC_URI[x86_64_v2_libsepol-utils.sha256sum] = "47db39727ba577587d9dbbf86ebe59c43c57342d694350183e6afcb4462096f4"

URI_aarch64_libsepol = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsepol-3.9-1.el10.aarch64.rpm;name=aarch64_libsepol;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol}"
SRC_URI[aarch64_libsepol.sha256sum] = "ee18c228003af7f521a054b47acb8ec9839688ab109cf06f4617ddce3369fe17"

URI_aarch64_libsepol-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsepol-devel-3.9-1.el10.aarch64.rpm;name=aarch64_libsepol-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol-devel}"
SRC_URI[aarch64_libsepol-devel.sha256sum] = "a2d973d890d7b0c5cfa6d7f00eb0f62096b4b6a9965d42c3f61e524d6ed88a89"

URI_aarch64_libsepol-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsepol-static-3.9-1.el10.aarch64.rpm;name=aarch64_libsepol-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol-static}"
SRC_URI[aarch64_libsepol-static.sha256sum] = "8117734333e944de035e7f1a3a55ef3df47c47ccd0b5f1448025567ec9795b4b"

URI_aarch64_libsepol-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsepol-utils-3.9-1.el10.aarch64.rpm;name=aarch64_libsepol-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol-utils}"
SRC_URI[aarch64_libsepol-utils.sha256sum] = "8ef7a469e65f21f9b35719bd970afdd5a96e6e40986b181b1753e5132700341e"

RDEPENDS:libsepol = " \
 glibc \
 "
RDEPENDS:libsepol-devel = " \
 libsepol \
 pkgconf-pkg-config \
 "
RDEPENDS:libsepol-static = " \
 libsepol-devel \
 "
RDEPENDS:libsepol-utils = " \
 glibc \
 libsepol \
 "
