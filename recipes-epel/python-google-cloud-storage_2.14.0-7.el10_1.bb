# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-google-cloud-storage"
PV = "2.14.0"
PR = "7.el10_1"
PACKAGES = " \
 python3-google-cloud-storage \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-google-cloud-storage-2.14.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8123144e839eeb156b6068a1a49b4154b9dd6bd4d34cdb82e8e8f65641475919"

URI_x86_64_v2_python3-google-cloud-storage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-cloud-storage-2.14.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-cloud-storage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-cloud-storage}"
SRC_URI[x86_64_v2_python3-google-cloud-storage.sha256sum] = "9556c47aa849b3a6b936666a298d40f4e59bdae2f64f9e2fb60ebb2f3c0bd1f1"

URI_aarch64_python3-google-cloud-storage = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-cloud-storage-2.14.0-7.el10_1.noarch.rpm;name=aarch64_python3-google-cloud-storage;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-cloud-storage}"
SRC_URI[aarch64_python3-google-cloud-storage.sha256sum] = "cbc2a5238d969ca84ae64a6c5ffa7279e935cbad2512212dbd587412e369e3cc"

RDEPENDS:python3-google-cloud-storage = " \
 python3 \
 python3-google-api-core \
 python3-google-auth \
 python3-google-cloud-core \
 python3-google-crc32c \
 python3-google-resumable-media \
 python3-requests \
 "
