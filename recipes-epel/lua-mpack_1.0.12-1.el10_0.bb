# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-mpack"
PV = "1.0.12"
PR = "1.el10_0"
PACKAGES = " \
 lua-mpack \
 lua5.1-mpack \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-mpack-1.0.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "719ded0a0605ae638d6b8465be8b0e1937853cf4c545ca4bc2b825551f10b52b"

URI_x86_64_v2_lua-mpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-mpack-1.0.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-mpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-mpack}"
SRC_URI[x86_64_v2_lua-mpack.sha256sum] = "92274a8d803b2505f8963b9dfd9d8ee549c42adccd8c990db7bb23be15c26dbe"

URI_x86_64_v2_lua5.1-mpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-mpack-1.0.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua5.1-mpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-mpack}"
SRC_URI[x86_64_v2_lua5.1-mpack.sha256sum] = "b303e814d90788b209d1b73f50563522e16bfb3a7727c3172887d7671c09cdfe"

URI_aarch64_lua-mpack = "${EPEL_MIRROR}/aarch64/Packages/l/lua-mpack-1.0.12-1.el10_0.aarch64.rpm;name=aarch64_lua-mpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-mpack}"
SRC_URI[aarch64_lua-mpack.sha256sum] = "708dd7d56ee0bb1acb0bbb8495dc3c8a3e16e5b9fee3a7ae479e2740985687dc"

URI_aarch64_lua5.1-mpack = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-mpack-1.0.12-1.el10_0.aarch64.rpm;name=aarch64_lua5.1-mpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-mpack}"
SRC_URI[aarch64_lua5.1-mpack.sha256sum] = "51feb47a17caaf7bb3a311e91bfad029b21f54a7ec134b087c9bb78df5db56c6"

RDEPENDS:lua-mpack = " \
 glibc \
 lua-libs \
 "
RDEPENDS:lua5.1-mpack = " \
 compat-lua-libs \
 glibc \
 "
