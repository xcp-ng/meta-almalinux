# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-openssl-module"
PV = "5.2"
PR = "8.el10_0"
PACKAGES = " \
 globus-openssl-module \
 globus-openssl-module-devel \
 globus-openssl-module-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-openssl-module-5.2-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd812530632d151afdf67aa048b1b707f8b826118744acfcf9f28d8844ff46ce"

URI_x86_64_v2_globus-openssl-module = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-openssl-module-5.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-openssl-module;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-openssl-module}"
SRC_URI[x86_64_v2_globus-openssl-module.sha256sum] = "b6ca61200fde4f9a40f472dfc001007b4810e82e5e26e35df72aec4cefa526da"

URI_x86_64_v2_globus-openssl-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-openssl-module-devel-5.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-openssl-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-openssl-module-devel}"
SRC_URI[x86_64_v2_globus-openssl-module-devel.sha256sum] = "84f17ccf11161e686db0e7f3bc7d4b1053aa90e8933ef6b91bdfbd2b578144af"

URI_x86_64_v2_globus-openssl-module-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-openssl-module-doc-5.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-openssl-module-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-openssl-module-doc}"
SRC_URI[x86_64_v2_globus-openssl-module-doc.sha256sum] = "40dfab4fc5189d85aec44da3a50064c0605948caf2f2014454cfb369d7f13e96"

URI_aarch64_globus-openssl-module = "${EPEL_MIRROR}/aarch64/Packages/g/globus-openssl-module-5.2-8.el10_0.aarch64.rpm;name=aarch64_globus-openssl-module;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-openssl-module}"
SRC_URI[aarch64_globus-openssl-module.sha256sum] = "b6ee52f5ced9ba50c3fc9225b34f0101b48afb3e010621696a38e9d14197dabb"

URI_aarch64_globus-openssl-module-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-openssl-module-devel-5.2-8.el10_0.aarch64.rpm;name=aarch64_globus-openssl-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-openssl-module-devel}"
SRC_URI[aarch64_globus-openssl-module-devel.sha256sum] = "a846b136eb65b0a637296a21c3e9a13ac0253b0d16cde020bea98d1df3c55eff"

URI_aarch64_globus-openssl-module-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-openssl-module-doc-5.2-8.el10_0.noarch.rpm;name=aarch64_globus-openssl-module-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-openssl-module-doc}"
SRC_URI[aarch64_globus-openssl-module-doc.sha256sum] = "8cc522fe761db2ba5438ba15ab0596b754e28401e73a5108ab7d37800c52b554"

RDEPENDS:globus-openssl-module = " \
 glibc \
 globus-common \
 globus-gsi-openssl-error \
 globus-gsi-proxy-ssl \
 openssl-libs \
 "
RDEPENDS:globus-openssl-module-devel = " \
 globus-common-devel \
 globus-gsi-openssl-error-devel \
 globus-gsi-proxy-ssl-devel \
 globus-openssl-module \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-openssl-module-doc = " \
 "
