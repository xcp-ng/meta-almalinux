# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bzip2-sys"
PV = "0.1.13"
PR = "1.el10_1"
PACKAGES = " \
 rust-bzip2-sys+__disabled-devel \
 rust-bzip2-sys+default-devel \
 rust-bzip2-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bzip2-sys-0.1.13-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "adc63f619a99f31b0c462ad4104caac1fae12a0c42b45fd22699c5c750decaed"

URI_x86_64_v2_rust-bzip2-sys+__disabled-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2-sys+__disabled-devel-0.1.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2-sys+__disabled-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2-sys+__disabled-devel}"
SRC_URI[x86_64_v2_rust-bzip2-sys+__disabled-devel.sha256sum] = "2641c6db3f08a090f19a6cf8630ef823c108436720c3ddf75bd06537d22e501a"

URI_x86_64_v2_rust-bzip2-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2-sys+default-devel-0.1.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2-sys+default-devel}"
SRC_URI[x86_64_v2_rust-bzip2-sys+default-devel.sha256sum] = "db89a458d5265f0828d54c4633fc4f63193161f8819978ac76653d06ae6a5542"

URI_x86_64_v2_rust-bzip2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2-sys-devel-0.1.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2-sys-devel}"
SRC_URI[x86_64_v2_rust-bzip2-sys-devel.sha256sum] = "5e9b599b11a17650562e4347e9218384935f47cf111442ce6c0f256a9b65f7cf"

URI_aarch64_rust-bzip2-sys+__disabled-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2-sys+__disabled-devel-0.1.13-1.el10_1.noarch.rpm;name=aarch64_rust-bzip2-sys+__disabled-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2-sys+__disabled-devel}"
SRC_URI[aarch64_rust-bzip2-sys+__disabled-devel.sha256sum] = "cf62f8bd42babc6cc3f45b69595013ac020eb846ca858ca5b917535e6bfd8248"

URI_aarch64_rust-bzip2-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2-sys+default-devel-0.1.13-1.el10_1.noarch.rpm;name=aarch64_rust-bzip2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2-sys+default-devel}"
SRC_URI[aarch64_rust-bzip2-sys+default-devel.sha256sum] = "ffbedc8e14713b84d66720b0da65a3ed5a97b444989f9775d24ffdf927806c18"

URI_aarch64_rust-bzip2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2-sys-devel-0.1.13-1.el10_1.noarch.rpm;name=aarch64_rust-bzip2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2-sys-devel}"
SRC_URI[aarch64_rust-bzip2-sys-devel.sha256sum] = "bee1c98c7377b2fcaf4c97978b90129318fb512617840aa1916aeee133d0157f"

RDEPENDS:rust-bzip2-sys+__disabled-devel = " \
 cargo \
 rust-bzip2-sys-devel \
 "
RDEPENDS:rust-bzip2-sys+default-devel = " \
 cargo \
 rust-bzip2-sys-devel \
 "
RDEPENDS:rust-bzip2-sys-devel = " \
 bzip2-devel \
 cargo \
 rust-cc+default-devel \
 rust-pkg-config+default-devel \
 "
