# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Glib-Object-Introspection"
PV = "0.052"
PR = "1.el10_0"
PACKAGES = " \
 perl-Glib-Object-Introspection \
 perl-Glib-Object-Introspection-tests \
 perli11ndoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Glib-Object-Introspection-0.052-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ccfe42e4d06320e0c8141e35a8084178b4e8baf99e5e7b06e754e21a54f956a0"

URI_x86_64_v2_perl-Glib-Object-Introspection = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Glib-Object-Introspection-0.052-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Glib-Object-Introspection;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Glib-Object-Introspection}"
SRC_URI[x86_64_v2_perl-Glib-Object-Introspection.sha256sum] = "50fb7127ea251011050deba11051a0d35287441179936fede70c4373710194af"

URI_x86_64_v2_perl-Glib-Object-Introspection-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Glib-Object-Introspection-tests-0.052-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Glib-Object-Introspection-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Glib-Object-Introspection-tests}"
SRC_URI[x86_64_v2_perl-Glib-Object-Introspection-tests.sha256sum] = "0f1fa3fc0fd417acd9d046f88bf932bce0c31ca31f4bd9beffb6967e2a8288a2"

URI_x86_64_v2_perli11ndoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perli11ndoc-0.052-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perli11ndoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perli11ndoc}"
SRC_URI[x86_64_v2_perli11ndoc.sha256sum] = "732a79d4da264a5a5854ad27fb4646cc1693dd5b2704399c13f76c86fa5a63b2"

URI_aarch64_perl-Glib-Object-Introspection = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Glib-Object-Introspection-0.052-1.el10_0.aarch64.rpm;name=aarch64_perl-Glib-Object-Introspection;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Glib-Object-Introspection}"
SRC_URI[aarch64_perl-Glib-Object-Introspection.sha256sum] = "b55c26109c5ba6e1d9161685896534e629bcfe4575d1131a1ba2341464b12787"

URI_aarch64_perl-Glib-Object-Introspection-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Glib-Object-Introspection-tests-0.052-1.el10_0.aarch64.rpm;name=aarch64_perl-Glib-Object-Introspection-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Glib-Object-Introspection-tests}"
SRC_URI[aarch64_perl-Glib-Object-Introspection-tests.sha256sum] = "b303b2bf39bc7dc3e0ce7a0870e96bf4fa04e6e83a2d885c3ed9d4228cf63567"

URI_aarch64_perli11ndoc = "${EPEL_MIRROR}/aarch64/Packages/p/perli11ndoc-0.052-1.el10_0.noarch.rpm;name=aarch64_perli11ndoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_perli11ndoc}"
SRC_URI[aarch64_perli11ndoc.sha256sum] = "8c787aee28aee0ddc10f3c1493a9476cb34cb8781bbd3a2cb6da060459ec4112"

RDEPENDS:perl-Glib-Object-Introspection = " \
 glib2 \
 glibc \
 gobject-introspection \
 libffi \
 perl-Carp \
 perl-Glib \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Glib-Object-Introspection-tests = " \
 bash \
 cairo \
 cairo-gobject \
 glib2 \
 glibc \
 perl-Glib \
 perl-Glib-Object-Introspection \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perli11ndoc = " \
 perl-File-Basename \
 perl-File-Find \
 perl-Glib-Object-Introspection \
 perl-PathTools \
 perl-Text-Tabs+Wrap \
 perl-XML-LibXML \
 perl-interpreter \
 perl-libs \
 perl-open \
 "
