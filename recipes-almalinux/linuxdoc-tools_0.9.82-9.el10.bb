# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linuxdoc-tools"
PV = "0.9.82"
PR = "9.el10"
PACKAGES = " \
 linuxdoc-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/linuxdoc-tools-0.9.82-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9fe0e970586f935e5dc75f1a7d5a1b3affba5f9efea8689ee237654435c9d2b"

URI_x86_64_v2_linuxdoc-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/linuxdoc-tools-0.9.82-9.el10.x86_64_v2.rpm;name=x86_64_v2_linuxdoc-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linuxdoc-tools}"
SRC_URI[x86_64_v2_linuxdoc-tools.sha256sum] = "8d90e1ac7be44945da31585757fc905284ed1f7d7613612cb255072e83bfa7fd"

URI_aarch64_linuxdoc-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/linuxdoc-tools-0.9.82-9.el10.aarch64.rpm;name=aarch64_linuxdoc-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_linuxdoc-tools}"
SRC_URI[aarch64_linuxdoc-tools.sha256sum] = "3e4c004707fa7771611b7647a58b957f1a562913cf70485e9b72d71a77745b69"

RDEPENDS:linuxdoc-tools = " \
 bash \
 gawk \
 glibc \
 groff \
 linuxdoc-tools \
 openjade \
 perl-DirHandle \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Temp \
 perl-FileHandle \
 perl-PathTools \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-subs \
 perl-vars \
 texlive-collection-latexrecommended \
 texlive-texlive-scripts-extra \
 "
