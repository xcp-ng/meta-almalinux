# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-nano"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 plasma-nano \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-nano-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e576cc531ee8cd431c9c0213e25c9d25141943f2d204a16ef8a1a6a0cffa08cc"

URI_x86_64_v2_plasma-nano = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nano-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nano;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nano}"
SRC_URI[x86_64_v2_plasma-nano.sha256sum] = "092d21640ddc16eb8e50a17c8ab7ba6b0f913c96cafd906a0bdb826ed5d95b44"

URI_aarch64_plasma-nano = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nano-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-nano;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nano}"
SRC_URI[aarch64_plasma-nano.sha256sum] = "76a23ce836512e0c2dfb4bb1fa0b8b212db8c140993d353adf8e38836b483317"

RDEPENDS:plasma-nano = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kwayland \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
