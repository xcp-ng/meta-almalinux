# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Business-ISMN"
PV = "1.205"
PR = "3.el10_2"
PACKAGES = " \
 perl-Business-ISMN \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Business-ISMN-1.205-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f5387896308ee635425a53ad029b2c6bdabf0fff86d9b03f310b185d088f854"

URI_x86_64_v2_perl-Business-ISMN = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Business-ISMN-1.205-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Business-ISMN;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Business-ISMN}"
SRC_URI[x86_64_v2_perl-Business-ISMN.sha256sum] = "dd5da0eef51693a22baf240586614fea5135aebb3cf192d9e7788fd64856c9d9"

URI_aarch64_perl-Business-ISMN = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Business-ISMN-1.205-3.el10_2.noarch.rpm;name=aarch64_perl-Business-ISMN;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Business-ISMN}"
SRC_URI[aarch64_perl-Business-ISMN.sha256sum] = "00cd25b031203b011644a9e6418b1f3b4acf6e0957c2b455358ad2f5030257a5"

RDEPENDS:perl-Business-ISMN = " \
 perl-Business-ISMN \
 perl-Carp \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-Tie-Cycle \
 perl-libs \
 perl-subs \
 perl-vars \
 "
