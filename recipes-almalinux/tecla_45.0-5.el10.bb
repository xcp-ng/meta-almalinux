# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tecla"
PV = "45.0"
PR = "5.el10"
PACKAGES = " \
 tecla \
 tecla-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tecla-45.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "80e15279938f0b3f8e7762e2d8b57da716737e70166674388594d1234e16c354"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tecla-45.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_tecla;unpack=0"
SRC_URI[x86_64_v2_tecla.sha256sum] = "657569828ba22fc78471bb2e66e3dd5aeb92559fca9d3db3c4744057370bcf91"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/tecla-devel-45.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_tecla-devel;unpack=0"
SRC_URI[x86_64_v2_tecla-devel.sha256sum] = "15e89b8cf4fd1f87b9c3ad19eb1f2c98883ac0b6b630fb0557dd3d430ee7bf04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tecla-45.0-5.el10.aarch64.rpm;name=aarch64_tecla;unpack=0"
SRC_URI[aarch64_tecla.sha256sum] = "b6f2523a952fe628345f432d062f647670658da50a1caaa5a4be0c0c88cd052f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/tecla-devel-45.0-5.el10.aarch64.rpm;name=aarch64_tecla-devel;unpack=0"
SRC_URI[aarch64_tecla-devel.sha256sum] = "fa6ef4a535e628f1316b6aa29a10b6e00b72d6a876a65d58edd7112fb72eb3f6"

RDEPENDS:tecla = " \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
 libgcc \
 libwayland-client \
 libxkbcommon \
 pango \
 "
RDEPENDS:tecla-devel = " \
 pkgconf-pkg-config \
 tecla \
 "
