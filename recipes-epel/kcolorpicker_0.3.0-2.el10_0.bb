# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcolorpicker"
PV = "0.3.0"
PR = "2.el10_0"
PACKAGES = " \
 kcolorpicker \
 kcolorpicker-devel \
 kcolorpicker-qt6 \
 kcolorpicker-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcolorpicker-0.3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aadec43345afa490baed317dc3714382c2df0359cc13bf3128ae76c704854849"

URI_x86_64_v2_kcolorpicker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcolorpicker-0.3.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcolorpicker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcolorpicker}"
SRC_URI[x86_64_v2_kcolorpicker.sha256sum] = "56260cf4e38850008d5374a52ea7f4af64492f3b62e8aa17891b463ddd327a9c"

URI_x86_64_v2_kcolorpicker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcolorpicker-devel-0.3.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcolorpicker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcolorpicker-devel}"
SRC_URI[x86_64_v2_kcolorpicker-devel.sha256sum] = "8c6fea766a09f03c8055282e97b519b558d7e856e06ad97eb5797b770ac933cc"

URI_x86_64_v2_kcolorpicker-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcolorpicker-qt6-0.3.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcolorpicker-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcolorpicker-qt6}"
SRC_URI[x86_64_v2_kcolorpicker-qt6.sha256sum] = "9f4267794c50f4d9ab8ab93d73dd535ed75fcb98bf97c1370be9efe521ee1e17"

URI_x86_64_v2_kcolorpicker-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcolorpicker-qt6-devel-0.3.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcolorpicker-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcolorpicker-qt6-devel}"
SRC_URI[x86_64_v2_kcolorpicker-qt6-devel.sha256sum] = "a457d5200e2e7c21405175233de8678274d86f266632008d532487cccf82e920"

URI_aarch64_kcolorpicker = "${EPEL_MIRROR}/aarch64/Packages/k/kcolorpicker-0.3.0-2.el10_0.aarch64.rpm;name=aarch64_kcolorpicker;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcolorpicker}"
SRC_URI[aarch64_kcolorpicker.sha256sum] = "27e6d869edd5acb21754b45791faa34701732b92de37458839ac85022777aca5"

URI_aarch64_kcolorpicker-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kcolorpicker-devel-0.3.0-2.el10_0.aarch64.rpm;name=aarch64_kcolorpicker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcolorpicker-devel}"
SRC_URI[aarch64_kcolorpicker-devel.sha256sum] = "64cce6f5b363a97cca807db339d17b99738a7826849efbb54517c972aab3f778"

URI_aarch64_kcolorpicker-qt6 = "${EPEL_MIRROR}/aarch64/Packages/k/kcolorpicker-qt6-0.3.0-2.el10_0.aarch64.rpm;name=aarch64_kcolorpicker-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcolorpicker-qt6}"
SRC_URI[aarch64_kcolorpicker-qt6.sha256sum] = "c32c225f8f3aab9ab57662bfe2343a97f3e446ebeb284db72d62c197116d62e4"

URI_aarch64_kcolorpicker-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kcolorpicker-qt6-devel-0.3.0-2.el10_0.aarch64.rpm;name=aarch64_kcolorpicker-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcolorpicker-qt6-devel}"
SRC_URI[aarch64_kcolorpicker-qt6-devel.sha256sum] = "3e0721f708b6ffd86ab40e89ea61a83b8bd1180227f8351a16ba37eb5e94c06e"

RDEPENDS:kcolorpicker = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:kcolorpicker-devel = " \
 cmake-filesystem \
 kcolorpicker \
 "
RDEPENDS:kcolorpicker-qt6 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kcolorpicker-qt6-devel = " \
 cmake-filesystem \
 kcolorpicker-qt6 \
 "
