# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-server"
PV = "0.31.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-wayland-server+default-devel \
 rust-wayland-server+log-devel \
 rust-wayland-server-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-server-0.31.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c875fa127a0a1466fa192070c3864990b2f45f20e5dc2be748f60cfbe4f807e4"

URI_x86_64_v2_rust-wayland-server+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+default-devel-0.31.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-server+default-devel.sha256sum] = "b80ee95a4beb8baaf29e033ada0bb8d5b20967e3c603b45a4b947ec3d539597e"

URI_x86_64_v2_rust-wayland-server+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+log-devel-0.31.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server+log-devel}"
SRC_URI[x86_64_v2_rust-wayland-server+log-devel.sha256sum] = "d6bb060d1d13b1e98336f80a44b9674356ecffdaa8f67b5b253319351ba188e9"

URI_x86_64_v2_rust-wayland-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server-devel-0.31.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server-devel}"
SRC_URI[x86_64_v2_rust-wayland-server-devel.sha256sum] = "baf005079f5c02b7a5e133653d2ab322ab15763f535466c627f80d41be1bf6e6"

URI_aarch64_rust-wayland-server+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+default-devel-0.31.9-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-server+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server+default-devel}"
SRC_URI[aarch64_rust-wayland-server+default-devel.sha256sum] = "0d92cef8bab8b253579e81cf25c50a0312f3a83bc6a41b77e174832fe944c922"

URI_aarch64_rust-wayland-server+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+log-devel-0.31.9-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-server+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server+log-devel}"
SRC_URI[aarch64_rust-wayland-server+log-devel.sha256sum] = "1c555d9d2f2d6cad585506385d8ebca5c4b4edc41ff04061829c660c4739f647"

URI_aarch64_rust-wayland-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server-devel-0.31.9-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server-devel}"
SRC_URI[aarch64_rust-wayland-server-devel.sha256sum] = "22150a238016aa41de58f975f8ac8ee1f5390b3d5a486c8690e0eea520ab2298"

RDEPENDS:rust-wayland-server+default-devel = " \
 cargo \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-downcast-rs+default-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
