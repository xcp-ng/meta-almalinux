# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Curses"
PV = "1.45"
PR = "7.el10_1"
PACKAGES = " \
 perl-Curses \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Curses-1.45-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0d82d1c372ea79016a19e1c36376ff69c8c48d54200b983a489063b03574631"

URI_x86_64_v2_perl-Curses = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Curses-1.45-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Curses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Curses}"
SRC_URI[x86_64_v2_perl-Curses.sha256sum] = "be7e4a75324abafa3bfd24c60f46e98dac6b8c9f03b76c235acab5851a4cfe5c"

URI_aarch64_perl-Curses = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Curses-1.45-7.el10_1.aarch64.rpm;name=aarch64_perl-Curses;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Curses}"
SRC_URI[aarch64_perl-Curses.sha256sum] = "699173ef8ba652eb003b0c55f411f724a179719a814cdcdd9f4c94211a8dc953"

RDEPENDS:perl-Curses = " \
 glibc \
 ncurses-libs \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
