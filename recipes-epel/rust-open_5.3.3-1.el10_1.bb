# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-open"
PV = "5.3.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-open+default-devel \
 rust-open-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-open-5.3.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f571e756d0c3994b4da0452313ba1f00799c65163a731603f7400e80dc468e54"

URI_x86_64_v2_rust-open+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-open+default-devel-5.3.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-open+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-open+default-devel}"
SRC_URI[x86_64_v2_rust-open+default-devel.sha256sum] = "4a45ce1a2f614314856e875182f26406cf7e38d03722d118f5b6f19d857caf96"

URI_x86_64_v2_rust-open-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-open-devel-5.3.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-open-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-open-devel}"
SRC_URI[x86_64_v2_rust-open-devel.sha256sum] = "8d69320dfe930fe1c40b753766a4febd67d7c158028fd171dbde4806b926ecf3"

URI_aarch64_rust-open+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-open+default-devel-5.3.3-1.el10_1.noarch.rpm;name=aarch64_rust-open+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-open+default-devel}"
SRC_URI[aarch64_rust-open+default-devel.sha256sum] = "0a556ee146f2c3fadf3bfcfea6277d959ca5b33eec767039104e74c30e959099"

URI_aarch64_rust-open-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-open-devel-5.3.3-1.el10_1.noarch.rpm;name=aarch64_rust-open-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-open-devel}"
SRC_URI[aarch64_rust-open-devel.sha256sum] = "bccef66d62eea93c20c87cca883792e6282d2655e88dfd9712d566f803427599"

RDEPENDS:rust-open+default-devel = " \
 cargo \
 rust-open-devel \
 "
RDEPENDS:rust-open-devel = " \
 cargo \
 rust \
 rust-is-wsl+default-devel \
 rust-libc+default-devel \
 rust-pathdiff+default-devel \
 "
