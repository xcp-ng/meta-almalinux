# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aes"
PV = "0.9.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-aes+default-devel \
 rust-aes+hazmat-devel \
 rust-aes+zeroize-devel \
 rust-aes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aes-0.9.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6cc56509fb9de28b92645cd3e4ecb21f8e01e1636efcdec1615c0179e6dae64"

URI_x86_64_v2_rust-aes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes+default-devel-0.9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes+default-devel}"
SRC_URI[x86_64_v2_rust-aes+default-devel.sha256sum] = "90e91e22c7c144656cbb49abc01502879b11f5b24e05911cc310e19833f92ecb"

URI_x86_64_v2_rust-aes+hazmat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes+hazmat-devel-0.9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes+hazmat-devel}"
SRC_URI[x86_64_v2_rust-aes+hazmat-devel.sha256sum] = "277a156ce67f6fb83d809c08de2871c4f8b8086f335beb4eec6e97660f5c5ec0"

URI_x86_64_v2_rust-aes+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes+zeroize-devel-0.9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes+zeroize-devel}"
SRC_URI[x86_64_v2_rust-aes+zeroize-devel.sha256sum] = "92d1ab8090cf0d12b43c889ceb96fcd151ae84f3fe85c8b17baed2213d8cdcb8"

URI_x86_64_v2_rust-aes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-devel-0.9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-devel}"
SRC_URI[x86_64_v2_rust-aes-devel.sha256sum] = "dbfeced7b5324f3c0dded0af297a8a68d063f75684e202f91bc34009999d0151"

URI_aarch64_rust-aes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes+default-devel-0.9.2-1.el10_3.noarch.rpm;name=aarch64_rust-aes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes+default-devel}"
SRC_URI[aarch64_rust-aes+default-devel.sha256sum] = "9e5785417bfd4afee64a8243a69a2306cd4020a9da48af643e29eeaebcf74817"

URI_aarch64_rust-aes+hazmat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes+hazmat-devel-0.9.2-1.el10_3.noarch.rpm;name=aarch64_rust-aes+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes+hazmat-devel}"
SRC_URI[aarch64_rust-aes+hazmat-devel.sha256sum] = "4d9b83b18cc48380eea0dad3eaf3ad1a56144406d0b7015fd526e20d3f47c424"

URI_aarch64_rust-aes+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes+zeroize-devel-0.9.2-1.el10_3.noarch.rpm;name=aarch64_rust-aes+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes+zeroize-devel}"
SRC_URI[aarch64_rust-aes+zeroize-devel.sha256sum] = "f935d40cabab02c88051b750dbfba49abf68cf7bce640efff26b9d79f1f8c4cc"

URI_aarch64_rust-aes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-devel-0.9.2-1.el10_3.noarch.rpm;name=aarch64_rust-aes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-devel}"
SRC_URI[aarch64_rust-aes-devel.sha256sum] = "5dffb994bc6d523ee0b9ebdda478f16424bd5996aba4e9d97d4d99967a729c74"

RDEPENDS:rust-aes+default-devel = " \
 cargo \
 rust-aes-devel \
 "
RDEPENDS:rust-aes+hazmat-devel = " \
 cargo \
 rust-aes-devel \
 "
RDEPENDS:rust-aes+zeroize-devel = " \
 cargo \
 rust-aes-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-aes-devel = " \
 cargo \
 rust \
 rust-cipher+default-devel \
 rust-cpubits+default-devel \
 rust-cpufeatures+default-devel \
 "
