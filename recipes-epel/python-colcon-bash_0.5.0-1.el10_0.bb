# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-bash"
PV = "0.5.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-bash \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-bash-0.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6323a227a27b6d64e11cca1061ff7e3001c5bc0324726e66fae1be511ec2e71"

URI_x86_64_v2_python3-colcon-bash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-bash-0.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-bash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-bash}"
SRC_URI[x86_64_v2_python3-colcon-bash.sha256sum] = "b6efab9e451b38d351f5d90c30bc82a740afb4a8bbf936b69a7e0b125f02f710"

URI_aarch64_python3-colcon-bash = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-bash-0.5.0-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-bash;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-bash}"
SRC_URI[aarch64_python3-colcon-bash.sha256sum] = "1aae144ae35b144cf6ae469ce938a3cf632a1b162df989de8f4abd4de3eacb3c"

RDEPENDS:python3-colcon-bash = " \
 python3 \
 python3-colcon-core \
 "
