# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pie"
PV = "1.2.1"
PR = "1.el10_0"
PACKAGES = " \
 pie \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pie-1.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb3515ffcc69c0abfec765214f6dc0fd6d90ea1ec4ba84904df5e3381eb3e911"

URI_x86_64_v2_pie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pie-1.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pie}"
SRC_URI[x86_64_v2_pie.sha256sum] = "031b06c7e0e5751589798c598a3d024f01bd68d2083cb33d68bdae52d9758e2b"

URI_aarch64_pie = "${EPEL_MIRROR}/aarch64/Packages/p/pie-1.2.1-1.el10_0.noarch.rpm;name=aarch64_pie;unpack=0"
SRC_URI:append = " ${URI_aarch64_pie}"
SRC_URI[aarch64_pie.sha256sum] = "b007caee4df550d0d9d3687473d2cf0a5e303b86364c6f83c24a4f226b741e7c"

RDEPENDS:pie = " \
 ca-certificates \
 php-cli \
 php-common \
 php-intl \
 php-mbstring \
 php-pecl-zip \
 php-process \
 php-xml \
 "
