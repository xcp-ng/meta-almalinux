# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chromium"
PV = "151.0.7922.169"
PR = "1.el10_2"
PACKAGES = " \
 chromedriver \
 chromium \
 chromium-common \
 chromium-headless \
 chromium-qt5-ui \
 chromium-qt6-ui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/chromium-151.0.7922.169-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05c74f8012baf23f899cd8eb98f52e2d40dec30df91e980d08bc2d1b0ea49977"

URI_aarch64_chromedriver = "${EPEL_MIRROR}/aarch64/Packages/c/chromedriver-151.0.7922.169-1.el10_2.aarch64.rpm;name=aarch64_chromedriver;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromedriver}"
SRC_URI[aarch64_chromedriver.sha256sum] = "3d9c3aa0efe023ec3263dd859229dad854d391249a9f2e7b23450ccfbd92ee15"

URI_aarch64_chromium = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-151.0.7922.169-1.el10_2.aarch64.rpm;name=aarch64_chromium;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium}"
SRC_URI[aarch64_chromium.sha256sum] = "c3a13b38be811abed1ea19b133dc55f8d900a24cbeeca708088f89a8775e3982"

URI_aarch64_chromium-common = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-common-151.0.7922.169-1.el10_2.aarch64.rpm;name=aarch64_chromium-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-common}"
SRC_URI[aarch64_chromium-common.sha256sum] = "7c7b3d5684f239195946897c4d11fa07325083005fed206043cc701f6a534d8d"

URI_aarch64_chromium-headless = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-headless-151.0.7922.169-1.el10_2.aarch64.rpm;name=aarch64_chromium-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-headless}"
SRC_URI[aarch64_chromium-headless.sha256sum] = "0fff5bd13c43f1c286181663969ecaa2681cf08d1ea627399bb82a2b05b7df10"

URI_aarch64_chromium-qt5-ui = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-qt5-ui-151.0.7922.169-1.el10_2.aarch64.rpm;name=aarch64_chromium-qt5-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-qt5-ui}"
SRC_URI[aarch64_chromium-qt5-ui.sha256sum] = "f3ca99b25a9049f7f6595aec17589bbd0f4ff28cd5afc158fae06228e53b375f"

URI_aarch64_chromium-qt6-ui = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-qt6-ui-151.0.7922.169-1.el10_2.aarch64.rpm;name=aarch64_chromium-qt6-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-qt6-ui}"
SRC_URI[aarch64_chromium-qt6-ui.sha256sum] = "38215327d96791a2272a2193b52f4efbf732d7feaf82af17952ae1646f7944e3"

RDEPENDS:chromedriver = " \
 chromium-common \
 double-conversion \
 glib2 \
 glibc \
 libbrotli \
 libgcc \
 libxcb \
 libzstd \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:chromium = " \
 alsa-lib \
 at-spi2-atk \
 at-spi2-core \
 atk \
 bash \
 cairo \
 chromium-common \
 cups-libs \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gtk4 \
 harfbuzz \
 lcms2 \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbrotli \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libusb1 \
 libwebp \
 libxcb \
 libxkbcommon \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-mdns \
 nss-util \
 openjpeg2 \
 opus \
 pango \
 pipewire-libs \
 policycoreutils \
 policycoreutils-python-utils \
 systemd-libs \
 "
RDEPENDS:chromium-common = " \
 glibc \
 libgcc \
 "
RDEPENDS:chromium-headless = " \
 alsa-lib \
 at-spi2-core \
 atk \
 chromium-common \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 harfbuzz \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbrotli \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libwebp \
 libxcb \
 libxkbcommon \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-util \
 opus \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:chromium-qt5-ui = " \
 chromium \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:chromium-qt6-ui = " \
 chromium \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
