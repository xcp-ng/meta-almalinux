# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tslib"
PV = "1.23"
PR = "2.el10_2"
PACKAGES = " \
 tslib \
 tslib-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tslib-1.23-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d247216be42b764d1952bdd16a476faa59c654499de2d9883137e900b99c3ede"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tslib-1.23-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tslib;unpack=0"
SRC_URI[x86_64_v2_tslib.sha256sum] = "4a2a445299655bc70741107de6d4c1e702cdeff2ae2531c3ca8b51e852b7db58"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tslib-devel-1.23-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tslib-devel;unpack=0"
SRC_URI[x86_64_v2_tslib-devel.sha256sum] = "2c07b7577d89cb1a26f9bb6384fae3beac1e5cf16596f6eb8d3d7acfe8f81ef8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tslib-1.23-2.el10_2.aarch64.rpm;name=aarch64_tslib;unpack=0"
SRC_URI[aarch64_tslib.sha256sum] = "d19dd448f0a11fe7b6645d180cdf794bc07538e2439cabfdc136e348aee1d5ac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tslib-devel-1.23-2.el10_2.aarch64.rpm;name=aarch64_tslib-devel;unpack=0"
SRC_URI[aarch64_tslib-devel.sha256sum] = "fff34328d88f812725186d579436ff81a11d233fd1d3c3c05b2e4513c9491325"

RDEPENDS:tslib = " \
 glibc \
 sdl2-compat \
 "
RDEPENDS:tslib-devel = " \
 pkgconf-pkg-config \
 tslib \
 "
