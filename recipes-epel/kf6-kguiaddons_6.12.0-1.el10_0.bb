# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kguiaddons"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kguiaddons \
 kf6-kguiaddons-devel \
 kf6-kguiaddons-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kguiaddons-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "21cf68ce43647f878296128b917772d171f0e26e230ddfc30ea7ada4374a79b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kguiaddons;unpack=0"
SRC_URI[x86_64_v2_kf6-kguiaddons.sha256sum] = "f2a35a8573ce52ede12dd771448a545d1fc29b08428b02485d64fcba4f6cb465"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kguiaddons-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kguiaddons-devel.sha256sum] = "692ac74645cc5907188c38ea5344bd1ccfc9241d12aa8f55b701586d7d3ce0c3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kguiaddons-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kguiaddons-doc.sha256sum] = "ef576c4955519b19132543f452fce6ceebcdfa1a8a5711cf143ce986dacfc25d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kguiaddons;unpack=0"
SRC_URI[aarch64_kf6-kguiaddons.sha256sum] = "f3b2879571db179cf9787048aeb2367105a5d3bc5672b34b32d1145b45d790a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kguiaddons-devel;unpack=0"
SRC_URI[aarch64_kf6-kguiaddons-devel.sha256sum] = "3aa787bcaf7d75c0bd1963baf148c8a0d25e657c09ed0060c2db73a6be4a7951"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kguiaddons-doc;unpack=0"
SRC_URI[aarch64_kf6-kguiaddons-doc.sha256sum] = "348c268be7ea5e5d7cc2797b9b7fa4d87a5ca9732d3bde02aa1b21c1ef5eda43"

RDEPENDS:kf6-kguiaddons = " \
 glibc \
 kf6-filesystem \
 libX11 \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
RDEPENDS:kf6-kguiaddons-devel = " \
 cmake-filesystem \
 kf6-kguiaddons \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kguiaddons-doc = " \
 "
