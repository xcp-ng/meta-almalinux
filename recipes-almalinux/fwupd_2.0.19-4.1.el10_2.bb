# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fwupd"
PV = "2.0.19"
PR = "4.1.el10_2"
PACKAGES = " \
 fwupd \
 fwupd-devel \
 fwupd-plugin-flashrom \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/fwupd-2.0.19-4.1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85ad1b56113cc89d57cdfd37a0e9cd85d6e7e09ab6e6323fd4d7ff5c7bafd4f3"

URI_x86_64_v2_fwupd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/fwupd-2.0.19-4.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_fwupd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fwupd}"
SRC_URI[x86_64_v2_fwupd.sha256sum] = "f81292684a3df229636199a2c3d6c5372121e44fbb2db68b2ea2eecaa16ac059"

URI_x86_64_v2_fwupd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fwupd-devel-2.0.19-4.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_fwupd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fwupd-devel}"
SRC_URI[x86_64_v2_fwupd-devel.sha256sum] = "3e362cfd0982fca354867352cf30cf7bfc324078491b71c7aa3710014ea876bc"

URI_x86_64_v2_fwupd-plugin-flashrom = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fwupd-plugin-flashrom-2.0.19-4.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_fwupd-plugin-flashrom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fwupd-plugin-flashrom}"
SRC_URI[x86_64_v2_fwupd-plugin-flashrom.sha256sum] = "583b281a362dcbff37bbe8fcfc5bfaab6246b8c0458c677a9064d47eaf1ab7f1"

URI_aarch64_fwupd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/fwupd-2.0.19-4.1.el10_2.aarch64.rpm;name=aarch64_fwupd;unpack=0"
SRC_URI:append = " ${URI_aarch64_fwupd}"
SRC_URI[aarch64_fwupd.sha256sum] = "4b4858cbffff36d6daf4ca92c9f1126a83cf6092a7028e3d55058d0324c1415a"

URI_aarch64_fwupd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fwupd-devel-2.0.19-4.1.el10_2.aarch64.rpm;name=aarch64_fwupd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fwupd-devel}"
SRC_URI[aarch64_fwupd-devel.sha256sum] = "40cf981729c86451fe830d79ad9b882985baa9596cd8503e32aba8b5988ecef7"

URI_aarch64_fwupd-plugin-flashrom = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fwupd-plugin-flashrom-2.0.19-4.1.el10_2.aarch64.rpm;name=aarch64_fwupd-plugin-flashrom;unpack=0"
SRC_URI:append = " ${URI_aarch64_fwupd-plugin-flashrom}"
SRC_URI[aarch64_fwupd-plugin-flashrom.sha256sum] = "9f79a5c865f5aa7cfa1d0a234aaa832f15a0ca59dd4e20ebc8ceffd7f60de8a3"

RDEPENDS:fwupd = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 json-glib \
 libarchive \
 libblkid \
 libcbor \
 libdrm \
 libgcc \
 libjcat \
 libmnl \
 libusb1 \
 libxmlb \
 polkit-libs \
 protobuf-c \
 readline \
 shared-mime-info \
 sqlite-libs \
 systemd \
 systemd-libs \
 tpm2-tss \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:fwupd-devel = " \
 fwupd \
 glib2-devel \
 json-glib-devel \
 libcurl-devel \
 libjcat-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:fwupd-plugin-flashrom = " \
 flashrom \
 fwupd \
 glib2 \
 glibc \
 libgcc \
 "
