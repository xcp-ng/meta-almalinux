# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "motif"
PV = "2.3.8"
PR = "2.el10_2"
PACKAGES = " \
 motif \
 motif-devel \
 motif-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/motif-2.3.8-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0759504daa4b7ac5b2f634d5c0202a17dd0733e1c127a8bf1df71fc0b013bdc"

URI_x86_64_v2_motif = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/motif-2.3.8-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_motif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_motif}"
SRC_URI[x86_64_v2_motif.sha256sum] = "56e4c8c1e3a3e3d0eec50c07e276173747b2979d18fb17b6b0a9e3e5d14df826"

URI_x86_64_v2_motif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/motif-devel-2.3.8-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_motif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_motif-devel}"
SRC_URI[x86_64_v2_motif-devel.sha256sum] = "4b1f762911e1a7f77e9fbaa8210c1c71f13483cceda04f94a45d73dc6e7e493a"

URI_x86_64_v2_motif-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/motif-static-2.3.8-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_motif-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_motif-static}"
SRC_URI[x86_64_v2_motif-static.sha256sum] = "5e8a2a566e9c863f7eff78e7dc55d0b9f190551e6c2f471c81449284319878b4"

URI_aarch64_motif = "${EPEL_MIRROR}/aarch64/Packages/m/motif-2.3.8-2.el10_2.aarch64.rpm;name=aarch64_motif;unpack=0"
SRC_URI:append = " ${URI_aarch64_motif}"
SRC_URI[aarch64_motif.sha256sum] = "648a9055143ffbb74654237c2878ba3c26762124ebb0fe76e0d3998e7363c6fc"

URI_aarch64_motif-devel = "${EPEL_MIRROR}/aarch64/Packages/m/motif-devel-2.3.8-2.el10_2.aarch64.rpm;name=aarch64_motif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_motif-devel}"
SRC_URI[aarch64_motif-devel.sha256sum] = "52a4a51646bf40b2bbc5e79518b178aeadb7cc3a4b89226848712c296f9b7df7"

URI_aarch64_motif-static = "${EPEL_MIRROR}/aarch64/Packages/m/motif-static-2.3.8-2.el10_2.aarch64.rpm;name=aarch64_motif-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_motif-static}"
SRC_URI[aarch64_motif-static.sha256sum] = "e7a0ed590280a183f9b1ec72d5a02ba9fb811100d2a7a1c2a725787919f612a3"

RDEPENDS:motif = " \
 bash \
 fontconfig \
 freetype \
 glibc \
 libICE \
 libSM \
 libX11 \
 libXext \
 libXft \
 libXmu \
 libXp \
 libXt \
 libjpeg-turbo \
 libpng \
 xorg-x11-xbitmaps \
 "
RDEPENDS:motif-devel = " \
 glibc \
 libXext-devel \
 libXft-devel \
 libXmu-devel \
 libXp-devel \
 libXt \
 libXt-devel \
 libjpeg-turbo-devel \
 libpng-devel \
 motif \
 "
RDEPENDS:motif-static = " \
 motif-devel \
 "
