# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libssh2"
PV = "1.11.1"
PR = "1.el10_1"
PACKAGES = " \
 libssh2 \
 libssh2-devel \
 libssh2-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libssh2-1.11.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "215c93a25014a08686a2ef81053934188b2fb57bdc63b50808d50af12e04bd4e"

URI_x86_64_v2_libssh2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libssh2-1.11.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libssh2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh2}"
SRC_URI[x86_64_v2_libssh2.sha256sum] = "5722bb8acd71bbb9544e705fd6c4ef9a7c0a0368278fd9b990caf338d3c0060f"

URI_x86_64_v2_libssh2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libssh2-devel-1.11.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libssh2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh2-devel}"
SRC_URI[x86_64_v2_libssh2-devel.sha256sum] = "e8dedbe7353c1ce9abe38fae7ba244f6ab080ebf6ecb83da97384bcaa5bd19ea"

URI_x86_64_v2_libssh2-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libssh2-docs-1.11.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libssh2-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh2-docs}"
SRC_URI[x86_64_v2_libssh2-docs.sha256sum] = "b04dfb143705f7cda5f70973e29df079ac7e894d950bdaeb53b76625093b44b2"

URI_aarch64_libssh2 = "${EPEL_MIRROR}/aarch64/Packages/l/libssh2-1.11.1-1.el10_1.aarch64.rpm;name=aarch64_libssh2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh2}"
SRC_URI[aarch64_libssh2.sha256sum] = "5091698191377d63c0167370ff079c8ca842cbdcff3b4f8c6e36d10ed39ae431"

URI_aarch64_libssh2-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libssh2-devel-1.11.1-1.el10_1.aarch64.rpm;name=aarch64_libssh2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh2-devel}"
SRC_URI[aarch64_libssh2-devel.sha256sum] = "6cf15a5ded98cf9505ca4943852283d70b9c37ea5a32c60cce19fdbbdcbbec37"

URI_aarch64_libssh2-docs = "${EPEL_MIRROR}/aarch64/Packages/l/libssh2-docs-1.11.1-1.el10_1.noarch.rpm;name=aarch64_libssh2-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh2-docs}"
SRC_URI[aarch64_libssh2-docs.sha256sum] = "ceebeb34c2526f6b8419ddddc0e68b433b9317da5548fa3046872cb52ac3757a"

RDEPENDS:libssh2 = " \
 glibc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libssh2-devel = " \
 libssh2 \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:libssh2-docs = " \
 libssh2 \
 "
