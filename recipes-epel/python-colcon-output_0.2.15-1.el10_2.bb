# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-output"
PV = "0.2.15"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-output \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-output-0.2.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e11dd7cfc060786864f97c9070bd451d7f0740a41a9df2c37bf52e4bbaf74360"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-output-0.2.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-output;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-output.sha256sum] = "be0833500115c0257afb3e280665e2f0cb9cd53e2e6f5ef6a32d6b4f38a94877"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-output-0.2.15-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-output;unpack=0"
SRC_URI[aarch64_python3-colcon-output.sha256sum] = "fae01b667c9aac0e80e889398ee8dbb2c59327b9531afbf4f94f7f44ab9c0d2a"

RDEPENDS:python3-colcon-output = " \
 python3 \
 python3-colcon-core \
 "
