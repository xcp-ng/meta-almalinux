# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serdect"
PV = "0.4.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-serdect+alloc-devel \
 rust-serdect+default-devel \
 rust-serdect+derive-devel \
 rust-serdect+zeroize-devel \
 rust-serdect-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serdect-0.4.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd54095bb60267bc2481d030a99ab4eda76afcc7cc5b8de3fe61e284c298690b"

URI_x86_64_v2_rust-serdect+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serdect+alloc-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serdect+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serdect+alloc-devel}"
SRC_URI[x86_64_v2_rust-serdect+alloc-devel.sha256sum] = "29c4e31457dd283281d035a6bddacdf0cca76da7c5bc4ac27d6df4edaa59bab3"

URI_x86_64_v2_rust-serdect+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serdect+default-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serdect+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serdect+default-devel}"
SRC_URI[x86_64_v2_rust-serdect+default-devel.sha256sum] = "c7ba482ca98e9df9b1f4b62bd35663fc1a878f4d75b15134276a8f472ae0aecf"

URI_x86_64_v2_rust-serdect+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serdect+derive-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serdect+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serdect+derive-devel}"
SRC_URI[x86_64_v2_rust-serdect+derive-devel.sha256sum] = "e4848ff07a250d217754d5098547bc792c0b8b457fa41fc1fb3fc454964f0627"

URI_x86_64_v2_rust-serdect+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serdect+zeroize-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serdect+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serdect+zeroize-devel}"
SRC_URI[x86_64_v2_rust-serdect+zeroize-devel.sha256sum] = "75ac3ce6b3ecac04b10f5f1c0127905918987d0776843c90bb63edf35fc4d90c"

URI_x86_64_v2_rust-serdect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serdect-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serdect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serdect-devel}"
SRC_URI[x86_64_v2_rust-serdect-devel.sha256sum] = "456db89b6fe643c9bc3dbc6d62b1716076e25737fb3493cf84484ea3c55e0776"

URI_aarch64_rust-serdect+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serdect+alloc-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-serdect+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serdect+alloc-devel}"
SRC_URI[aarch64_rust-serdect+alloc-devel.sha256sum] = "031b5e66d93c56844ce55f26c07a783c2736003dba929bf98378a456212262b6"

URI_aarch64_rust-serdect+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serdect+default-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-serdect+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serdect+default-devel}"
SRC_URI[aarch64_rust-serdect+default-devel.sha256sum] = "7d7e66de7e773efb5a24acd6f74cdeb3998911c0f884e5b21a00cb0b528792d5"

URI_aarch64_rust-serdect+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serdect+derive-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-serdect+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serdect+derive-devel}"
SRC_URI[aarch64_rust-serdect+derive-devel.sha256sum] = "d114b1c6f0b4010228c25831f9114f93dbd95ec1328b22d9ef255e19060b3fed"

URI_aarch64_rust-serdect+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serdect+zeroize-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-serdect+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serdect+zeroize-devel}"
SRC_URI[aarch64_rust-serdect+zeroize-devel.sha256sum] = "1ae3715683bbe290c7a208fcda5449b8bc9624ed64a76221ff142e51a74d473f"

URI_aarch64_rust-serdect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serdect-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-serdect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serdect-devel}"
SRC_URI[aarch64_rust-serdect-devel.sha256sum] = "84d3d140c204a8eb02f51aa8d26cae54546b5faff5998b90af09076f9d427d52"

RDEPENDS:rust-serdect+alloc-devel = " \
 cargo \
 rust-base16ct+alloc-devel \
 rust-serde+alloc-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-serdect+default-devel = " \
 cargo \
 rust-serdect+alloc-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-serdect+derive-devel = " \
 cargo \
 rust-serde+derive-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-serdect+zeroize-devel = " \
 cargo \
 rust-serdect-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-serdect-devel = " \
 cargo \
 rust \
 rust-base16ct-devel \
 rust-serde-devel \
 "
