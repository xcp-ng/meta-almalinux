# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_printf"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_printf+default-devel \
 rust-uu_printf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_printf-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4633a141a265a8d5b867198583414fa685f42dadd99411dacc770b375f9320a0"

URI_x86_64_v2_rust-uu_printf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_printf+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_printf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_printf+default-devel}"
SRC_URI[x86_64_v2_rust-uu_printf+default-devel.sha256sum] = "a72b368f1d65b8840fb6a1c37c478e27a0dd621f04b3200b2bfabe5499293868"

URI_x86_64_v2_rust-uu_printf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_printf-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_printf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_printf-devel}"
SRC_URI[x86_64_v2_rust-uu_printf-devel.sha256sum] = "0df970c0a52eb9a01117e4cc3f9d0dedc6562c897924ba93677678306443708a"

URI_aarch64_rust-uu_printf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_printf+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_printf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_printf+default-devel}"
SRC_URI[aarch64_rust-uu_printf+default-devel.sha256sum] = "a071e08c4fcda083605a4e170ee4f24ab5091571c2707a7426c85c11da723b39"

URI_aarch64_rust-uu_printf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_printf-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_printf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_printf-devel}"
SRC_URI[aarch64_rust-uu_printf-devel.sha256sum] = "1bd0b24b0e2785a0159f799a5f51dd762f5dde0e028430f5a4c2a0b49a41360f"

RDEPENDS:rust-uu_printf+default-devel = " \
 cargo \
 rust-uu_printf-devel \
 "
RDEPENDS:rust-uu_printf-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+format-devel \
 rust-uucore+quoting-style-devel \
 "
