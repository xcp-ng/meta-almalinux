# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmail"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kmail \
 kmail-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmail-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "053cef0515d9755f6cd9762b64aed35593c41eec06e5d8c0581410642c00b77f"

URI_x86_64_v2_kmail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmail-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmail}"
SRC_URI[x86_64_v2_kmail.sha256sum] = "68a08e7021a7f73822e0daa2131d9c2474349b95088c377e82bb44b3f81103a7"

URI_x86_64_v2_kmail-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmail-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmail-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmail-libs}"
SRC_URI[x86_64_v2_kmail-libs.sha256sum] = "534ab9a66c2a300f889684f262bf4ed469f2470335b1c2481c48325c32e3311a"

URI_aarch64_kmail = "${EPEL_MIRROR}/aarch64/Packages/k/kmail-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmail;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmail}"
SRC_URI[aarch64_kmail.sha256sum] = "350195ac27591ae591e7baec0b71c7f58067e6390c3242494844993190f893b2"

URI_aarch64_kmail-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kmail-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmail-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmail-libs}"
SRC_URI[aarch64_kmail-libs.sha256sum] = "a86d0b20ae3b294d2ee8db24237f01ff8c17f7420f734ad7696708c1f5ddd5a3"

RDEPENDS:kmail = " \
 akonadi-import-wizard \
 akonadi-mime \
 akonadi-server \
 glibc \
 grantlee-editor \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kidentitymanagement \
 kmail-account-wizard \
 kmail-libs \
 kmailtransport \
 kmime \
 kontactinterface \
 ktnef \
 libgcc \
 libstdc++ \
 mailcommon \
 messagelib \
 pim-data-exporter \
 pim-sieve-editor \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:kmail-libs = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-search \
 akonadi-server \
 glibc \
 gpgmepp \
 kcalutils \
 kf6-kbookmarks \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 kidentitymanagement \
 kldap \
 kmail \
 kmailtransport \
 kmime \
 kontactinterface \
 kpimtextedit \
 ktextaddons-qt6 \
 libgcc \
 libgpg-error \
 libgravatar \
 libkdepim \
 libkleo \
 libksieve \
 libstdc++ \
 mailcommon \
 messagelib \
 pimcommon \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
