# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-region"
PV = "3.0.2"
PR = "3.el10_1"
PACKAGES = " \
 rust-region+default-devel \
 rust-region-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-region-3.0.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c58e411e50b64e7ea30d89a4a7dfa16c521d197928fb31195878d3284da876b"

URI_x86_64_v2_rust-region+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-region+default-devel-3.0.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-region+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-region+default-devel}"
SRC_URI[x86_64_v2_rust-region+default-devel.sha256sum] = "13681505a4d88c2e02b74cb63702cbc790982b6465114477ad2c21dde1f48307"

URI_x86_64_v2_rust-region-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-region-devel-3.0.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-region-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-region-devel}"
SRC_URI[x86_64_v2_rust-region-devel.sha256sum] = "afc72803ec3a56526c1782971f824bc45f729bd261e037fd939551655d126171"

URI_aarch64_rust-region+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-region+default-devel-3.0.2-3.el10_1.noarch.rpm;name=aarch64_rust-region+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-region+default-devel}"
SRC_URI[aarch64_rust-region+default-devel.sha256sum] = "7ca968057209d06c61618f57744e81e46f02266d407ead3f441756f93193da7d"

URI_aarch64_rust-region-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-region-devel-3.0.2-3.el10_1.noarch.rpm;name=aarch64_rust-region-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-region-devel}"
SRC_URI[aarch64_rust-region-devel.sha256sum] = "167c4d6a9660b4ce22daf0e9fc47d2eafba22f1e814271395e693acb7d576211"

RDEPENDS:rust-region+default-devel = " \
 cargo \
 rust-region-devel \
 "
RDEPENDS:rust-region-devel = " \
 cargo \
 rust-bitflags1+default-devel \
 rust-libc+default-devel \
 "
