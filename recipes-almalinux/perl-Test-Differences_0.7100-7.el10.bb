# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Differences"
PV = "0.7100"
PR = "7.el10"
PACKAGES = " \
 perl-Test-Differences \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Test-Differences-0.7100-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c06ac1bd3e1e8f5dbf924f85cd0f1a5092be1df0a97b902a5431612b20ecd59"

URI_x86_64_v2_perl-Test-Differences = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Test-Differences-0.7100-7.el10.noarch.rpm;name=x86_64_v2_perl-Test-Differences;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Differences}"
SRC_URI[x86_64_v2_perl-Test-Differences.sha256sum] = "e16fb8b0fda2e53dfba5c48c54ca97ab6b7d11c7df0d5edb87fb8e98f3465910"

URI_aarch64_perl-Test-Differences = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Test-Differences-0.7100-7.el10.noarch.rpm;name=aarch64_perl-Test-Differences;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Differences}"
SRC_URI[aarch64_perl-Test-Differences.sha256sum] = "e16fb8b0fda2e53dfba5c48c54ca97ab6b7d11c7df0d5edb87fb8e98f3465910"

RDEPENDS:perl-Test-Differences = " \
 perl-B \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-Text-Diff \
 perl-constant \
 perl-libs \
 "
