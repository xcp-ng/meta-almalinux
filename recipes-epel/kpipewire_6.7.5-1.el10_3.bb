# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpipewire"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kpipewire \
 kpipewire-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kpipewire-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "75213348f0123f2c5369596d9c348462de811fe3df46dcaa52d9ff63f9ddb09c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpipewire-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpipewire;unpack=0"
SRC_URI[x86_64_v2_kpipewire.sha256sum] = "1a678c63a6e3ec001c7cdb182ab566bdd73af6f167586b8e3854bc0e0b4208b4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpipewire-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpipewire-devel;unpack=0"
SRC_URI[x86_64_v2_kpipewire-devel.sha256sum] = "3e9016b431e09ca5a8bd461a7cb1e02d4cbb9e76468796d5137400bd98946c6c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kpipewire-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kpipewire;unpack=0"
SRC_URI[aarch64_kpipewire.sha256sum] = "439833fdbf71d471be9a16d76a8be24b4037e23f261afcda3f00a4fec95b76b8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kpipewire-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kpipewire-devel;unpack=0"
SRC_URI[aarch64_kpipewire-devel.sha256sum] = "198e5a49752489004e25ffdba4a96880b97062b5f0ff806fc0aca4858480ed1a"

RDEPENDS:kpipewire = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libdrm \
 libepoxy \
 libgcc \
 libstdc++ \
 libva \
 mesa-libgbm \
 pipewire-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kpipewire-devel = " \
 cmake-filesystem \
 kpipewire \
 pipewire-devel \
 "
