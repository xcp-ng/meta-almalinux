# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdk-pixbuf2"
PV = "2.42.12"
PR = "4.el10_0"
PACKAGES = " \
 gdk-pixbuf2 \
 gdk-pixbuf2-devel \
 gdk-pixbuf2-modules \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdk-pixbuf2-2.42.12-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffc87e0f298659cee80abd3273e8fcd90c38d5985d0514ae5b8b9c0155535bfe"

URI_x86_64_v2_gdk-pixbuf2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-2.42.12-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdk-pixbuf2}"
SRC_URI[x86_64_v2_gdk-pixbuf2.sha256sum] = "47e80bc11ef408764a2a8f07f1d66853d481e58e8357dab991a371a440f6650f"

URI_x86_64_v2_gdk-pixbuf2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-devel-2.42.12-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdk-pixbuf2-devel}"
SRC_URI[x86_64_v2_gdk-pixbuf2-devel.sha256sum] = "782e2e76ce4890c511a5b80f04adfec724e451be9bcc30b04ae9c4bbfecff70c"

URI_x86_64_v2_gdk-pixbuf2-modules = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-modules-2.42.12-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdk-pixbuf2-modules}"
SRC_URI[x86_64_v2_gdk-pixbuf2-modules.sha256sum] = "b8b8e7c3f7a5b0cdb459afd4b0bc0ebe7bc0bb91db793e844c4c40982aaf6725"

URI_aarch64_gdk-pixbuf2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdk-pixbuf2-2.42.12-4.el10_0.aarch64.rpm;name=aarch64_gdk-pixbuf2;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdk-pixbuf2}"
SRC_URI[aarch64_gdk-pixbuf2.sha256sum] = "c739b949b17feb4c7baf3f5889c08aa2cc8a054159a21f69d66abbff4a2b2f80"

URI_aarch64_gdk-pixbuf2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdk-pixbuf2-devel-2.42.12-4.el10_0.aarch64.rpm;name=aarch64_gdk-pixbuf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdk-pixbuf2-devel}"
SRC_URI[aarch64_gdk-pixbuf2-devel.sha256sum] = "52712d36b9b87581de2d0b8ba1280c05d902a619d031acc5adc1baf4d6cf8abb"

URI_aarch64_gdk-pixbuf2-modules = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdk-pixbuf2-modules-2.42.12-4.el10_0.aarch64.rpm;name=aarch64_gdk-pixbuf2-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdk-pixbuf2-modules}"
SRC_URI[aarch64_gdk-pixbuf2-modules.sha256sum] = "f4b08718235354be8f2aa0a10b335365a075cf3fb56ae07f64dab41547899cfc"

RDEPENDS:gdk-pixbuf2 = " \
 bash \
 glib2 \
 glibc \
 libjpeg-turbo \
 libpng \
 shared-mime-info \
 "
RDEPENDS:gdk-pixbuf2-devel = " \
 gdk-pixbuf2 \
 glib2 \
 glib2-devel \
 glibc \
 libjpeg-turbo-devel \
 libpng-devel \
 libtiff-devel \
 pkgconf-pkg-config \
 shared-mime-info \
 "
RDEPENDS:gdk-pixbuf2-modules = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libtiff \
 "
