# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fast-simplification"
PV = "0.1.12"
PR = "1.el10_1"
PACKAGES = " \
 python3-fast-simplification \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fast-simplification-0.1.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b5204e917594b28842d4437571673eeba09301bd2f00d5d8af74fadb7dccebe"

URI_x86_64_v2_python3-fast-simplification = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fast-simplification-0.1.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fast-simplification;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fast-simplification}"
SRC_URI[x86_64_v2_python3-fast-simplification.sha256sum] = "d951eaffcd8e4f185a4226e490b6d3f261ecd6f366c3bcdad24e425e56a0aac5"

URI_aarch64_python3-fast-simplification = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fast-simplification-0.1.12-1.el10_1.aarch64.rpm;name=aarch64_python3-fast-simplification;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fast-simplification}"
SRC_URI[aarch64_python3-fast-simplification.sha256sum] = "b570b534bacaefdb6c2cb8356e5908757304f8f044689253832a00f4b6c24152"

RDEPENDS:python3-fast-simplification = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-numpy \
 "
