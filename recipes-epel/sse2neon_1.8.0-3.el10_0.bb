# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sse2neon"
PV = "1.8.0"
PR = "3.el10_0"
PACKAGES:x86_64_v2 = " \
  \
"
PACKAGES:aarch64 = " \
 sse2neon-devel \
"

URI_src = "${EPELSRC_MIRROR}/Packages/s/sse2neon-1.8.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8354ef693ffa1a1ca9ebbb5afde68909a59355e2f34a8dd3538c6edd0a00af7d"

URI_aarch64_sse2neon-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sse2neon-devel-1.8.0-3.el10_0.aarch64.rpm;name=aarch64_sse2neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sse2neon-devel}"
SRC_URI[aarch64_sse2neon-devel.sha256sum] = "3d7c8b16e9b662da957b95a550bcb775664ca80d2e6fc9c0a807eb5569646563"

RDEPENDS:sse2neon-devel = " \
 "
