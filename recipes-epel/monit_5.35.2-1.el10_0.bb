# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "monit"
PV = "5.35.2"
PR = "1.el10_0"
PACKAGES = " \
 monit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/monit-5.35.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36a2f49392fe67c7ddac339987770bf3505743c696736db2f36640da4ee86c55"

URI_x86_64_v2_monit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/monit-5.35.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_monit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_monit}"
SRC_URI[x86_64_v2_monit.sha256sum] = "4c460ff0d76d35bd4d7d7c6a35d8d190926b802fad07e7ac41c7201c4f296fb5"

URI_aarch64_monit = "${EPEL_MIRROR}/aarch64/Packages/m/monit-5.35.2-1.el10_0.aarch64.rpm;name=aarch64_monit;unpack=0"
SRC_URI:append = " ${URI_aarch64_monit}"
SRC_URI[aarch64_monit.sha256sum] = "b01bbeb902a97cf556d999100cbf3dcca29b611d40583f34b2d5af05305a5218"

RDEPENDS:monit = " \
 bash \
 glibc \
 libxcrypt \
 openssl-libs \
 pam-libs \
 systemd \
 zlib-ng-compat \
 "
