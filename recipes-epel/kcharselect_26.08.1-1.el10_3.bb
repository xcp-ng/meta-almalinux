# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcharselect"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kcharselect \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kcharselect-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7ed0e524d1b41e5715358ccada45b0d5bbab9644bb2a6c20602a6d36888e745e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcharselect-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcharselect;unpack=0"
SRC_URI[x86_64_v2_kcharselect.sha256sum] = "1c44dc5e5482d4ad48741136cfa09e481c80f7b2e4d569b28d35cc7078a6f9a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcharselect-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kcharselect;unpack=0"
SRC_URI[aarch64_kcharselect.sha256sum] = "89be6cb99f1cbb1f3013c10ac65659af9c0f9e21093f78a773354f1b0f586d85"

RDEPENDS:kcharselect = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
