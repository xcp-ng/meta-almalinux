# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bovo"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 bovo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bovo-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11353846925ad436ba0d6a38de65099b7c359abb3f6d1f67faf0fb10d1e3a532"

URI_x86_64_v2_bovo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bovo-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bovo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bovo}"
SRC_URI[x86_64_v2_bovo.sha256sum] = "b73ef775a2cd6a3d7afc91863a8495d4954dc04f7be09ab959f59c4f08ce6d44"

URI_aarch64_bovo = "${EPEL_MIRROR}/aarch64/Packages/b/bovo-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_bovo;unpack=0"
SRC_URI:append = " ${URI_aarch64_bovo}"
SRC_URI[aarch64_bovo.sha256sum] = "e49f5327d5db4ea6e65b83fe5501ad50a29681191e3604bb09952ba28a0b8f50"

RDEPENDS:bovo = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
