# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uhd"
PV = "4.9.0.0"
PR = "2.el10_2"
PACKAGES = " \
 uhd \
 uhd-devel \
 uhd-doc \
 uhd-firmware \
 uhd-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uhd-4.9.0.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fabe5e509c7cf766aafa14a2572df70700b02da0fc663d53344145a75916309b"

URI_x86_64_v2_uhd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uhd-4.9.0.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uhd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uhd}"
SRC_URI[x86_64_v2_uhd.sha256sum] = "b529880f2767020619f5e3458e73661e9f8c6b5cb5f870616d52465a1aa062c0"

URI_x86_64_v2_uhd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uhd-devel-4.9.0.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uhd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uhd-devel}"
SRC_URI[x86_64_v2_uhd-devel.sha256sum] = "db0d92097046707995d21c608671f8ad63bbe586330a413d89dc81c42b5da560"

URI_x86_64_v2_uhd-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uhd-doc-4.9.0.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uhd-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uhd-doc}"
SRC_URI[x86_64_v2_uhd-doc.sha256sum] = "66ff81e3a9a70242b0c1396774a53e5ee2907f1e48e42b85648f231a30d6d202"

URI_x86_64_v2_uhd-firmware = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uhd-firmware-4.9.0.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_uhd-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uhd-firmware}"
SRC_URI[x86_64_v2_uhd-firmware.sha256sum] = "7cfe142fa75490750856b6e4be8836d3b2a1a78efbdeec40fdd4d461af4f6ea8"

URI_x86_64_v2_uhd-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uhd-tools-4.9.0.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uhd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uhd-tools}"
SRC_URI[x86_64_v2_uhd-tools.sha256sum] = "e864302da40dc99f8c59dbb1ba6d21c4b0bac1cc57c4c1dee89c14d05001ac3a"

URI_aarch64_uhd = "${EPEL_MIRROR}/aarch64/Packages/u/uhd-4.9.0.0-2.el10_2.aarch64.rpm;name=aarch64_uhd;unpack=0"
SRC_URI:append = " ${URI_aarch64_uhd}"
SRC_URI[aarch64_uhd.sha256sum] = "e09b64122a0121e1cbd8e48e5a91599f46fc93da149810cb52a2e7f89fdb3633"

URI_aarch64_uhd-devel = "${EPEL_MIRROR}/aarch64/Packages/u/uhd-devel-4.9.0.0-2.el10_2.aarch64.rpm;name=aarch64_uhd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_uhd-devel}"
SRC_URI[aarch64_uhd-devel.sha256sum] = "ef6b52e35084cb535feb14e57f68f6566a8527985f742b53b359a37577a73cc0"

URI_aarch64_uhd-doc = "${EPEL_MIRROR}/aarch64/Packages/u/uhd-doc-4.9.0.0-2.el10_2.aarch64.rpm;name=aarch64_uhd-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_uhd-doc}"
SRC_URI[aarch64_uhd-doc.sha256sum] = "67368366af990d80a26c6aba233f741ed1c3e0763e769b25af7561e98d21830c"

URI_aarch64_uhd-firmware = "${EPEL_MIRROR}/aarch64/Packages/u/uhd-firmware-4.9.0.0-2.el10_2.noarch.rpm;name=aarch64_uhd-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_uhd-firmware}"
SRC_URI[aarch64_uhd-firmware.sha256sum] = "20c87c10896b11ee51087d226ab7e71ddbe8dc89d9b064d8e5ee6b150c2b8a06"

URI_aarch64_uhd-tools = "${EPEL_MIRROR}/aarch64/Packages/u/uhd-tools-4.9.0.0-2.el10_2.aarch64.rpm;name=aarch64_uhd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_uhd-tools}"
SRC_URI[aarch64_uhd-tools.sha256sum] = "f6e1beb983bb9d18a77d0d38fc6b7e5cc5649b561e2299f95eeda0986c00f666"

RDEPENDS:uhd = " \
 boost-chrono \
 boost-filesystem \
 boost-program-options \
 boost-serialization \
 boost-thread \
 glibc \
 glibc-common \
 libgcc \
 libstdc++ \
 libusb1 \
 ncurses-libs \
 python3 \
 python3-libs \
 python3-tkinter \
 "
RDEPENDS:uhd-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 uhd \
 "
RDEPENDS:uhd-doc = " \
 "
RDEPENDS:uhd-firmware = " \
 uhd \
 "
RDEPENDS:uhd-tools = " \
 bash \
 uhd \
 "
