# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-graylog2-gelf"
PV = "2.0.0"
PR = "11.20201111git1550ee6.el10_0"
PACKAGES = " \
 compat-golang-gopkg-graylog2-gelf-2-devel \
 golang-github-graylog2-gelf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-graylog2-gelf-2.0.0-11.20201111git1550ee6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e46e70f68f466888fbc747c99719f10fe3ff501a2fca268dde4109230cb0dae"

URI_aarch64_compat-golang-gopkg-graylog2-gelf-2-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-gopkg-graylog2-gelf-2-devel-2.0.0-11.20201111git1550ee6.el10_0.noarch.rpm;name=aarch64_compat-golang-gopkg-graylog2-gelf-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-gopkg-graylog2-gelf-2-devel}"
SRC_URI[aarch64_compat-golang-gopkg-graylog2-gelf-2-devel.sha256sum] = "6f9f2e93253a78098275a86208ea73be4eace382e5ee7de9ff5aa8dc0e2be577"

URI_aarch64_golang-github-graylog2-gelf-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-graylog2-gelf-devel-2.0.0-11.20201111git1550ee6.el10_0.noarch.rpm;name=aarch64_golang-github-graylog2-gelf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-graylog2-gelf-devel}"
SRC_URI[aarch64_golang-github-graylog2-gelf-devel.sha256sum] = "a16fad1d644514b849388b25b70cf869db6554e4ec07746d4315f9b7def24f25"

RDEPENDS:compat-golang-gopkg-graylog2-gelf-2-devel = " \
 go-filesystem \
 golang-github-graylog2-gelf-devel \
 "
RDEPENDS:golang-github-graylog2-gelf-devel = " \
 go-filesystem \
 "
