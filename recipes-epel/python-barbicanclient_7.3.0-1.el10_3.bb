# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-barbicanclient"
PV = "7.3.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-barbicanclient \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-barbicanclient-7.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "eaf363ace8c834bc57bdf0b554c3ab5fc1f1292784063a3e70462379dacf2903"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-barbicanclient-7.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-barbicanclient;unpack=0"
SRC_URI[x86_64_v2_python3-barbicanclient.sha256sum] = "6ec21e0a0e9a0910966834b4c8ddfda01ef7c8c68e6eb2fc4146faca6c318cdd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-barbicanclient-7.3.0-1.el10_3.noarch.rpm;name=aarch64_python3-barbicanclient;unpack=0"
SRC_URI[aarch64_python3-barbicanclient.sha256sum] = "d2d39448452c6e57c520eada5ae3c5fd9b5898f15d53ea1b8e2095248a9bc9cc"

RDEPENDS:python3-barbicanclient = " \
 python3 \
 python3-cliff \
 python3-keystoneauth1 \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-requests \
 "
