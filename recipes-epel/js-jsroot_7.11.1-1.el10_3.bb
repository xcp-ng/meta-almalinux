# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "js-jsroot"
PV = "7.11.1"
PR = "1.el10_3"
PACKAGES = " \
 js-jsroot \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/js-jsroot-7.11.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3ad4500b54a3c48a5a6ad544794467346fc19eca82b6a8183a5fa5ac172e349c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/js-jsroot-7.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_js-jsroot;unpack=0"
SRC_URI[x86_64_v2_js-jsroot.sha256sum] = "efaad457ab42e2bef4e38b024da4983b51a9ec128a156b0caf4dcef16ad68a35"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/js-jsroot-7.11.1-1.el10_3.noarch.rpm;name=aarch64_js-jsroot;unpack=0"
SRC_URI[aarch64_js-jsroot.sha256sum] = "208c4a91a282c60d7c29ce7241d6071e17cf906c38bfca087040e2e01011ba15"

RDEPENDS:js-jsroot = " \
 mathjax3 \
 web-assets-filesystem \
 "
