# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros"
PV = "0.24.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+experimental-async-devel \
 rust-pyo3-macros+multiple-pymethods-devel \
 rust-pyo3-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros-0.24.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f24c8e5a775b24d797101ed082c394126e9a8e9df0b509ea2f803f3575707174"

URI_x86_64_v2_rust-pyo3-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+default-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+default-devel.sha256sum] = "a349ee991eb36e8ea1af6f3837ae16c65e22481dce136aa218253b4835150409"

URI_x86_64_v2_rust-pyo3-macros+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+experimental-async-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+experimental-async-devel.sha256sum] = "2969e67f600e9676b052903bf0c5423f425a95f6d10ffae3f8ea05ce34484e65"

URI_x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+multiple-pymethods-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel.sha256sum] = "adc9bab222858760e15ada49bc3f1c48779a3c0f40cd29d8e34084f25402e795"

URI_x86_64_v2_rust-pyo3-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-devel.sha256sum] = "6fe13377730de13abacad6c9be9815eac73e299faef23d13ca5029338e064789"

URI_aarch64_rust-pyo3-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+default-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros+default-devel.sha256sum] = "b5b85585d3f82b5d82c90a8d5743940fb835ac0d2b92f8c8b2bc4cd54fae2190"

URI_aarch64_rust-pyo3-macros+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+experimental-async-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros+experimental-async-devel.sha256sum] = "dc767a0f6a7ff6ae7ef17bc5b2f7cdccbd799437a8f0a27ad6dab878e0c37722"

URI_aarch64_rust-pyo3-macros+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+multiple-pymethods-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3-macros+multiple-pymethods-devel.sha256sum] = "83474cc80e0656d450565eaf3823758785577e3225da48a6696304a4946e92d4"

URI_aarch64_rust-pyo3-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-devel}"
SRC_URI[aarch64_rust-pyo3-macros-devel.sha256sum] = "072a5e70dde14cd738425fd2310574228ebb21cbdb29272b05a82ebf8a37220e"

RDEPENDS:rust-pyo3-macros+default-devel = " \
 cargo \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend+experimental-async-devel \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-pyo3-macros-backend+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 "
