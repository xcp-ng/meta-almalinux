# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-bsddb3"
PV = "6.2.9"
PR = "18.el10_0"
PACKAGES = " \
 python3-bsddb3 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-bsddb3-6.2.9-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "12c57a92015d484418e700546cf037a9abe651402f484e6acebe82957b06bf35"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bsddb3-6.2.9-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-bsddb3;unpack=0"
SRC_URI[x86_64_v2_python3-bsddb3.sha256sum] = "87429b351c729179bf8ff10f8c8f8b3ecfe46f33afe2b72848547c30fb6e94f8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-bsddb3-6.2.9-18.el10_0.aarch64.rpm;name=aarch64_python3-bsddb3;unpack=0"
SRC_URI[aarch64_python3-bsddb3.sha256sum] = "c0f51e43d55f4079a1d051409b56eeba52d6f1a157024fec552b4f86150b5e72"

RDEPENDS:python3-bsddb3 = " \
 glibc \
 libdb \
 python3 \
 "
