# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reflink-copy"
PV = "0.1.30"
PR = "1.el10_2"
PACKAGES = " \
 rust-reflink-copy+default-devel \
 rust-reflink-copy+tracing-devel \
 rust-reflink-copy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reflink-copy-0.1.30-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31e806d0ce25a6cf77792bd290512e03b6fa6b70f9d64d502971965b552910a8"

URI_x86_64_v2_rust-reflink-copy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reflink-copy+default-devel-0.1.30-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reflink-copy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reflink-copy+default-devel}"
SRC_URI[x86_64_v2_rust-reflink-copy+default-devel.sha256sum] = "c2e39b1fbfdc7ebd26bd73c328d9a580f7f3d523a494b155167fc205a3056e22"

URI_x86_64_v2_rust-reflink-copy+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reflink-copy+tracing-devel-0.1.30-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reflink-copy+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reflink-copy+tracing-devel}"
SRC_URI[x86_64_v2_rust-reflink-copy+tracing-devel.sha256sum] = "f96e6edccccf405f8c2d8c1fcc5b1fdfded732913dd97432aa3136020cc3823b"

URI_x86_64_v2_rust-reflink-copy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reflink-copy-devel-0.1.30-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reflink-copy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reflink-copy-devel}"
SRC_URI[x86_64_v2_rust-reflink-copy-devel.sha256sum] = "49144cca9622fa376c5d890008ce1000b159571625e5c2ec816ea532388b45af"

URI_aarch64_rust-reflink-copy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reflink-copy+default-devel-0.1.30-1.el10_2.noarch.rpm;name=aarch64_rust-reflink-copy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reflink-copy+default-devel}"
SRC_URI[aarch64_rust-reflink-copy+default-devel.sha256sum] = "119acb37b97fa694b2f47bf838545c6f7494a977488232f42d263860fcc0134b"

URI_aarch64_rust-reflink-copy+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reflink-copy+tracing-devel-0.1.30-1.el10_2.noarch.rpm;name=aarch64_rust-reflink-copy+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reflink-copy+tracing-devel}"
SRC_URI[aarch64_rust-reflink-copy+tracing-devel.sha256sum] = "beebd60b187fc9296648091d13891a64f24f233718a9281d87bdb86301ee6d0c"

URI_aarch64_rust-reflink-copy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reflink-copy-devel-0.1.30-1.el10_2.noarch.rpm;name=aarch64_rust-reflink-copy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reflink-copy-devel}"
SRC_URI[aarch64_rust-reflink-copy-devel.sha256sum] = "6acd4531ebbff79c44e685f4071c174b75542bccaf6055d0c4b00b3694fa1274"

RDEPENDS:rust-reflink-copy+default-devel = " \
 cargo \
 rust-reflink-copy-devel \
 "
RDEPENDS:rust-reflink-copy+tracing-devel = " \
 cargo \
 rust-reflink-copy-devel \
 rust-tracing-attributes+default-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-reflink-copy-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
