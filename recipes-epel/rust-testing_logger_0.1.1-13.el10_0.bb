# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-testing_logger"
PV = "0.1.1"
PR = "13.el10_0"
PACKAGES = " \
 rust-testing_logger+default-devel \
 rust-testing_logger-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-testing_logger-0.1.1-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91664b9d9f0aa8f759f623fbb071d1a04f8a9c206aa3e798066fcaf436884516"

URI_x86_64_v2_rust-testing_logger+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-testing_logger+default-devel-0.1.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-testing_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-testing_logger+default-devel}"
SRC_URI[x86_64_v2_rust-testing_logger+default-devel.sha256sum] = "3a47b84275a6387d7b5fcb25e8ddb0fdc3803cf5fbcc95bfb89ba2e2842e791a"

URI_x86_64_v2_rust-testing_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-testing_logger-devel-0.1.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-testing_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-testing_logger-devel}"
SRC_URI[x86_64_v2_rust-testing_logger-devel.sha256sum] = "32629798d2b200de0f89a5a8ba9d6848c8a42abb1479bdb37b6c8ae8aad16534"

URI_aarch64_rust-testing_logger+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-testing_logger+default-devel-0.1.1-13.el10_0.noarch.rpm;name=aarch64_rust-testing_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-testing_logger+default-devel}"
SRC_URI[aarch64_rust-testing_logger+default-devel.sha256sum] = "b6059cf965c82e5e1661cbe4b4679042ab2e6d33bc0cf28f23be84da34eeadeb"

URI_aarch64_rust-testing_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-testing_logger-devel-0.1.1-13.el10_0.noarch.rpm;name=aarch64_rust-testing_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-testing_logger-devel}"
SRC_URI[aarch64_rust-testing_logger-devel.sha256sum] = "df2f5a4bb418407db812d7f5e1754b5d60dd3a69bd6125642f119169e79915d1"

RDEPENDS:rust-testing_logger+default-devel = " \
 cargo \
 rust-testing_logger-devel \
 "
RDEPENDS:rust-testing_logger-devel = " \
 cargo \
 rust-log+default-devel \
 "
