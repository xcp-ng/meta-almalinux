# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "picmi"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 picmi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/picmi-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7767181e81219ea69e059f5288864eebb4b938226a1020d1f37f022af96995ac"

URI_x86_64_v2_picmi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/picmi-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_picmi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_picmi}"
SRC_URI[x86_64_v2_picmi.sha256sum] = "dfa80bb46d1db6f56ce72821cd100e3b2acc1af1925eb6aff89a85bf940fb370"

URI_aarch64_picmi = "${EPEL_MIRROR}/aarch64/Packages/p/picmi-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_picmi;unpack=0"
SRC_URI:append = " ${URI_aarch64_picmi}"
SRC_URI[aarch64_picmi.sha256sum] = "8e0ee07659b33dbba12c577a184071a51f1bd610118e9452fe511f425c712d99"

RDEPENDS:picmi = " \
 glibc \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
