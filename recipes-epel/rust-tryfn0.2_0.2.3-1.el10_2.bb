# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tryfn0.2"
PV = "0.2.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-tryfn0.2+color-auto-devel \
 rust-tryfn0.2+color-devel \
 rust-tryfn0.2+default-devel \
 rust-tryfn0.2+diff-devel \
 rust-tryfn0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tryfn0.2-0.2.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "049b92722fe3c654389bfe3c76581aa600969c875a3ceaf9da10924d8982f52a"

URI_x86_64_v2_rust-tryfn0.2+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn0.2+color-auto-devel-0.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn0.2+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn0.2+color-auto-devel}"
SRC_URI[x86_64_v2_rust-tryfn0.2+color-auto-devel.sha256sum] = "ba9e938959094eba97a70d05cb4900501cac46788ca2beeaad1b5a99e7243a2a"

URI_x86_64_v2_rust-tryfn0.2+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn0.2+color-devel-0.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn0.2+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn0.2+color-devel}"
SRC_URI[x86_64_v2_rust-tryfn0.2+color-devel.sha256sum] = "55813d478a2a4037d6375463ec759a1130dbf140e38a368bbfd823188cbf06c9"

URI_x86_64_v2_rust-tryfn0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn0.2+default-devel-0.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn0.2+default-devel}"
SRC_URI[x86_64_v2_rust-tryfn0.2+default-devel.sha256sum] = "3873c003af2ece1a306b7cde68d71bdbc3f74ec0ff927118446cb9b38b399378"

URI_x86_64_v2_rust-tryfn0.2+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn0.2+diff-devel-0.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn0.2+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn0.2+diff-devel}"
SRC_URI[x86_64_v2_rust-tryfn0.2+diff-devel.sha256sum] = "9626ea4f4626d3408d5b5dc9422154c40946e4ac978c296f2db11201a3f33c88"

URI_x86_64_v2_rust-tryfn0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn0.2-devel-0.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn0.2-devel}"
SRC_URI[x86_64_v2_rust-tryfn0.2-devel.sha256sum] = "5c7a7e469d1b27f01f03459689f6cff6ac47d337d6a23a35f0922ae1ff222564"

URI_aarch64_rust-tryfn0.2+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn0.2+color-auto-devel-0.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-tryfn0.2+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn0.2+color-auto-devel}"
SRC_URI[aarch64_rust-tryfn0.2+color-auto-devel.sha256sum] = "818d386f8a062d6a536bf9ed260fdd61881156faa2cce0d2675004a90bb05963"

URI_aarch64_rust-tryfn0.2+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn0.2+color-devel-0.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-tryfn0.2+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn0.2+color-devel}"
SRC_URI[aarch64_rust-tryfn0.2+color-devel.sha256sum] = "4f3eff15e79f713f7d242a77aad2370506f406855bf7040248d2886d87f451a4"

URI_aarch64_rust-tryfn0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn0.2+default-devel-0.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-tryfn0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn0.2+default-devel}"
SRC_URI[aarch64_rust-tryfn0.2+default-devel.sha256sum] = "5e9968f7c95e85dd576f22c2664e081eace85908950944de0c2932dcb16b4836"

URI_aarch64_rust-tryfn0.2+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn0.2+diff-devel-0.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-tryfn0.2+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn0.2+diff-devel}"
SRC_URI[aarch64_rust-tryfn0.2+diff-devel.sha256sum] = "127bf512f392d3cef86aae4e9180a5b2c147fbd566277e63b3e9ea66f0064a35"

URI_aarch64_rust-tryfn0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn0.2-devel-0.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-tryfn0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn0.2-devel}"
SRC_URI[aarch64_rust-tryfn0.2-devel.sha256sum] = "0722e3ead4f8cd2d34c336b5e113cad783b07ad975266f9a6dce55ae28afc6e6"

RDEPENDS:rust-tryfn0.2+color-auto-devel = " \
 cargo \
 rust-snapbox0.6+color-auto-devel \
 rust-tryfn0.2-devel \
 "
RDEPENDS:rust-tryfn0.2+color-devel = " \
 cargo \
 rust-snapbox0.6+color-devel \
 rust-tryfn0.2-devel \
 "
RDEPENDS:rust-tryfn0.2+default-devel = " \
 cargo \
 rust-tryfn0.2+color-auto-devel \
 rust-tryfn0.2+diff-devel \
 rust-tryfn0.2-devel \
 "
RDEPENDS:rust-tryfn0.2+diff-devel = " \
 cargo \
 rust-snapbox0.6+diff-devel \
 rust-tryfn0.2-devel \
 "
RDEPENDS:rust-tryfn0.2-devel = " \
 cargo \
 rust \
 rust-ignore+default-devel \
 rust-libtest-mimic+default-devel \
 rust-snapbox0.6-devel \
 "
