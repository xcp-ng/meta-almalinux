# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus"
PV = "1.5.31"
PR = "3.el10"
PACKAGES = " \
 ibus \
 ibus-devel \
 ibus-devel-docs \
 ibus-gtk3 \
 ibus-gtk4 \
 ibus-libs \
 ibus-panel \
 ibus-setup \
 ibus-wayland \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ibus-1.5.31-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4aabd458f962d072612e3909a892d358a44871290abd51c8b07dad193f65f1dd"

URI_x86_64_v2_ibus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-1.5.31-3.el10.x86_64_v2.rpm;name=x86_64_v2_ibus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus}"
SRC_URI[x86_64_v2_ibus.sha256sum] = "246309a4a5691b5c94264e69b2385e83e871ad08b995f1e7efc3b35244acaa83"

URI_x86_64_v2_ibus-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ibus-devel-1.5.31-3.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-devel}"
SRC_URI[x86_64_v2_ibus-devel.sha256sum] = "de2818f82a4b321ca0a517db8bc819cffb3a23297fb123f73601d23cc51d0321"

URI_x86_64_v2_ibus-devel-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ibus-devel-docs-1.5.31-3.el10.noarch.rpm;name=x86_64_v2_ibus-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-devel-docs}"
SRC_URI[x86_64_v2_ibus-devel-docs.sha256sum] = "dae8307f76cb599e1a767f3a8e6db531915681d90640c63722573f18005269d1"

URI_x86_64_v2_ibus-gtk3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-gtk3-1.5.31-3.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-gtk3}"
SRC_URI[x86_64_v2_ibus-gtk3.sha256sum] = "61a16840d409f19f4bbeb0879737b67fba7aaf7c7d40c8b289daa819cf685ed9"

URI_x86_64_v2_ibus-gtk4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-gtk4-1.5.31-3.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-gtk4}"
SRC_URI[x86_64_v2_ibus-gtk4.sha256sum] = "2b4da6b4a6d6398e132a629f0e66f271755eeb2a064a012dedc2abb5bfb00278"

URI_x86_64_v2_ibus-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-libs-1.5.31-3.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-libs}"
SRC_URI[x86_64_v2_ibus-libs.sha256sum] = "33e8b900b7e6e0fdbb59eff3849f4034c7edc2f3ade3182d878813d395cc3a54"

URI_x86_64_v2_ibus-panel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ibus-panel-1.5.31-3.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-panel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-panel}"
SRC_URI[x86_64_v2_ibus-panel.sha256sum] = "3ca54c776c8eca368b551d215d65a1aaa140cc6259476cffcc982e23b4780bc8"

URI_x86_64_v2_ibus-setup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-setup-1.5.31-3.el10.noarch.rpm;name=x86_64_v2_ibus-setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-setup}"
SRC_URI[x86_64_v2_ibus-setup.sha256sum] = "4147b3e73bd17c9b2d4d3ea9fc476c28872a64d3d7e8eb5e6d1b2635e9965ea5"

URI_x86_64_v2_ibus-wayland = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-wayland-1.5.31-3.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-wayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-wayland}"
SRC_URI[x86_64_v2_ibus-wayland.sha256sum] = "c2bc8ede3523e371e56f59d7e49d55e4d43266edd04c9224d7ad156f6cb2dc7f"

URI_aarch64_ibus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-1.5.31-3.el10.aarch64.rpm;name=aarch64_ibus;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus}"
SRC_URI[aarch64_ibus.sha256sum] = "1eb894c894280de74f17ef24db05bfa3e12cdda2cf1cb4181a4b65727a33bd3f"

URI_aarch64_ibus-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ibus-devel-1.5.31-3.el10.aarch64.rpm;name=aarch64_ibus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-devel}"
SRC_URI[aarch64_ibus-devel.sha256sum] = "c793b97a75806d6c289932140d3bdfd8e8cc55153419428aa4d2fcfc983e852d"

URI_aarch64_ibus-devel-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ibus-devel-docs-1.5.31-3.el10.noarch.rpm;name=aarch64_ibus-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-devel-docs}"
SRC_URI[aarch64_ibus-devel-docs.sha256sum] = "dae8307f76cb599e1a767f3a8e6db531915681d90640c63722573f18005269d1"

URI_aarch64_ibus-gtk3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-gtk3-1.5.31-3.el10.aarch64.rpm;name=aarch64_ibus-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-gtk3}"
SRC_URI[aarch64_ibus-gtk3.sha256sum] = "5bc77c0831404e279d5f8a6bb8ff1e3ae00e72a66d03d569034c41f3cc09f36f"

URI_aarch64_ibus-gtk4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-gtk4-1.5.31-3.el10.aarch64.rpm;name=aarch64_ibus-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-gtk4}"
SRC_URI[aarch64_ibus-gtk4.sha256sum] = "b7316bf46c01022ee2639a0b8b09e342da5d995760e123d80df823965dce04fc"

URI_aarch64_ibus-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-libs-1.5.31-3.el10.aarch64.rpm;name=aarch64_ibus-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-libs}"
SRC_URI[aarch64_ibus-libs.sha256sum] = "267346bc2f95e9d39aeccc81e7811e2535aaab904d1abe2d6fa129c393f33c23"

URI_aarch64_ibus-panel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ibus-panel-1.5.31-3.el10.aarch64.rpm;name=aarch64_ibus-panel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-panel}"
SRC_URI[aarch64_ibus-panel.sha256sum] = "8e38a7a5518890a6098619975282cef337018c8644421fd3c63e3ba867ce31b8"

URI_aarch64_ibus-setup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-setup-1.5.31-3.el10.noarch.rpm;name=aarch64_ibus-setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-setup}"
SRC_URI[aarch64_ibus-setup.sha256sum] = "4147b3e73bd17c9b2d4d3ea9fc476c28872a64d3d7e8eb5e6d1b2635e9965ea5"

URI_aarch64_ibus-wayland = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-wayland-1.5.31-3.el10.aarch64.rpm;name=aarch64_ibus-wayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-wayland}"
SRC_URI[aarch64_ibus-wayland.sha256sum] = "29d3caf61ff90379b0b748caba518e54152d9680d3919b6de6e0fb65f6e8af09"

RDEPENDS:ibus = " \
 alternatives \
 bash \
 dconf \
 desktop-file-utils \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 ibus-gtk3 \
 ibus-libs \
 ibus-setup \
 iso-codes \
 libX11 \
 libXfixes \
 libXi \
 pango \
 python3 \
 python3-gobject \
 "
RDEPENDS:ibus-devel = " \
 dbus-devel \
 gettext-runtime \
 glib2-devel \
 ibus-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:ibus-devel-docs = " \
 "
RDEPENDS:ibus-gtk3 = " \
 atk \
 cairo \
 cairo-gobject \
 dbus-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 ibus-libs \
 pango \
 "
RDEPENDS:ibus-gtk4 = " \
 cairo \
 cairo-gobject \
 dbus-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 harfbuzz \
 ibus-libs \
 pango \
 vulkan-loader \
 "
RDEPENDS:ibus-libs = " \
 dbus \
 glib2 \
 glibc \
 gobject-introspection \
 "
RDEPENDS:ibus-panel = " \
 atk \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 ibus \
 ibus-libs \
 libX11 \
 libXi \
 libdbusmenu \
 libdbusmenu-gtk3 \
 libnotify \
 libwayland-client \
 libxkbcommon \
 pango \
 "
RDEPENDS:ibus-setup = " \
 bash \
 ibus \
 python3 \
 python3-gobject \
 "
RDEPENDS:ibus-wayland = " \
 glib2 \
 glibc \
 ibus-libs \
 libwayland-client \
 libxkbcommon \
 "
