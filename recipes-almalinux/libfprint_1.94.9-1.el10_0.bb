# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libfprint"
PV = "1.94.9"
PR = "1.el10_0"
PACKAGES = " \
 libfprint \
 libfprint-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/libfprint-1.94.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94f744c1b6fce44f0cb5ca4dd0c1cb331a1021c6024cac634ac6ac6c592a3027"

URI_x86_64_v2_libfprint = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libfprint-1.94.9-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_libfprint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfprint}"
SRC_URI[x86_64_v2_libfprint.sha256sum] = "5dbc53bc82577511a6396bc2fe3df2caeaf88b43ff8cff043b771a6a5ab1960a"

URI_x86_64_v2_libfprint-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libfprint-devel-1.94.9-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_libfprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfprint-devel}"
SRC_URI[x86_64_v2_libfprint-devel.sha256sum] = "1742c7b42acd5229b87994c8a6f0c202a4880d18f3f01ab43a7de04ea84a442b"

URI_aarch64_libfprint = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfprint-1.94.9-1.el10_0.aarch64.rpm;name=aarch64_libfprint;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfprint}"
SRC_URI[aarch64_libfprint.sha256sum] = "0820cc769f61d01a66796c26c79f8da912517b75cff4cd8bdee18f2157dece4b"

URI_aarch64_libfprint-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfprint-devel-1.94.9-1.el10_0.aarch64.rpm;name=aarch64_libfprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfprint-devel}"
SRC_URI[aarch64_libfprint-devel.sha256sum] = "6779af39375fbae753bbc4afc4eedebf3f201d33bb32fcb5bc122e20d7a5eceb"

RDEPENDS:libfprint = " \
 glib2 \
 glibc \
 libgcc \
 libgudev \
 libgusb \
 openssl-libs \
 pixman \
 "
RDEPENDS:libfprint-devel = " \
 glib2-devel \
 libfprint \
 pkgconf-pkg-config \
 "
