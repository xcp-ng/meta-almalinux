# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdepim-addons"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kdepim-addons \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdepim-addons-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a944d02671a8eabcf99081f98ff210418ea49b3fe09ab8c343dc217dfd24a88"

URI_x86_64_v2_kdepim-addons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdepim-addons-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdepim-addons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdepim-addons}"
SRC_URI[x86_64_v2_kdepim-addons.sha256sum] = "81398450bdb59a5c5c2ffbf070f3a24aba8f2db4cf6217654237ffe41eee6136"

URI_aarch64_kdepim-addons = "${EPEL_MIRROR}/aarch64/Packages/k/kdepim-addons-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdepim-addons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdepim-addons}"
SRC_URI[aarch64_kdepim-addons.sha256sum] = "f4ad1ffd4e8a9ec41099d66e95ab35427a25e535cdb68bc0cd0e88054e8d84b7"

RDEPENDS:kdepim-addons = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-import-wizard \
 akonadi-mime \
 akonadi-server \
 bash \
 calendarsupport \
 glibc \
 gpgmepp \
 grantleetheme \
 incidenceeditor \
 kaddressbook-libs \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kdeclarative \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kservice \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-prison \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kimap \
 kitinerary \
 kmailtransport \
 kmime \
 kpimtextedit \
 kpkpass \
 ktextaddons-qt6 \
 ktnef \
 libgcc \
 libgravatar \
 libkleo \
 libksieve \
 libmarkdown \
 libstdc++ \
 mailcommon \
 mailimporter \
 messagelib \
 pimcommon \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 "
