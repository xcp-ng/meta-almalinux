# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "goose"
PV = "1.38.0"
PR = "1.el10_3"
PACKAGES = " \
 goose \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/goose-1.38.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c09c64d45e1f4d032ecb93a97f7b57b99426af9a32e0e85c2254bf2b433d141"

URI_x86_64_v2_goose = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/goose-1.38.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_goose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_goose}"
SRC_URI[x86_64_v2_goose.sha256sum] = "74e7d8a2ce845b96e9330ed78c2a285db77382fa9572e2ebd016e39b759eb6b5"

URI_aarch64_goose = "${EPEL_MIRROR}/aarch64/Packages/g/goose-1.38.0-1.el10_3.aarch64.rpm;name=aarch64_goose;unpack=0"
SRC_URI:append = " ${URI_aarch64_goose}"
SRC_URI[aarch64_goose.sha256sum] = "b396c4cfe2c37886d59070e64a88b5d9c29c597107f2750646ccddf1ce1d269a"

RDEPENDS:goose = " \
 dbus-libs \
 glibc \
 libgcc \
 libzstd \
 oniguruma \
 openssl-libs \
 sqlite-libs \
 "
