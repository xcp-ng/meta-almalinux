# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-natsort"
PV = "8.4.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-natsort \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-natsort-8.4.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5c4d29093f4727425eca3f879a65ed999241713f2c15b60763005d3c4846deb"

URI_x86_64_v2_python3-natsort = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-natsort-8.4.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-natsort;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-natsort}"
SRC_URI[x86_64_v2_python3-natsort.sha256sum] = "1376db97215e9e2900c828ed5b8d8b41dcc525d64a45830cffeaae84c9da790f"

URI_aarch64_python3-natsort = "${EPEL_MIRROR}/aarch64/Packages/p/python3-natsort-8.4.0-2.el10_0.noarch.rpm;name=aarch64_python3-natsort;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-natsort}"
SRC_URI[aarch64_python3-natsort.sha256sum] = "c24061c346e8862db579c437052b05df50d4b97cd5385671d93ad96d57ca0b6b"

RDEPENDS:python3-natsort = " \
 python3 \
 "
