# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_segmenter_data"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_segmenter_data+default-devel \
 rust-icu_segmenter_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_segmenter_data-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad14c1139f91f2023cc3e80b252e4e7ebe0ee7edf3d9a56bd7953fc7cb49d280"

URI_x86_64_v2_rust-icu_segmenter_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_segmenter_data+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_segmenter_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_segmenter_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_segmenter_data+default-devel.sha256sum] = "d4b3d3f726db9b12bf1b897531b622f1a4e27fc1931304084979ffaef82fa80c"

URI_x86_64_v2_rust-icu_segmenter_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_segmenter_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_segmenter_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_segmenter_data-devel}"
SRC_URI[x86_64_v2_rust-icu_segmenter_data-devel.sha256sum] = "de4375f29ded4626e40647cf306875b1576b75b0f484484e8e561dbbff557baa"

URI_aarch64_rust-icu_segmenter_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_segmenter_data+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_segmenter_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_segmenter_data+default-devel}"
SRC_URI[aarch64_rust-icu_segmenter_data+default-devel.sha256sum] = "078d0aa3e90be38d1908e42b67908399c48987c73cc706ebd4ce0aa88919a8c0"

URI_aarch64_rust-icu_segmenter_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_segmenter_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_segmenter_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_segmenter_data-devel}"
SRC_URI[aarch64_rust-icu_segmenter_data-devel.sha256sum] = "5adf657db948cfd81ae13144c64741153a5a66ce75285c689f6b355a6aac17b4"

RDEPENDS:rust-icu_segmenter_data+default-devel = " \
 cargo \
 rust-icu_segmenter_data-devel \
 "
RDEPENDS:rust-icu_segmenter_data-devel = " \
 cargo \
 rust \
 "
