# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "accessibility-inspector"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 accessibility-inspector \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/accessibility-inspector-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d24b026adbf216e996f8924b972fc6f3e515c2e421f63f70fcba29856578b9f8"

URI_x86_64_v2_accessibility-inspector = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/accessibility-inspector-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_accessibility-inspector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accessibility-inspector}"
SRC_URI[x86_64_v2_accessibility-inspector.sha256sum] = "2d6be3865760d3846822d149149b8f13ff454b7431a77f071de4ab06a72601bb"

URI_aarch64_accessibility-inspector = "${EPEL_MIRROR}/aarch64/Packages/a/accessibility-inspector-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_accessibility-inspector;unpack=0"
SRC_URI:append = " ${URI_aarch64_accessibility-inspector}"
SRC_URI[aarch64_accessibility-inspector.sha256sum] = "44d9239dbef1450a12f794ea60f8c2accc20a31d89aa585a2bbad507b1cd4cb0"

RDEPENDS:accessibility-inspector = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qaccessibilityclient-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
