# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-io"
PV = "2.6.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-async-io+default-devel \
 rust-async-io+tracing-devel \
 rust-async-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-io-2.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "920410d1993f56c298d266565bf00486735f0d18350d9c576dcafaebcb0351b6"

URI_x86_64_v2_rust-async-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-io+default-devel-2.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-io+default-devel}"
SRC_URI[x86_64_v2_rust-async-io+default-devel.sha256sum] = "b1bfccc74eaf2b73742a08d2f5f8e11f5a578836bf28e981cedc3eda1706e8f1"

URI_x86_64_v2_rust-async-io+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-io+tracing-devel-2.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-io+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-io+tracing-devel}"
SRC_URI[x86_64_v2_rust-async-io+tracing-devel.sha256sum] = "f53bf13f87755a980f48a5553a79d94c2d34d57e96592e2999fc9def246e3d90"

URI_x86_64_v2_rust-async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-io-devel-2.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-io-devel}"
SRC_URI[x86_64_v2_rust-async-io-devel.sha256sum] = "274a24ead1487cf43649faa554a03bf0989e4d59dd377148f7297fa82e44cb78"

URI_aarch64_rust-async-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-io+default-devel-2.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-async-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-io+default-devel}"
SRC_URI[aarch64_rust-async-io+default-devel.sha256sum] = "8593fc9f38e2dfb9f8bb0440688e65d91704dd89347be15f00c6c6383f82b120"

URI_aarch64_rust-async-io+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-io+tracing-devel-2.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-async-io+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-io+tracing-devel}"
SRC_URI[aarch64_rust-async-io+tracing-devel.sha256sum] = "ce2e60a794860cbbeb761d0b1661e98e6859966735747850dbd3aaa71da649f9"

URI_aarch64_rust-async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-io-devel-2.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-io-devel}"
SRC_URI[aarch64_rust-async-io-devel.sha256sum] = "5cccac33c63e213950c593a8d81476a343fc9ee6d2d3b85c5dad168f37aa8faa"

RDEPENDS:rust-async-io+default-devel = " \
 cargo \
 rust-async-io-devel \
 "
RDEPENDS:rust-async-io+tracing-devel = " \
 cargo \
 rust-async-io-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-async-io-devel = " \
 cargo \
 rust \
 rust-autocfg+default-devel \
 rust-cfg-if+default-devel \
 rust-concurrent-queue+default-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-lite-devel \
 rust-parking+default-devel \
 rust-polling+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 rust-slab+default-devel \
 "
