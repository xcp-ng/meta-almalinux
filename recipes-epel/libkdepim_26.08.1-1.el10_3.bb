# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdepim"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 libkdepim \
 libkdepim-devel \
 libkdepim-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libkdepim-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1d3bcb3bada0d367df7b8088e623b167c13f146b2c4d982f3a5d76eb6c4c1962"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdepim;unpack=0"
SRC_URI[x86_64_v2_libkdepim.sha256sum] = "8a2a3fd0670a70160ed67a57631b7513957915dfc6cb27006fe1dc01288bd34b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdepim-devel;unpack=0"
SRC_URI[x86_64_v2_libkdepim-devel.sha256sum] = "f6f2fed3a54140024c113c6fb6f19222321d36e0df98b24417c63752923c8831"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libkdepim-doc;unpack=0"
SRC_URI[x86_64_v2_libkdepim-doc.sha256sum] = "89250aaf60cdd82e0308af487faa4d453f903fd50ad2b5e006432c9baaf28553"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkdepim;unpack=0"
SRC_URI[aarch64_libkdepim.sha256sum] = "ce61ee85292017be89e32d9e744912f884ac26b8449868884b624d13e9f606d0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkdepim-devel;unpack=0"
SRC_URI[aarch64_libkdepim-devel.sha256sum] = "eb20aeae88d428a7b1fdf16d2664331b4bb3a8ea9add613a58802250a26277ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_libkdepim-doc;unpack=0"
SRC_URI[aarch64_libkdepim-doc.sha256sum] = "ad59dc059566d83a37228272ce8edca65ceba7d99a9c31d05f602b767e8a4438"

RDEPENDS:libkdepim = " \
 glibc \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdepim-devel = " \
 cmake-filesystem \
 glibc \
 libkdepim \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdepim-doc = " \
 "
