# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl"
PE = "4"
PV = "5.40.2"
PR = "514.el10"
PACKAGES = " \
 perl \
 perl-Attribute-Handlers \
 perl-AutoLoader \
 perl-AutoSplit \
 perl-B \
 perl-Benchmark \
 perl-Class-Struct \
 perl-Config-Extensions \
 perl-DBM_Filter \
 perl-Devel-Peek \
 perl-Devel-SelfStubber \
 perl-DirHandle \
 perl-Dumpvalue \
 perl-DynaLoader \
 perl-English \
 perl-Errno \
 perl-ExtUtils-Constant \
 perl-ExtUtils-Embed \
 perl-ExtUtils-Miniperl \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-DosGlob \
 perl-File-Find \
 perl-File-stat \
 perl-FileCache \
 perl-FileHandle \
 perl-FindBin \
 perl-GDBM_File \
 perl-Getopt-Std \
 perl-Hash-Util \
 perl-Hash-Util-FieldHash \
 perl-I18N-Collate \
 perl-I18N-LangTags \
 perl-I18N-Langinfo \
 perl-IO \
 perl-IPC-Open3 \
 perl-Locale-Maketext-Simple \
 perl-Math-Complex \
 perl-Memoize \
 perl-Module-Loaded \
 perl-NDBM_File \
 perl-NEXT \
 perl-Net \
 perl-ODBM_File \
 perl-Opcode \
 perl-POSIX \
 perl-Pod-Functions \
 perl-Pod-Html \
 perl-Safe \
 perl-Search-Dict \
 perl-SelectSaver \
 perl-SelfLoader \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Term-Complete \
 perl-Term-ReadLine \
 perl-Test \
 perl-Text-Abbrev \
 perl-Thread \
 perl-Thread-Semaphore \
 perl-Tie \
 perl-Tie-File \
 perl-Tie-Memoize \
 perl-Time \
 perl-Time-Piece \
 perl-Unicode-UCD \
 perl-User-pwent \
 perl-autouse \
 perl-base \
 perl-blib \
 perl-debugger \
 perl-deprecate \
 perl-devel \
 perl-diagnostics \
 perl-doc \
 perl-encoding-warnings \
 perl-fields \
 perl-filetest \
 perl-if \
 perl-interpreter \
 perl-less \
 perl-lib \
 perl-libnetcfg \
 perl-libs \
 perl-locale \
 perl-macros \
 perl-meta-notation \
 perl-mro \
 perl-open \
 perl-overload \
 perl-overloading \
 perl-ph \
 perl-sigtrap \
 perl-sort \
 perl-subs \
 perl-utils \
 perl-vars \
 perl-vmsish \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-5.40.2-514.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e79741492b284fdc556584480af40e6e3bcc760a3a6537a85fa32c97907bc0f9"

URI_x86_64_v2_perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-5.40.2-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl}"
SRC_URI[x86_64_v2_perl.sha256sum] = "9dcc314e34b54ad3384e4f56c576facf5642cd11ce7cced7e02c795bfe51f04c"

URI_x86_64_v2_perl-Attribute-Handlers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Attribute-Handlers-1.03-514.el10.noarch.rpm;name=x86_64_v2_perl-Attribute-Handlers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Attribute-Handlers}"
SRC_URI[x86_64_v2_perl-Attribute-Handlers.sha256sum] = "76b745af28f1e3c31af32b2acaececf3265929f113ab2a79b1c44a89410a470b"

URI_x86_64_v2_perl-AutoLoader = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-AutoLoader-5.74-514.el10.noarch.rpm;name=x86_64_v2_perl-AutoLoader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-AutoLoader}"
SRC_URI[x86_64_v2_perl-AutoLoader.sha256sum] = "0ee96d09300cb63d8e967d7c4cda558ea437976d689c643ac26368a9ec2c3eca"

URI_x86_64_v2_perl-AutoSplit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-AutoSplit-5.74-514.el10.noarch.rpm;name=x86_64_v2_perl-AutoSplit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-AutoSplit}"
SRC_URI[x86_64_v2_perl-AutoSplit.sha256sum] = "ea82c29bc39c400340f4b9113ec4bcddcb97050eda29f03ec0df63b06cc32a2e"

URI_x86_64_v2_perl-B = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-B-1.89-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-B;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-B}"
SRC_URI[x86_64_v2_perl-B.sha256sum] = "9af6f9bb7ea87fda0cac787d9d136a12f615d81e944a65029961e2d5f9882e4d"

URI_x86_64_v2_perl-Benchmark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Benchmark-1.25-514.el10.noarch.rpm;name=x86_64_v2_perl-Benchmark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Benchmark}"
SRC_URI[x86_64_v2_perl-Benchmark.sha256sum] = "7e42c78834724e0786a9b10d0ec1bc58ab676a1c9aac095976cc96ce37d8bd54"

URI_x86_64_v2_perl-Class-Struct = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Class-Struct-0.68-514.el10.noarch.rpm;name=x86_64_v2_perl-Class-Struct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Struct}"
SRC_URI[x86_64_v2_perl-Class-Struct.sha256sum] = "90d32d7c9374e545adc56adcc048147c59b50e2b148a05e87becefb2fb7465d2"

URI_x86_64_v2_perl-Config-Extensions = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Config-Extensions-0.03-514.el10.noarch.rpm;name=x86_64_v2_perl-Config-Extensions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Config-Extensions}"
SRC_URI[x86_64_v2_perl-Config-Extensions.sha256sum] = "2f8af9ff1f8179f5c6d78264f0a0ec9006509063665e87b76289407a582319ef"

URI_x86_64_v2_perl-DBM_Filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DBM_Filter-0.06-514.el10.noarch.rpm;name=x86_64_v2_perl-DBM_Filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DBM_Filter}"
SRC_URI[x86_64_v2_perl-DBM_Filter.sha256sum] = "cebd5fe0f8c3ffc3dec59ac29a928083093e6c2c724ebd1a118b27e4c975d23c"

URI_x86_64_v2_perl-Devel-Peek = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Devel-Peek-1.34-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Devel-Peek;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-Peek}"
SRC_URI[x86_64_v2_perl-Devel-Peek.sha256sum] = "df92366cac950abd0d486c7e791b2ca4512e9d3225bbdd439e3d2476d59fb1ad"

URI_x86_64_v2_perl-Devel-SelfStubber = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Devel-SelfStubber-1.06-514.el10.noarch.rpm;name=x86_64_v2_perl-Devel-SelfStubber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-SelfStubber}"
SRC_URI[x86_64_v2_perl-Devel-SelfStubber.sha256sum] = "bc785d7ce38d51508d1319fec769a15927ab2733f234d6114227fed3a9f66914"

URI_x86_64_v2_perl-DirHandle = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DirHandle-1.05-514.el10.noarch.rpm;name=x86_64_v2_perl-DirHandle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DirHandle}"
SRC_URI[x86_64_v2_perl-DirHandle.sha256sum] = "a56a8bc9a0a3269d96d6323812f70dc2a87ae6d6889d377a1f49fe1b8df35d53"

URI_x86_64_v2_perl-Dumpvalue = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Dumpvalue-2.27-514.el10.noarch.rpm;name=x86_64_v2_perl-Dumpvalue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Dumpvalue}"
SRC_URI[x86_64_v2_perl-Dumpvalue.sha256sum] = "81ae38bd402bf06c8c5c95f82cd1e0228b53d05ad0d1ccf24c9dd0e6eb593cf8"

URI_x86_64_v2_perl-DynaLoader = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DynaLoader-1.56-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-DynaLoader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DynaLoader}"
SRC_URI[x86_64_v2_perl-DynaLoader.sha256sum] = "ed0c707c9c6f28622cfdb61c803dee396eee5b1e1bdbf3d2aee446a3a73f2f8b"

URI_x86_64_v2_perl-English = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-English-1.11-514.el10.noarch.rpm;name=x86_64_v2_perl-English;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-English}"
SRC_URI[x86_64_v2_perl-English.sha256sum] = "3c74b306afd2bf73f4237c2d9f0b7574e6d21081e191261a88736b0f57143e78"

URI_x86_64_v2_perl-Errno = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Errno-1.38-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Errno;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Errno}"
SRC_URI[x86_64_v2_perl-Errno.sha256sum] = "9d13aab52f6e0c42ce051acb8249bbcfae7a050a14ef14323dd74304b122f535"

URI_x86_64_v2_perl-ExtUtils-Constant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Constant-0.25-514.el10.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Constant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ExtUtils-Constant}"
SRC_URI[x86_64_v2_perl-ExtUtils-Constant.sha256sum] = "c7c2b936c95e9e4e293431f6b24052efc94d6a021bbe5a19e0fc5c1a878df37f"

URI_x86_64_v2_perl-ExtUtils-Embed = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Embed-1.35-514.el10.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Embed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ExtUtils-Embed}"
SRC_URI[x86_64_v2_perl-ExtUtils-Embed.sha256sum] = "f3cfbd6fa043e0a20064cd6ad6115450ee77f22ee0c33d27b10b0b1ca8a8f36d"

URI_x86_64_v2_perl-ExtUtils-Miniperl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Miniperl-1.14-514.el10.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Miniperl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ExtUtils-Miniperl}"
SRC_URI[x86_64_v2_perl-ExtUtils-Miniperl.sha256sum] = "7f699b1aece4dd1d9c573cff830b7bdc584d368e78161b62b8d8aa478fa9b7b8"

URI_x86_64_v2_perl-Fcntl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Fcntl-1.18-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Fcntl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Fcntl}"
SRC_URI[x86_64_v2_perl-Fcntl.sha256sum] = "cc681d1285ed52a6a5fbd0b24a265857f0ac25253f8f2b699667f079ee5fead3"

URI_x86_64_v2_perl-File-Basename = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Basename-2.86-514.el10.noarch.rpm;name=x86_64_v2_perl-File-Basename;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Basename}"
SRC_URI[x86_64_v2_perl-File-Basename.sha256sum] = "cb63f6036ae39b0714c55d186688e7d59553ae141d5e46dd15aadb827b35cb95"

URI_x86_64_v2_perl-File-Compare = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Compare-1.100.800-514.el10.noarch.rpm;name=x86_64_v2_perl-File-Compare;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Compare}"
SRC_URI[x86_64_v2_perl-File-Compare.sha256sum] = "e23df46d7227a2b2b20abe6b086e40f16192fef86cdbdb79f725059bbcececa7"

URI_x86_64_v2_perl-File-Copy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Copy-2.41-514.el10.noarch.rpm;name=x86_64_v2_perl-File-Copy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Copy}"
SRC_URI[x86_64_v2_perl-File-Copy.sha256sum] = "af0cbc2fd1f33273b86725c2ed17d038983ce5f46d7fdab3c6317a9408704644"

URI_x86_64_v2_perl-File-DosGlob = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-DosGlob-1.12-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-File-DosGlob;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-DosGlob}"
SRC_URI[x86_64_v2_perl-File-DosGlob.sha256sum] = "36d69128501600905c92c69612eb74435d4aa46ac448e4c595ee536c9f53f8ad"

URI_x86_64_v2_perl-File-Find = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Find-1.44-514.el10.noarch.rpm;name=x86_64_v2_perl-File-Find;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Find}"
SRC_URI[x86_64_v2_perl-File-Find.sha256sum] = "2070a080cc78e7d2c9f7f126b16af30784ecddc3e27a0f57d7409f6941f91155"

URI_x86_64_v2_perl-File-stat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-stat-1.14-514.el10.noarch.rpm;name=x86_64_v2_perl-File-stat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-stat}"
SRC_URI[x86_64_v2_perl-File-stat.sha256sum] = "7c88bf8e578fc3733f737ccd57968f048c810db26cc0b59d302cc07ee99e381c"

URI_x86_64_v2_perl-FileCache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-FileCache-1.10-514.el10.noarch.rpm;name=x86_64_v2_perl-FileCache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-FileCache}"
SRC_URI[x86_64_v2_perl-FileCache.sha256sum] = "f7aac4af2f36fe90e4a09a0b358526c6f80a26204f9d92833f5af72791ab7ce7"

URI_x86_64_v2_perl-FileHandle = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-FileHandle-2.05-514.el10.noarch.rpm;name=x86_64_v2_perl-FileHandle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-FileHandle}"
SRC_URI[x86_64_v2_perl-FileHandle.sha256sum] = "f2f2183a51dcd0a8f3034598516a4327216e7b91b76857ca0e69087d984a0d88"

URI_x86_64_v2_perl-FindBin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-FindBin-1.54-514.el10.noarch.rpm;name=x86_64_v2_perl-FindBin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-FindBin}"
SRC_URI[x86_64_v2_perl-FindBin.sha256sum] = "618b0cdd38027dd0a55be308bf4706b4773c5d4df46dcf41339d99538bca51b9"

URI_x86_64_v2_perl-GDBM_File = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-GDBM_File-1.24-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-GDBM_File;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GDBM_File}"
SRC_URI[x86_64_v2_perl-GDBM_File.sha256sum] = "270faf00b6640d2af17d46dfb52a2240771ec09de7a7dbb0b6d579863b6b6421"

URI_x86_64_v2_perl-Getopt-Std = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Getopt-Std-1.14-514.el10.noarch.rpm;name=x86_64_v2_perl-Getopt-Std;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Getopt-Std}"
SRC_URI[x86_64_v2_perl-Getopt-Std.sha256sum] = "68f5dfff31f52cdc2bd4fe7dad46ead5c854467008685c80888c80d68873310b"

URI_x86_64_v2_perl-Hash-Util = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Hash-Util-0.32-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Hash-Util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Hash-Util}"
SRC_URI[x86_64_v2_perl-Hash-Util.sha256sum] = "890010c7a0eb9a28b60b8110b5470f657b724fa88c290d0dccaa4ddf8ce97e65"

URI_x86_64_v2_perl-Hash-Util-FieldHash = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Hash-Util-FieldHash-1.27-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Hash-Util-FieldHash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Hash-Util-FieldHash}"
SRC_URI[x86_64_v2_perl-Hash-Util-FieldHash.sha256sum] = "2bfcd11a7a416a028011431f32743c32f4651c93ca108b9cd5702c5210886394"

URI_x86_64_v2_perl-I18N-Collate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-I18N-Collate-1.02-514.el10.noarch.rpm;name=x86_64_v2_perl-I18N-Collate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-I18N-Collate}"
SRC_URI[x86_64_v2_perl-I18N-Collate.sha256sum] = "f6f29962f1daa0eabee5b3ce1983cc7b7716d087a7e1222a282656857f6e8788"

URI_x86_64_v2_perl-I18N-LangTags = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-I18N-LangTags-0.45-514.el10.noarch.rpm;name=x86_64_v2_perl-I18N-LangTags;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-I18N-LangTags}"
SRC_URI[x86_64_v2_perl-I18N-LangTags.sha256sum] = "a8b4752668d3c2373bc237e1fb53f5d1e29aa93ad74e3964821af84745f365c1"

URI_x86_64_v2_perl-I18N-Langinfo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-I18N-Langinfo-0.24-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-I18N-Langinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-I18N-Langinfo}"
SRC_URI[x86_64_v2_perl-I18N-Langinfo.sha256sum] = "8c687bdac4804f45cd2468db5791ae0d2e295a8555bfd79c137b963a071109f3"

URI_x86_64_v2_perl-IO = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IO-1.55-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-IO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO}"
SRC_URI[x86_64_v2_perl-IO.sha256sum] = "3796af90284589756ba8c54b99b0b9d0b9657c90fd670f9b5a3e4857426fc3e0"

URI_x86_64_v2_perl-IPC-Open3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IPC-Open3-1.22-514.el10.noarch.rpm;name=x86_64_v2_perl-IPC-Open3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IPC-Open3}"
SRC_URI[x86_64_v2_perl-IPC-Open3.sha256sum] = "b19188486a33e4d5a07fade99b1b406b64d11177983551e37eeb7e16f678462f"

URI_x86_64_v2_perl-Locale-Maketext-Simple = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Locale-Maketext-Simple-0.21-514.el10.noarch.rpm;name=x86_64_v2_perl-Locale-Maketext-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Locale-Maketext-Simple}"
SRC_URI[x86_64_v2_perl-Locale-Maketext-Simple.sha256sum] = "bec736bed664c5010462522b5335bf7e8140b430fb33f107f412c457743cb9cc"

URI_x86_64_v2_perl-Math-Complex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Math-Complex-1.62-514.el10.noarch.rpm;name=x86_64_v2_perl-Math-Complex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Math-Complex}"
SRC_URI[x86_64_v2_perl-Math-Complex.sha256sum] = "27782eba884a58bd89bedfb2de5444a3d050201dfa7057d6a16ab4792a1b8eb3"

URI_x86_64_v2_perl-Memoize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Memoize-1.16-514.el10.noarch.rpm;name=x86_64_v2_perl-Memoize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Memoize}"
SRC_URI[x86_64_v2_perl-Memoize.sha256sum] = "ed07ca409736e8f543ae39157887aab4607ec746119312f40240a36265aa81e6"

URI_x86_64_v2_perl-Module-Loaded = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Module-Loaded-0.08-514.el10.noarch.rpm;name=x86_64_v2_perl-Module-Loaded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Loaded}"
SRC_URI[x86_64_v2_perl-Module-Loaded.sha256sum] = "64a99724577101f7c5b74a9808ab7ae4db7e7285d0ad4db011d0011b7cb9b415"

URI_x86_64_v2_perl-NDBM_File = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-NDBM_File-1.17-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-NDBM_File;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-NDBM_File}"
SRC_URI[x86_64_v2_perl-NDBM_File.sha256sum] = "f4ca8e4ffafc3dfa2599cb0a42ef369ae388b4e8fb018c99e2f5b0018d220e22"

URI_x86_64_v2_perl-NEXT = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-NEXT-0.69-514.el10.noarch.rpm;name=x86_64_v2_perl-NEXT;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-NEXT}"
SRC_URI[x86_64_v2_perl-NEXT.sha256sum] = "81a26c4ca6d5c06dda14e07b1d5eb82bc6ada563f39a74233209b93742f6ee62"

URI_x86_64_v2_perl-Net = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Net-1.04-514.el10.noarch.rpm;name=x86_64_v2_perl-Net;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net}"
SRC_URI[x86_64_v2_perl-Net.sha256sum] = "01f9ebe77c577599a38ae31d4baaaba313e437ef1d78e0a0e4b6dca72600e8fc"

URI_x86_64_v2_perl-ODBM_File = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ODBM_File-1.18-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-ODBM_File;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ODBM_File}"
SRC_URI[x86_64_v2_perl-ODBM_File.sha256sum] = "3bbee8a12924d05edf07c314d1bff99c9b81021006eb5f60815ffcca7d7be82b"

URI_x86_64_v2_perl-Opcode = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Opcode-1.65-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Opcode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Opcode}"
SRC_URI[x86_64_v2_perl-Opcode.sha256sum] = "63c1d66928cc1c6ff6a7e5b189349c7d1186f6d390fbd72c2ad72d27020b0b54"

URI_x86_64_v2_perl-POSIX = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-POSIX-2.20-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-POSIX;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-POSIX}"
SRC_URI[x86_64_v2_perl-POSIX.sha256sum] = "2c75c57a09eeeb82399e35540594ac65003d2d3f70170fc152409b395b08e48a"

URI_x86_64_v2_perl-Pod-Functions = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Pod-Functions-1.14-514.el10.noarch.rpm;name=x86_64_v2_perl-Pod-Functions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Pod-Functions}"
SRC_URI[x86_64_v2_perl-Pod-Functions.sha256sum] = "b14c95ded1b3afd6356d60c5e85af64d310214601a41e824e9eea75f35ad6925"

URI_x86_64_v2_perl-Pod-Html = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Pod-Html-1.35-514.el10.noarch.rpm;name=x86_64_v2_perl-Pod-Html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Pod-Html}"
SRC_URI[x86_64_v2_perl-Pod-Html.sha256sum] = "ca00f6901262d4d8f02db3f5ed86c531ddf8a0a729ed8f87a06b285d2f819f54"

URI_x86_64_v2_perl-Safe = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Safe-2.46-514.el10.noarch.rpm;name=x86_64_v2_perl-Safe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Safe}"
SRC_URI[x86_64_v2_perl-Safe.sha256sum] = "84c4722f3405b862edb27fb15a6d3b32407c89f60b531d4c513bcb3e003de81e"

URI_x86_64_v2_perl-Search-Dict = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Search-Dict-1.07-514.el10.noarch.rpm;name=x86_64_v2_perl-Search-Dict;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Search-Dict}"
SRC_URI[x86_64_v2_perl-Search-Dict.sha256sum] = "fc52704cf7dd04525023e52f01fa93543f58e90ddb0b573092ccfd67aa936bf7"

URI_x86_64_v2_perl-SelectSaver = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-SelectSaver-1.02-514.el10.noarch.rpm;name=x86_64_v2_perl-SelectSaver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SelectSaver}"
SRC_URI[x86_64_v2_perl-SelectSaver.sha256sum] = "f2c6203439e606b6aa6deae84f53bb69b87c8abd76f867046648d8738409044a"

URI_x86_64_v2_perl-SelfLoader = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-SelfLoader-1.27-514.el10.noarch.rpm;name=x86_64_v2_perl-SelfLoader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SelfLoader}"
SRC_URI[x86_64_v2_perl-SelfLoader.sha256sum] = "c4995e7cb28af22de1f683f7c025396d903c6426a5e03151c282d94ccd61dcb6"

URI_x86_64_v2_perl-Symbol = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Symbol-1.09-514.el10.noarch.rpm;name=x86_64_v2_perl-Symbol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Symbol}"
SRC_URI[x86_64_v2_perl-Symbol.sha256sum] = "a6a8ebf84ed89b21f3abedb2525ff587e0e5622391bb0eba0f83b64e5b19f2cf"

URI_x86_64_v2_perl-Sys-Hostname = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Sys-Hostname-1.25-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Hostname;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-Hostname}"
SRC_URI[x86_64_v2_perl-Sys-Hostname.sha256sum] = "16cfd3a8cd350959882ea5eb4adc822436bc01ae57774d5d253b5cfc599a3114"

URI_x86_64_v2_perl-Term-Complete = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Term-Complete-1.403-514.el10.noarch.rpm;name=x86_64_v2_perl-Term-Complete;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Term-Complete}"
SRC_URI[x86_64_v2_perl-Term-Complete.sha256sum] = "22c7703807be721df57116c8c91f69dfdec8b75c0d16b4d2a26f52f7ce2a94dc"

URI_x86_64_v2_perl-Term-ReadLine = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Term-ReadLine-1.17-514.el10.noarch.rpm;name=x86_64_v2_perl-Term-ReadLine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Term-ReadLine}"
SRC_URI[x86_64_v2_perl-Term-ReadLine.sha256sum] = "e3ca96489f62e69018bb50ea2949b32b33ac166fc97d27cad2fc2926a518f298"

URI_x86_64_v2_perl-Test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Test-1.31-514.el10.noarch.rpm;name=x86_64_v2_perl-Test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test}"
SRC_URI[x86_64_v2_perl-Test.sha256sum] = "a8d0acf61cc6085338cec44a7d9d06ebb6ce7e066a57e76edd5645562d47d2bf"

URI_x86_64_v2_perl-Text-Abbrev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Text-Abbrev-1.02-514.el10.noarch.rpm;name=x86_64_v2_perl-Text-Abbrev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-Abbrev}"
SRC_URI[x86_64_v2_perl-Text-Abbrev.sha256sum] = "19ad5caea8f4a1ba670cee0727f10b114b7a45bc8d1f327ac0026b7e1d9fc702"

URI_x86_64_v2_perl-Thread = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Thread-3.05-514.el10.noarch.rpm;name=x86_64_v2_perl-Thread;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Thread}"
SRC_URI[x86_64_v2_perl-Thread.sha256sum] = "b2adf0f65e3bf420040780726a18319ab79b4d93c786f8fda07dd2b8153e74d3"

URI_x86_64_v2_perl-Thread-Semaphore = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Thread-Semaphore-2.13-514.el10.noarch.rpm;name=x86_64_v2_perl-Thread-Semaphore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Thread-Semaphore}"
SRC_URI[x86_64_v2_perl-Thread-Semaphore.sha256sum] = "59cc51cd152d8b6e399453fd3e878b62e8dc31a3ee942c655592798488cd92a1"

URI_x86_64_v2_perl-Tie = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Tie-4.6-514.el10.noarch.rpm;name=x86_64_v2_perl-Tie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie}"
SRC_URI[x86_64_v2_perl-Tie.sha256sum] = "4de8c8ea16fc1b00a3907fc72d927fc04484b17a00ddfbe593664cb2998d8741"

URI_x86_64_v2_perl-Tie-File = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Tie-File-1.09-514.el10.noarch.rpm;name=x86_64_v2_perl-Tie-File;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-File}"
SRC_URI[x86_64_v2_perl-Tie-File.sha256sum] = "f1a6389071932f0d1d34cd97a0bd10f106907083724ae274be89891f97599280"

URI_x86_64_v2_perl-Tie-Memoize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Tie-Memoize-1.1-514.el10.noarch.rpm;name=x86_64_v2_perl-Tie-Memoize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-Memoize}"
SRC_URI[x86_64_v2_perl-Tie-Memoize.sha256sum] = "73b85aba2ce640e8d56d58795344881507e8fe7868e7c177b8894f6fbcd0073c"

URI_x86_64_v2_perl-Time = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Time-1.04-514.el10.noarch.rpm;name=x86_64_v2_perl-Time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Time}"
SRC_URI[x86_64_v2_perl-Time.sha256sum] = "adb8e53f583a5a554f71a9ba550e2c8484cf5b96145d2aa3dc579a3b7c1bfb95"

URI_x86_64_v2_perl-Time-Piece = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Time-Piece-1.3401-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Time-Piece;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Time-Piece}"
SRC_URI[x86_64_v2_perl-Time-Piece.sha256sum] = "1562e12f03415f92ed74eae504c996f838870d4f39bbe358f37a91bc410e5ed6"

URI_x86_64_v2_perl-Unicode-UCD = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Unicode-UCD-0.78-514.el10.noarch.rpm;name=x86_64_v2_perl-Unicode-UCD;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Unicode-UCD}"
SRC_URI[x86_64_v2_perl-Unicode-UCD.sha256sum] = "eac2a1778c321a6dfd06ab07ae7af8fc37edae4000affe7726a59904d5c818e5"

URI_x86_64_v2_perl-User-pwent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-User-pwent-1.05-514.el10.noarch.rpm;name=x86_64_v2_perl-User-pwent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-User-pwent}"
SRC_URI[x86_64_v2_perl-User-pwent.sha256sum] = "bd923d5bf9ac9868d5e3df86f6fc83e1d9ddf97c9365fca39fd4e3fafe253559"

URI_x86_64_v2_perl-autouse = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-autouse-1.11-514.el10.noarch.rpm;name=x86_64_v2_perl-autouse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-autouse}"
SRC_URI[x86_64_v2_perl-autouse.sha256sum] = "faf18e4eb3d6296c892f51f546440052e60e6f55fb2a328a673527424837c244"

URI_x86_64_v2_perl-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-base-2.27-514.el10.noarch.rpm;name=x86_64_v2_perl-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-base}"
SRC_URI[x86_64_v2_perl-base.sha256sum] = "e4b216f5ab766d06171e0d16c9facc91c22da273e38b05400e1a423e1ef97400"

URI_x86_64_v2_perl-blib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-blib-1.07-514.el10.noarch.rpm;name=x86_64_v2_perl-blib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-blib}"
SRC_URI[x86_64_v2_perl-blib.sha256sum] = "821585c820ab1a9acc90654f038b389559430305594af1d0f3eb97faebc549e9"

URI_x86_64_v2_perl-debugger = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-debugger-1.60-514.el10.noarch.rpm;name=x86_64_v2_perl-debugger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-debugger}"
SRC_URI[x86_64_v2_perl-debugger.sha256sum] = "35f15b3b9a38e519f6b5b2605eac49f3b2e0f3dc04746d3f952bcab557085dfd"

URI_x86_64_v2_perl-deprecate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-deprecate-0.04-514.el10.noarch.rpm;name=x86_64_v2_perl-deprecate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-deprecate}"
SRC_URI[x86_64_v2_perl-deprecate.sha256sum] = "7358a7d608bf6aae7981294e34337d5a439dde34c5a9b04b0d92b7162df82f7e"

URI_x86_64_v2_perl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-devel-5.40.2-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-devel}"
SRC_URI[x86_64_v2_perl-devel.sha256sum] = "2a01133586f664d040d01a932165f629e427d321d1cbaa4a8ca1ce549674a984"

URI_x86_64_v2_perl-diagnostics = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-diagnostics-1.40-514.el10.noarch.rpm;name=x86_64_v2_perl-diagnostics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-diagnostics}"
SRC_URI[x86_64_v2_perl-diagnostics.sha256sum] = "9d542a623ed23da38cb146a5fd71aa139f20a7c7f66e7be4706fd2c37ae0953c"

URI_x86_64_v2_perl-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-doc-5.40.2-514.el10.noarch.rpm;name=x86_64_v2_perl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-doc}"
SRC_URI[x86_64_v2_perl-doc.sha256sum] = "7728cf649557f8d2493f7c0ead923bf6b465dc787569c3f5eeb41c28b24ed883"

URI_x86_64_v2_perl-encoding-warnings = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-encoding-warnings-0.14-514.el10.noarch.rpm;name=x86_64_v2_perl-encoding-warnings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-encoding-warnings}"
SRC_URI[x86_64_v2_perl-encoding-warnings.sha256sum] = "3fe7bf782eff4801b8e5623303710d8529a129ac09921b1b61443dd5397d33fa"

URI_x86_64_v2_perl-fields = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-fields-2.27-514.el10.noarch.rpm;name=x86_64_v2_perl-fields;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-fields}"
SRC_URI[x86_64_v2_perl-fields.sha256sum] = "3e72c2aa83f49188eb051d24eddce9d8e0d56682a71ad3a5c54bd59cf20e3854"

URI_x86_64_v2_perl-filetest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-filetest-1.03-514.el10.noarch.rpm;name=x86_64_v2_perl-filetest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-filetest}"
SRC_URI[x86_64_v2_perl-filetest.sha256sum] = "ccb1cbe616c99447dff815738d9dab25602f224075a3554995e441fc2165bbf8"

URI_x86_64_v2_perl-if = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-if-0.61.000-514.el10.noarch.rpm;name=x86_64_v2_perl-if;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-if}"
SRC_URI[x86_64_v2_perl-if.sha256sum] = "42f0a44b818c73cf655cf0dec06f9c517841bc2e93811c81db655af4ad16fdbe"

URI_x86_64_v2_perl-interpreter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-interpreter-5.40.2-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-interpreter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-interpreter}"
SRC_URI[x86_64_v2_perl-interpreter.sha256sum] = "9a92082dd525e6eb65878aaaaa857eb681acfb2885c985c8038bcaa860062875"

URI_x86_64_v2_perl-less = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-less-0.03-514.el10.noarch.rpm;name=x86_64_v2_perl-less;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-less}"
SRC_URI[x86_64_v2_perl-less.sha256sum] = "42e63c8baef154862d74525aaae5cac883105d722b3c8562bc256e83c5e9b245"

URI_x86_64_v2_perl-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-lib-0.65-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-lib}"
SRC_URI[x86_64_v2_perl-lib.sha256sum] = "dc296cc7b13c0760b69b275607ca6469b289a379bd11e31f32bdc10c5066c339"

URI_x86_64_v2_perl-libnetcfg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-libnetcfg-5.40.2-514.el10.noarch.rpm;name=x86_64_v2_perl-libnetcfg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-libnetcfg}"
SRC_URI[x86_64_v2_perl-libnetcfg.sha256sum] = "8598b21d938219fe4016d91ba9af6605543ca3acfc536608014a0fb13109c7d4"

URI_x86_64_v2_perl-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-libs-5.40.2-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-libs}"
SRC_URI[x86_64_v2_perl-libs.sha256sum] = "0a67bae9f0c90515b904c6b8a883683409b9380e738d904f9c7e67f33dc9ad41"

URI_x86_64_v2_perl-locale = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-locale-1.12-514.el10.noarch.rpm;name=x86_64_v2_perl-locale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-locale}"
SRC_URI[x86_64_v2_perl-locale.sha256sum] = "63079490f3982f99a215afcb2ad5993f3ce78273d61bee5762213caa65ce36b9"

URI_x86_64_v2_perl-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-macros-5.40.2-514.el10.noarch.rpm;name=x86_64_v2_perl-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-macros}"
SRC_URI[x86_64_v2_perl-macros.sha256sum] = "d52972fa9a42ac5aaeeade0fc5fc3a0963c445e12e2557413e6930293bb09976"

URI_x86_64_v2_perl-meta-notation = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-meta-notation-5.40.2-514.el10.noarch.rpm;name=x86_64_v2_perl-meta-notation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-meta-notation}"
SRC_URI[x86_64_v2_perl-meta-notation.sha256sum] = "9efdb87feaaf058d9974daee789b36b228fcffa28220f16b642ce2e7f414edab"

URI_x86_64_v2_perl-mro = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-mro-1.29-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-mro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-mro}"
SRC_URI[x86_64_v2_perl-mro.sha256sum] = "99ca4ebad762f598ac4e8a680b10105c2eb8aee8cc081b6fa4ce46042def84d8"

URI_x86_64_v2_perl-open = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-open-1.13-514.el10.noarch.rpm;name=x86_64_v2_perl-open;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-open}"
SRC_URI[x86_64_v2_perl-open.sha256sum] = "f86b726a28c986e1d0f20d29cc041c9b0b630cc1be5fb16af895ae1f8f891034"

URI_x86_64_v2_perl-overload = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-overload-1.37-514.el10.noarch.rpm;name=x86_64_v2_perl-overload;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-overload}"
SRC_URI[x86_64_v2_perl-overload.sha256sum] = "c37648ac09f25409f9c4044f6b71947fa151a1841fdd8d4998c08dc2c4698bf1"

URI_x86_64_v2_perl-overloading = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-overloading-0.02-514.el10.noarch.rpm;name=x86_64_v2_perl-overloading;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-overloading}"
SRC_URI[x86_64_v2_perl-overloading.sha256sum] = "fe17a9f98f77871060d293c0d74656236e64ae68b9ceb62b4039d37e7f0411b7"

URI_x86_64_v2_perl-ph = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ph-5.40.2-514.el10.x86_64_v2.rpm;name=x86_64_v2_perl-ph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ph}"
SRC_URI[x86_64_v2_perl-ph.sha256sum] = "b9ea533c896b228afe0829375f5a7d3fc9d30803e0a9640465279e320b945514"

URI_x86_64_v2_perl-sigtrap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-sigtrap-1.10-514.el10.noarch.rpm;name=x86_64_v2_perl-sigtrap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-sigtrap}"
SRC_URI[x86_64_v2_perl-sigtrap.sha256sum] = "4e92b321bc883dd5343f7d4634901502c8532ea2efa6fce0aa92b673e107ab52"

URI_x86_64_v2_perl-sort = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-sort-2.05-514.el10.noarch.rpm;name=x86_64_v2_perl-sort;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-sort}"
SRC_URI[x86_64_v2_perl-sort.sha256sum] = "6fe928b3268d8ade70053c70ac5de672129f277241a69c794b87782edf599f9f"

URI_x86_64_v2_perl-subs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-subs-1.04-514.el10.noarch.rpm;name=x86_64_v2_perl-subs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-subs}"
SRC_URI[x86_64_v2_perl-subs.sha256sum] = "0831142846750b61174ed73b26f4c67a40e15f9b777d3dbd62e7926d60133b9c"

URI_x86_64_v2_perl-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-utils-5.40.2-514.el10.noarch.rpm;name=x86_64_v2_perl-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-utils}"
SRC_URI[x86_64_v2_perl-utils.sha256sum] = "541814d496e60a238f843b30a9e8e843b1662c6113785c7a852251467455329c"

URI_x86_64_v2_perl-vars = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-vars-1.05-514.el10.noarch.rpm;name=x86_64_v2_perl-vars;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-vars}"
SRC_URI[x86_64_v2_perl-vars.sha256sum] = "59132cb461532a6363525910adab165f933161a5720284e14e163541cfa3454b"

URI_x86_64_v2_perl-vmsish = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-vmsish-1.04-514.el10.noarch.rpm;name=x86_64_v2_perl-vmsish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-vmsish}"
SRC_URI[x86_64_v2_perl-vmsish.sha256sum] = "074a459a5db0a81c37d0aa81374c0705f621ccf3417e56f232ab09f3f40a5905"

URI_aarch64_perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-5.40.2-514.el10.aarch64.rpm;name=aarch64_perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl}"
SRC_URI[aarch64_perl.sha256sum] = "05705361c37d006968ed66d66245c4cb9c4e5798d892acc58019abf877039b6f"

URI_aarch64_perl-Attribute-Handlers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Attribute-Handlers-1.03-514.el10.noarch.rpm;name=aarch64_perl-Attribute-Handlers;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Attribute-Handlers}"
SRC_URI[aarch64_perl-Attribute-Handlers.sha256sum] = "76b745af28f1e3c31af32b2acaececf3265929f113ab2a79b1c44a89410a470b"

URI_aarch64_perl-AutoLoader = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-AutoLoader-5.74-514.el10.noarch.rpm;name=aarch64_perl-AutoLoader;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-AutoLoader}"
SRC_URI[aarch64_perl-AutoLoader.sha256sum] = "0ee96d09300cb63d8e967d7c4cda558ea437976d689c643ac26368a9ec2c3eca"

URI_aarch64_perl-AutoSplit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-AutoSplit-5.74-514.el10.noarch.rpm;name=aarch64_perl-AutoSplit;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-AutoSplit}"
SRC_URI[aarch64_perl-AutoSplit.sha256sum] = "ea82c29bc39c400340f4b9113ec4bcddcb97050eda29f03ec0df63b06cc32a2e"

URI_aarch64_perl-B = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-B-1.89-514.el10.aarch64.rpm;name=aarch64_perl-B;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-B}"
SRC_URI[aarch64_perl-B.sha256sum] = "cfe8b3ce28990f3e4cdd58ec0e7ea8b02b19361e98f32d6d774fe051b2161698"

URI_aarch64_perl-Benchmark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Benchmark-1.25-514.el10.noarch.rpm;name=aarch64_perl-Benchmark;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Benchmark}"
SRC_URI[aarch64_perl-Benchmark.sha256sum] = "7e42c78834724e0786a9b10d0ec1bc58ab676a1c9aac095976cc96ce37d8bd54"

URI_aarch64_perl-Class-Struct = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Class-Struct-0.68-514.el10.noarch.rpm;name=aarch64_perl-Class-Struct;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Struct}"
SRC_URI[aarch64_perl-Class-Struct.sha256sum] = "90d32d7c9374e545adc56adcc048147c59b50e2b148a05e87becefb2fb7465d2"

URI_aarch64_perl-Config-Extensions = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Config-Extensions-0.03-514.el10.noarch.rpm;name=aarch64_perl-Config-Extensions;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Config-Extensions}"
SRC_URI[aarch64_perl-Config-Extensions.sha256sum] = "2f8af9ff1f8179f5c6d78264f0a0ec9006509063665e87b76289407a582319ef"

URI_aarch64_perl-DBM_Filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DBM_Filter-0.06-514.el10.noarch.rpm;name=aarch64_perl-DBM_Filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DBM_Filter}"
SRC_URI[aarch64_perl-DBM_Filter.sha256sum] = "cebd5fe0f8c3ffc3dec59ac29a928083093e6c2c724ebd1a118b27e4c975d23c"

URI_aarch64_perl-Devel-Peek = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Devel-Peek-1.34-514.el10.aarch64.rpm;name=aarch64_perl-Devel-Peek;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-Peek}"
SRC_URI[aarch64_perl-Devel-Peek.sha256sum] = "41f4f7cd30c505e85a27cce6ec5407963e9c73b0697a30330dbaa791143d6aa8"

URI_aarch64_perl-Devel-SelfStubber = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Devel-SelfStubber-1.06-514.el10.noarch.rpm;name=aarch64_perl-Devel-SelfStubber;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-SelfStubber}"
SRC_URI[aarch64_perl-Devel-SelfStubber.sha256sum] = "bc785d7ce38d51508d1319fec769a15927ab2733f234d6114227fed3a9f66914"

URI_aarch64_perl-DirHandle = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DirHandle-1.05-514.el10.noarch.rpm;name=aarch64_perl-DirHandle;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DirHandle}"
SRC_URI[aarch64_perl-DirHandle.sha256sum] = "a56a8bc9a0a3269d96d6323812f70dc2a87ae6d6889d377a1f49fe1b8df35d53"

URI_aarch64_perl-Dumpvalue = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Dumpvalue-2.27-514.el10.noarch.rpm;name=aarch64_perl-Dumpvalue;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Dumpvalue}"
SRC_URI[aarch64_perl-Dumpvalue.sha256sum] = "81ae38bd402bf06c8c5c95f82cd1e0228b53d05ad0d1ccf24c9dd0e6eb593cf8"

URI_aarch64_perl-DynaLoader = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DynaLoader-1.56-514.el10.aarch64.rpm;name=aarch64_perl-DynaLoader;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DynaLoader}"
SRC_URI[aarch64_perl-DynaLoader.sha256sum] = "7d001418294d8d5c63113e080770836acb7a0c2bd41bce7a824087d1c7d5cecf"

URI_aarch64_perl-English = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-English-1.11-514.el10.noarch.rpm;name=aarch64_perl-English;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-English}"
SRC_URI[aarch64_perl-English.sha256sum] = "3c74b306afd2bf73f4237c2d9f0b7574e6d21081e191261a88736b0f57143e78"

URI_aarch64_perl-Errno = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Errno-1.38-514.el10.aarch64.rpm;name=aarch64_perl-Errno;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Errno}"
SRC_URI[aarch64_perl-Errno.sha256sum] = "15ce676d7d472200f34b0fd815c3ae20ab24ae26160b6d6f723a06445338a0e4"

URI_aarch64_perl-ExtUtils-Constant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ExtUtils-Constant-0.25-514.el10.noarch.rpm;name=aarch64_perl-ExtUtils-Constant;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ExtUtils-Constant}"
SRC_URI[aarch64_perl-ExtUtils-Constant.sha256sum] = "c7c2b936c95e9e4e293431f6b24052efc94d6a021bbe5a19e0fc5c1a878df37f"

URI_aarch64_perl-ExtUtils-Embed = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ExtUtils-Embed-1.35-514.el10.noarch.rpm;name=aarch64_perl-ExtUtils-Embed;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ExtUtils-Embed}"
SRC_URI[aarch64_perl-ExtUtils-Embed.sha256sum] = "f3cfbd6fa043e0a20064cd6ad6115450ee77f22ee0c33d27b10b0b1ca8a8f36d"

URI_aarch64_perl-ExtUtils-Miniperl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ExtUtils-Miniperl-1.14-514.el10.noarch.rpm;name=aarch64_perl-ExtUtils-Miniperl;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ExtUtils-Miniperl}"
SRC_URI[aarch64_perl-ExtUtils-Miniperl.sha256sum] = "7f699b1aece4dd1d9c573cff830b7bdc584d368e78161b62b8d8aa478fa9b7b8"

URI_aarch64_perl-Fcntl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Fcntl-1.18-514.el10.aarch64.rpm;name=aarch64_perl-Fcntl;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Fcntl}"
SRC_URI[aarch64_perl-Fcntl.sha256sum] = "968590a6901902077a0c3c9d997265f27a72f54ae05608f24a8461a92d23463d"

URI_aarch64_perl-File-Basename = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Basename-2.86-514.el10.noarch.rpm;name=aarch64_perl-File-Basename;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Basename}"
SRC_URI[aarch64_perl-File-Basename.sha256sum] = "cb63f6036ae39b0714c55d186688e7d59553ae141d5e46dd15aadb827b35cb95"

URI_aarch64_perl-File-Compare = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Compare-1.100.800-514.el10.noarch.rpm;name=aarch64_perl-File-Compare;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Compare}"
SRC_URI[aarch64_perl-File-Compare.sha256sum] = "e23df46d7227a2b2b20abe6b086e40f16192fef86cdbdb79f725059bbcececa7"

URI_aarch64_perl-File-Copy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Copy-2.41-514.el10.noarch.rpm;name=aarch64_perl-File-Copy;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Copy}"
SRC_URI[aarch64_perl-File-Copy.sha256sum] = "af0cbc2fd1f33273b86725c2ed17d038983ce5f46d7fdab3c6317a9408704644"

URI_aarch64_perl-File-DosGlob = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-DosGlob-1.12-514.el10.aarch64.rpm;name=aarch64_perl-File-DosGlob;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-DosGlob}"
SRC_URI[aarch64_perl-File-DosGlob.sha256sum] = "9aac97916faa093762fda0601c32faaaadd3fafeb2f1e91f0c93be4c005a318b"

URI_aarch64_perl-File-Find = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Find-1.44-514.el10.noarch.rpm;name=aarch64_perl-File-Find;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Find}"
SRC_URI[aarch64_perl-File-Find.sha256sum] = "2070a080cc78e7d2c9f7f126b16af30784ecddc3e27a0f57d7409f6941f91155"

URI_aarch64_perl-File-stat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-stat-1.14-514.el10.noarch.rpm;name=aarch64_perl-File-stat;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-stat}"
SRC_URI[aarch64_perl-File-stat.sha256sum] = "7c88bf8e578fc3733f737ccd57968f048c810db26cc0b59d302cc07ee99e381c"

URI_aarch64_perl-FileCache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-FileCache-1.10-514.el10.noarch.rpm;name=aarch64_perl-FileCache;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-FileCache}"
SRC_URI[aarch64_perl-FileCache.sha256sum] = "f7aac4af2f36fe90e4a09a0b358526c6f80a26204f9d92833f5af72791ab7ce7"

URI_aarch64_perl-FileHandle = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-FileHandle-2.05-514.el10.noarch.rpm;name=aarch64_perl-FileHandle;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-FileHandle}"
SRC_URI[aarch64_perl-FileHandle.sha256sum] = "f2f2183a51dcd0a8f3034598516a4327216e7b91b76857ca0e69087d984a0d88"

URI_aarch64_perl-FindBin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-FindBin-1.54-514.el10.noarch.rpm;name=aarch64_perl-FindBin;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-FindBin}"
SRC_URI[aarch64_perl-FindBin.sha256sum] = "618b0cdd38027dd0a55be308bf4706b4773c5d4df46dcf41339d99538bca51b9"

URI_aarch64_perl-GDBM_File = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-GDBM_File-1.24-514.el10.aarch64.rpm;name=aarch64_perl-GDBM_File;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GDBM_File}"
SRC_URI[aarch64_perl-GDBM_File.sha256sum] = "77a529c4f7efcb8f55040e4be70a1a68931b78c019c42661b8faf257c35333e2"

URI_aarch64_perl-Getopt-Std = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Getopt-Std-1.14-514.el10.noarch.rpm;name=aarch64_perl-Getopt-Std;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Getopt-Std}"
SRC_URI[aarch64_perl-Getopt-Std.sha256sum] = "68f5dfff31f52cdc2bd4fe7dad46ead5c854467008685c80888c80d68873310b"

URI_aarch64_perl-Hash-Util = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Hash-Util-0.32-514.el10.aarch64.rpm;name=aarch64_perl-Hash-Util;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Hash-Util}"
SRC_URI[aarch64_perl-Hash-Util.sha256sum] = "26ca51dc656fd84c5555007d2f1addf1efe9b36cae1f83836a9452cb6de5ed55"

URI_aarch64_perl-Hash-Util-FieldHash = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Hash-Util-FieldHash-1.27-514.el10.aarch64.rpm;name=aarch64_perl-Hash-Util-FieldHash;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Hash-Util-FieldHash}"
SRC_URI[aarch64_perl-Hash-Util-FieldHash.sha256sum] = "c287eba71775d3cfc678ddb67a36812429cdde87eeefe86dc6d7cf8c4101f9a3"

URI_aarch64_perl-I18N-Collate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-I18N-Collate-1.02-514.el10.noarch.rpm;name=aarch64_perl-I18N-Collate;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-I18N-Collate}"
SRC_URI[aarch64_perl-I18N-Collate.sha256sum] = "f6f29962f1daa0eabee5b3ce1983cc7b7716d087a7e1222a282656857f6e8788"

URI_aarch64_perl-I18N-LangTags = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-I18N-LangTags-0.45-514.el10.noarch.rpm;name=aarch64_perl-I18N-LangTags;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-I18N-LangTags}"
SRC_URI[aarch64_perl-I18N-LangTags.sha256sum] = "a8b4752668d3c2373bc237e1fb53f5d1e29aa93ad74e3964821af84745f365c1"

URI_aarch64_perl-I18N-Langinfo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-I18N-Langinfo-0.24-514.el10.aarch64.rpm;name=aarch64_perl-I18N-Langinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-I18N-Langinfo}"
SRC_URI[aarch64_perl-I18N-Langinfo.sha256sum] = "40c38d9b78421a1e0a9c63f881f986699801a8ffc077f3d7d552c6424000f689"

URI_aarch64_perl-IO = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IO-1.55-514.el10.aarch64.rpm;name=aarch64_perl-IO;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO}"
SRC_URI[aarch64_perl-IO.sha256sum] = "60006738238654d1513e7be30a08f3986a38791ac6ff881fcc7d15958a5823e9"

URI_aarch64_perl-IPC-Open3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IPC-Open3-1.22-514.el10.noarch.rpm;name=aarch64_perl-IPC-Open3;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IPC-Open3}"
SRC_URI[aarch64_perl-IPC-Open3.sha256sum] = "b19188486a33e4d5a07fade99b1b406b64d11177983551e37eeb7e16f678462f"

URI_aarch64_perl-Locale-Maketext-Simple = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Locale-Maketext-Simple-0.21-514.el10.noarch.rpm;name=aarch64_perl-Locale-Maketext-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Locale-Maketext-Simple}"
SRC_URI[aarch64_perl-Locale-Maketext-Simple.sha256sum] = "bec736bed664c5010462522b5335bf7e8140b430fb33f107f412c457743cb9cc"

URI_aarch64_perl-Math-Complex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Math-Complex-1.62-514.el10.noarch.rpm;name=aarch64_perl-Math-Complex;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Math-Complex}"
SRC_URI[aarch64_perl-Math-Complex.sha256sum] = "27782eba884a58bd89bedfb2de5444a3d050201dfa7057d6a16ab4792a1b8eb3"

URI_aarch64_perl-Memoize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Memoize-1.16-514.el10.noarch.rpm;name=aarch64_perl-Memoize;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Memoize}"
SRC_URI[aarch64_perl-Memoize.sha256sum] = "ed07ca409736e8f543ae39157887aab4607ec746119312f40240a36265aa81e6"

URI_aarch64_perl-Module-Loaded = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Module-Loaded-0.08-514.el10.noarch.rpm;name=aarch64_perl-Module-Loaded;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Loaded}"
SRC_URI[aarch64_perl-Module-Loaded.sha256sum] = "64a99724577101f7c5b74a9808ab7ae4db7e7285d0ad4db011d0011b7cb9b415"

URI_aarch64_perl-NDBM_File = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-NDBM_File-1.17-514.el10.aarch64.rpm;name=aarch64_perl-NDBM_File;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-NDBM_File}"
SRC_URI[aarch64_perl-NDBM_File.sha256sum] = "f1c87a4c5fecd9780c112e0d1fffc50bfaaae99de96b1a981ff76856898f3f47"

URI_aarch64_perl-NEXT = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-NEXT-0.69-514.el10.noarch.rpm;name=aarch64_perl-NEXT;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-NEXT}"
SRC_URI[aarch64_perl-NEXT.sha256sum] = "81a26c4ca6d5c06dda14e07b1d5eb82bc6ada563f39a74233209b93742f6ee62"

URI_aarch64_perl-Net = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Net-1.04-514.el10.noarch.rpm;name=aarch64_perl-Net;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net}"
SRC_URI[aarch64_perl-Net.sha256sum] = "01f9ebe77c577599a38ae31d4baaaba313e437ef1d78e0a0e4b6dca72600e8fc"

URI_aarch64_perl-ODBM_File = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ODBM_File-1.18-514.el10.aarch64.rpm;name=aarch64_perl-ODBM_File;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ODBM_File}"
SRC_URI[aarch64_perl-ODBM_File.sha256sum] = "fcee8b966953e71b1fad0ad66884c28dc40919f604b90e542110ad67c7f8fe0b"

URI_aarch64_perl-Opcode = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Opcode-1.65-514.el10.aarch64.rpm;name=aarch64_perl-Opcode;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Opcode}"
SRC_URI[aarch64_perl-Opcode.sha256sum] = "6fbbed9a2229390e9148252f933d170ff8ee9d95c8d4e5d8f0fa462a3fe8ee7c"

URI_aarch64_perl-POSIX = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-POSIX-2.20-514.el10.aarch64.rpm;name=aarch64_perl-POSIX;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-POSIX}"
SRC_URI[aarch64_perl-POSIX.sha256sum] = "8725c971ae97db141dc68b2cfcf57b5be41c12c41ec4371e168f45e0d198a146"

URI_aarch64_perl-Pod-Functions = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Pod-Functions-1.14-514.el10.noarch.rpm;name=aarch64_perl-Pod-Functions;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Pod-Functions}"
SRC_URI[aarch64_perl-Pod-Functions.sha256sum] = "b14c95ded1b3afd6356d60c5e85af64d310214601a41e824e9eea75f35ad6925"

URI_aarch64_perl-Pod-Html = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Pod-Html-1.35-514.el10.noarch.rpm;name=aarch64_perl-Pod-Html;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Pod-Html}"
SRC_URI[aarch64_perl-Pod-Html.sha256sum] = "ca00f6901262d4d8f02db3f5ed86c531ddf8a0a729ed8f87a06b285d2f819f54"

URI_aarch64_perl-Safe = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Safe-2.46-514.el10.noarch.rpm;name=aarch64_perl-Safe;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Safe}"
SRC_URI[aarch64_perl-Safe.sha256sum] = "84c4722f3405b862edb27fb15a6d3b32407c89f60b531d4c513bcb3e003de81e"

URI_aarch64_perl-Search-Dict = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Search-Dict-1.07-514.el10.noarch.rpm;name=aarch64_perl-Search-Dict;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Search-Dict}"
SRC_URI[aarch64_perl-Search-Dict.sha256sum] = "fc52704cf7dd04525023e52f01fa93543f58e90ddb0b573092ccfd67aa936bf7"

URI_aarch64_perl-SelectSaver = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-SelectSaver-1.02-514.el10.noarch.rpm;name=aarch64_perl-SelectSaver;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SelectSaver}"
SRC_URI[aarch64_perl-SelectSaver.sha256sum] = "f2c6203439e606b6aa6deae84f53bb69b87c8abd76f867046648d8738409044a"

URI_aarch64_perl-SelfLoader = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-SelfLoader-1.27-514.el10.noarch.rpm;name=aarch64_perl-SelfLoader;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SelfLoader}"
SRC_URI[aarch64_perl-SelfLoader.sha256sum] = "c4995e7cb28af22de1f683f7c025396d903c6426a5e03151c282d94ccd61dcb6"

URI_aarch64_perl-Symbol = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Symbol-1.09-514.el10.noarch.rpm;name=aarch64_perl-Symbol;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Symbol}"
SRC_URI[aarch64_perl-Symbol.sha256sum] = "a6a8ebf84ed89b21f3abedb2525ff587e0e5622391bb0eba0f83b64e5b19f2cf"

URI_aarch64_perl-Sys-Hostname = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Sys-Hostname-1.25-514.el10.aarch64.rpm;name=aarch64_perl-Sys-Hostname;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-Hostname}"
SRC_URI[aarch64_perl-Sys-Hostname.sha256sum] = "3b335237da37e6b31dbf5eef76a97e546e16ddf9a2f53ce53dfe2bc4c0068559"

URI_aarch64_perl-Term-Complete = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Term-Complete-1.403-514.el10.noarch.rpm;name=aarch64_perl-Term-Complete;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Term-Complete}"
SRC_URI[aarch64_perl-Term-Complete.sha256sum] = "22c7703807be721df57116c8c91f69dfdec8b75c0d16b4d2a26f52f7ce2a94dc"

URI_aarch64_perl-Term-ReadLine = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Term-ReadLine-1.17-514.el10.noarch.rpm;name=aarch64_perl-Term-ReadLine;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Term-ReadLine}"
SRC_URI[aarch64_perl-Term-ReadLine.sha256sum] = "e3ca96489f62e69018bb50ea2949b32b33ac166fc97d27cad2fc2926a518f298"

URI_aarch64_perl-Test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Test-1.31-514.el10.noarch.rpm;name=aarch64_perl-Test;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test}"
SRC_URI[aarch64_perl-Test.sha256sum] = "a8d0acf61cc6085338cec44a7d9d06ebb6ce7e066a57e76edd5645562d47d2bf"

URI_aarch64_perl-Text-Abbrev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Text-Abbrev-1.02-514.el10.noarch.rpm;name=aarch64_perl-Text-Abbrev;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-Abbrev}"
SRC_URI[aarch64_perl-Text-Abbrev.sha256sum] = "19ad5caea8f4a1ba670cee0727f10b114b7a45bc8d1f327ac0026b7e1d9fc702"

URI_aarch64_perl-Thread = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Thread-3.05-514.el10.noarch.rpm;name=aarch64_perl-Thread;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Thread}"
SRC_URI[aarch64_perl-Thread.sha256sum] = "b2adf0f65e3bf420040780726a18319ab79b4d93c786f8fda07dd2b8153e74d3"

URI_aarch64_perl-Thread-Semaphore = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Thread-Semaphore-2.13-514.el10.noarch.rpm;name=aarch64_perl-Thread-Semaphore;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Thread-Semaphore}"
SRC_URI[aarch64_perl-Thread-Semaphore.sha256sum] = "59cc51cd152d8b6e399453fd3e878b62e8dc31a3ee942c655592798488cd92a1"

URI_aarch64_perl-Tie = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Tie-4.6-514.el10.noarch.rpm;name=aarch64_perl-Tie;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie}"
SRC_URI[aarch64_perl-Tie.sha256sum] = "4de8c8ea16fc1b00a3907fc72d927fc04484b17a00ddfbe593664cb2998d8741"

URI_aarch64_perl-Tie-File = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Tie-File-1.09-514.el10.noarch.rpm;name=aarch64_perl-Tie-File;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-File}"
SRC_URI[aarch64_perl-Tie-File.sha256sum] = "f1a6389071932f0d1d34cd97a0bd10f106907083724ae274be89891f97599280"

URI_aarch64_perl-Tie-Memoize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Tie-Memoize-1.1-514.el10.noarch.rpm;name=aarch64_perl-Tie-Memoize;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-Memoize}"
SRC_URI[aarch64_perl-Tie-Memoize.sha256sum] = "73b85aba2ce640e8d56d58795344881507e8fe7868e7c177b8894f6fbcd0073c"

URI_aarch64_perl-Time = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Time-1.04-514.el10.noarch.rpm;name=aarch64_perl-Time;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Time}"
SRC_URI[aarch64_perl-Time.sha256sum] = "adb8e53f583a5a554f71a9ba550e2c8484cf5b96145d2aa3dc579a3b7c1bfb95"

URI_aarch64_perl-Time-Piece = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Time-Piece-1.3401-514.el10.aarch64.rpm;name=aarch64_perl-Time-Piece;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Time-Piece}"
SRC_URI[aarch64_perl-Time-Piece.sha256sum] = "a1da55fc85467747a79933d317e0a85164008938d9b39f5833edbfb82c28368b"

URI_aarch64_perl-Unicode-UCD = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Unicode-UCD-0.78-514.el10.noarch.rpm;name=aarch64_perl-Unicode-UCD;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Unicode-UCD}"
SRC_URI[aarch64_perl-Unicode-UCD.sha256sum] = "eac2a1778c321a6dfd06ab07ae7af8fc37edae4000affe7726a59904d5c818e5"

URI_aarch64_perl-User-pwent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-User-pwent-1.05-514.el10.noarch.rpm;name=aarch64_perl-User-pwent;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-User-pwent}"
SRC_URI[aarch64_perl-User-pwent.sha256sum] = "bd923d5bf9ac9868d5e3df86f6fc83e1d9ddf97c9365fca39fd4e3fafe253559"

URI_aarch64_perl-autouse = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-autouse-1.11-514.el10.noarch.rpm;name=aarch64_perl-autouse;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-autouse}"
SRC_URI[aarch64_perl-autouse.sha256sum] = "faf18e4eb3d6296c892f51f546440052e60e6f55fb2a328a673527424837c244"

URI_aarch64_perl-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-base-2.27-514.el10.noarch.rpm;name=aarch64_perl-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-base}"
SRC_URI[aarch64_perl-base.sha256sum] = "e4b216f5ab766d06171e0d16c9facc91c22da273e38b05400e1a423e1ef97400"

URI_aarch64_perl-blib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-blib-1.07-514.el10.noarch.rpm;name=aarch64_perl-blib;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-blib}"
SRC_URI[aarch64_perl-blib.sha256sum] = "821585c820ab1a9acc90654f038b389559430305594af1d0f3eb97faebc549e9"

URI_aarch64_perl-debugger = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-debugger-1.60-514.el10.noarch.rpm;name=aarch64_perl-debugger;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-debugger}"
SRC_URI[aarch64_perl-debugger.sha256sum] = "35f15b3b9a38e519f6b5b2605eac49f3b2e0f3dc04746d3f952bcab557085dfd"

URI_aarch64_perl-deprecate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-deprecate-0.04-514.el10.noarch.rpm;name=aarch64_perl-deprecate;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-deprecate}"
SRC_URI[aarch64_perl-deprecate.sha256sum] = "7358a7d608bf6aae7981294e34337d5a439dde34c5a9b04b0d92b7162df82f7e"

URI_aarch64_perl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-devel-5.40.2-514.el10.aarch64.rpm;name=aarch64_perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-devel}"
SRC_URI[aarch64_perl-devel.sha256sum] = "548e43730bf374f3d3c1a3f13a1f929e6f7f2e3bca1ca95d8c310380a15259b7"

URI_aarch64_perl-diagnostics = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-diagnostics-1.40-514.el10.noarch.rpm;name=aarch64_perl-diagnostics;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-diagnostics}"
SRC_URI[aarch64_perl-diagnostics.sha256sum] = "9d542a623ed23da38cb146a5fd71aa139f20a7c7f66e7be4706fd2c37ae0953c"

URI_aarch64_perl-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-doc-5.40.2-514.el10.noarch.rpm;name=aarch64_perl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-doc}"
SRC_URI[aarch64_perl-doc.sha256sum] = "7728cf649557f8d2493f7c0ead923bf6b465dc787569c3f5eeb41c28b24ed883"

URI_aarch64_perl-encoding-warnings = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-encoding-warnings-0.14-514.el10.noarch.rpm;name=aarch64_perl-encoding-warnings;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-encoding-warnings}"
SRC_URI[aarch64_perl-encoding-warnings.sha256sum] = "3fe7bf782eff4801b8e5623303710d8529a129ac09921b1b61443dd5397d33fa"

URI_aarch64_perl-fields = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-fields-2.27-514.el10.noarch.rpm;name=aarch64_perl-fields;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-fields}"
SRC_URI[aarch64_perl-fields.sha256sum] = "3e72c2aa83f49188eb051d24eddce9d8e0d56682a71ad3a5c54bd59cf20e3854"

URI_aarch64_perl-filetest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-filetest-1.03-514.el10.noarch.rpm;name=aarch64_perl-filetest;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-filetest}"
SRC_URI[aarch64_perl-filetest.sha256sum] = "ccb1cbe616c99447dff815738d9dab25602f224075a3554995e441fc2165bbf8"

URI_aarch64_perl-if = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-if-0.61.000-514.el10.noarch.rpm;name=aarch64_perl-if;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-if}"
SRC_URI[aarch64_perl-if.sha256sum] = "42f0a44b818c73cf655cf0dec06f9c517841bc2e93811c81db655af4ad16fdbe"

URI_aarch64_perl-interpreter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-interpreter-5.40.2-514.el10.aarch64.rpm;name=aarch64_perl-interpreter;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-interpreter}"
SRC_URI[aarch64_perl-interpreter.sha256sum] = "df395e04514391856e2db9feeebeb07467987cf9712f1b44b0dfa11afe77533f"

URI_aarch64_perl-less = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-less-0.03-514.el10.noarch.rpm;name=aarch64_perl-less;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-less}"
SRC_URI[aarch64_perl-less.sha256sum] = "42e63c8baef154862d74525aaae5cac883105d722b3c8562bc256e83c5e9b245"

URI_aarch64_perl-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-lib-0.65-514.el10.aarch64.rpm;name=aarch64_perl-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-lib}"
SRC_URI[aarch64_perl-lib.sha256sum] = "bb16c1638fbf9adf0023013e43841b9578d57c1d36e1f018acb223b2fc74d3d7"

URI_aarch64_perl-libnetcfg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-libnetcfg-5.40.2-514.el10.noarch.rpm;name=aarch64_perl-libnetcfg;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-libnetcfg}"
SRC_URI[aarch64_perl-libnetcfg.sha256sum] = "8598b21d938219fe4016d91ba9af6605543ca3acfc536608014a0fb13109c7d4"

URI_aarch64_perl-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-libs-5.40.2-514.el10.aarch64.rpm;name=aarch64_perl-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-libs}"
SRC_URI[aarch64_perl-libs.sha256sum] = "94e908011eaaac0187504cb11d43ee91990e6e6094cca0e2c4ef04038c2b8585"

URI_aarch64_perl-locale = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-locale-1.12-514.el10.noarch.rpm;name=aarch64_perl-locale;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-locale}"
SRC_URI[aarch64_perl-locale.sha256sum] = "63079490f3982f99a215afcb2ad5993f3ce78273d61bee5762213caa65ce36b9"

URI_aarch64_perl-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-macros-5.40.2-514.el10.noarch.rpm;name=aarch64_perl-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-macros}"
SRC_URI[aarch64_perl-macros.sha256sum] = "d52972fa9a42ac5aaeeade0fc5fc3a0963c445e12e2557413e6930293bb09976"

URI_aarch64_perl-meta-notation = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-meta-notation-5.40.2-514.el10.noarch.rpm;name=aarch64_perl-meta-notation;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-meta-notation}"
SRC_URI[aarch64_perl-meta-notation.sha256sum] = "9efdb87feaaf058d9974daee789b36b228fcffa28220f16b642ce2e7f414edab"

URI_aarch64_perl-mro = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-mro-1.29-514.el10.aarch64.rpm;name=aarch64_perl-mro;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-mro}"
SRC_URI[aarch64_perl-mro.sha256sum] = "ec0c9199285297ff5cb8a9c93604127cb1e0aec1c18bf59f7f80a126531d8141"

URI_aarch64_perl-open = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-open-1.13-514.el10.noarch.rpm;name=aarch64_perl-open;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-open}"
SRC_URI[aarch64_perl-open.sha256sum] = "f86b726a28c986e1d0f20d29cc041c9b0b630cc1be5fb16af895ae1f8f891034"

URI_aarch64_perl-overload = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-overload-1.37-514.el10.noarch.rpm;name=aarch64_perl-overload;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-overload}"
SRC_URI[aarch64_perl-overload.sha256sum] = "c37648ac09f25409f9c4044f6b71947fa151a1841fdd8d4998c08dc2c4698bf1"

URI_aarch64_perl-overloading = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-overloading-0.02-514.el10.noarch.rpm;name=aarch64_perl-overloading;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-overloading}"
SRC_URI[aarch64_perl-overloading.sha256sum] = "fe17a9f98f77871060d293c0d74656236e64ae68b9ceb62b4039d37e7f0411b7"

URI_aarch64_perl-ph = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ph-5.40.2-514.el10.aarch64.rpm;name=aarch64_perl-ph;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ph}"
SRC_URI[aarch64_perl-ph.sha256sum] = "70304e50b289caeb097f84dfde76624df3729ad36c675d5009a22462c18008e1"

URI_aarch64_perl-sigtrap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-sigtrap-1.10-514.el10.noarch.rpm;name=aarch64_perl-sigtrap;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-sigtrap}"
SRC_URI[aarch64_perl-sigtrap.sha256sum] = "4e92b321bc883dd5343f7d4634901502c8532ea2efa6fce0aa92b673e107ab52"

URI_aarch64_perl-sort = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-sort-2.05-514.el10.noarch.rpm;name=aarch64_perl-sort;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-sort}"
SRC_URI[aarch64_perl-sort.sha256sum] = "6fe928b3268d8ade70053c70ac5de672129f277241a69c794b87782edf599f9f"

URI_aarch64_perl-subs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-subs-1.04-514.el10.noarch.rpm;name=aarch64_perl-subs;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-subs}"
SRC_URI[aarch64_perl-subs.sha256sum] = "0831142846750b61174ed73b26f4c67a40e15f9b777d3dbd62e7926d60133b9c"

URI_aarch64_perl-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-utils-5.40.2-514.el10.noarch.rpm;name=aarch64_perl-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-utils}"
SRC_URI[aarch64_perl-utils.sha256sum] = "541814d496e60a238f843b30a9e8e843b1662c6113785c7a852251467455329c"

URI_aarch64_perl-vars = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-vars-1.05-514.el10.noarch.rpm;name=aarch64_perl-vars;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-vars}"
SRC_URI[aarch64_perl-vars.sha256sum] = "59132cb461532a6363525910adab165f933161a5720284e14e163541cfa3454b"

URI_aarch64_perl-vmsish = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-vmsish-1.04-514.el10.noarch.rpm;name=aarch64_perl-vmsish;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-vmsish}"
SRC_URI[aarch64_perl-vmsish.sha256sum] = "074a459a5db0a81c37d0aa81374c0705f621ccf3417e56f232ab09f3f40a5905"

RDEPENDS:perl = " \
 perl-Archive-Tar \
 perl-Attribute-Handlers \
 perl-AutoLoader \
 perl-AutoSplit \
 perl-B \
 perl-Benchmark \
 perl-CPAN \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-CPAN-Meta-YAML \
 perl-Carp \
 perl-Class-Struct \
 perl-Compress-Raw-Bzip2 \
 perl-Compress-Raw-Zlib \
 perl-Config-Extensions \
 perl-Config-Perl-V \
 perl-DBM_Filter \
 perl-Data-Dumper \
 perl-Devel-PPPort \
 perl-Devel-Peek \
 perl-Devel-SelfStubber \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-DirHandle \
 perl-Dumpvalue \
 perl-DynaLoader \
 perl-Encode \
 perl-Encode-devel \
 perl-English \
 perl-Env \
 perl-Errno \
 perl-Exporter \
 perl-ExtUtils-CBuilder \
 perl-ExtUtils-Command \
 perl-ExtUtils-Constant \
 perl-ExtUtils-Embed \
 perl-ExtUtils-Install \
 perl-ExtUtils-MM-Utils \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-ExtUtils-Miniperl \
 perl-ExtUtils-ParseXS \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-DosGlob \
 perl-File-Fetch \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-File-stat \
 perl-FileCache \
 perl-FileHandle \
 perl-Filter \
 perl-Filter-Simple \
 perl-FindBin \
 perl-GDBM_File \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-HTTP-Tiny \
 perl-Hash-Util \
 perl-Hash-Util-FieldHash \
 perl-I18N-Collate \
 perl-I18N-LangTags \
 perl-I18N-Langinfo \
 perl-IO \
 perl-IO-Compress \
 perl-IO-Socket-IP \
 perl-IO-Zlib \
 perl-IPC-Cmd \
 perl-IPC-Open3 \
 perl-IPC-SysV \
 perl-JSON-PP \
 perl-Locale-Maketext \
 perl-Locale-Maketext-Simple \
 perl-MIME-Base64 \
 perl-Math-BigInt \
 perl-Math-BigInt-FastCalc \
 perl-Math-Complex \
 perl-Memoize \
 perl-Module-CoreList \
 perl-Module-CoreList-tools \
 perl-Module-Load \
 perl-Module-Load-Conditional \
 perl-Module-Loaded \
 perl-Module-Metadata \
 perl-NDBM_File \
 perl-NEXT \
 perl-Net \
 perl-Net-Ping \
 perl-ODBM_File \
 perl-Opcode \
 perl-POSIX \
 perl-Params-Check \
 perl-PathTools \
 perl-Perl-OSType \
 perl-PerlIO-via-QuotedPrint \
 perl-Pod-Checker \
 perl-Pod-Escapes \
 perl-Pod-Functions \
 perl-Pod-Html \
 perl-Pod-Perldoc \
 perl-Pod-Simple \
 perl-Pod-Usage \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Search-Dict \
 perl-SelectSaver \
 perl-SelfLoader \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Term-ANSIColor \
 perl-Term-Cap \
 perl-Term-Complete \
 perl-Term-ReadLine \
 perl-Term-Table \
 perl-Test \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Test2-Suite \
 perl-Text-Abbrev \
 perl-Text-Balanced \
 perl-Text-ParseWords \
 perl-Text-Tabs+Wrap \
 perl-Thread \
 perl-Thread-Queue \
 perl-Thread-Semaphore \
 perl-Tie \
 perl-Tie-File \
 perl-Tie-Memoize \
 perl-Tie-RefHash \
 perl-Time \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-Time-Piece \
 perl-Unicode-Collate \
 perl-Unicode-Normalize \
 perl-Unicode-UCD \
 perl-User-pwent \
 perl-autodie \
 perl-autouse \
 perl-base \
 perl-bignum \
 perl-blib \
 perl-constant \
 perl-debugger \
 perl-deprecate \
 perl-devel \
 perl-diagnostics \
 perl-doc \
 perl-encoding \
 perl-encoding-warnings \
 perl-experimental \
 perl-fields \
 perl-filetest \
 perl-if \
 perl-interpreter \
 perl-less \
 perl-lib \
 perl-libnet \
 perl-libnetcfg \
 perl-libs \
 perl-locale \
 perl-macros \
 perl-meta-notation \
 perl-mro \
 perl-open \
 perl-overload \
 perl-overloading \
 perl-parent \
 perl-perlfaq \
 perl-ph \
 perl-podlators \
 perl-sigtrap \
 perl-sort \
 perl-subs \
 perl-threads \
 perl-threads-shared \
 perl-utils \
 perl-vars \
 perl-version \
 perl-vmsish \
 "
RDEPENDS:perl-Attribute-Handlers = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-AutoLoader = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-AutoSplit = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Path \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-B = " \
 glibc \
 perl-B \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-if \
 perl-libs \
 perl-overloading \
 "
RDEPENDS:perl-Benchmark = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Class-Struct = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Config-Extensions = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-DBM_Filter = " \
 perl-Carp \
 perl-Encode \
 perl-IO-Compress \
 perl-libs \
 "
RDEPENDS:perl-Devel-Peek = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Devel-SelfStubber = " \
 perl-PathTools \
 perl-SelfLoader \
 perl-libs \
 "
RDEPENDS:perl-DirHandle = " \
 perl-Carp \
 perl-Symbol \
 perl-libs \
 "
RDEPENDS:perl-Dumpvalue = " \
 perl-libs \
 "
RDEPENDS:perl-DynaLoader = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-English = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Errno = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-ExtUtils-Constant = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-ExtUtils-Constant \
 perl-Text-Tabs+Wrap \
 perl-constant \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-ExtUtils-Embed = " \
 perl-Exporter \
 perl-PathTools \
 perl-devel \
 perl-libs \
 "
RDEPENDS:perl-ExtUtils-Miniperl = " \
 perl-Exporter \
 perl-ExtUtils-Embed \
 perl-devel \
 perl-libs \
 "
RDEPENDS:perl-Fcntl = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-File-Basename = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-File-Compare = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-File-Copy = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-File-DosGlob = " \
 glibc \
 perl-Text-ParseWords \
 perl-libs \
 "
RDEPENDS:perl-File-Find = " \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-File-stat = " \
 perl-Carp \
 perl-Class-Struct \
 perl-Exporter \
 perl-Fcntl \
 perl-Symbol \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-FileCache = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-FileHandle = " \
 perl-Exporter \
 perl-IO \
 perl-libs \
 "
RDEPENDS:perl-FindBin = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-GDBM_File = " \
 gdbm-libs \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Getopt-Std = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Hash-Util = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Hash-Util-FieldHash \
 perl-libs \
 "
RDEPENDS:perl-Hash-Util-FieldHash = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-I18N-Collate = " \
 perl-Exporter \
 perl-POSIX \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-I18N-LangTags = " \
 perl-Exporter \
 perl-I18N-LangTags \
 perl-libs \
 "
RDEPENDS:perl-I18N-Langinfo = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-IO = " \
 glibc \
 perl-Carp \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-stat \
 perl-IO \
 perl-PathTools \
 perl-SelectSaver \
 perl-Socket \
 perl-Symbol \
 perl-libs \
 "
RDEPENDS:perl-IPC-Open3 = " \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-IO \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-Symbol \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Locale-Maketext-Simple = " \
 perl-Locale-Maketext \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-Math-Complex = " \
 perl-Exporter \
 perl-Math-Complex \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Memoize = " \
 perl-Carp \
 perl-Exporter \
 perl-NDBM_File \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-libs \
 "
RDEPENDS:perl-Module-Loaded = " \
 perl-Carp \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-NDBM_File = " \
 gdbm-libs \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-NEXT = " \
 perl-Carp \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Net = " \
 perl-Class-Struct \
 perl-Exporter \
 perl-Socket \
 perl-libs \
 "
RDEPENDS:perl-ODBM_File = " \
 gdbm-libs \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-Opcode = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Opcode \
 perl-libs \
 perl-subs \
 "
RDEPENDS:perl-POSIX = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-libs \
 perl-locale \
 "
RDEPENDS:perl-Pod-Functions = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Pod-Html = " \
 perl-Exporter \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Html \
 perl-Pod-Simple \
 perl-Text-Tabs+Wrap \
 perl-interpreter \
 perl-libs \
 perl-locale \
 perl-parent \
 "
RDEPENDS:perl-Safe = " \
 perl-B \
 perl-Carp \
 perl-Opcode \
 perl-Scalar-List-Utils \
 perl-libs \
 "
RDEPENDS:perl-Search-Dict = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-SelectSaver = " \
 perl-Carp \
 perl-Symbol \
 perl-libs \
 "
RDEPENDS:perl-SelfLoader = " \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-libs \
 "
RDEPENDS:perl-Symbol = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Sys-Hostname = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Term-Complete = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Term-ReadLine = " \
 perl-Term-Cap \
 perl-libs \
 "
RDEPENDS:perl-Test = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Temp \
 perl-libs \
 "
RDEPENDS:perl-Text-Abbrev = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Thread = " \
 perl-Exporter \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 "
RDEPENDS:perl-Thread-Semaphore = " \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-threads-shared \
 "
RDEPENDS:perl-Tie = " \
 perl-Carp \
 perl-Tie \
 perl-libs \
 "
RDEPENDS:perl-Tie-File = " \
 perl-Carp \
 perl-Fcntl \
 perl-POSIX \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Tie-Memoize = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-Time = " \
 perl-Class-Struct \
 perl-Exporter \
 perl-Time \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-Time-Piece = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-Time-Local \
 perl-Time-Piece \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Unicode-UCD = " \
 perl-Carp \
 perl-Exporter \
 perl-PathTools \
 perl-Storable \
 perl-Unicode-Normalize \
 perl-if \
 perl-libs \
 "
RDEPENDS:perl-User-pwent = " \
 perl-Carp \
 perl-Class-Struct \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-autouse = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-base = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-blib = " \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-debugger = " \
 perl-IO \
 perl-PathTools \
 perl-Term-ReadLine \
 perl-libs \
 perl-meta-notation \
 perl-mro \
 perl-threads \
 perl-threads-shared \
 perl-vars \
 "
RDEPENDS:perl-deprecate = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-devel = " \
 libxcrypt-devel \
 perl-Devel-PPPort \
 perl-ExtUtils-Constant \
 perl-ExtUtils-Install \
 perl-ExtUtils-ParseXS \
 perl-File-Compare \
 perl-File-Path \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Text-Tabs+Wrap \
 perl-interpreter \
 perl-libs \
 perl-vars \
 redhat-rpm-config \
 systemtap-sdt-devel \
 systemtap-sdt-dtrace \
 "
RDEPENDS:perl-diagnostics = " \
 perl-Carp \
 perl-Getopt-Std \
 perl-Text-Tabs+Wrap \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-doc = " \
 perl-libs \
 "
RDEPENDS:perl-encoding-warnings = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-fields = " \
 perl-Carp \
 perl-Hash-Util \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-filetest = " \
 perl-libs \
 "
RDEPENDS:perl-if = " \
 perl-libs \
 "
RDEPENDS:perl-interpreter = " \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-less = " \
 perl-libs \
 "
RDEPENDS:perl-lib = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-libnetcfg = " \
 perl-ExtUtils-MakeMaker \
 perl-Getopt-Std \
 perl-IO \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-libs = " \
 glibc \
 libxcrypt \
 perl-Carp \
 perl-DynaLoader \
 perl-Encode \
 perl-Exporter \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-locale = " \
 perl-Carp \
 perl-POSIX \
 perl-libs \
 "
RDEPENDS:perl-macros = " \
 perl-interpreter \
 "
RDEPENDS:perl-meta-notation = " \
 perl-libs \
 "
RDEPENDS:perl-mro = " \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-open = " \
 perl-Carp \
 perl-Encode \
 perl-encoding \
 perl-libs \
 "
RDEPENDS:perl-overload = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-mro \
 perl-overloading \
 "
RDEPENDS:perl-overloading = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-ph = " \
 perl-libs \
 "
RDEPENDS:perl-sigtrap = " \
 perl-Carp \
 perl-Symbol \
 perl-libs \
 perl-meta-notation \
 "
RDEPENDS:perl-sort = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-subs = " \
 perl-libs \
 "
RDEPENDS:perl-utils = " \
 perl-File-Basename \
 perl-File-Path \
 perl-Getopt-Std \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-vars = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-vmsish = " \
 perl-libs \
 "
