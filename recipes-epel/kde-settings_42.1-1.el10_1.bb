# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-settings"
PV = "42.1"
PR = "1.el10_1"
PACKAGES = " \
 initial-setup-gui-wayland-plasma \
 kde-settings \
 kde-settings-plasma \
 kde-settings-pulseaudio \
 kde-settings-sddm \
 qt-settings \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-settings-42.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ffb49efd7ce5be89f680caa62c19cce468e15d111b20e4cb00a0d8057a40bd3"

URI_x86_64_v2_initial-setup-gui-wayland-plasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/initial-setup-gui-wayland-plasma-42.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_initial-setup-gui-wayland-plasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_initial-setup-gui-wayland-plasma}"
SRC_URI[x86_64_v2_initial-setup-gui-wayland-plasma.sha256sum] = "4f20f3deec425dd1eb6651bddcd378e1696cbbee44f7eec29d753484ee14b3e7"
RPROVIDES:initial-setup-gui-wayland-plasma:x86_64_v2 = "virtual/firstboot_gui-backend_"

URI_x86_64_v2_kde-settings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-settings-42.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kde-settings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-settings}"
SRC_URI[x86_64_v2_kde-settings.sha256sum] = "1a2f4784bb012a91e433327f960fb5a0f7e76a83463e199e7ef182bf75ad0853"

URI_x86_64_v2_kde-settings-plasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-settings-plasma-42.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kde-settings-plasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-settings-plasma}"
SRC_URI[x86_64_v2_kde-settings-plasma.sha256sum] = "7db268fdab64a3a56b7bda8445878fc9242a8ea0dc79c73e63424ded67377b28"

URI_x86_64_v2_kde-settings-pulseaudio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-settings-pulseaudio-42.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kde-settings-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-settings-pulseaudio}"
SRC_URI[x86_64_v2_kde-settings-pulseaudio.sha256sum] = "a2813466239e5bbf809aff687e2d70fdb0f6d49bf05cfe341b4db81987f22205"

URI_x86_64_v2_kde-settings-sddm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-settings-sddm-42.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kde-settings-sddm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-settings-sddm}"
SRC_URI[x86_64_v2_kde-settings-sddm.sha256sum] = "79b153844ad235975a57af18e9f010f7a4337d4c90acac30c2317359ff7d0b72"

URI_x86_64_v2_qt-settings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-settings-42.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt-settings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt-settings}"
SRC_URI[x86_64_v2_qt-settings.sha256sum] = "336a06b4f2ec840df8bbfff6b1d3835d9bd0e9ebf3fd00b8b51b4aa61d2be6b5"

URI_aarch64_initial-setup-gui-wayland-plasma = "${EPEL_MIRROR}/aarch64/Packages/i/initial-setup-gui-wayland-plasma-42.1-1.el10_1.noarch.rpm;name=aarch64_initial-setup-gui-wayland-plasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_initial-setup-gui-wayland-plasma}"
SRC_URI[aarch64_initial-setup-gui-wayland-plasma.sha256sum] = "079668cbb23430f805ad752a050b44a92ec867194de8dcc8eb2cf269f84d160a"
RPROVIDES:initial-setup-gui-wayland-plasma:aarch64 = "virtual/firstboot_gui-backend_"

URI_aarch64_kde-settings = "${EPEL_MIRROR}/aarch64/Packages/k/kde-settings-42.1-1.el10_1.noarch.rpm;name=aarch64_kde-settings;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-settings}"
SRC_URI[aarch64_kde-settings.sha256sum] = "9bb714acb7d482caa95276f58714cb6e296c8192b445449d2d8ef28c08997abc"

URI_aarch64_kde-settings-plasma = "${EPEL_MIRROR}/aarch64/Packages/k/kde-settings-plasma-42.1-1.el10_1.noarch.rpm;name=aarch64_kde-settings-plasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-settings-plasma}"
SRC_URI[aarch64_kde-settings-plasma.sha256sum] = "d88bfb6b6342bbebda8e89ec9e129747cd1f6c27cbe139eb6d0bab70f38a9edb"

URI_aarch64_kde-settings-pulseaudio = "${EPEL_MIRROR}/aarch64/Packages/k/kde-settings-pulseaudio-42.1-1.el10_1.noarch.rpm;name=aarch64_kde-settings-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-settings-pulseaudio}"
SRC_URI[aarch64_kde-settings-pulseaudio.sha256sum] = "9ec65d37580a118bafd8114f2e9ad609369591d4336f4698825d6f5e5e041e1c"

URI_aarch64_kde-settings-sddm = "${EPEL_MIRROR}/aarch64/Packages/k/kde-settings-sddm-42.1-1.el10_1.noarch.rpm;name=aarch64_kde-settings-sddm;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-settings-sddm}"
SRC_URI[aarch64_kde-settings-sddm.sha256sum] = "e60da99b909fec11fb40edad8a3783a093288c6b585b48bd2bf923e168a39da6"

URI_aarch64_qt-settings = "${EPEL_MIRROR}/aarch64/Packages/q/qt-settings-42.1-1.el10_1.noarch.rpm;name=aarch64_qt-settings;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt-settings}"
SRC_URI[aarch64_qt-settings.sha256sum] = "7efe52f39b95be8a3d4bb26f7adbf961ce358fed2672431e732059d15601a3f7"

RDEPENDS:initial-setup-gui-wayland-plasma = " \
 bash \
 initial-setup-gui \
 kwin \
 maliit-keyboard \
 xorg-x11-server-Xwayland \
 "
RDEPENDS:kde-settings = " \
 bash \
 breeze-icon-theme \
 kde-filesystem \
 shared-mime-info \
 xdg-user-dirs \
 "
RDEPENDS:kde-settings-plasma = " \
 almalinux-logos \
 f42-backgrounds-kde \
 google-noto-sans-fonts \
 google-noto-sans-mono-fonts \
 kde-settings \
 "
RDEPENDS:kde-settings-pulseaudio = " \
 alsa-plugins-pulseaudio \
 kde-settings \
 pipewire-alsa \
 pipewire-pulseaudio \
 "
RDEPENDS:kde-settings-sddm = " \
 breeze-cursor-theme \
 sddm \
 "
RDEPENDS:qt-settings = " \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/firstboot_gui-backend_"

PROVIDES:append:aarch64 = " rpm/virtual/firstboot_gui-backend_"
