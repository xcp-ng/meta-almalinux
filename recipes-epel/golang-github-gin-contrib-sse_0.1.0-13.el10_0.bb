# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-gin-contrib-sse"
PV = "0.1.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-gin-contrib-sse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-gin-contrib-sse-0.1.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d56136995215ebcb45d14384ba69c56b59b04fb3e270d9290fdea1152a5356b"

URI_x86_64_v2_golang-github-gin-contrib-sse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-gin-contrib-sse-devel-0.1.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-gin-contrib-sse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-gin-contrib-sse-devel}"
SRC_URI[x86_64_v2_golang-github-gin-contrib-sse-devel.sha256sum] = "cb9af5451b5c8cecd847da52e0d7d2eacc1bde6b09f82eb4b3abf82d8215bf28"

URI_aarch64_golang-github-gin-contrib-sse-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-gin-contrib-sse-devel-0.1.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-gin-contrib-sse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-gin-contrib-sse-devel}"
SRC_URI[aarch64_golang-github-gin-contrib-sse-devel.sha256sum] = "6e6c7925a57bb8e96b61d3b03e96643cc85c750193bd54dfbf4c689261e5a56c"

RDEPENDS:golang-github-gin-contrib-sse-devel = " \
 go-filesystem \
 "
