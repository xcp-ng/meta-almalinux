# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-archspec"
PV = "0.2.5"
PR = "6.el10_2"
PACKAGES:x86_64_v2 = " \
 python3-archspec \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-archspec-0.2.5-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "159719c7f730f23d2696f497e36b68f670ac47fb63d5d19d5ccea94aeb4c5407"

URI_x86_64_v2_python3-archspec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-archspec-0.2.5-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-archspec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-archspec}"
SRC_URI[x86_64_v2_python3-archspec.sha256sum] = "394945b3c28c25b09e2908bf8a811e96b38ba8838a700cacac7c2c44437e33d0"

RDEPENDS:python3-archspec = " \
 python3 \
 "
