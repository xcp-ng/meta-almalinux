# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pim-sieve-editor"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 pim-sieve-editor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pim-sieve-editor-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "373d2a0156a5b0481e39fe431de02adad007f82a0a400c0372218f66c999dc7f"

URI_x86_64_v2_pim-sieve-editor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pim-sieve-editor-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pim-sieve-editor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pim-sieve-editor}"
SRC_URI[x86_64_v2_pim-sieve-editor.sha256sum] = "2d7146011c50db407cc1e3ba3e438c3ded767e51a99e27a676b03a9912dde268"

URI_aarch64_pim-sieve-editor = "${EPEL_MIRROR}/aarch64/Packages/p/pim-sieve-editor-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_pim-sieve-editor;unpack=0"
SRC_URI:append = " ${URI_aarch64_pim-sieve-editor}"
SRC_URI[aarch64_pim-sieve-editor.sha256sum] = "fc22dc07b5befacaaa352b6c14ffa3cce01617c02d1b0005cc1ac430b0010540"

RDEPENDS:pim-sieve-editor = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kmailtransport \
 libksieve \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
