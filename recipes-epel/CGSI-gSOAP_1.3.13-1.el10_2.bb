# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "CGSI-gSOAP"
PV = "1.3.13"
PR = "1.el10_2"
PACKAGES = " \
 CGSI-gSOAP \
 CGSI-gSOAP-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/CGSI-gSOAP-1.3.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79a003e6707b2bff73c80a46da6bcc750a14c2f744b2169c31eacde7fda9d1c0"

URI_x86_64_v2_CGSI-gSOAP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CGSI-gSOAP-1.3.13-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CGSI-gSOAP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CGSI-gSOAP}"
SRC_URI[x86_64_v2_CGSI-gSOAP.sha256sum] = "ef54a52664a4e795a329f2fb5c245b809988c62357a0dbbb579cf7286d01a3fc"

URI_x86_64_v2_CGSI-gSOAP-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CGSI-gSOAP-devel-1.3.13-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CGSI-gSOAP-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CGSI-gSOAP-devel}"
SRC_URI[x86_64_v2_CGSI-gSOAP-devel.sha256sum] = "8fd8faaf5e03ac711e940c43e8f1ebeeebde11d23abaaa790d68cc8188fed7b0"

URI_aarch64_CGSI-gSOAP = "${EPEL_MIRROR}/aarch64/Packages/c/CGSI-gSOAP-1.3.13-1.el10_2.aarch64.rpm;name=aarch64_CGSI-gSOAP;unpack=0"
SRC_URI:append = " ${URI_aarch64_CGSI-gSOAP}"
SRC_URI[aarch64_CGSI-gSOAP.sha256sum] = "171827fff34d2ebf265ec6d137ca73cc8e5298ea65b581dce009d0c9d74b38e4"

URI_aarch64_CGSI-gSOAP-devel = "${EPEL_MIRROR}/aarch64/Packages/c/CGSI-gSOAP-devel-1.3.13-1.el10_2.aarch64.rpm;name=aarch64_CGSI-gSOAP-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_CGSI-gSOAP-devel}"
SRC_URI[aarch64_CGSI-gSOAP-devel.sha256sum] = "25f2aad5a4aa877b437dce4f24a9330c51827b83b9b0391d1a98c98a6d9c7ea3"

RDEPENDS:CGSI-gSOAP = " \
 glibc \
 globus-common \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-openssl-module \
 libstdc++ \
 openssl-libs \
 voms \
 "
RDEPENDS:CGSI-gSOAP-devel = " \
 CGSI-gSOAP \
 gsoap-devel \
 "
