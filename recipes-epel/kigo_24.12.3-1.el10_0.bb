# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kigo"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kigo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kigo-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "879dc69634bc04a3f43e419b25db2edc741fda694b35ca51027dd04e3c3b3668"

URI_x86_64_v2_kigo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kigo-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kigo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kigo}"
SRC_URI[x86_64_v2_kigo.sha256sum] = "0913691714b7c3d39cc2cf01b1ffb53a25d485ae0301aedc70a5a8f194ccd3f3"

URI_aarch64_kigo = "${EPEL_MIRROR}/aarch64/Packages/k/kigo-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kigo;unpack=0"
SRC_URI:append = " ${URI_aarch64_kigo}"
SRC_URI[aarch64_kigo.sha256sum] = "76ed0066cd9d10ef5a1ab754a79760500dbe59c14a98d14d6f1c55c277c08e21"

RDEPENDS:kigo = " \
 glibc \
 gnugo \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
