# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proptest-macro"
PV = "0.2.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-proptest-macro+default-devel \
 rust-proptest-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proptest-macro-0.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88018eab1b6ac511434bb08b82bc43b1ddd2307627f7aa9eab18f77ad05f49b1"

URI_x86_64_v2_rust-proptest-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-macro+default-devel-0.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-macro+default-devel}"
SRC_URI[x86_64_v2_rust-proptest-macro+default-devel.sha256sum] = "6ff1c79e2c56946d36318346ad9039e5c6d4a9f66f7456c3eb6e7fb48d3af377"

URI_x86_64_v2_rust-proptest-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-macro-devel-0.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-macro-devel}"
SRC_URI[x86_64_v2_rust-proptest-macro-devel.sha256sum] = "4c318c08cdfdb383a61e9d2e17a4ed45de5d581c2ba5f00295800e1312ff1635"

URI_aarch64_rust-proptest-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-macro+default-devel-0.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-macro+default-devel}"
SRC_URI[aarch64_rust-proptest-macro+default-devel.sha256sum] = "fc9fb5a2015a50b2400f8f5d6875fcd2b9faecda2e44415378457956ba655aba"

URI_aarch64_rust-proptest-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-macro-devel-0.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-macro-devel}"
SRC_URI[aarch64_rust-proptest-macro-devel.sha256sum] = "f6a38cb4b83419122cd81b603a7998f5898fd3bab7dd654b6f68cbedfffb2394"

RDEPENDS:rust-proptest-macro+default-devel = " \
 cargo \
 rust-proptest-macro-devel \
 "
RDEPENDS:rust-proptest-macro-devel = " \
 cargo \
 rust \
 rust-convert_case0.6+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
