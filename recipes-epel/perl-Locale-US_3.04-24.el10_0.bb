# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Locale-US"
PV = "3.04"
PR = "24.el10_0"
PACKAGES = " \
 perl-Locale-US \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Locale-US-3.04-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbabbd2388d591657d39eaf5a6c5df2418daacce888e623704647e1e70a9f0cd"

URI_x86_64_v2_perl-Locale-US = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Locale-US-3.04-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Locale-US;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Locale-US}"
SRC_URI[x86_64_v2_perl-Locale-US.sha256sum] = "243a0a0eac12b97f8a02cfbea3129ea77f932b71bc8deffa9d09ab87a75e4f60"

URI_aarch64_perl-Locale-US = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Locale-US-3.04-24.el10_0.noarch.rpm;name=aarch64_perl-Locale-US;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Locale-US}"
SRC_URI[aarch64_perl-Locale-US.sha256sum] = "6bce2caaccc59cc54fadb36f19b13a8f04d87f75ae55620a6febc9db42e3bf48"

RDEPENDS:perl-Locale-US = " \
 perl-Data-Section-Simple \
 perl-interpreter \
 perl-libs \
 "
