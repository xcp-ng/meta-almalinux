# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtk-doc"
PV = "1.33.2"
PR = "12.el10"
PACKAGES = " \
 gtk-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/gtk-doc-1.33.2-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed96e37be631326af03da26f5815945811adbeea7e34945d3cb546e8bd2f15c0"

URI_x86_64_v2_gtk-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gtk-doc-1.33.2-12.el10.x86_64_v2.rpm;name=x86_64_v2_gtk-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk-doc}"
SRC_URI[x86_64_v2_gtk-doc.sha256sum] = "27f2e3122bbd4bc9af032d204a83e6a9acd66c507a5d3c1df30d9c91a11fd4e3"

URI_aarch64_gtk-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gtk-doc-1.33.2-12.el10.aarch64.rpm;name=aarch64_gtk-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk-doc}"
SRC_URI[aarch64_gtk-doc.sha256sum] = "932d06f20c482a619e81e1fa45762a7fc11b446d5fe0c1664c572991505686d9"

RDEPENDS:gtk-doc = " \
 bash \
 cmake-filesystem \
 docbook-style-xsl \
 docbook-utils \
 libxslt \
 pkgconf-pkg-config \
 python3 \
 python3-lxml \
 python3-pygments \
 "
