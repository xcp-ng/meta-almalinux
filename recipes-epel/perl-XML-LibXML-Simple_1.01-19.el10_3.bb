# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-LibXML-Simple"
PV = "1.01"
PR = "19.el10_3"
PACKAGES = " \
 perl-XML-LibXML-Simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XML-LibXML-Simple-1.01-19.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a81de85007256ca81f3f0b638d7d8b5979a6a08d953e43be3da8cf88dc3da31b"

URI_x86_64_v2_perl-XML-LibXML-Simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-LibXML-Simple-1.01-19.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-LibXML-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-LibXML-Simple}"
SRC_URI[x86_64_v2_perl-XML-LibXML-Simple.sha256sum] = "c8f9425160d2bdef1de022cd5772b77081de8c3eda20cc5783f8880c0619db20"

URI_aarch64_perl-XML-LibXML-Simple = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-LibXML-Simple-1.01-19.el10_3.noarch.rpm;name=aarch64_perl-XML-LibXML-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-LibXML-Simple}"
SRC_URI[aarch64_perl-XML-LibXML-Simple.sha256sum] = "8c04d2e99d693574c27797f1c2eca7e7142bc34974f7a08bb41628f5cd17a642"

RDEPENDS:perl-XML-LibXML-Simple = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-XML-LibXML \
 perl-base \
 perl-libs \
 perl-vars \
 "
