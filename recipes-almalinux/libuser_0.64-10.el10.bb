# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libuser"
PV = "0.64"
PR = "10.el10"
PACKAGES = " \
 libuser \
 libuser-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libuser-0.64-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf58b6097de99e1fc4028efb03e5f27f69ba022106d95910871815e7df0c7609"

URI_x86_64_v2_libuser = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libuser-0.64-10.el10.x86_64_v2.rpm;name=x86_64_v2_libuser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuser}"
SRC_URI[x86_64_v2_libuser.sha256sum] = "309b57492cd95ff96635fbffa7d29be3a86597de8ccdabef46a1240b4f0b5257"

URI_x86_64_v2_libuser-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libuser-devel-0.64-10.el10.x86_64_v2.rpm;name=x86_64_v2_libuser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuser-devel}"
SRC_URI[x86_64_v2_libuser-devel.sha256sum] = "ebf35b59fec26fd303a7fc0fba811d558f009cf19f1bcef70ea7e013aa67f53f"

URI_aarch64_libuser = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libuser-0.64-10.el10.aarch64.rpm;name=aarch64_libuser;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuser}"
SRC_URI[aarch64_libuser.sha256sum] = "43ea5c81b72da6f96da6fa72d022f2f4cb4829019c8fd90603edd70819d59eb9"

URI_aarch64_libuser-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libuser-devel-0.64-10.el10.aarch64.rpm;name=aarch64_libuser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuser-devel}"
SRC_URI[aarch64_libuser-devel.sha256sum] = "c39def4fd17241226dada37dbf730a992ebd30fdfe6c37a80057dd7b4067afb3"

RDEPENDS:libuser = " \
 audit-libs \
 glib2 \
 glibc \
 libselinux \
 libxcrypt \
 openldap \
 pam-libs \
 popt \
 "
RDEPENDS:libuser-devel = " \
 glib2-devel \
 libuser \
 pkgconf-pkg-config \
 "
