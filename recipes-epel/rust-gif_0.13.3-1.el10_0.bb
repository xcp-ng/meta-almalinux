# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gif"
PV = "0.13.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-gif+color_quant-devel \
 rust-gif+default-devel \
 rust-gif+raii_no_panic-devel \
 rust-gif+std-devel \
 rust-gif-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gif-0.13.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0bf6eae5df30e86c09f6922cc33a3eb30e3217f76bf44f6a3750e2c236f680e"

URI_x86_64_v2_rust-gif+color_quant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+color_quant-devel-0.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+color_quant-devel}"
SRC_URI[x86_64_v2_rust-gif+color_quant-devel.sha256sum] = "02604d1a4b426fb58619ef9cc14afd6b8dccc1886a7a27f738fe05442b806c3f"

URI_x86_64_v2_rust-gif+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+default-devel-0.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+default-devel}"
SRC_URI[x86_64_v2_rust-gif+default-devel.sha256sum] = "6134654bc4d176f2e75adeaac648db2a72410f9e0123ae2d79b0e689dc0c4ab8"

URI_x86_64_v2_rust-gif+raii_no_panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+raii_no_panic-devel-0.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+raii_no_panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+raii_no_panic-devel}"
SRC_URI[x86_64_v2_rust-gif+raii_no_panic-devel.sha256sum] = "4af96a5ef59b87734ac240e622c948059945b94b89e1b349c970bc23aafb5a95"

URI_x86_64_v2_rust-gif+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+std-devel-0.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+std-devel}"
SRC_URI[x86_64_v2_rust-gif+std-devel.sha256sum] = "e11d62599c8e7b3f0be55a08c903702afcd6e382aebab103d1563955ec0bac80"

URI_x86_64_v2_rust-gif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif-devel-0.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif-devel}"
SRC_URI[x86_64_v2_rust-gif-devel.sha256sum] = "56ab0fec296169b670088419d8407d1f900840c51ac8b02d37ce9b575e29c65e"

URI_aarch64_rust-gif+color_quant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+color_quant-devel-0.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-gif+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+color_quant-devel}"
SRC_URI[aarch64_rust-gif+color_quant-devel.sha256sum] = "70881deb6280067e16ece67e4193a061876403d4e47976c22bbe8eabd5f2cc5d"

URI_aarch64_rust-gif+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+default-devel-0.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-gif+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+default-devel}"
SRC_URI[aarch64_rust-gif+default-devel.sha256sum] = "272562f630eaf07b7d3c8f6bac7bffe2e2e49d617293c690430ee062ff9506c0"

URI_aarch64_rust-gif+raii_no_panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+raii_no_panic-devel-0.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-gif+raii_no_panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+raii_no_panic-devel}"
SRC_URI[aarch64_rust-gif+raii_no_panic-devel.sha256sum] = "36e8ddd8b67d09ef202ae477b7fa35ad27d304ac0ee749d34c0dcbdd24cc14fa"

URI_aarch64_rust-gif+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+std-devel-0.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-gif+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+std-devel}"
SRC_URI[aarch64_rust-gif+std-devel.sha256sum] = "98dca3142d404e2d1739e174cb5d9b5ac7dae358c7d663d745c100ab1a8f4f1e"

URI_aarch64_rust-gif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif-devel-0.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-gif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif-devel}"
SRC_URI[aarch64_rust-gif-devel.sha256sum] = "0b51dc3c45629b35ad3d2b9c39c2e2b54cab0d1732db0bc601b67ef0568a502d"

RDEPENDS:rust-gif+color_quant-devel = " \
 cargo \
 rust-color_quant+default-devel \
 rust-gif-devel \
 "
RDEPENDS:rust-gif+default-devel = " \
 cargo \
 rust-gif+color_quant-devel \
 rust-gif+raii_no_panic-devel \
 rust-gif+std-devel \
 rust-gif-devel \
 "
RDEPENDS:rust-gif+raii_no_panic-devel = " \
 cargo \
 rust-gif-devel \
 "
RDEPENDS:rust-gif+std-devel = " \
 cargo \
 rust-gif-devel \
 "
RDEPENDS:rust-gif-devel = " \
 cargo \
 rust \
 rust-weezl+default-devel \
 "
