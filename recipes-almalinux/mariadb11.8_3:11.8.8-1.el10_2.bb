# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mariadb11.8"
PE = "3"
PV = "11.8.8"
PR = "1.el10_2"
PACKAGES = " \
 mariadb11.8 \
 mariadb11.8-backup \
 mariadb11.8-client-utils \
 mariadb11.8-common \
 mariadb11.8-devel \
 mariadb11.8-embedded \
 mariadb11.8-embedded-devel \
 mariadb11.8-errmsg \
 mariadb11.8-gssapi-server \
 mariadb11.8-oqgraph-engine \
 mariadb11.8-pam \
 mariadb11.8-server \
 mariadb11.8-server-galera \
 mariadb11.8-server-utils \
 mariadb11.8-test \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mariadb11.8-11.8.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6078d114f1300e23eb0c39b794ae6e3d9f491f89a70a417c6d952d0ace15c0ce"

URI_x86_64_v2_mariadb11.8 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-11.8.8-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8}"
SRC_URI[x86_64_v2_mariadb11.8.sha256sum] = "475bd090087cfe499aa3993bf8b00c60a72f1e71b259d23e9814ae678039d24d"
RPROVIDES:mariadb11.8:x86_64_v2 = "virtual//usr/bin/mariadb-dump virtual//usr/bin/mysqldump"

URI_x86_64_v2_mariadb11.8-backup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-backup-11.8.8-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-backup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8-backup}"
SRC_URI[x86_64_v2_mariadb11.8-backup.sha256sum] = "298d1fda34be69112c9a3f762ac718dcd333d0f6e522b19bca87e46c15d3c037"
RPROVIDES:mariadb11.8-backup:x86_64_v2 = "virtual//usr/bin/mariabackup"

URI_x86_64_v2_mariadb11.8-client-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-client-utils-11.8.8-1.el10_2.noarch.rpm;name=x86_64_v2_mariadb11.8-client-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8-client-utils}"
SRC_URI[x86_64_v2_mariadb11.8-client-utils.sha256sum] = "1b8213a94b5a803fee91159889715d18dce58d1206715acfe2ca987d9c88560c"

URI_x86_64_v2_mariadb11.8-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-common-11.8.8-1.el10_2.noarch.rpm;name=x86_64_v2_mariadb11.8-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8-common}"
SRC_URI[x86_64_v2_mariadb11.8-common.sha256sum] = "bf247857f833df313151be70c72cf6cc08b2708a50410ff68503d30347ea33e0"

URI_x86_64_v2_mariadb11.8-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-devel-11.8.8-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8-devel}"
SRC_URI[x86_64_v2_mariadb11.8-devel.sha256sum] = "d8ab80bd89cd9d37b5b98788837ea1038417011375135494a1ee7c5a0fc2be16"

URI_x86_64_v2_mariadb11.8-embedded = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-embedded-11.8.8-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-embedded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8-embedded}"
SRC_URI[x86_64_v2_mariadb11.8-embedded.sha256sum] = "119b8635a3df4135b1e45b524dd9cf111c7b2c1c83e409f9d42b05053346311d"
RPROVIDES:mariadb11.8-embedded:x86_64_v2 = "virtual/libmariadbd.so.19___64bit_"

URI_x86_64_v2_mariadb11.8-embedded-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-embedded-devel-11.8.8-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-embedded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8-embedded-devel}"
SRC_URI[x86_64_v2_mariadb11.8-embedded-devel.sha256sum] = "1a193ea137287b97c274bedbebfc09bc5e4a6f9dd266543bbaa07997f6ab3535"

URI_x86_64_v2_mariadb11.8-errmsg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-errmsg-11.8.8-1.el10_2.noarch.rpm;name=x86_64_v2_mariadb11.8-errmsg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8-errmsg}"
SRC_URI[x86_64_v2_mariadb11.8-errmsg.sha256sum] = "cedb5ef493d966e6486d252d6067e6b53503d8ae6ebdb7dd3e8f68edfd7f05aa"

URI_x86_64_v2_mariadb11.8-gssapi-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-gssapi-server-11.8.8-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-gssapi-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8-gssapi-server}"
SRC_URI[x86_64_v2_mariadb11.8-gssapi-server.sha256sum] = "c5c8bf9b3037eed4bc7e1322df2d05d051ce673848e8d60c9ff51471125178a0"

URI_x86_64_v2_mariadb11.8-oqgraph-engine = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-oqgraph-engine-11.8.8-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-oqgraph-engine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8-oqgraph-engine}"
SRC_URI[x86_64_v2_mariadb11.8-oqgraph-engine.sha256sum] = "853688e781256d6a26e0a9ec7f467ee5916a627dfb46fbc72b0932ff5aed24f1"

URI_x86_64_v2_mariadb11.8-pam = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-pam-11.8.8-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8-pam}"
SRC_URI[x86_64_v2_mariadb11.8-pam.sha256sum] = "5526a2b9b56c6600ec99a60f00490ff6d90ec10f03dad771136bc83b8d927041"

URI_x86_64_v2_mariadb11.8-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-server-11.8.8-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8-server}"
SRC_URI[x86_64_v2_mariadb11.8-server.sha256sum] = "dac45bed8beac340c99f5b062f30bf832f447f162ac17ecc315007ba3473ed5e"

URI_x86_64_v2_mariadb11.8-server-galera = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-server-galera-11.8.8-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-server-galera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8-server-galera}"
SRC_URI[x86_64_v2_mariadb11.8-server-galera.sha256sum] = "6db62f194e6877f25d1b65258c0b30629b1ce1fcef324266243206e3030af61f"

URI_x86_64_v2_mariadb11.8-server-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-server-utils-11.8.8-1.el10_2.noarch.rpm;name=x86_64_v2_mariadb11.8-server-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8-server-utils}"
SRC_URI[x86_64_v2_mariadb11.8-server-utils.sha256sum] = "9b959318939709d585735442a771104817080a3fa715a214b85e0185a5e94ac0"

URI_x86_64_v2_mariadb11.8-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-test-11.8.8-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb11.8-test}"
SRC_URI[x86_64_v2_mariadb11.8-test.sha256sum] = "0d5336f75633c3e99ac54fb294be19de6329703e01a6f819ce5aa887eae78992"

URI_aarch64_mariadb11.8 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-11.8.8-1.el10_2.aarch64.rpm;name=aarch64_mariadb11.8;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8}"
SRC_URI[aarch64_mariadb11.8.sha256sum] = "c9456c3b0438fa85430471a8ec0580d64731eb1c9125653f642d34f8926b62e4"
RPROVIDES:mariadb11.8:aarch64 = "virtual//usr/bin/mariadb-dump virtual//usr/bin/mysqldump"

URI_aarch64_mariadb11.8-backup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-backup-11.8.8-1.el10_2.aarch64.rpm;name=aarch64_mariadb11.8-backup;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8-backup}"
SRC_URI[aarch64_mariadb11.8-backup.sha256sum] = "b10c4fa64d2bc25e353bf4741ca0dbfb8ad6784f77d70d9fde4e8f27b7c23387"
RPROVIDES:mariadb11.8-backup:aarch64 = "virtual//usr/bin/mariabackup"

URI_aarch64_mariadb11.8-client-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-client-utils-11.8.8-1.el10_2.noarch.rpm;name=aarch64_mariadb11.8-client-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8-client-utils}"
SRC_URI[aarch64_mariadb11.8-client-utils.sha256sum] = "1b8213a94b5a803fee91159889715d18dce58d1206715acfe2ca987d9c88560c"

URI_aarch64_mariadb11.8-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-common-11.8.8-1.el10_2.noarch.rpm;name=aarch64_mariadb11.8-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8-common}"
SRC_URI[aarch64_mariadb11.8-common.sha256sum] = "bf247857f833df313151be70c72cf6cc08b2708a50410ff68503d30347ea33e0"

URI_aarch64_mariadb11.8-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-devel-11.8.8-1.el10_2.aarch64.rpm;name=aarch64_mariadb11.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8-devel}"
SRC_URI[aarch64_mariadb11.8-devel.sha256sum] = "13a203e1dff43e30a79f3239f2e0c79809a475f93012d934591b45040433c416"

URI_aarch64_mariadb11.8-embedded = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-embedded-11.8.8-1.el10_2.aarch64.rpm;name=aarch64_mariadb11.8-embedded;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8-embedded}"
SRC_URI[aarch64_mariadb11.8-embedded.sha256sum] = "37b6a02c855186a4b1bc97a01645379c8ebcaea412a97eea0de2fa8b6063ffa1"
RPROVIDES:mariadb11.8-embedded:aarch64 = "virtual/libmariadbd.so.19___64bit_"

URI_aarch64_mariadb11.8-embedded-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-embedded-devel-11.8.8-1.el10_2.aarch64.rpm;name=aarch64_mariadb11.8-embedded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8-embedded-devel}"
SRC_URI[aarch64_mariadb11.8-embedded-devel.sha256sum] = "5d65b83b7f9a3ac0f4ea0ff45675bdede1a83ff97fb0b923c332d22d12a2f530"

URI_aarch64_mariadb11.8-errmsg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-errmsg-11.8.8-1.el10_2.noarch.rpm;name=aarch64_mariadb11.8-errmsg;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8-errmsg}"
SRC_URI[aarch64_mariadb11.8-errmsg.sha256sum] = "cedb5ef493d966e6486d252d6067e6b53503d8ae6ebdb7dd3e8f68edfd7f05aa"

URI_aarch64_mariadb11.8-gssapi-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-gssapi-server-11.8.8-1.el10_2.aarch64.rpm;name=aarch64_mariadb11.8-gssapi-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8-gssapi-server}"
SRC_URI[aarch64_mariadb11.8-gssapi-server.sha256sum] = "0a295e317d16f4c781d96a9d1c9864b0d7e602843081c4821632b34902c3c697"

URI_aarch64_mariadb11.8-oqgraph-engine = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-oqgraph-engine-11.8.8-1.el10_2.aarch64.rpm;name=aarch64_mariadb11.8-oqgraph-engine;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8-oqgraph-engine}"
SRC_URI[aarch64_mariadb11.8-oqgraph-engine.sha256sum] = "5189bbdf2fa6a9f1014c2ebec85859cb7f70c62a22e50a8f6c5f9bb77972bc4c"

URI_aarch64_mariadb11.8-pam = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-pam-11.8.8-1.el10_2.aarch64.rpm;name=aarch64_mariadb11.8-pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8-pam}"
SRC_URI[aarch64_mariadb11.8-pam.sha256sum] = "9598009f058648b38edab051972be46b3255b8733bf4b488241f5b91f197ad8b"

URI_aarch64_mariadb11.8-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-server-11.8.8-1.el10_2.aarch64.rpm;name=aarch64_mariadb11.8-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8-server}"
SRC_URI[aarch64_mariadb11.8-server.sha256sum] = "ebb4a9df18427231c591dc7fc409c9ff4991639b76c5da267cf76304612e18db"

URI_aarch64_mariadb11.8-server-galera = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-server-galera-11.8.8-1.el10_2.aarch64.rpm;name=aarch64_mariadb11.8-server-galera;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8-server-galera}"
SRC_URI[aarch64_mariadb11.8-server-galera.sha256sum] = "ebe11487d38248b68bee84d81a49146c927aeebaf95e9fe734a6e8b1a1b852f7"

URI_aarch64_mariadb11.8-server-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-server-utils-11.8.8-1.el10_2.noarch.rpm;name=aarch64_mariadb11.8-server-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8-server-utils}"
SRC_URI[aarch64_mariadb11.8-server-utils.sha256sum] = "9b959318939709d585735442a771104817080a3fa715a214b85e0185a5e94ac0"

URI_aarch64_mariadb11.8-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-test-11.8.8-1.el10_2.aarch64.rpm;name=aarch64_mariadb11.8-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb11.8-test}"
SRC_URI[aarch64_mariadb11.8-test.sha256sum] = "f1592ea34cfe2629497d286fc767059d5a0e1aa6df6753043cea91ed355cc0e8"

RDEPENDS:mariadb11.8 = " \
 bash \
 glibc \
 grep \
 libedit \
 libgcc \
 libstdc++ \
 mariadb-connector-c \
 mariadb11.8-common \
 ncurses-libs \
 openssl-libs \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:mariadb11.8-backup = " \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb11.8-server \
 openssl-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:mariadb11.8-client-utils = " \
 mariadb11.8 \
 perl-DBI \
 perl-Data-Dumper \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-Sys-Hostname \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:mariadb11.8-common = " \
 mariadb-connector-c-config \
 "
RDEPENDS:mariadb11.8-devel = " \
 mariadb-connector-c-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:mariadb11.8-embedded = " \
 glibc \
 libaio \
 libedit \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb11.8-common \
 mariadb11.8-errmsg \
 ncurses-libs \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:mariadb11.8-embedded-devel = " \
 libaio-devel \
 mariadb11.8-devel \
 mariadb11.8-embedded \
 virtual/libmariadbd.so.19___64bit_ \
 "
RDEPENDS:mariadb11.8-errmsg = " \
 mariadb11.8-common \
 "
RDEPENDS:mariadb11.8-gssapi-server = " \
 glibc \
 krb5-libs \
 mariadb11.8-server \
 "
RDEPENDS:mariadb11.8-oqgraph-engine = " \
 Judy \
 glibc \
 libgcc \
 libstdc++ \
 mariadb11.8-server \
 "
RDEPENDS:mariadb11.8-pam = " \
 glibc \
 mariadb11.8-server \
 pam-libs \
 "
RDEPENDS:mariadb11.8-server = " \
 bash \
 bzip2-libs \
 glibc \
 iproute \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 lz4-libs \
 lzo \
 mariadb-connector-c-config \
 mariadb11.8 \
 mariadb11.8-common \
 mariadb11.8-errmsg \
 mysql-selinux \
 openssl-libs \
 shadow-utils \
 snappy \
 systemd \
 systemd-libs \
 virtual/coreutils \
 which \
 zlib-ng-compat \
 "
RDEPENDS:mariadb11.8-server-galera = " \
 bash \
 galera \
 glibc \
 libgcc \
 libselinux-utils \
 libstdc++ \
 lsof \
 mariadb11.8-common \
 mariadb11.8-server \
 policycoreutils \
 policycoreutils-python-utils \
 rsync \
 selinux-policy-targeted \
 "
RDEPENDS:mariadb11.8-server-utils = " \
 mariadb11.8-server \
 perl-DBD-MariaDB \
 perl-DBI \
 perl-File-Path \
 perl-Getopt-Long \
 perl-POSIX \
 perl-interpreter \
 "
RDEPENDS:mariadb11.8-test = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb11.8 \
 mariadb11.8-common \
 mariadb11.8-server \
 openssl-libs \
 pam-libs \
 patch \
 perl-Carp \
 perl-Data-Dumper \
 perl-English \
 perl-Env \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-Memoize \
 perl-Net-SSLeay \
 perl-POSIX \
 perl-PathTools \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Test-Simple \
 perl-Text-Tabs+Wrap \
 perl-Time \
 perl-Time-HiRes \
 perl-autodie \
 perl-base \
 perl-constant \
 perl-if \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 perl-threads \
 perl-threads-shared \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/mariabackup rpm/virtual//usr/bin/mariadb-dump rpm/virtual//usr/bin/mysqldump rpm/virtual/libmariadbd.so.19___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/mariabackup rpm/virtual//usr/bin/mariadb-dump rpm/virtual//usr/bin/mysqldump rpm/virtual/libmariadbd.so.19___64bit_"
