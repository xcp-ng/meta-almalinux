# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-gunicorn"
PV = "23.0.0"
PR = "1.el10_0"
PACKAGES = " \
 python-gunicorn-doc \
 python3-gunicorn \
 python3-gunicorn+gevent \
 python3-gunicorn+setproctitle \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-gunicorn-23.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cfcff9475a8976be7d5f29768fb46358e17979b03313c2290122d8e8b8bf18ac"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-gunicorn-doc-23.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-gunicorn-doc;unpack=0"
SRC_URI[x86_64_v2_python-gunicorn-doc.sha256sum] = "eb6986ecc90d9cf0a43671d257e2ff8437196e755e6c62bbe57c4190e06ee7e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gunicorn-23.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gunicorn;unpack=0"
SRC_URI[x86_64_v2_python3-gunicorn.sha256sum] = "c93bc4a954c22ce80092ea0a13ae25f8fac58ee776f94d172ae8c1dc3884ca8d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gunicorn+gevent-23.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gunicorn+gevent;unpack=0"
SRC_URI[x86_64_v2_python3-gunicorn+gevent.sha256sum] = "c07d902c58e1931b072e40844afcf1011401c2a15eb73c1a33743e0e433ee839"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gunicorn+setproctitle-23.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gunicorn+setproctitle;unpack=0"
SRC_URI[x86_64_v2_python3-gunicorn+setproctitle.sha256sum] = "f14b083d84910c67cb129f28fe422a3896a7f022f86c822f8b173e796ab8d3b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-gunicorn-doc-23.0.0-1.el10_0.noarch.rpm;name=aarch64_python-gunicorn-doc;unpack=0"
SRC_URI[aarch64_python-gunicorn-doc.sha256sum] = "5d096123ceaf184bfab1bd7f645db3fe04155b7358eb0dfd4bfb636c14955521"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-gunicorn-23.0.0-1.el10_0.noarch.rpm;name=aarch64_python3-gunicorn;unpack=0"
SRC_URI[aarch64_python3-gunicorn.sha256sum] = "32baaebd82f275028778f5969f04df0d7a10f342207c2798d846de790ba90828"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-gunicorn+gevent-23.0.0-1.el10_0.noarch.rpm;name=aarch64_python3-gunicorn+gevent;unpack=0"
SRC_URI[aarch64_python3-gunicorn+gevent.sha256sum] = "13c26e4e8a2d7d10f3416e9854e66373d87f7d9bbb7b7454657c7bd4078e3f34"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-gunicorn+setproctitle-23.0.0-1.el10_0.noarch.rpm;name=aarch64_python3-gunicorn+setproctitle;unpack=0"
SRC_URI[aarch64_python3-gunicorn+setproctitle.sha256sum] = "46858f6cf4692cc95369bcd5d2050fc0a2b555718dfa7b352ab1c5723f555c1e"

RDEPENDS:python-gunicorn-doc = " \
 "
RDEPENDS:python3-gunicorn = " \
 python3 \
 python3-packaging \
 "
RDEPENDS:python3-gunicorn+gevent = " \
 python3 \
 python3-gevent \
 python3-gunicorn \
 "
RDEPENDS:python3-gunicorn+setproctitle = " \
 python3 \
 python3-gunicorn \
 python3-setproctitle \
 "
