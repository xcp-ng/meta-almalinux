# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nmstate"
PV = "2.2.62"
PR = "1.el10"
PACKAGES = " \
 nmstate \
 nmstate-devel \
 nmstate-libs \
 nmstate-static \
 python3-libnmstate \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nmstate-2.2.62-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cedbf7bd1f028eb807711a88ff09bc2df863f95d8794c237362bd4435a13b484"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nmstate-2.2.62-1.el10.x86_64_v2.rpm;name=x86_64_v2_nmstate;unpack=0"
SRC_URI[x86_64_v2_nmstate.sha256sum] = "6236d727c6fa9c32a6a9fd07dca1b29d73a58b54414539f1fd2ce3ede552eca1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nmstate-devel-2.2.62-1.el10.x86_64_v2.rpm;name=x86_64_v2_nmstate-devel;unpack=0"
SRC_URI[x86_64_v2_nmstate-devel.sha256sum] = "8581bffa4b150907d8e977b94e357375e10f18849032c6a691d425f0f818c1c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nmstate-libs-2.2.62-1.el10.x86_64_v2.rpm;name=x86_64_v2_nmstate-libs;unpack=0"
SRC_URI[x86_64_v2_nmstate-libs.sha256sum] = "908d8eb55eac9e0d1fe02500c4c0b8e6c970dfab2bb3257ff72a315d9c479cb0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nmstate-static-2.2.62-1.el10.x86_64_v2.rpm;name=x86_64_v2_nmstate-static;unpack=0"
SRC_URI[x86_64_v2_nmstate-static.sha256sum] = "2b4e4c9fb5b467eee6dc25520a7aa7a759f1890732420f38f0fd1f72ad929a4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnmstate-2.2.62-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libnmstate;unpack=0"
SRC_URI[x86_64_v2_python3-libnmstate.sha256sum] = "b125ad1d1edcd4707cc525c2fac6f6186e135faa9d5b31c8e0b2a4d027d49f55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nmstate-2.2.62-1.el10.aarch64.rpm;name=aarch64_nmstate;unpack=0"
SRC_URI[aarch64_nmstate.sha256sum] = "c425711bc7b851c2ab3f84a2c7dfafaac341f5dc9b1742273328e70314e09144"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nmstate-devel-2.2.62-1.el10.aarch64.rpm;name=aarch64_nmstate-devel;unpack=0"
SRC_URI[aarch64_nmstate-devel.sha256sum] = "1c0e4c471b347a4a93d8ce6dfbf4fd2f10bada74eb52d62f6af276f573acee79"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nmstate-libs-2.2.62-1.el10.aarch64.rpm;name=aarch64_nmstate-libs;unpack=0"
SRC_URI[aarch64_nmstate-libs.sha256sum] = "0c41f39328c16ef413a7da2cecc79488ead47482c5625e4eae0be63ef1c895ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nmstate-static-2.2.62-1.el10.aarch64.rpm;name=aarch64_nmstate-static;unpack=0"
SRC_URI[aarch64_nmstate-static.sha256sum] = "e0ceabe941faf2479c4ad4c5ba4b67471531f91c77167140591bf8f1cc92861c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnmstate-2.2.62-1.el10.aarch64.rpm;name=aarch64_python3-libnmstate;unpack=0"
SRC_URI[aarch64_python3-libnmstate.sha256sum] = "b6c18782fb996218d52c2335e632b8e3d0eed2a828a6f53c8baff3a68c3a45c2"

RDEPENDS:nmstate = " \
 glibc \
 libgcc \
 nmstate-libs \
 "
RDEPENDS:nmstate-devel = " \
 nmstate-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:nmstate-libs = " \
 glibc \
 libgcc \
 "
RDEPENDS:nmstate-static = " \
 nmstate-devel \
 "
RDEPENDS:python3-libnmstate = " \
 nmstate-libs \
 python3 \
 python3-pyyaml \
 "
