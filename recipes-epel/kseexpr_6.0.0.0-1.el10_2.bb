# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kseexpr"
PV = "6.0.0.0"
PR = "1.el10_2"
PACKAGES = " \
 kseexpr \
 kseexpr-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kseexpr-6.0.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0526bdb2c13053912e2897ed8ea4cf9157884e17fd10aab5db51f9a054c4f4ef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kseexpr-6.0.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kseexpr;unpack=0"
SRC_URI[x86_64_v2_kseexpr.sha256sum] = "eb911cddb73048cecba770847c88519c8a708a0b1fab3f6cefe0638d2d4f9ee6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kseexpr-devel-6.0.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kseexpr-devel;unpack=0"
SRC_URI[x86_64_v2_kseexpr-devel.sha256sum] = "90a7680147b1a71822311b964cf976f66e3d45e4b6a02ccbbe556c0b8c822cf8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kseexpr-6.0.0.0-1.el10_2.aarch64.rpm;name=aarch64_kseexpr;unpack=0"
SRC_URI[aarch64_kseexpr.sha256sum] = "8a8708e37bd30e1ad0f83c8d03971f2058c27d73727516115d6ddbb784b1eb31"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kseexpr-devel-6.0.0.0-1.el10_2.aarch64.rpm;name=aarch64_kseexpr-devel;unpack=0"
SRC_URI[aarch64_kseexpr-devel.sha256sum] = "1f69aad54f34f2e313f889d7d6ad60f975926ff7cc2859a8c94f8d3f4102ac36"

RDEPENDS:kseexpr = " \
 glibc \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kseexpr-devel = " \
 cmake-filesystem \
 kseexpr \
 pkgconf-pkg-config \
 "
