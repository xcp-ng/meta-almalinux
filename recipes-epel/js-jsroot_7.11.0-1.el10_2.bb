# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "js-jsroot"
PV = "7.11.0"
PR = "1.el10_2"
PACKAGES = " \
 js-jsroot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/js-jsroot-7.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a47da8984d59cfa8f556f1fd9a7c557db9cc53bb8d957d0569bf1c8ef75e3d55"

URI_x86_64_v2_js-jsroot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/js-jsroot-7.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_js-jsroot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_js-jsroot}"
SRC_URI[x86_64_v2_js-jsroot.sha256sum] = "4daea5f31d15d6d67bcdb55dad911ae6b70cd932be663ad67044be96131cb4db"

URI_aarch64_js-jsroot = "${EPEL_MIRROR}/aarch64/Packages/j/js-jsroot-7.11.0-1.el10_2.noarch.rpm;name=aarch64_js-jsroot;unpack=0"
SRC_URI:append = " ${URI_aarch64_js-jsroot}"
SRC_URI[aarch64_js-jsroot.sha256sum] = "2849ec45d5239426ab7b42fd265be06a26a358e4a3ff045de68bd34a66bcb69e"

RDEPENDS:js-jsroot = " \
 mathjax3 \
 web-assets-filesystem \
 "
