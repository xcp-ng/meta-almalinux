# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc9.12"
PV = "9.12.3"
PR = "13.el10_2"
PACKAGES:x86_64_v2 = " \
 ghc9.12 \
 ghc9.12-Cabal \
 ghc9.12-Cabal-devel \
 ghc9.12-Cabal-doc \
 ghc9.12-Cabal-syntax \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-Cabal-syntax-doc \
 ghc9.12-array \
 ghc9.12-array-devel \
 ghc9.12-array-doc \
 ghc9.12-base \
 ghc9.12-base-devel \
 ghc9.12-base-doc \
 ghc9.12-binary \
 ghc9.12-binary-devel \
 ghc9.12-binary-doc \
 ghc9.12-bytestring \
 ghc9.12-bytestring-devel \
 ghc9.12-bytestring-doc \
 ghc9.12-compiler \
 ghc9.12-compiler-default \
 ghc9.12-containers \
 ghc9.12-containers-devel \
 ghc9.12-containers-doc \
 ghc9.12-deepseq \
 ghc9.12-deepseq-devel \
 ghc9.12-deepseq-doc \
 ghc9.12-devel \
 ghc9.12-directory \
 ghc9.12-directory-devel \
 ghc9.12-directory-doc \
 ghc9.12-doc \
 ghc9.12-doc-index \
 ghc9.12-exceptions \
 ghc9.12-exceptions-devel \
 ghc9.12-exceptions-doc \
 ghc9.12-file-io \
 ghc9.12-file-io-devel \
 ghc9.12-file-io-doc \
 ghc9.12-filepath \
 ghc9.12-filepath-devel \
 ghc9.12-filepath-doc \
 ghc9.12-filesystem \
 ghc9.12-ghc \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-bignum-devel \
 ghc9.12-ghc-bignum-doc \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-doc \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-boot-th-doc \
 ghc9.12-ghc-compact \
 ghc9.12-ghc-compact-devel \
 ghc9.12-ghc-compact-doc \
 ghc9.12-ghc-devel \
 ghc9.12-ghc-doc \
 ghc9.12-ghc-experimental \
 ghc9.12-ghc-experimental-devel \
 ghc9.12-ghc-experimental-doc \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghc-heap-doc \
 ghc9.12-ghc-platform \
 ghc9.12-ghc-platform-devel \
 ghc9.12-ghc-platform-doc \
 ghc9.12-ghc-toolchain \
 ghc9.12-ghc-toolchain-devel \
 ghc9.12-ghc-toolchain-doc \
 ghc9.12-ghci \
 ghc9.12-ghci-devel \
 ghc9.12-ghci-doc \
 ghc9.12-haddock-api \
 ghc9.12-haddock-api-devel \
 ghc9.12-haddock-api-doc \
 ghc9.12-haddock-library \
 ghc9.12-haddock-library-devel \
 ghc9.12-haddock-library-doc \
 ghc9.12-hadrian \
 ghc9.12-haskeline \
 ghc9.12-haskeline-devel \
 ghc9.12-haskeline-doc \
 ghc9.12-hpc \
 ghc9.12-hpc-devel \
 ghc9.12-hpc-doc \
 ghc9.12-manual \
 ghc9.12-mtl \
 ghc9.12-mtl-devel \
 ghc9.12-mtl-doc \
 ghc9.12-os-string \
 ghc9.12-os-string-devel \
 ghc9.12-os-string-doc \
 ghc9.12-parsec \
 ghc9.12-parsec-devel \
 ghc9.12-parsec-doc \
 ghc9.12-pretty \
 ghc9.12-pretty-devel \
 ghc9.12-pretty-doc \
 ghc9.12-process \
 ghc9.12-process-devel \
 ghc9.12-process-doc \
 ghc9.12-semaphore-compat \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-semaphore-compat-doc \
 ghc9.12-stm \
 ghc9.12-stm-devel \
 ghc9.12-stm-doc \
 ghc9.12-template-haskell \
 ghc9.12-template-haskell-devel \
 ghc9.12-template-haskell-doc \
 ghc9.12-terminfo \
 ghc9.12-terminfo-devel \
 ghc9.12-terminfo-doc \
 ghc9.12-text \
 ghc9.12-text-devel \
 ghc9.12-text-doc \
 ghc9.12-time \
 ghc9.12-time-devel \
 ghc9.12-time-doc \
 ghc9.12-transformers \
 ghc9.12-transformers-devel \
 ghc9.12-transformers-doc \
 ghc9.12-unix \
 ghc9.12-unix-devel \
 ghc9.12-unix-doc \
 ghc9.12-xhtml \
 ghc9.12-xhtml-devel \
 ghc9.12-xhtml-doc \
"
PACKAGES:aarch64 = " \
 ghc9.12 \
 ghc9.12-Cabal \
 ghc9.12-Cabal-devel \
 ghc9.12-Cabal-doc \
 ghc9.12-Cabal-prof \
 ghc9.12-Cabal-syntax \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-Cabal-syntax-doc \
 ghc9.12-Cabal-syntax-prof \
 ghc9.12-array \
 ghc9.12-array-devel \
 ghc9.12-array-doc \
 ghc9.12-array-prof \
 ghc9.12-base \
 ghc9.12-base-devel \
 ghc9.12-base-doc \
 ghc9.12-base-prof \
 ghc9.12-binary \
 ghc9.12-binary-devel \
 ghc9.12-binary-doc \
 ghc9.12-binary-prof \
 ghc9.12-bytestring \
 ghc9.12-bytestring-devel \
 ghc9.12-bytestring-doc \
 ghc9.12-bytestring-prof \
 ghc9.12-compiler \
 ghc9.12-compiler-default \
 ghc9.12-containers \
 ghc9.12-containers-devel \
 ghc9.12-containers-doc \
 ghc9.12-containers-prof \
 ghc9.12-deepseq \
 ghc9.12-deepseq-devel \
 ghc9.12-deepseq-doc \
 ghc9.12-deepseq-prof \
 ghc9.12-devel \
 ghc9.12-directory \
 ghc9.12-directory-devel \
 ghc9.12-directory-doc \
 ghc9.12-directory-prof \
 ghc9.12-doc \
 ghc9.12-doc-index \
 ghc9.12-exceptions \
 ghc9.12-exceptions-devel \
 ghc9.12-exceptions-doc \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io \
 ghc9.12-file-io-devel \
 ghc9.12-file-io-doc \
 ghc9.12-file-io-prof \
 ghc9.12-filepath \
 ghc9.12-filepath-devel \
 ghc9.12-filepath-doc \
 ghc9.12-filepath-prof \
 ghc9.12-filesystem \
 ghc9.12-ghc \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-bignum-devel \
 ghc9.12-ghc-bignum-doc \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-doc \
 ghc9.12-ghc-boot-prof \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-boot-th-doc \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-compact \
 ghc9.12-ghc-compact-devel \
 ghc9.12-ghc-compact-doc \
 ghc9.12-ghc-compact-prof \
 ghc9.12-ghc-devel \
 ghc9.12-ghc-doc \
 ghc9.12-ghc-experimental \
 ghc9.12-ghc-experimental-devel \
 ghc9.12-ghc-experimental-doc \
 ghc9.12-ghc-experimental-prof \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghc-heap-doc \
 ghc9.12-ghc-heap-prof \
 ghc9.12-ghc-platform \
 ghc9.12-ghc-platform-devel \
 ghc9.12-ghc-platform-doc \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghc-prof \
 ghc9.12-ghc-toolchain \
 ghc9.12-ghc-toolchain-devel \
 ghc9.12-ghc-toolchain-doc \
 ghc9.12-ghc-toolchain-prof \
 ghc9.12-ghci \
 ghc9.12-ghci-devel \
 ghc9.12-ghci-doc \
 ghc9.12-ghci-prof \
 ghc9.12-haddock-api \
 ghc9.12-haddock-api-devel \
 ghc9.12-haddock-api-doc \
 ghc9.12-haddock-api-prof \
 ghc9.12-haddock-library \
 ghc9.12-haddock-library-devel \
 ghc9.12-haddock-library-doc \
 ghc9.12-haddock-library-prof \
 ghc9.12-hadrian \
 ghc9.12-haskeline \
 ghc9.12-haskeline-devel \
 ghc9.12-haskeline-doc \
 ghc9.12-haskeline-prof \
 ghc9.12-hpc \
 ghc9.12-hpc-devel \
 ghc9.12-hpc-doc \
 ghc9.12-hpc-prof \
 ghc9.12-manual \
 ghc9.12-mtl \
 ghc9.12-mtl-devel \
 ghc9.12-mtl-doc \
 ghc9.12-mtl-prof \
 ghc9.12-os-string \
 ghc9.12-os-string-devel \
 ghc9.12-os-string-doc \
 ghc9.12-os-string-prof \
 ghc9.12-parsec \
 ghc9.12-parsec-devel \
 ghc9.12-parsec-doc \
 ghc9.12-parsec-prof \
 ghc9.12-pretty \
 ghc9.12-pretty-devel \
 ghc9.12-pretty-doc \
 ghc9.12-pretty-prof \
 ghc9.12-process \
 ghc9.12-process-devel \
 ghc9.12-process-doc \
 ghc9.12-process-prof \
 ghc9.12-prof \
 ghc9.12-semaphore-compat \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-semaphore-compat-doc \
 ghc9.12-semaphore-compat-prof \
 ghc9.12-stm \
 ghc9.12-stm-devel \
 ghc9.12-stm-doc \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell \
 ghc9.12-template-haskell-devel \
 ghc9.12-template-haskell-doc \
 ghc9.12-template-haskell-prof \
 ghc9.12-terminfo \
 ghc9.12-terminfo-devel \
 ghc9.12-terminfo-doc \
 ghc9.12-terminfo-prof \
 ghc9.12-text \
 ghc9.12-text-devel \
 ghc9.12-text-doc \
 ghc9.12-text-prof \
 ghc9.12-time \
 ghc9.12-time-devel \
 ghc9.12-time-doc \
 ghc9.12-time-prof \
 ghc9.12-transformers \
 ghc9.12-transformers-devel \
 ghc9.12-transformers-doc \
 ghc9.12-transformers-prof \
 ghc9.12-unix \
 ghc9.12-unix-devel \
 ghc9.12-unix-doc \
 ghc9.12-unix-prof \
 ghc9.12-xhtml \
 ghc9.12-xhtml-devel \
 ghc9.12-xhtml-doc \
 ghc9.12-xhtml-prof \
"

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc9.12-9.12.3-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2acb9bd4f672136f9d35bc666c94cc867937b84a6c129a59a84bcb1b603a17e6"

URI_x86_64_v2_ghc9.12 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12}"
SRC_URI[x86_64_v2_ghc9.12.sha256sum] = "b3ad3a2a086f5cdac0c212c388335f149cac6b0ab4236ec5087fe0b8d90e4e73"

URI_x86_64_v2_ghc9.12-Cabal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-3.14.2.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-Cabal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal}"
SRC_URI[x86_64_v2_ghc9.12-Cabal.sha256sum] = "309028762bd3135f9c76769d6ff95346278d2256b53a0bbfba0f35070386e91b"

URI_x86_64_v2_ghc9.12-Cabal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-devel-3.14.2.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-devel}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-devel.sha256sum] = "ed4a558ba2fee6526e16e089c96e6b38397fda040119f8924e941d95ff697ec9"

URI_x86_64_v2_ghc9.12-Cabal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-doc-3.14.2.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-doc}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-doc.sha256sum] = "733346e21063b11d7d7c0c94fd049ccbcca291f89e6fa573df3a2798d30dc5c5"

URI_x86_64_v2_ghc9.12-Cabal-syntax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-syntax-3.14.2.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-syntax}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-syntax.sha256sum] = "5ff0ce4c3f02313f009d9fb7883131eabea3490320951e090c4199815d632555"

URI_x86_64_v2_ghc9.12-Cabal-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-syntax-devel-3.14.2.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-syntax-devel}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-syntax-devel.sha256sum] = "7bda0c0c809ec7ab5cfd37f9337b19767f1ed68a0a98646a7c2e10c552b6f1ab"

URI_x86_64_v2_ghc9.12-Cabal-syntax-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-syntax-doc-3.14.2.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-syntax-doc}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-syntax-doc.sha256sum] = "8a6842f882e4578b2d6b8020a15946ddd9eda8d411ada3a58f8e957e01683640"

URI_x86_64_v2_ghc9.12-array = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-array-0.5.8.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-array}"
SRC_URI[x86_64_v2_ghc9.12-array.sha256sum] = "cf64504ca3d1cb0c01d5cce8e10a03e4fc8129dbbf2f923e92fca8e5bccee429"

URI_x86_64_v2_ghc9.12-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-array-devel-0.5.8.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-array-devel}"
SRC_URI[x86_64_v2_ghc9.12-array-devel.sha256sum] = "461a0a8df1bbdc3ee62a3f238d922a5672874c08c486a28a9b0c83447cc70c7f"

URI_x86_64_v2_ghc9.12-array-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-array-doc-0.5.8.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-array-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-array-doc}"
SRC_URI[x86_64_v2_ghc9.12-array-doc.sha256sum] = "3dc7a4b31295bbbf167d95560042d70e85f9e940db4bd3696aaca9730e8a5014"

URI_x86_64_v2_ghc9.12-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-base-4.21.1.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-base}"
SRC_URI[x86_64_v2_ghc9.12-base.sha256sum] = "226176308c239bba53eae7873e06acc6128256fc27049ee1c6b9d55c320c11c1"

URI_x86_64_v2_ghc9.12-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-base-devel-4.21.1.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-base-devel}"
SRC_URI[x86_64_v2_ghc9.12-base-devel.sha256sum] = "97d9c988892e5196cb5cda647db8f6d7e63054249de6d4aa215bef8941ce1b28"

URI_x86_64_v2_ghc9.12-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-base-doc-4.21.1.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-base-doc}"
SRC_URI[x86_64_v2_ghc9.12-base-doc.sha256sum] = "9d225eec64c676683c25a5d4208f7ef573e2cf8cd995e173fd56ab98c7e7d103"

URI_x86_64_v2_ghc9.12-binary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-binary-0.8.9.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-binary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-binary}"
SRC_URI[x86_64_v2_ghc9.12-binary.sha256sum] = "97a8edc4a360cf67e22398fcd16521c91dc65b4b511a0baaa56a5c7115d57219"

URI_x86_64_v2_ghc9.12-binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-binary-devel-0.8.9.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-binary-devel}"
SRC_URI[x86_64_v2_ghc9.12-binary-devel.sha256sum] = "1c0e55deb6f6361b14d0914ece4dc34daafec5b77ad2f92dc7befc41b4e6be16"

URI_x86_64_v2_ghc9.12-binary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-binary-doc-0.8.9.3-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-binary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-binary-doc}"
SRC_URI[x86_64_v2_ghc9.12-binary-doc.sha256sum] = "af40113c5b836d64d352e539d567bff0a3d5ea78deaec4d21827c0203c85ac30"

URI_x86_64_v2_ghc9.12-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-bytestring-0.12.2.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-bytestring}"
SRC_URI[x86_64_v2_ghc9.12-bytestring.sha256sum] = "615729fa200d4a5ef978dcc875440bf0bbc351b0b572b0af729bc4457a32e84d"

URI_x86_64_v2_ghc9.12-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-bytestring-devel-0.12.2.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-bytestring-devel}"
SRC_URI[x86_64_v2_ghc9.12-bytestring-devel.sha256sum] = "9207ecf3238a2739beb6b5483a2cb8ed78ff4b8f8e7f6876acc99231ffc4035c"

URI_x86_64_v2_ghc9.12-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-bytestring-doc-0.12.2.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-bytestring-doc}"
SRC_URI[x86_64_v2_ghc9.12-bytestring-doc.sha256sum] = "efa53785ca6996342a87d88408a6f60c93184b51651761f6c703fbcc9f3279d2"

URI_x86_64_v2_ghc9.12-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-compiler-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-compiler}"
SRC_URI[x86_64_v2_ghc9.12-compiler.sha256sum] = "8d2b67d08031e9e71bb3bf180ce481c1fd7ce9bea00d1ce8b7c9ac24415f3300"

URI_x86_64_v2_ghc9.12-compiler-default = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-compiler-default-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-compiler-default;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-compiler-default}"
SRC_URI[x86_64_v2_ghc9.12-compiler-default.sha256sum] = "a9554a4f1475fa0e8eeddd897662731103c6082bce2752017b118d24ac770942"

URI_x86_64_v2_ghc9.12-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-containers-0.7-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-containers}"
SRC_URI[x86_64_v2_ghc9.12-containers.sha256sum] = "98dbd2310ea5b4fc807ac0e6c59322caff35f679efe90d1e32ff86b0e23f1f04"

URI_x86_64_v2_ghc9.12-containers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-containers-devel-0.7-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-containers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-containers-devel}"
SRC_URI[x86_64_v2_ghc9.12-containers-devel.sha256sum] = "d7f6f8037a9d73d601fecd4224ae8aee6af952540113267081f168fe014713cd"

URI_x86_64_v2_ghc9.12-containers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-containers-doc-0.7-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-containers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-containers-doc}"
SRC_URI[x86_64_v2_ghc9.12-containers-doc.sha256sum] = "4f3aac253c3c843f1dacd4c9f42b86bed9d5237bf2f48864a578013d7466f4f1"

URI_x86_64_v2_ghc9.12-deepseq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-deepseq-1.5.1.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-deepseq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-deepseq}"
SRC_URI[x86_64_v2_ghc9.12-deepseq.sha256sum] = "b511a5c05446f8725651c0e58380693d9257daa417661fd5b0343f0818cb7063"

URI_x86_64_v2_ghc9.12-deepseq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-deepseq-devel-1.5.1.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-deepseq-devel}"
SRC_URI[x86_64_v2_ghc9.12-deepseq-devel.sha256sum] = "fde7a7d3ca46a83500bc9c2754d017ef2ce371185d68a65c5358ea69374e22b0"

URI_x86_64_v2_ghc9.12-deepseq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-deepseq-doc-1.5.1.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-deepseq-doc}"
SRC_URI[x86_64_v2_ghc9.12-deepseq-doc.sha256sum] = "dca8b1fa6239b2013efad1ab2cdd8be0526bdcd705ea59ec7b92a339913f34b7"

URI_x86_64_v2_ghc9.12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-devel-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-devel}"
SRC_URI[x86_64_v2_ghc9.12-devel.sha256sum] = "179762e19074c284bc05e7b67568738a749a873c5df97226bfc821de67706366"

URI_x86_64_v2_ghc9.12-directory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-directory-1.3.9.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-directory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-directory}"
SRC_URI[x86_64_v2_ghc9.12-directory.sha256sum] = "b443fe1b5c6e5b76946dcc45cae4701b36f79a2915ce025a2cab9ef051e4dfe8"

URI_x86_64_v2_ghc9.12-directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-directory-devel-1.3.9.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-directory-devel}"
SRC_URI[x86_64_v2_ghc9.12-directory-devel.sha256sum] = "c1e12366992b8eaf9119a0d0831769d138efe69d597a798f25c4bceba930ee54"

URI_x86_64_v2_ghc9.12-directory-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-directory-doc-1.3.9.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-directory-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-directory-doc}"
SRC_URI[x86_64_v2_ghc9.12-directory-doc.sha256sum] = "80229183f3ddddd34e78378efcd2af26ef370939c9a17458420d5118ca708e4f"

URI_x86_64_v2_ghc9.12-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-doc-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-doc}"
SRC_URI[x86_64_v2_ghc9.12-doc.sha256sum] = "752963c9538702db6234eb2373df90dad6de90d8ae26abee91758108800fdf4c"

URI_x86_64_v2_ghc9.12-doc-index = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-doc-index-9.12.3-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-doc-index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-doc-index}"
SRC_URI[x86_64_v2_ghc9.12-doc-index.sha256sum] = "030daf0ed4340e4028a829db3998bae6fcaf9c0352cbbbd931777f233195b9c2"

URI_x86_64_v2_ghc9.12-exceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-exceptions-0.10.10-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-exceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-exceptions}"
SRC_URI[x86_64_v2_ghc9.12-exceptions.sha256sum] = "06b457a0a7042419108a460d5f39f8b5486a4ad124d75732bd5725e2391cd7d5"

URI_x86_64_v2_ghc9.12-exceptions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-exceptions-devel-0.10.10-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-exceptions-devel}"
SRC_URI[x86_64_v2_ghc9.12-exceptions-devel.sha256sum] = "d065f56004e10b643f2c97ac462f20bb5fae049116be3a2935325e9fbf5a40a0"

URI_x86_64_v2_ghc9.12-exceptions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-exceptions-doc-0.10.10-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-exceptions-doc}"
SRC_URI[x86_64_v2_ghc9.12-exceptions-doc.sha256sum] = "17de0754b6c2cc059610798abc792b2fb70b19595f2bbd5ef8c1c9b19d1e99cc"

URI_x86_64_v2_ghc9.12-file-io = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-file-io-0.1.5-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-file-io;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-file-io}"
SRC_URI[x86_64_v2_ghc9.12-file-io.sha256sum] = "eda1facba3ff15aecdf9291327e433406cec553c51a83a3fcc28adf989562b03"

URI_x86_64_v2_ghc9.12-file-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-file-io-devel-0.1.5-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-file-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-file-io-devel}"
SRC_URI[x86_64_v2_ghc9.12-file-io-devel.sha256sum] = "ba91d850e927063b16d21b03fca88ea1b015aa9fb7a348289a971ff7d692b43e"

URI_x86_64_v2_ghc9.12-file-io-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-file-io-doc-0.1.5-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-file-io-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-file-io-doc}"
SRC_URI[x86_64_v2_ghc9.12-file-io-doc.sha256sum] = "8459580bc3793ac2842d00ebb55c4e6ada157ad9c322b92091e4a810ebd5e2fb"

URI_x86_64_v2_ghc9.12-filepath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-filepath-1.5.4.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-filepath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-filepath}"
SRC_URI[x86_64_v2_ghc9.12-filepath.sha256sum] = "30cbdf3171e843adac55f0edb05daf9417840a197c9858d18ec9f1a299e5f658"

URI_x86_64_v2_ghc9.12-filepath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-filepath-devel-1.5.4.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-filepath-devel}"
SRC_URI[x86_64_v2_ghc9.12-filepath-devel.sha256sum] = "292c120838eb0be42ce8d8458ade2e3720d912de1f0eee31b5c32fa65de151f7"

URI_x86_64_v2_ghc9.12-filepath-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-filepath-doc-1.5.4.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-filepath-doc}"
SRC_URI[x86_64_v2_ghc9.12-filepath-doc.sha256sum] = "cd1a56d651e0a35814157fd9c718671a505f009f4b0c05f0c970097dd6e31491"

URI_x86_64_v2_ghc9.12-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-filesystem-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-filesystem}"
SRC_URI[x86_64_v2_ghc9.12-filesystem.sha256sum] = "e107dfcaea1ccd366544ea57f56621cebb03510305d4819f13fa4ccab84982db"

URI_x86_64_v2_ghc9.12-ghc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc}"
SRC_URI[x86_64_v2_ghc9.12-ghc.sha256sum] = "5349125bb64b5025d3eb34794f8fe175873e82091b33a9199727a2efc3f466f4"

URI_x86_64_v2_ghc9.12-ghc-bignum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-bignum-1.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-bignum}"
SRC_URI[x86_64_v2_ghc9.12-ghc-bignum.sha256sum] = "aa2252399cf38c239f9e32c8d710d541a2f995d1d8cb58a610a74b3a71f438aa"

URI_x86_64_v2_ghc9.12-ghc-bignum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-bignum-devel-1.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-bignum-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-bignum-devel.sha256sum] = "2b7a62b5ac6fc9cf092e5f1857b783cbd565fbace2cd683b6a293e8530a9e2d7"

URI_x86_64_v2_ghc9.12-ghc-bignum-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-bignum-doc-1.3-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-bignum-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-bignum-doc.sha256sum] = "d5b4f88fb1806b88d145148cc90d66656ab8266048760093b0604cf7ba6aeff9"

URI_x86_64_v2_ghc9.12-ghc-boot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot.sha256sum] = "c24e4429f96e512f4066f7d02ace3276904fdd669c8a92eb5ed927e562c97fc6"

URI_x86_64_v2_ghc9.12-ghc-boot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-devel-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-devel.sha256sum] = "1b9010c18d1e1a8599e8056e7ca4931cf9077e3adc6dd1bb87d03b8b1a554d98"

URI_x86_64_v2_ghc9.12-ghc-boot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-doc-9.12.3-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-doc.sha256sum] = "09b0399ba372925f3252916d629245c4fd22f4ad094714999f8903b88fcec9a9"

URI_x86_64_v2_ghc9.12-ghc-boot-th = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-th-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-th}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-th.sha256sum] = "2418a15e8d16b7789870c020d94add3edd4bb3df42155848f17a2a0485dfc8e4"

URI_x86_64_v2_ghc9.12-ghc-boot-th-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-th-devel-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-th-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-th-devel.sha256sum] = "e93254b34f0dc12e2184da151176accd0d4eb620f086f50ebcae2fce09571dfa"

URI_x86_64_v2_ghc9.12-ghc-boot-th-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-th-doc-9.12.3-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-th-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-th-doc.sha256sum] = "0f9648c545d87bec80a0f9711e398c87c3e2251108558eedcac095b01458e202"

URI_x86_64_v2_ghc9.12-ghc-compact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-compact-0.1.0.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-compact}"
SRC_URI[x86_64_v2_ghc9.12-ghc-compact.sha256sum] = "8a9f982b2b17967b4b8dcdfcfbceaba6c31aa97d8e1388887583ed8077f4abc5"

URI_x86_64_v2_ghc9.12-ghc-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-compact-devel-0.1.0.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-compact-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-compact-devel.sha256sum] = "7a26d77a9dc73969a8f364109149c89e532f88bc36ba65d6af8a26fff7742509"

URI_x86_64_v2_ghc9.12-ghc-compact-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-compact-doc-0.1.0.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-compact-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-compact-doc.sha256sum] = "de7c21b434587e99facd8b0aa73e60dee11234e0fd4ec8759d401eb4a39df3b8"

URI_x86_64_v2_ghc9.12-ghc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-devel-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-devel.sha256sum] = "5db5e61d624784a4fc42153aff569db34431d41d55bc73c79f3bd2a4f4b9c54f"

URI_x86_64_v2_ghc9.12-ghc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-doc-9.12.3-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-doc.sha256sum] = "64e380566449b38b9b18366cdd616720519026264eeefe8db01e1f74a0e7470e"

URI_x86_64_v2_ghc9.12-ghc-experimental = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-experimental-9.1203.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-experimental;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-experimental}"
SRC_URI[x86_64_v2_ghc9.12-ghc-experimental.sha256sum] = "a662edcda7c31800c0c57da2331797c530da175601f400989b86f9c3b8d8d59d"

URI_x86_64_v2_ghc9.12-ghc-experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-experimental-devel-9.1203.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-experimental-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-experimental-devel.sha256sum] = "08427b9c45495f644cbdb665cb888983113f7b688ad661734c5c71696eb042aa"

URI_x86_64_v2_ghc9.12-ghc-experimental-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-experimental-doc-9.1203.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-experimental-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-experimental-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-experimental-doc.sha256sum] = "7ecd2247c3949ce4b202720c8dc40072638577da11ffed2c784a5b6904d5009a"

URI_x86_64_v2_ghc9.12-ghc-heap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-heap-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-heap}"
SRC_URI[x86_64_v2_ghc9.12-ghc-heap.sha256sum] = "ea3c013ec1ae8e032ab9278553d14960d57cdad0008f3e969a9cf301ee7b82e0"

URI_x86_64_v2_ghc9.12-ghc-heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-heap-devel-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-heap-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-heap-devel.sha256sum] = "191f73850c6c606b41757208181f99046cc45101373b86bc68192591db135163"

URI_x86_64_v2_ghc9.12-ghc-heap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-heap-doc-9.12.3-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-heap-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-heap-doc.sha256sum] = "19c9f7eb5779599d582a4c67192e7726fdc6fb7f8cbd662a371db28a3ef58f2b"

URI_x86_64_v2_ghc9.12-ghc-platform = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-platform-0.1.0.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-platform;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-platform}"
SRC_URI[x86_64_v2_ghc9.12-ghc-platform.sha256sum] = "c364be12ea37ab1d89c5fdb3aee3a20258c107bd47051fca27606bf33fdb4be5"

URI_x86_64_v2_ghc9.12-ghc-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-platform-devel-0.1.0.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-platform-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-platform-devel.sha256sum] = "239ee0c4ecf418c18ff55b90e4a7301f1286dcb2ccef0d8ee7ae60779cf56756"

URI_x86_64_v2_ghc9.12-ghc-platform-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-platform-doc-0.1.0.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-platform-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-platform-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-platform-doc.sha256sum] = "5ca6303b9c3f42f34aec1710bd0ecb37ba325ae5b0c6dfcfde536251a78ff3cb"

URI_x86_64_v2_ghc9.12-ghc-toolchain = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-toolchain-0.1.0.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-toolchain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-toolchain}"
SRC_URI[x86_64_v2_ghc9.12-ghc-toolchain.sha256sum] = "256b27608f4017db3cc037aadab1363a8ba295becc385683485209bc7bb2804c"

URI_x86_64_v2_ghc9.12-ghc-toolchain-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-toolchain-devel-0.1.0.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-toolchain-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-toolchain-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-toolchain-devel.sha256sum] = "bcd7e01091a15f9d2c10fcf740d6cc620573900c6b56be0942697336f8819137"

URI_x86_64_v2_ghc9.12-ghc-toolchain-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-toolchain-doc-0.1.0.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-toolchain-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-toolchain-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-toolchain-doc.sha256sum] = "a2ae477d03a071372551a7a4aab7bef6c1146295b017dc1c4eee9495544d30fb"

URI_x86_64_v2_ghc9.12-ghci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghci-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghci}"
SRC_URI[x86_64_v2_ghc9.12-ghci.sha256sum] = "3b400b3b1bb050d3c95c62c11fd4912fb5935995cd25babd8dc8ed873199d2f3"

URI_x86_64_v2_ghc9.12-ghci-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghci-devel-9.12.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghci-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghci-devel.sha256sum] = "62300dbb6664cea23ae7e2cb09b4ac1bf9153cd78e8134f610318366d191a12f"

URI_x86_64_v2_ghc9.12-ghci-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghci-doc-9.12.3-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghci-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghci-doc.sha256sum] = "bc58c45d79fd1c2f4a3e3c7d339e6efeb0b795fb282c222addc36ffda4bff853"

URI_x86_64_v2_ghc9.12-haddock-api = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-api-2.32.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haddock-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-api}"
SRC_URI[x86_64_v2_ghc9.12-haddock-api.sha256sum] = "48517d5c29a6bfeac5b007ebdd01fc66c9f66104a23262a367e9f89eab5225f2"

URI_x86_64_v2_ghc9.12-haddock-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-api-devel-2.32.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haddock-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-api-devel}"
SRC_URI[x86_64_v2_ghc9.12-haddock-api-devel.sha256sum] = "3c3a7b8a0c9e319d146b37051e6ce1b0a83f233c3855fba5b4473f3aa4009f35"

URI_x86_64_v2_ghc9.12-haddock-api-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-api-doc-2.32.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-haddock-api-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-api-doc}"
SRC_URI[x86_64_v2_ghc9.12-haddock-api-doc.sha256sum] = "195d83784f98dd83261f92ec80af2bd2266e7fc0b414b47d56dbfaf66541cc23"

URI_x86_64_v2_ghc9.12-haddock-library = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-library-1.11.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haddock-library;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-library}"
SRC_URI[x86_64_v2_ghc9.12-haddock-library.sha256sum] = "977e6ee6575c9b3585d9d53c5fd67278d61bf2bfcc50cdfafcb3a3538b1219ec"

URI_x86_64_v2_ghc9.12-haddock-library-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-library-devel-1.11.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haddock-library-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-library-devel}"
SRC_URI[x86_64_v2_ghc9.12-haddock-library-devel.sha256sum] = "4d71c5e1eba3eb259c5e928e15d377b6efc8a465256530379756456c4bba61b9"

URI_x86_64_v2_ghc9.12-haddock-library-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-library-doc-1.11.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-haddock-library-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-library-doc}"
SRC_URI[x86_64_v2_ghc9.12-haddock-library-doc.sha256sum] = "71c289216bfc05a67725198e6224b2f049505699e00f0d0c925b8ad8c48b2e26"

URI_x86_64_v2_ghc9.12-hadrian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-hadrian-0.1.0.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-hadrian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-hadrian}"
SRC_URI[x86_64_v2_ghc9.12-hadrian.sha256sum] = "9345277b47315a236c4e7de46d5fdae740a27103ad164319276db4b255faf561"

URI_x86_64_v2_ghc9.12-haskeline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haskeline-0.8.2.1-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haskeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haskeline}"
SRC_URI[x86_64_v2_ghc9.12-haskeline.sha256sum] = "6932c5c2b7b104121285bededf081e2f642eb2fe4d241ee1ccc38b078a78c0a7"

URI_x86_64_v2_ghc9.12-haskeline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haskeline-devel-0.8.2.1-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haskeline-devel}"
SRC_URI[x86_64_v2_ghc9.12-haskeline-devel.sha256sum] = "eaeda877f5461102b3c6fa8558c99be7725105a01c008720a08f1c315ea45923"

URI_x86_64_v2_ghc9.12-haskeline-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haskeline-doc-0.8.2.1-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haskeline-doc}"
SRC_URI[x86_64_v2_ghc9.12-haskeline-doc.sha256sum] = "a54dfbfc8e920a3496a16f40b4a95ebd45f00207fc29a4b4af8c97efb782c018"

URI_x86_64_v2_ghc9.12-hpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-hpc-0.7.0.2-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-hpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-hpc}"
SRC_URI[x86_64_v2_ghc9.12-hpc.sha256sum] = "4e1736915cad58af899efda9e9c6b2aee02959afa97acee97cd542c55bb4c9a8"

URI_x86_64_v2_ghc9.12-hpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-hpc-devel-0.7.0.2-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-hpc-devel}"
SRC_URI[x86_64_v2_ghc9.12-hpc-devel.sha256sum] = "b1ed7ae787297c8e30bf0fa2be14ffeb5c951c459a93de8e5ffc4e673fccf5de"

URI_x86_64_v2_ghc9.12-hpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-hpc-doc-0.7.0.2-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-hpc-doc}"
SRC_URI[x86_64_v2_ghc9.12-hpc-doc.sha256sum] = "9216f6dc2fd9e62e31118abe7f0a1133ce8e3ba5113c4e244226ef5ed04a4d79"

URI_x86_64_v2_ghc9.12-manual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-manual-9.12.3-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-manual}"
SRC_URI[x86_64_v2_ghc9.12-manual.sha256sum] = "af6b2cd28b2d81ddfe7f8c99398012b0d69286115a2a92a4827a73d83bb30bdf"

URI_x86_64_v2_ghc9.12-mtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-mtl-2.3.1-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-mtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-mtl}"
SRC_URI[x86_64_v2_ghc9.12-mtl.sha256sum] = "e3c2639adef28a91e14e9e2b78219d660a53583760f7fd7eb66a25ccfba01cc8"

URI_x86_64_v2_ghc9.12-mtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-mtl-devel-2.3.1-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-mtl-devel}"
SRC_URI[x86_64_v2_ghc9.12-mtl-devel.sha256sum] = "fd85f7145dfe8386088766fb251c28451d6e2799e611b20b5f909ae8a3a154b0"

URI_x86_64_v2_ghc9.12-mtl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-mtl-doc-2.3.1-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-mtl-doc}"
SRC_URI[x86_64_v2_ghc9.12-mtl-doc.sha256sum] = "c3ca829ad04d98d53cc6fafb471c6b18a1c6ac8edc3ffd5a6035f2ae87d5c0d0"

URI_x86_64_v2_ghc9.12-os-string = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-os-string-2.0.8-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-os-string;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-os-string}"
SRC_URI[x86_64_v2_ghc9.12-os-string.sha256sum] = "c2de067c7c065546ee49da753e4b9ce71302b2a021a24bb4566266d2dc23ab55"

URI_x86_64_v2_ghc9.12-os-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-os-string-devel-2.0.8-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-os-string-devel}"
SRC_URI[x86_64_v2_ghc9.12-os-string-devel.sha256sum] = "56a7ad7189acf1f253a586fc299cdcb9a6906b0746a24ed52faea6c3bdbf0eeb"

URI_x86_64_v2_ghc9.12-os-string-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-os-string-doc-2.0.8-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-os-string-doc}"
SRC_URI[x86_64_v2_ghc9.12-os-string-doc.sha256sum] = "84fdd3068ef6c50812085eeff9a9fb3a5b067e6c200133c143fba1808885023c"

URI_x86_64_v2_ghc9.12-parsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-parsec-3.1.18.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-parsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-parsec}"
SRC_URI[x86_64_v2_ghc9.12-parsec.sha256sum] = "9c992d1ffc700a18868c9f64a4b26523d5e5cc4c8021c229afdbb678ea8ce298"

URI_x86_64_v2_ghc9.12-parsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-parsec-devel-3.1.18.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-parsec-devel}"
SRC_URI[x86_64_v2_ghc9.12-parsec-devel.sha256sum] = "8fec796d16daff968727056598d21d886aacca41475ac6d81cc8beaaed4b23e7"

URI_x86_64_v2_ghc9.12-parsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-parsec-doc-3.1.18.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-parsec-doc}"
SRC_URI[x86_64_v2_ghc9.12-parsec-doc.sha256sum] = "450a5d7527b01ee9202ece649790535ac0f821cec1d80c9dc8b36e9dfa3c4a66"

URI_x86_64_v2_ghc9.12-pretty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-pretty-1.1.3.6-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-pretty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-pretty}"
SRC_URI[x86_64_v2_ghc9.12-pretty.sha256sum] = "5048f8bdb30ac0238a964752da19343b9376396a341d7900afe1d8f11ad2e543"

URI_x86_64_v2_ghc9.12-pretty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-pretty-devel-1.1.3.6-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-pretty-devel}"
SRC_URI[x86_64_v2_ghc9.12-pretty-devel.sha256sum] = "82a1f0d62470adb86a160ec40cccdd7157ee64e7674710e87ca064f4191be783"

URI_x86_64_v2_ghc9.12-pretty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-pretty-doc-1.1.3.6-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-pretty-doc}"
SRC_URI[x86_64_v2_ghc9.12-pretty-doc.sha256sum] = "810da43e47015cf33336cf54d46d49c833b66083847a85770c2ff80f66cf604b"

URI_x86_64_v2_ghc9.12-process = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-process-1.6.26.1-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-process}"
SRC_URI[x86_64_v2_ghc9.12-process.sha256sum] = "48c283e61971784b7a34e4c20e5fe69459d9f0575a79dce81d337eba1f740934"

URI_x86_64_v2_ghc9.12-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-process-devel-1.6.26.1-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-process-devel}"
SRC_URI[x86_64_v2_ghc9.12-process-devel.sha256sum] = "9dcf57c3e52f605c8c78f8eba4278cebcf18899a020354915f203c146af6b078"

URI_x86_64_v2_ghc9.12-process-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-process-doc-1.6.26.1-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-process-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-process-doc}"
SRC_URI[x86_64_v2_ghc9.12-process-doc.sha256sum] = "1284500747d82d84177ed5c45d794d141660aa25d98e4c36f6260627e6455e54"

URI_x86_64_v2_ghc9.12-semaphore-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-semaphore-compat-1.0.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-semaphore-compat}"
SRC_URI[x86_64_v2_ghc9.12-semaphore-compat.sha256sum] = "88bff94d8e1bb755eb7dc255af2c325423e0006e069068de980e2b72dec02276"

URI_x86_64_v2_ghc9.12-semaphore-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-semaphore-compat-devel-1.0.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-semaphore-compat-devel}"
SRC_URI[x86_64_v2_ghc9.12-semaphore-compat-devel.sha256sum] = "ec50313b33affe001b768c147b6026c6d911d605dd1789badab57a10f5037a5b"

URI_x86_64_v2_ghc9.12-semaphore-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-semaphore-compat-doc-1.0.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-semaphore-compat-doc}"
SRC_URI[x86_64_v2_ghc9.12-semaphore-compat-doc.sha256sum] = "f44af1500d843064096bdd4bb4e4cc10c1d95022a3a87fab8a80098302b7d26d"

URI_x86_64_v2_ghc9.12-stm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-stm-2.5.3.1-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-stm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-stm}"
SRC_URI[x86_64_v2_ghc9.12-stm.sha256sum] = "4d5535acaa46657001fdf2b79dcfe5e7d0030864dc0b1e78cb98f25adb37c2f5"

URI_x86_64_v2_ghc9.12-stm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-stm-devel-2.5.3.1-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-stm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-stm-devel}"
SRC_URI[x86_64_v2_ghc9.12-stm-devel.sha256sum] = "c71bf5db93dd160afffd53432227cf64a7dac277856e91777299bbebf13435fb"

URI_x86_64_v2_ghc9.12-stm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-stm-doc-2.5.3.1-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-stm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-stm-doc}"
SRC_URI[x86_64_v2_ghc9.12-stm-doc.sha256sum] = "d0df63dda90d7749e68cacf1c1e82929a7134a026b5b519c58fe5c06f517a927"

URI_x86_64_v2_ghc9.12-template-haskell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-template-haskell-2.23.0.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-template-haskell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-template-haskell}"
SRC_URI[x86_64_v2_ghc9.12-template-haskell.sha256sum] = "93b18844973cc7e8809728bf67b652064cc982ede9f220c0c29ee017f4347924"

URI_x86_64_v2_ghc9.12-template-haskell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-template-haskell-devel-2.23.0.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-template-haskell-devel}"
SRC_URI[x86_64_v2_ghc9.12-template-haskell-devel.sha256sum] = "6f66494833c45c181a91649310d72e667225dedd6d8a41fd51103c42d54a9862"

URI_x86_64_v2_ghc9.12-template-haskell-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-template-haskell-doc-2.23.0.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-template-haskell-doc}"
SRC_URI[x86_64_v2_ghc9.12-template-haskell-doc.sha256sum] = "5ce178477751cd4c0a913cddfecbc21cfd6f4cd9ed242a75fc1e260e53f6b00d"

URI_x86_64_v2_ghc9.12-terminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-terminfo-0.4.1.7-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-terminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-terminfo}"
SRC_URI[x86_64_v2_ghc9.12-terminfo.sha256sum] = "3d004761a74e97f6ef53a81ab9885f56f669e1fbb0564800e7d2b2b3c2533089"

URI_x86_64_v2_ghc9.12-terminfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-terminfo-devel-0.4.1.7-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-terminfo-devel}"
SRC_URI[x86_64_v2_ghc9.12-terminfo-devel.sha256sum] = "513eb762afbcff3462fbc80b2413a7cfe1506c507d7432142f36d00625140222"

URI_x86_64_v2_ghc9.12-terminfo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-terminfo-doc-0.4.1.7-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-terminfo-doc}"
SRC_URI[x86_64_v2_ghc9.12-terminfo-doc.sha256sum] = "788f459796baf9f36c4fcb0d59db605d85f8031aeb6361cfa75e367f74dd5eb3"

URI_x86_64_v2_ghc9.12-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-text-2.1.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-text}"
SRC_URI[x86_64_v2_ghc9.12-text.sha256sum] = "e722da112167855f7cad631a78b4c1af6091e328f9e6a05430b87f3271144919"

URI_x86_64_v2_ghc9.12-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-text-devel-2.1.3-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-text-devel}"
SRC_URI[x86_64_v2_ghc9.12-text-devel.sha256sum] = "b353853ccb175e77086849eedcbb4e71955bfadf2a1de20e6fe7fffe6bafa95a"

URI_x86_64_v2_ghc9.12-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-text-doc-2.1.3-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-text-doc}"
SRC_URI[x86_64_v2_ghc9.12-text-doc.sha256sum] = "632c7c9e1850ddae6aa404bf3cce28d29a635132ea8a103c19ea939dea86f20c"

URI_x86_64_v2_ghc9.12-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-time-1.14-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-time}"
SRC_URI[x86_64_v2_ghc9.12-time.sha256sum] = "0ddde4323ff59689f37364ec81aa44086cfacf82c18e4848fecb2c92ae2fb82b"

URI_x86_64_v2_ghc9.12-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-time-devel-1.14-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-time-devel}"
SRC_URI[x86_64_v2_ghc9.12-time-devel.sha256sum] = "d03463cbbf1d1fb0e55179f2a3e7970764ec33b2035969145a47e2f0e29b517f"

URI_x86_64_v2_ghc9.12-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-time-doc-1.14-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-time-doc}"
SRC_URI[x86_64_v2_ghc9.12-time-doc.sha256sum] = "b4da4e84430f853ea0322171eee7d0e730435e2a464d698ece29d7a07c698b40"

URI_x86_64_v2_ghc9.12-transformers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-transformers-0.6.1.2-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-transformers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-transformers}"
SRC_URI[x86_64_v2_ghc9.12-transformers.sha256sum] = "e653667e388e7a614eb9d7985545124306b424e8da5dc7c80c96d5fa025a11bc"

URI_x86_64_v2_ghc9.12-transformers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-transformers-devel-0.6.1.2-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-transformers-devel}"
SRC_URI[x86_64_v2_ghc9.12-transformers-devel.sha256sum] = "09ba654e8a3125b0be7b28b444c3c4f00a7bd2dcc57118f6b3d32990725ef74c"

URI_x86_64_v2_ghc9.12-transformers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-transformers-doc-0.6.1.2-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-transformers-doc}"
SRC_URI[x86_64_v2_ghc9.12-transformers-doc.sha256sum] = "9a6143ffd5dfcc806d0a25eec871341db3ec6ccf2f2b2d5693a974cb78e03dda"

URI_x86_64_v2_ghc9.12-unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-unix-2.8.7.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-unix}"
SRC_URI[x86_64_v2_ghc9.12-unix.sha256sum] = "38b91e3f1bb4bddcaa5557ba38fbaa0a747e98041aeef014d414549115b268cf"

URI_x86_64_v2_ghc9.12-unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-unix-devel-2.8.7.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-unix-devel}"
SRC_URI[x86_64_v2_ghc9.12-unix-devel.sha256sum] = "851d24cb83b21c59e6e60fc8bfa77737f5067c0b9a265878ebaa34d710e342e4"

URI_x86_64_v2_ghc9.12-unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-unix-doc-2.8.7.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-unix-doc}"
SRC_URI[x86_64_v2_ghc9.12-unix-doc.sha256sum] = "6b9d7273aa953c5b00d0b10c627e4df4a9d175856cf881115b5a53bf958cd02e"

URI_x86_64_v2_ghc9.12-xhtml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-xhtml-3000.2.2.1-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-xhtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-xhtml}"
SRC_URI[x86_64_v2_ghc9.12-xhtml.sha256sum] = "53484e3e59f6484929637825f4f9c6a6431c4b851d6eeeeecafdfaf3fe6b7282"

URI_x86_64_v2_ghc9.12-xhtml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-xhtml-devel-3000.2.2.1-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-xhtml-devel}"
SRC_URI[x86_64_v2_ghc9.12-xhtml-devel.sha256sum] = "683c4435fdcbe3269ae11ff7288304dd2b7be26c65d7625f242bfb604d25069c"

URI_x86_64_v2_ghc9.12-xhtml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-xhtml-doc-3000.2.2.1-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-xhtml-doc}"
SRC_URI[x86_64_v2_ghc9.12-xhtml-doc.sha256sum] = "915a748bac6ad3b22fc2d9794e8d07902dd2c7e6bf3919e4068a142ecbcacf66"

URI_aarch64_ghc9.12 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12}"
SRC_URI[aarch64_ghc9.12.sha256sum] = "82b0ca976b3613a79f6f85423877fb7ce6327c98c9944ea99c63fb860100e902"

URI_aarch64_ghc9.12-Cabal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-3.14.2.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-Cabal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal}"
SRC_URI[aarch64_ghc9.12-Cabal.sha256sum] = "6dbc188ee33e8b897e3c70c33ac9549cb5c69a40b310716d066e7870503bade9"

URI_aarch64_ghc9.12-Cabal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-devel-3.14.2.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-devel}"
SRC_URI[aarch64_ghc9.12-Cabal-devel.sha256sum] = "7ba2a8bc1e6687bf6a2cbf03d6c42da4982ee95fede6a36f3327b59afc67da90"

URI_aarch64_ghc9.12-Cabal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-doc-3.14.2.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-doc}"
SRC_URI[aarch64_ghc9.12-Cabal-doc.sha256sum] = "740020912666dbf58be2897340cc51c91349ce25480a2e829ecb282db93f2c1d"

URI_aarch64_ghc9.12-Cabal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-prof-3.14.2.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-prof}"
SRC_URI[aarch64_ghc9.12-Cabal-prof.sha256sum] = "4a8502c4b83a05617ccc79c500600cf43116dcba63e322c919805f6c1bb20199"

URI_aarch64_ghc9.12-Cabal-syntax = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-syntax-3.14.2.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-syntax}"
SRC_URI[aarch64_ghc9.12-Cabal-syntax.sha256sum] = "079cd9bcf546e564b5a14383183b240b6e2ef4aad60dd8bea39389394a308de6"

URI_aarch64_ghc9.12-Cabal-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-syntax-devel-3.14.2.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-syntax-devel}"
SRC_URI[aarch64_ghc9.12-Cabal-syntax-devel.sha256sum] = "49daa06f5a8150295a2e056094f122810a01ed9e89e2a6c341d59aca6cd1909a"

URI_aarch64_ghc9.12-Cabal-syntax-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-syntax-doc-3.14.2.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-syntax-doc}"
SRC_URI[aarch64_ghc9.12-Cabal-syntax-doc.sha256sum] = "91655398cb5588a0f0cd5d0a9569c9b687553706be0e960d89a14455875390a1"

URI_aarch64_ghc9.12-Cabal-syntax-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-syntax-prof-3.14.2.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-Cabal-syntax-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-syntax-prof}"
SRC_URI[aarch64_ghc9.12-Cabal-syntax-prof.sha256sum] = "63f69cb99d12a1c2484a60896f7b6a2da1eabdf46e3006a4fa8f856a502ea515"

URI_aarch64_ghc9.12-array = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-array-0.5.8.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-array;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-array}"
SRC_URI[aarch64_ghc9.12-array.sha256sum] = "5b3d3b9d1d217d27b858a861d1607905e2ce8091b5da5c1279123c0a3f82229f"

URI_aarch64_ghc9.12-array-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-array-devel-0.5.8.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-array-devel}"
SRC_URI[aarch64_ghc9.12-array-devel.sha256sum] = "51a3846a06c90ab36c9904614ac27109d52b4c679a3565fbd1d4e4944a5306bf"

URI_aarch64_ghc9.12-array-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-array-doc-0.5.8.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-array-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-array-doc}"
SRC_URI[aarch64_ghc9.12-array-doc.sha256sum] = "c47b5e101823a1b0d959dac3f5ac4f24884bea9137f9385f337d04ee8a0ead82"

URI_aarch64_ghc9.12-array-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-array-prof-0.5.8.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-array-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-array-prof}"
SRC_URI[aarch64_ghc9.12-array-prof.sha256sum] = "6bed4b5e18a5be1dd0ea05cc95d874f5a2dbdd78257adf09a837c9f718e250e8"

URI_aarch64_ghc9.12-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-base-4.21.1.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-base}"
SRC_URI[aarch64_ghc9.12-base.sha256sum] = "0dc7d9417120f3be7a46e206ac6aa7fb1a7c13b3fbd1b942bcfce3b11bf6469f"

URI_aarch64_ghc9.12-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-base-devel-4.21.1.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-base-devel}"
SRC_URI[aarch64_ghc9.12-base-devel.sha256sum] = "2b63c879950035c87e0cd5075f3e3e45ca6336eaf640e47ba5e3662d7a7976b5"

URI_aarch64_ghc9.12-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-base-doc-4.21.1.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-base-doc}"
SRC_URI[aarch64_ghc9.12-base-doc.sha256sum] = "ed354e133e4b31303284ec0660eb58c873e9c0b45303507d670dc4e0908ba469"

URI_aarch64_ghc9.12-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-base-prof-4.21.1.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-base-prof}"
SRC_URI[aarch64_ghc9.12-base-prof.sha256sum] = "968387584b264eb6e7e6a16c2d2253624e566a2eb835f1b60e5eb34e18b8e991"

URI_aarch64_ghc9.12-binary = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-binary-0.8.9.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-binary;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-binary}"
SRC_URI[aarch64_ghc9.12-binary.sha256sum] = "8af359b1e0f021bfb6bde72f8c3e92b41634cbe3b50cefbd6be7aa653f01ddc9"

URI_aarch64_ghc9.12-binary-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-binary-devel-0.8.9.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-binary-devel}"
SRC_URI[aarch64_ghc9.12-binary-devel.sha256sum] = "547a344e36867aaaf2b06e6b18e590faf6422482b261ecce9c800fb151b51a98"

URI_aarch64_ghc9.12-binary-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-binary-doc-0.8.9.3-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-binary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-binary-doc}"
SRC_URI[aarch64_ghc9.12-binary-doc.sha256sum] = "c1faeefdf214a61b163e9a3291564c3038ce898e71780d3ae23cbd8bfb77a570"

URI_aarch64_ghc9.12-binary-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-binary-prof-0.8.9.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-binary-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-binary-prof}"
SRC_URI[aarch64_ghc9.12-binary-prof.sha256sum] = "c8da4f3fca4b327b1869421e51dd7443e274867b92dbef8ac0dd1780e4ebcaaa"

URI_aarch64_ghc9.12-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-bytestring-0.12.2.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-bytestring}"
SRC_URI[aarch64_ghc9.12-bytestring.sha256sum] = "b57a35434e9faf2fb1b63cf856de47ab2c224032067bf7e52fb3cc72a30e68ab"

URI_aarch64_ghc9.12-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-bytestring-devel-0.12.2.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-bytestring-devel}"
SRC_URI[aarch64_ghc9.12-bytestring-devel.sha256sum] = "a86cc136108d4461f2c9a108b9fac4948ce4d08e3b7d9d34fc4c8cfda143ec69"

URI_aarch64_ghc9.12-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-bytestring-doc-0.12.2.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-bytestring-doc}"
SRC_URI[aarch64_ghc9.12-bytestring-doc.sha256sum] = "8971bab4a944155a0e448490e0bf3f694d53b7c161560aa548fb8d6db39f94e3"

URI_aarch64_ghc9.12-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-bytestring-prof-0.12.2.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-bytestring-prof}"
SRC_URI[aarch64_ghc9.12-bytestring-prof.sha256sum] = "1d17610d753c08b8e5c403dcae4e19eabafb38512be3de9dc0d61db44b3c15c8"

URI_aarch64_ghc9.12-compiler = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-compiler-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-compiler}"
SRC_URI[aarch64_ghc9.12-compiler.sha256sum] = "beb3ca56799020303925b5f943cc6cfdcf758f41f55470fec04f520be632b508"

URI_aarch64_ghc9.12-compiler-default = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-compiler-default-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-compiler-default;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-compiler-default}"
SRC_URI[aarch64_ghc9.12-compiler-default.sha256sum] = "ef888a13f01590cf98cd414fc2fce9b732bdf3d546c8f1385bb193f868af18b2"

URI_aarch64_ghc9.12-containers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-containers-0.7-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-containers}"
SRC_URI[aarch64_ghc9.12-containers.sha256sum] = "fb46591c6102adce264ef923e9ba8ea46cd5a1dbe2089c15936e8150f398f22e"

URI_aarch64_ghc9.12-containers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-containers-devel-0.7-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-containers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-containers-devel}"
SRC_URI[aarch64_ghc9.12-containers-devel.sha256sum] = "b9fab5e51f15d0d75d15a6f9b88cbe7f282bfe8d67aa7e08b7573718320ad951"

URI_aarch64_ghc9.12-containers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-containers-doc-0.7-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-containers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-containers-doc}"
SRC_URI[aarch64_ghc9.12-containers-doc.sha256sum] = "17c2a4606aea90583d8e1097ad710e86297cf2f45321dc5953b9bdf287f607a9"

URI_aarch64_ghc9.12-containers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-containers-prof-0.7-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-containers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-containers-prof}"
SRC_URI[aarch64_ghc9.12-containers-prof.sha256sum] = "a4266fcb8b322d84cf196df51d9b96db000aa94523d41e40b882d6a81bfb9f02"

URI_aarch64_ghc9.12-deepseq = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-deepseq-1.5.1.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-deepseq;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-deepseq}"
SRC_URI[aarch64_ghc9.12-deepseq.sha256sum] = "83268501776dc0e4c4343d2ac20c75c0f4e1a50f99302e660368741c0f5c7b3d"

URI_aarch64_ghc9.12-deepseq-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-deepseq-devel-1.5.1.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-deepseq-devel}"
SRC_URI[aarch64_ghc9.12-deepseq-devel.sha256sum] = "e945756b6833c74011535c9fad21d8121c4c6844be8b8d45f7a1f50727124588"

URI_aarch64_ghc9.12-deepseq-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-deepseq-doc-1.5.1.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-deepseq-doc}"
SRC_URI[aarch64_ghc9.12-deepseq-doc.sha256sum] = "97a390dd72a0fa1f7d45035c7ffcbb1559bb4f54d67df2082c513f63fe652542"

URI_aarch64_ghc9.12-deepseq-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-deepseq-prof-1.5.1.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-deepseq-prof}"
SRC_URI[aarch64_ghc9.12-deepseq-prof.sha256sum] = "96f7bc2905b9234f1a7c4ed4f6e0cb9120600f15467112ad3b0e2343f11729da"

URI_aarch64_ghc9.12-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-devel-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-devel}"
SRC_URI[aarch64_ghc9.12-devel.sha256sum] = "43a078381992b4cb1074faca82dda96f8c4a681dbeb61ad0d06486df90e0141b"

URI_aarch64_ghc9.12-directory = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-directory-1.3.9.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-directory;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-directory}"
SRC_URI[aarch64_ghc9.12-directory.sha256sum] = "23434df0a6ccd882007f88917fdf871214bdfd6e7e9e102a111e195b40969caa"

URI_aarch64_ghc9.12-directory-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-directory-devel-1.3.9.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-directory-devel}"
SRC_URI[aarch64_ghc9.12-directory-devel.sha256sum] = "5e1ba7d175ac4f438fa3ef75ce56d0e0a5c59e0e0a1de3cb7feec36981f1e167"

URI_aarch64_ghc9.12-directory-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-directory-doc-1.3.9.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-directory-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-directory-doc}"
SRC_URI[aarch64_ghc9.12-directory-doc.sha256sum] = "537b8f008e52326c34b87fc3a917bdaa4b8bf4a2de09e6be93e656e22af90eed"

URI_aarch64_ghc9.12-directory-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-directory-prof-1.3.9.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-directory-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-directory-prof}"
SRC_URI[aarch64_ghc9.12-directory-prof.sha256sum] = "7e5829c3bdde182987a858c12de0657e3c3a995df46b233e77d292c759a683a5"

URI_aarch64_ghc9.12-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-doc-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-doc}"
SRC_URI[aarch64_ghc9.12-doc.sha256sum] = "b66ab3cf8dcd0cc4efeeb0bfb0f78dcb69e2f681902c080b85b570d68ae7da25"

URI_aarch64_ghc9.12-doc-index = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-doc-index-9.12.3-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-doc-index;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-doc-index}"
SRC_URI[aarch64_ghc9.12-doc-index.sha256sum] = "d1c8f763302d39d9196699e3c7c2cf39708fb7ed3eb303fe30437f8f754eff4e"

URI_aarch64_ghc9.12-exceptions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-exceptions-0.10.10-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-exceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-exceptions}"
SRC_URI[aarch64_ghc9.12-exceptions.sha256sum] = "2e38a5c42a923eed2667c681b31a07f671ec53a53990429e48fceeeffadcf668"

URI_aarch64_ghc9.12-exceptions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-exceptions-devel-0.10.10-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-exceptions-devel}"
SRC_URI[aarch64_ghc9.12-exceptions-devel.sha256sum] = "bc08c4b2b64f5a66ae70b50d75f9f7a9b92d41848d921b1c94870d61438f2a2f"

URI_aarch64_ghc9.12-exceptions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-exceptions-doc-0.10.10-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-exceptions-doc}"
SRC_URI[aarch64_ghc9.12-exceptions-doc.sha256sum] = "a109be9142cee0cc8f89886a95d39e2d60e92277fa73097a48852d0b8e156f7c"

URI_aarch64_ghc9.12-exceptions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-exceptions-prof-0.10.10-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-exceptions-prof}"
SRC_URI[aarch64_ghc9.12-exceptions-prof.sha256sum] = "57c7658c4d8487abf1be8e2fe7de4785af0030446909be69ad9cd38643f04b13"

URI_aarch64_ghc9.12-file-io = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-file-io-0.1.5-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-file-io;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-file-io}"
SRC_URI[aarch64_ghc9.12-file-io.sha256sum] = "306e0c803651ecfd4de3b7885c2644d5695fce786ff70d9ee8c0975982dd8821"

URI_aarch64_ghc9.12-file-io-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-file-io-devel-0.1.5-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-file-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-file-io-devel}"
SRC_URI[aarch64_ghc9.12-file-io-devel.sha256sum] = "15c1b5dbaca51349387db166ac0ba05c38a524b9f56fb40302a1b7196a182f33"

URI_aarch64_ghc9.12-file-io-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-file-io-doc-0.1.5-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-file-io-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-file-io-doc}"
SRC_URI[aarch64_ghc9.12-file-io-doc.sha256sum] = "a1f080cbf3dc110b071ea352402ea1f738fc74b9a725f9eabdadafc931b313f4"

URI_aarch64_ghc9.12-file-io-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-file-io-prof-0.1.5-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-file-io-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-file-io-prof}"
SRC_URI[aarch64_ghc9.12-file-io-prof.sha256sum] = "9c47eeb2b52c0335f1f660238fdccaffb7370ba2bd388f6ce06f0f44931dea0c"

URI_aarch64_ghc9.12-filepath = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filepath-1.5.4.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-filepath;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filepath}"
SRC_URI[aarch64_ghc9.12-filepath.sha256sum] = "bed8967318c83cce39cb9c18ceb84f18d38d83c3e1715395baffaaf1db551bd4"

URI_aarch64_ghc9.12-filepath-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filepath-devel-1.5.4.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filepath-devel}"
SRC_URI[aarch64_ghc9.12-filepath-devel.sha256sum] = "33578d0aa3d32b2755f9a0420febb43e04052b6806dcc0b09cf85eab12196969"

URI_aarch64_ghc9.12-filepath-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filepath-doc-1.5.4.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filepath-doc}"
SRC_URI[aarch64_ghc9.12-filepath-doc.sha256sum] = "ebfa7f4c9a10b41d97541a458821640b7d962943a71644e7d49fa4eeb30efa0c"

URI_aarch64_ghc9.12-filepath-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filepath-prof-1.5.4.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filepath-prof}"
SRC_URI[aarch64_ghc9.12-filepath-prof.sha256sum] = "5c66771548708add1c8de832e95276a8069ca4f7c83e31368063b0caf54bf6fb"

URI_aarch64_ghc9.12-filesystem = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filesystem-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filesystem}"
SRC_URI[aarch64_ghc9.12-filesystem.sha256sum] = "77615207a3b4a0d5e31a641f3e9f9be150caadc749174cf7de255ab74fc7974e"

URI_aarch64_ghc9.12-ghc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc}"
SRC_URI[aarch64_ghc9.12-ghc.sha256sum] = "14a6bb5c30ade5ac56f40153ec1017caaed44802e78f5fc229ecccb35bc82878"

URI_aarch64_ghc9.12-ghc-bignum = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-bignum-1.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-bignum}"
SRC_URI[aarch64_ghc9.12-ghc-bignum.sha256sum] = "8342632cc6741c225f425fb679282b579fd86fd09b0d2f9d7bfce27e0544d899"

URI_aarch64_ghc9.12-ghc-bignum-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-bignum-devel-1.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-bignum-devel}"
SRC_URI[aarch64_ghc9.12-ghc-bignum-devel.sha256sum] = "07bbd69c94df80141632bd793fc6387d278557a182324b1dfe4ff0f783e1259d"

URI_aarch64_ghc9.12-ghc-bignum-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-bignum-doc-1.3-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-bignum-doc}"
SRC_URI[aarch64_ghc9.12-ghc-bignum-doc.sha256sum] = "853aa86c9246509d57bf3125065bc48e32ef3df6bfa0d9959266a2681889b529"

URI_aarch64_ghc9.12-ghc-bignum-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-bignum-prof-1.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-bignum-prof}"
SRC_URI[aarch64_ghc9.12-ghc-bignum-prof.sha256sum] = "cdce761cc68a90f7035474371819ef2b8e1d8d091a8fc94ffc5b1ce2e2c81dc4"

URI_aarch64_ghc9.12-ghc-boot = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot}"
SRC_URI[aarch64_ghc9.12-ghc-boot.sha256sum] = "4914dacde56852697063bb688412a93a3fe31e4ee93d27f689d11acfe58886e3"

URI_aarch64_ghc9.12-ghc-boot-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-devel-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-devel}"
SRC_URI[aarch64_ghc9.12-ghc-boot-devel.sha256sum] = "7d0c363d827dfbf063ad3373290ed6be13b4c0a86e8cb5c4fa0e6d1e811dafd9"

URI_aarch64_ghc9.12-ghc-boot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-doc-9.12.3-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-doc}"
SRC_URI[aarch64_ghc9.12-ghc-boot-doc.sha256sum] = "bfef5266a322e26dffbf65a947be74e18a8a5bec5587a863f71581a55d0682da"

URI_aarch64_ghc9.12-ghc-boot-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-prof-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-prof}"
SRC_URI[aarch64_ghc9.12-ghc-boot-prof.sha256sum] = "60ef57855262a35ed5619be319241a8e3349900fcadd943cf2a3eb09c7169f31"

URI_aarch64_ghc9.12-ghc-boot-th = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-th-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-th}"
SRC_URI[aarch64_ghc9.12-ghc-boot-th.sha256sum] = "0cdb35062c7548caa902e5a58c3367a61208b3b41aa8dc3131fd465722056e57"

URI_aarch64_ghc9.12-ghc-boot-th-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-th-devel-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-th-devel}"
SRC_URI[aarch64_ghc9.12-ghc-boot-th-devel.sha256sum] = "1741933283504bf51894ce1b0301f53b57aad57fead74a850d30017f57272d81"

URI_aarch64_ghc9.12-ghc-boot-th-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-th-doc-9.12.3-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-th-doc}"
SRC_URI[aarch64_ghc9.12-ghc-boot-th-doc.sha256sum] = "e0c9d933b7f5b24aee517bfc86a9a3969ba02fd8d8a942f9ac33ca576e0744ae"

URI_aarch64_ghc9.12-ghc-boot-th-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-th-prof-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-th-prof}"
SRC_URI[aarch64_ghc9.12-ghc-boot-th-prof.sha256sum] = "b64a6cb3cdbdc070094fab038b4cea8e627a7f62d2697f8cfe7ff340749aa8e9"

URI_aarch64_ghc9.12-ghc-compact = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-compact-0.1.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-compact}"
SRC_URI[aarch64_ghc9.12-ghc-compact.sha256sum] = "75a761a911e5d6c95ed48cb3335de034688ba2b1dfe084dc159127690c341593"

URI_aarch64_ghc9.12-ghc-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-compact-devel-0.1.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-compact-devel}"
SRC_URI[aarch64_ghc9.12-ghc-compact-devel.sha256sum] = "59ebc5e31c49bc6b25171d5b0cb810ed28246ae1c628f9c6203e6100adc22664"

URI_aarch64_ghc9.12-ghc-compact-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-compact-doc-0.1.0.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-compact-doc}"
SRC_URI[aarch64_ghc9.12-ghc-compact-doc.sha256sum] = "1e232bd91b51c8361de68967b5dc3a0aae67b7eba309437475348a1c54322951"

URI_aarch64_ghc9.12-ghc-compact-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-compact-prof-0.1.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-compact-prof}"
SRC_URI[aarch64_ghc9.12-ghc-compact-prof.sha256sum] = "1c2f5541b775001a791ea14c6516c650d3cd65afdd40d4d764fde5af6381ac9e"

URI_aarch64_ghc9.12-ghc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-devel-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-devel}"
SRC_URI[aarch64_ghc9.12-ghc-devel.sha256sum] = "d18118c7219833eeedf932760f850d7deba98ba94ac698736345ee46546fd11c"

URI_aarch64_ghc9.12-ghc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-doc-9.12.3-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-doc}"
SRC_URI[aarch64_ghc9.12-ghc-doc.sha256sum] = "906cf142c077e318a9180464a8237cb9a05f9ffd07dbad82436866ecdce25636"

URI_aarch64_ghc9.12-ghc-experimental = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-experimental-9.1203.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-experimental;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-experimental}"
SRC_URI[aarch64_ghc9.12-ghc-experimental.sha256sum] = "2d0149692109bdee0660a56967713ec7e41bbf3ccf097c5f6579298db8e47337"

URI_aarch64_ghc9.12-ghc-experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-experimental-devel-9.1203.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-experimental-devel}"
SRC_URI[aarch64_ghc9.12-ghc-experimental-devel.sha256sum] = "1690d08fe32d148ec2f10bad87764c4029642e5e7bec2d342188940070e93123"

URI_aarch64_ghc9.12-ghc-experimental-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-experimental-doc-9.1203.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-ghc-experimental-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-experimental-doc}"
SRC_URI[aarch64_ghc9.12-ghc-experimental-doc.sha256sum] = "e05aa588461182727b80f46116d3de8cc1a02707bbd6ddba23887babd663e3a5"

URI_aarch64_ghc9.12-ghc-experimental-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-experimental-prof-9.1203.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-experimental-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-experimental-prof}"
SRC_URI[aarch64_ghc9.12-ghc-experimental-prof.sha256sum] = "79666d1f43b487f67dc522e832cd5dcac153072384f9a1d0857346340b7e7f99"

URI_aarch64_ghc9.12-ghc-heap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-heap-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-heap}"
SRC_URI[aarch64_ghc9.12-ghc-heap.sha256sum] = "4452b7c4baa7e5ec7e8d785c05658484421d606f4f11caffc9d3c0062ca7aa7f"

URI_aarch64_ghc9.12-ghc-heap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-heap-devel-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-heap-devel}"
SRC_URI[aarch64_ghc9.12-ghc-heap-devel.sha256sum] = "7fec2f8b34854a9e5519c8c6b075f77f03bedffc864971448f734c3a298a176b"

URI_aarch64_ghc9.12-ghc-heap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-heap-doc-9.12.3-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-heap-doc}"
SRC_URI[aarch64_ghc9.12-ghc-heap-doc.sha256sum] = "879dccdc293178b01c3970fe0b1d2d7a267221caeb79d3f1087e467e397bcb6e"

URI_aarch64_ghc9.12-ghc-heap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-heap-prof-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-heap-prof}"
SRC_URI[aarch64_ghc9.12-ghc-heap-prof.sha256sum] = "d511137f78b1ea70a68dec308699b89c564407d969f0523b020d09b2bcf29ae1"

URI_aarch64_ghc9.12-ghc-platform = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-platform-0.1.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-platform;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-platform}"
SRC_URI[aarch64_ghc9.12-ghc-platform.sha256sum] = "47161501613f2e818e013c20c1e3a3913fddecaa03aaa8be74c6564dc93be489"

URI_aarch64_ghc9.12-ghc-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-platform-devel-0.1.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-platform-devel}"
SRC_URI[aarch64_ghc9.12-ghc-platform-devel.sha256sum] = "348d79a3a4eeed46849d4f6ddbd37afc39b98ffcb4054dd78ce5749bb34e29fa"

URI_aarch64_ghc9.12-ghc-platform-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-platform-doc-0.1.0.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-ghc-platform-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-platform-doc}"
SRC_URI[aarch64_ghc9.12-ghc-platform-doc.sha256sum] = "4691b5385087b809896f991e42d160be716efe239ddc86134d6e70ae50b94b73"

URI_aarch64_ghc9.12-ghc-platform-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-platform-prof-0.1.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-platform-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-platform-prof}"
SRC_URI[aarch64_ghc9.12-ghc-platform-prof.sha256sum] = "f88691c37ea8c3a5831d80b94c305b4f43609c2777c61921827f3ed729405ad8"

URI_aarch64_ghc9.12-ghc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-prof-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-prof}"
SRC_URI[aarch64_ghc9.12-ghc-prof.sha256sum] = "01134edf30cb2a5fdc9c0076f111ccfc3543235b1b1c808255e3e17e47781e50"

URI_aarch64_ghc9.12-ghc-toolchain = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-toolchain-0.1.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-toolchain;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-toolchain}"
SRC_URI[aarch64_ghc9.12-ghc-toolchain.sha256sum] = "dbdf0f237e8848884111ed006094767796fdf49b2624d77955d6556235e8fca3"

URI_aarch64_ghc9.12-ghc-toolchain-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-toolchain-devel-0.1.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-toolchain-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-toolchain-devel}"
SRC_URI[aarch64_ghc9.12-ghc-toolchain-devel.sha256sum] = "d36c6fa05283745f18fee500ae50f3c20c9e774d92452f3530cd7d0ba1789ec6"

URI_aarch64_ghc9.12-ghc-toolchain-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-toolchain-doc-0.1.0.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-ghc-toolchain-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-toolchain-doc}"
SRC_URI[aarch64_ghc9.12-ghc-toolchain-doc.sha256sum] = "d33e38686fafc84236fd4cfd8f1725b3969482ecb957889384767a46561fdad4"

URI_aarch64_ghc9.12-ghc-toolchain-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-toolchain-prof-0.1.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghc-toolchain-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-toolchain-prof}"
SRC_URI[aarch64_ghc9.12-ghc-toolchain-prof.sha256sum] = "35a677f798fda97d45c3c43ce748134269a5e70695bd17b7d999a6b269ed3937"

URI_aarch64_ghc9.12-ghci = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghci-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghci;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghci}"
SRC_URI[aarch64_ghc9.12-ghci.sha256sum] = "e73ced1a1c4ad245018a280aacb3f60f657ddeef4259aafec5911ddf4657e5fe"

URI_aarch64_ghc9.12-ghci-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghci-devel-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghci-devel}"
SRC_URI[aarch64_ghc9.12-ghci-devel.sha256sum] = "6bf242fe5272883c18cdb63611838eb161689da5691c950890bb62bd76cbaf1d"

URI_aarch64_ghc9.12-ghci-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghci-doc-9.12.3-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghci-doc}"
SRC_URI[aarch64_ghc9.12-ghci-doc.sha256sum] = "329c239cc953f6a7ee4ad4cdb1751c89103e7750d4898b18814842c7871a7d22"

URI_aarch64_ghc9.12-ghci-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghci-prof-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghci-prof}"
SRC_URI[aarch64_ghc9.12-ghci-prof.sha256sum] = "0b3454266587d9639fdb991061248800dee3ef41ec009441f2876c0a8ff7f563"

URI_aarch64_ghc9.12-haddock-api = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-api-2.32.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-haddock-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-api}"
SRC_URI[aarch64_ghc9.12-haddock-api.sha256sum] = "5f5ea8fe2010e3973829d7194b49f8c86451d1b7e82328e262cc1c89c13d4675"

URI_aarch64_ghc9.12-haddock-api-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-api-devel-2.32.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-haddock-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-api-devel}"
SRC_URI[aarch64_ghc9.12-haddock-api-devel.sha256sum] = "7c1399323d5f364e8d09cbe5b7058c4ca40b7fe78d70e3a8fb9c92a63aa5929d"

URI_aarch64_ghc9.12-haddock-api-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-api-doc-2.32.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-haddock-api-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-api-doc}"
SRC_URI[aarch64_ghc9.12-haddock-api-doc.sha256sum] = "0e766a28485546241ba5a4fbf14242221c52eef3bd0fa5f44eada568ed747fdb"

URI_aarch64_ghc9.12-haddock-api-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-api-prof-2.32.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-haddock-api-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-api-prof}"
SRC_URI[aarch64_ghc9.12-haddock-api-prof.sha256sum] = "b6d9aa69e8b0ff87f215c9c124de4776dfc75374695a3b5b14fddd03560bfb0d"

URI_aarch64_ghc9.12-haddock-library = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-library-1.11.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-haddock-library;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-library}"
SRC_URI[aarch64_ghc9.12-haddock-library.sha256sum] = "54f07b4ff2375117bae7a0ab53c0ec141b1785d37dd1f50a5def4ada010db7db"

URI_aarch64_ghc9.12-haddock-library-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-library-devel-1.11.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-haddock-library-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-library-devel}"
SRC_URI[aarch64_ghc9.12-haddock-library-devel.sha256sum] = "95300e127eb3c8463c8db178b530cc786f673da465d8014e94c8d0763b7102c2"

URI_aarch64_ghc9.12-haddock-library-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-library-doc-1.11.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-haddock-library-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-library-doc}"
SRC_URI[aarch64_ghc9.12-haddock-library-doc.sha256sum] = "439dc1088b66bece316e6a746a45cf78325fb5fdcefbbcbbcddd69a0392a029f"

URI_aarch64_ghc9.12-haddock-library-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-library-prof-1.11.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-haddock-library-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-library-prof}"
SRC_URI[aarch64_ghc9.12-haddock-library-prof.sha256sum] = "a85edf72c0284fe4612f89ce904fe5dc8fe29df5f573dbe53ed9064577e9af85"

URI_aarch64_ghc9.12-hadrian = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hadrian-0.1.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-hadrian;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hadrian}"
SRC_URI[aarch64_ghc9.12-hadrian.sha256sum] = "15d28c975afa1525e7aa3f0916a12d7537fe5315a4ee6965b62dcac40e8b7f62"

URI_aarch64_ghc9.12-haskeline = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haskeline-0.8.2.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-haskeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haskeline}"
SRC_URI[aarch64_ghc9.12-haskeline.sha256sum] = "30fb8fca9eda715c3137e19320b6ce3fc38f1dc177208fea223dbb52b35ff46d"

URI_aarch64_ghc9.12-haskeline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haskeline-devel-0.8.2.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haskeline-devel}"
SRC_URI[aarch64_ghc9.12-haskeline-devel.sha256sum] = "d0ca76d41d4f77c3ebe3b5f746b20939306e91b67a7fb1e5a059b0da129746ad"

URI_aarch64_ghc9.12-haskeline-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haskeline-doc-0.8.2.1-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haskeline-doc}"
SRC_URI[aarch64_ghc9.12-haskeline-doc.sha256sum] = "0b34abb1b2e77f59f6e5b247c83dd6a2570b780f7b1647010a4d91a104e55cdb"

URI_aarch64_ghc9.12-haskeline-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haskeline-prof-0.8.2.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haskeline-prof}"
SRC_URI[aarch64_ghc9.12-haskeline-prof.sha256sum] = "28e6623e086ea33dc0836c04745023a58c69c7b4af5c224f4ba4e841a4d7d293"

URI_aarch64_ghc9.12-hpc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hpc-0.7.0.2-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-hpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hpc}"
SRC_URI[aarch64_ghc9.12-hpc.sha256sum] = "26b9a7a3f62f3372bb0e32d62584135dcec183912a91565e1006b899e69ff5fd"

URI_aarch64_ghc9.12-hpc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hpc-devel-0.7.0.2-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hpc-devel}"
SRC_URI[aarch64_ghc9.12-hpc-devel.sha256sum] = "ecec841437844f82cea7293057bbd6e8a10a59dc91768649055022f9f2842a8b"

URI_aarch64_ghc9.12-hpc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hpc-doc-0.7.0.2-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hpc-doc}"
SRC_URI[aarch64_ghc9.12-hpc-doc.sha256sum] = "f3cc561334aae6b99e84763257271109a7e8eccdfd79c2d22be3d290062bf347"

URI_aarch64_ghc9.12-hpc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hpc-prof-0.7.0.2-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hpc-prof}"
SRC_URI[aarch64_ghc9.12-hpc-prof.sha256sum] = "c13640209874f1c16646ead71c89939606920381ff4f3851570b8656c3e2d287"

URI_aarch64_ghc9.12-manual = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-manual-9.12.3-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-manual}"
SRC_URI[aarch64_ghc9.12-manual.sha256sum] = "26b3c28939b455d0ccd7945b0ffc9f04084d05c6eb79c952d15c7893b8df9008"

URI_aarch64_ghc9.12-mtl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-mtl-2.3.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-mtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-mtl}"
SRC_URI[aarch64_ghc9.12-mtl.sha256sum] = "208a07b3bfa69013bbca5d673684ec688fddbcac2c2dd5457d2632033f7782a3"

URI_aarch64_ghc9.12-mtl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-mtl-devel-2.3.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-mtl-devel}"
SRC_URI[aarch64_ghc9.12-mtl-devel.sha256sum] = "dae9b220a05b7eccf516b0b18b816ddba6a6f8744697e11dc124e659d73e0d32"

URI_aarch64_ghc9.12-mtl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-mtl-doc-2.3.1-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-mtl-doc}"
SRC_URI[aarch64_ghc9.12-mtl-doc.sha256sum] = "e22aaafa9195ffda0e08c0202b0a2d51c1c63ca9aca68b4cf68f6b1e0673787e"

URI_aarch64_ghc9.12-mtl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-mtl-prof-2.3.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-mtl-prof}"
SRC_URI[aarch64_ghc9.12-mtl-prof.sha256sum] = "7c8973b49e4e855a9b90c77fa34051f56bd4d6e7d39fd8aff7f9c4583d6c880e"

URI_aarch64_ghc9.12-os-string = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-os-string-2.0.8-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-os-string;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-os-string}"
SRC_URI[aarch64_ghc9.12-os-string.sha256sum] = "f91576e81db2c28d3333f24e1c125ad6fc00d491394b45cca3a2d4b61fffff3a"

URI_aarch64_ghc9.12-os-string-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-os-string-devel-2.0.8-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-os-string-devel}"
SRC_URI[aarch64_ghc9.12-os-string-devel.sha256sum] = "474ad127ad3e0710598831e33cb979f9be610ffc659d37a867fba4182ae73027"

URI_aarch64_ghc9.12-os-string-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-os-string-doc-2.0.8-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-os-string-doc}"
SRC_URI[aarch64_ghc9.12-os-string-doc.sha256sum] = "f580790acff28b443054fb130d02599463e3230c1e7685685f08364043ef5552"

URI_aarch64_ghc9.12-os-string-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-os-string-prof-2.0.8-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-os-string-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-os-string-prof}"
SRC_URI[aarch64_ghc9.12-os-string-prof.sha256sum] = "58c9e5a3487b85ca874b96b1221c3a04c1a9f05db2e2b82e377f81135fbfcdfe"

URI_aarch64_ghc9.12-parsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-parsec-3.1.18.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-parsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-parsec}"
SRC_URI[aarch64_ghc9.12-parsec.sha256sum] = "61c4710a62b36c457cd78e28550d586f623e80923221b3c1391acc75d65616f0"

URI_aarch64_ghc9.12-parsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-parsec-devel-3.1.18.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-parsec-devel}"
SRC_URI[aarch64_ghc9.12-parsec-devel.sha256sum] = "ad95ddc414de8fe66c246f03233fbe6296807f9d8503a77b9a1b850523300d70"

URI_aarch64_ghc9.12-parsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-parsec-doc-3.1.18.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-parsec-doc}"
SRC_URI[aarch64_ghc9.12-parsec-doc.sha256sum] = "1e24feacd553613da1c1e4883e6b3ae276186cdbf8f8fa98648db7c0056a46ee"

URI_aarch64_ghc9.12-parsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-parsec-prof-3.1.18.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-parsec-prof}"
SRC_URI[aarch64_ghc9.12-parsec-prof.sha256sum] = "cb6dfbc49be73be51e006d611c8591ee844b13bdcedc633d39aeca152a9e7945"

URI_aarch64_ghc9.12-pretty = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-pretty-1.1.3.6-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-pretty;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-pretty}"
SRC_URI[aarch64_ghc9.12-pretty.sha256sum] = "fab370453363fb6d6df90bb03ae64678b148ba6c260a4d1129645b3b460bc74e"

URI_aarch64_ghc9.12-pretty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-pretty-devel-1.1.3.6-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-pretty-devel}"
SRC_URI[aarch64_ghc9.12-pretty-devel.sha256sum] = "fc0fe57e00720758220d650dc674f87bdee7ac5d3fc3deecc85778960fc6e3ee"

URI_aarch64_ghc9.12-pretty-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-pretty-doc-1.1.3.6-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-pretty-doc}"
SRC_URI[aarch64_ghc9.12-pretty-doc.sha256sum] = "56bbb1957d46e1e36284e98d5340a7fdeb808d163dd8f9e3d6339870193aa043"

URI_aarch64_ghc9.12-pretty-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-pretty-prof-1.1.3.6-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-pretty-prof}"
SRC_URI[aarch64_ghc9.12-pretty-prof.sha256sum] = "25e3f30e8889833261dec9e4bad71c425888dbec9a6ecf3ac01a331b9e53cb0e"

URI_aarch64_ghc9.12-process = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-process-1.6.26.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-process}"
SRC_URI[aarch64_ghc9.12-process.sha256sum] = "4576ff983c7b34d0c8f6ed350501c394bde0685d51096e5c6cb69f5bc7c0b4db"

URI_aarch64_ghc9.12-process-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-process-devel-1.6.26.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-process-devel}"
SRC_URI[aarch64_ghc9.12-process-devel.sha256sum] = "17381a523d5d2a0987199c00773ae2f2b84cd7f64371a6a4378f7f311e1dd417"

URI_aarch64_ghc9.12-process-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-process-doc-1.6.26.1-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-process-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-process-doc}"
SRC_URI[aarch64_ghc9.12-process-doc.sha256sum] = "b3b60d76b0d668e1d6f8c035077f94d3b4bd1f96e8b1f8532b836d566d021f13"

URI_aarch64_ghc9.12-process-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-process-prof-1.6.26.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-process-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-process-prof}"
SRC_URI[aarch64_ghc9.12-process-prof.sha256sum] = "b35cb348ba6384696f58d92958f564b649c04b4da80e923bf90a9489e274e78e"

URI_aarch64_ghc9.12-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-prof-9.12.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-prof}"
SRC_URI[aarch64_ghc9.12-prof.sha256sum] = "55738b39a3b4e7be654cc462bd617a12d063cced0cfd372fc612279deaf22ef0"

URI_aarch64_ghc9.12-semaphore-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-semaphore-compat-1.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-semaphore-compat}"
SRC_URI[aarch64_ghc9.12-semaphore-compat.sha256sum] = "b85deb01a75754f5b7d6f6dc9e56ad4457e2fbc7cab096a5244acfb87d7841e0"

URI_aarch64_ghc9.12-semaphore-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-semaphore-compat-devel-1.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-semaphore-compat-devel}"
SRC_URI[aarch64_ghc9.12-semaphore-compat-devel.sha256sum] = "da4cfbe90c8e63ce5350512c2666079caa49b93189a088b4920b44480216ef90"

URI_aarch64_ghc9.12-semaphore-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-semaphore-compat-doc-1.0.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-semaphore-compat-doc}"
SRC_URI[aarch64_ghc9.12-semaphore-compat-doc.sha256sum] = "2bf3974d612fb1548b1f97fc8f49dd0190303ecbc3da30fa5a9dbfadeb66f072"

URI_aarch64_ghc9.12-semaphore-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-semaphore-compat-prof-1.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-semaphore-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-semaphore-compat-prof}"
SRC_URI[aarch64_ghc9.12-semaphore-compat-prof.sha256sum] = "54394ef23ac576ddbc0b8304e50ab5b80a57a37be8ac834c6aac5ebbd1f16b1e"

URI_aarch64_ghc9.12-stm = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-stm-2.5.3.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-stm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-stm}"
SRC_URI[aarch64_ghc9.12-stm.sha256sum] = "f73a8dad05cc8e7303f5862c605b313cca3bd174d739ad9289a29e35076e2469"

URI_aarch64_ghc9.12-stm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-stm-devel-2.5.3.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-stm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-stm-devel}"
SRC_URI[aarch64_ghc9.12-stm-devel.sha256sum] = "102ec56c7a80dfa8d87d595d0fe3cfcd1197d2babf7176ac157a5c4528130036"

URI_aarch64_ghc9.12-stm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-stm-doc-2.5.3.1-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-stm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-stm-doc}"
SRC_URI[aarch64_ghc9.12-stm-doc.sha256sum] = "82a1214448ef64c133a59f29d510a9e95365a17b51d1ec5564629ccdb580f7fc"

URI_aarch64_ghc9.12-stm-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-stm-prof-2.5.3.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-stm-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-stm-prof}"
SRC_URI[aarch64_ghc9.12-stm-prof.sha256sum] = "f935a20a313e91f7a593e8bce28721e792405d5a5bcd2c0b8a2b71eaa2c59ea1"

URI_aarch64_ghc9.12-template-haskell = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-template-haskell-2.23.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-template-haskell;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-template-haskell}"
SRC_URI[aarch64_ghc9.12-template-haskell.sha256sum] = "7c838db9fdf5000fbf6d6e1250c5b606d52625cdb18590fafb428216051248de"

URI_aarch64_ghc9.12-template-haskell-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-template-haskell-devel-2.23.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-template-haskell-devel}"
SRC_URI[aarch64_ghc9.12-template-haskell-devel.sha256sum] = "4a9b4a3ae26835808b91b0e1570ce6cd2b7a303c51c70f59f28bc0aebbb4aec0"

URI_aarch64_ghc9.12-template-haskell-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-template-haskell-doc-2.23.0.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-template-haskell-doc}"
SRC_URI[aarch64_ghc9.12-template-haskell-doc.sha256sum] = "8d3e8cbaa80cbd818dee396d376872115aa8e3cba4fcee57f5f3a2fcfcffd0cd"

URI_aarch64_ghc9.12-template-haskell-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-template-haskell-prof-2.23.0.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-template-haskell-prof}"
SRC_URI[aarch64_ghc9.12-template-haskell-prof.sha256sum] = "cd6cdea065d407845e3234b39a71fc7cd864be1d7deb5430479f2ae6b8f86372"

URI_aarch64_ghc9.12-terminfo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-terminfo-0.4.1.7-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-terminfo}"
SRC_URI[aarch64_ghc9.12-terminfo.sha256sum] = "7fece5aeb85ba5dd471994131d16853a498c1e2dc815f5695696fae19f4369ca"

URI_aarch64_ghc9.12-terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-terminfo-devel-0.4.1.7-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-terminfo-devel}"
SRC_URI[aarch64_ghc9.12-terminfo-devel.sha256sum] = "f77c5f600311a9fd25a24576a1dfe8d767dc9e5d98804733faab289903030f1d"

URI_aarch64_ghc9.12-terminfo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-terminfo-doc-0.4.1.7-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-terminfo-doc}"
SRC_URI[aarch64_ghc9.12-terminfo-doc.sha256sum] = "24a7d14a3e14950230a359eb07985a6dcd6d4cc1551fcec8c74ddd269e7ad894"

URI_aarch64_ghc9.12-terminfo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-terminfo-prof-0.4.1.7-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-terminfo-prof}"
SRC_URI[aarch64_ghc9.12-terminfo-prof.sha256sum] = "af94191f7f73444e207a5129810f32b55f230e541359f2e6a42c374388e9c6e3"

URI_aarch64_ghc9.12-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-text-2.1.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-text}"
SRC_URI[aarch64_ghc9.12-text.sha256sum] = "45031c17e61ed12042a15a55f55c34f103b77ce4fa5749a0724fdbb26d5ac24c"

URI_aarch64_ghc9.12-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-text-devel-2.1.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-text-devel}"
SRC_URI[aarch64_ghc9.12-text-devel.sha256sum] = "95ed8f839af1e53e4500f7c97326f66ee572c43382ff5bd42baeea43d9c6a9a4"

URI_aarch64_ghc9.12-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-text-doc-2.1.3-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-text-doc}"
SRC_URI[aarch64_ghc9.12-text-doc.sha256sum] = "e9d4cff48544e4f33e9a6df54a14763c9fdcab763d2e28dca9e699f4c925a60c"

URI_aarch64_ghc9.12-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-text-prof-2.1.3-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-text-prof}"
SRC_URI[aarch64_ghc9.12-text-prof.sha256sum] = "de3e51a7138fc985f40cd0ee2b222f653f902660461cb01e04b42c236183450a"

URI_aarch64_ghc9.12-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-time-1.14-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-time}"
SRC_URI[aarch64_ghc9.12-time.sha256sum] = "ff158cb3ef77eefb3796de97de84c72e7c44c2938c4d67130c889f160d84cbec"

URI_aarch64_ghc9.12-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-time-devel-1.14-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-time-devel}"
SRC_URI[aarch64_ghc9.12-time-devel.sha256sum] = "5c7f95bf44528a663f70d4388237a8a58e30b44e45ea7dbec9d5cd87e0e82088"

URI_aarch64_ghc9.12-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-time-doc-1.14-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-time-doc}"
SRC_URI[aarch64_ghc9.12-time-doc.sha256sum] = "c41e20413a8db97f35a4900281dd0b632e9094e3593236b22f4156099b92b7b0"

URI_aarch64_ghc9.12-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-time-prof-1.14-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-time-prof}"
SRC_URI[aarch64_ghc9.12-time-prof.sha256sum] = "647a897db12bfcfd1bda21a6dc4e6518c5f7a5539f530cde6a1c48033f9791fc"

URI_aarch64_ghc9.12-transformers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-transformers-0.6.1.2-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-transformers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-transformers}"
SRC_URI[aarch64_ghc9.12-transformers.sha256sum] = "bb7732bd7fc942d3b61ee6a2be489f92aec73d218efef8832e361a50de01ef93"

URI_aarch64_ghc9.12-transformers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-transformers-devel-0.6.1.2-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-transformers-devel}"
SRC_URI[aarch64_ghc9.12-transformers-devel.sha256sum] = "adb4acfa19394d31d0d70e6c59e5439e5d9e9100f894c8c5a88832af5314afff"

URI_aarch64_ghc9.12-transformers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-transformers-doc-0.6.1.2-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-transformers-doc}"
SRC_URI[aarch64_ghc9.12-transformers-doc.sha256sum] = "fb50c32e18e1ea47b7222dc63077105e6c66a343c2d21514b551805cf468a0ff"

URI_aarch64_ghc9.12-transformers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-transformers-prof-0.6.1.2-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-transformers-prof}"
SRC_URI[aarch64_ghc9.12-transformers-prof.sha256sum] = "e1867bc00199efb61ed985b0d6799a0d50e1b88e0b9ef861efc80374c24ddf8f"

URI_aarch64_ghc9.12-unix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-unix-2.8.7.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-unix}"
SRC_URI[aarch64_ghc9.12-unix.sha256sum] = "b02464cb2e3979d0832595ae83d10c30d37989c90596438a2c8b36b814642957"

URI_aarch64_ghc9.12-unix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-unix-devel-2.8.7.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-unix-devel}"
SRC_URI[aarch64_ghc9.12-unix-devel.sha256sum] = "b0d8da4d52f513d608384b5aa622c5ce0c01890f911b885fa3de42de34bfa242"

URI_aarch64_ghc9.12-unix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-unix-doc-2.8.7.0-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-unix-doc}"
SRC_URI[aarch64_ghc9.12-unix-doc.sha256sum] = "d9e64211555988a9886666da1717584b0d82fa86e97bf7ff24174e0b3f10d09d"

URI_aarch64_ghc9.12-unix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-unix-prof-2.8.7.0-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-unix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-unix-prof}"
SRC_URI[aarch64_ghc9.12-unix-prof.sha256sum] = "48c42189d96fbb15e683093ed8076bb3a259aac7a4a97779959558e762b6203c"

URI_aarch64_ghc9.12-xhtml = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-xhtml-3000.2.2.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-xhtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-xhtml}"
SRC_URI[aarch64_ghc9.12-xhtml.sha256sum] = "cb04ab4efe3749c631ca60fbfd8f32c66de2015ca303f3d6b011cd4e06252681"

URI_aarch64_ghc9.12-xhtml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-xhtml-devel-3000.2.2.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-xhtml-devel}"
SRC_URI[aarch64_ghc9.12-xhtml-devel.sha256sum] = "c48b5f72a81866a9a24d842bbfc2c52784e193c2a6225abd4c009cb52bb28376"

URI_aarch64_ghc9.12-xhtml-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-xhtml-doc-3000.2.2.1-13.el10_2.noarch.rpm;name=aarch64_ghc9.12-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-xhtml-doc}"
SRC_URI[aarch64_ghc9.12-xhtml-doc.sha256sum] = "4fa74cd1da6ea414511fabeeac4a1662342dc287a9b5bc5081da241b4cc5d369"

URI_aarch64_ghc9.12-xhtml-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-xhtml-prof-3000.2.2.1-13.el10_2.aarch64.rpm;name=aarch64_ghc9.12-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-xhtml-prof}"
SRC_URI[aarch64_ghc9.12-xhtml-prof.sha256sum] = "2b5672cfc9c3745478e5849073ebde008fa25c417b71f1162b92fafb9f18f0a0"

RDEPENDS:ghc9.12 = " \
 ghc9.12-compiler \
 ghc9.12-devel \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-compact-devel \
 ghc9.12-ghc-devel \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghci-devel \
 ghc9.12-hpc-devel \
 "
RDEPENDS:ghc9.12-Cabal = " \
 ghc9.12-Cabal-syntax \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-Cabal-devel = " \
 ghc9.12-Cabal \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-mtl-devel \
 ghc9.12-parsec-devel \
 ghc9.12-pretty-devel \
 ghc9.12-process-devel \
 ghc9.12-time-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-Cabal-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-Cabal-syntax = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-Cabal-syntax-devel = " \
 ghc9.12-Cabal-syntax \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-mtl-devel \
 ghc9.12-parsec-devel \
 ghc9.12-pretty-devel \
 ghc9.12-text-devel \
 ghc9.12-time-devel \
 ghc9.12-transformers-devel \
 "
RDEPENDS:ghc9.12-Cabal-syntax-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-array = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-array-devel = " \
 ghc9.12-array \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 "
RDEPENDS:ghc9.12-array-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-base = " \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 libffi \
 numactl-libs \
 "
RDEPENDS:ghc9.12-base-devel = " \
 ghc9.12-base \
 ghc9.12-compiler \
 ghc9.12-ghc-bignum-devel \
 gmp-devel \
 libffi-devel \
 numactl-devel \
 "
RDEPENDS:ghc9.12-base-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-binary = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-binary-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 "
RDEPENDS:ghc9.12-binary-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-bytestring = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-bytestring-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-template-haskell-devel \
 "
RDEPENDS:ghc9.12-bytestring-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-compiler = " \
 bash \
 binutils \
 gcc \
 ghc9.12-Cabal \
 ghc9.12-Cabal-syntax \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-base-devel \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-filesystem \
 ghc9.12-ghc \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-platform \
 ghc9.12-ghc-toolchain \
 ghc9.12-ghci \
 ghc9.12-haddock-api \
 ghc9.12-haddock-library \
 ghc9.12-haskeline \
 ghc9.12-hpc \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-semaphore-compat \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-terminfo \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 ghc9.12-xhtml \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 numactl-libs \
 "
RDEPENDS:ghc9.12-compiler-default = " \
 bash \
 ghc9.12-compiler \
 "
RDEPENDS:ghc9.12-containers = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-containers-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-containers \
 ghc9.12-deepseq-devel \
 ghc9.12-template-haskell-devel \
 "
RDEPENDS:ghc9.12-containers-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-deepseq = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-deepseq-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq \
 "
RDEPENDS:ghc9.12-deepseq-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-devel = " \
 ghc9.12-Cabal-devel \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-file-io-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-haddock-api-devel \
 ghc9.12-haddock-library-devel \
 ghc9.12-haskeline-devel \
 ghc9.12-mtl-devel \
 ghc9.12-os-string-devel \
 ghc9.12-parsec-devel \
 ghc9.12-pretty-devel \
 ghc9.12-process-devel \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-stm-devel \
 ghc9.12-template-haskell-devel \
 ghc9.12-terminfo-devel \
 ghc9.12-text-devel \
 ghc9.12-time-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 ghc9.12-xhtml-devel \
 "
RDEPENDS:ghc9.12-directory = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-directory-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-directory \
 ghc9.12-file-io-devel \
 ghc9.12-filepath-devel \
 ghc9.12-os-string-devel \
 ghc9.12-time-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-directory-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-doc = " \
 "
RDEPENDS:ghc9.12-doc-index = " \
 ghc9.12-compiler \
 "
RDEPENDS:ghc9.12-exceptions = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-exceptions-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-exceptions \
 ghc9.12-mtl-devel \
 ghc9.12-stm-devel \
 ghc9.12-template-haskell-devel \
 ghc9.12-transformers-devel \
 "
RDEPENDS:ghc9.12-exceptions-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-file-io = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-file-io-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-file-io \
 ghc9.12-filepath-devel \
 ghc9.12-os-string-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-file-io-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-filepath = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-filepath-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-filepath \
 ghc9.12-os-string-devel \
 ghc9.12-template-haskell-devel \
 "
RDEPENDS:ghc9.12-filepath-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-filesystem = " \
 "
RDEPENDS:ghc9.12-ghc = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-platform \
 ghc9.12-ghci \
 ghc9.12-hpc \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-semaphore-compat \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-bignum = " \
 ghc9.12-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-bignum-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-bignum \
 "
RDEPENDS:ghc9.12-ghc-bignum-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-boot = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-platform \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-boot-devel = " \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-platform-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-ghc-boot-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-boot-th = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-boot-th-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty-devel \
 "
RDEPENDS:ghc9.12-ghc-boot-th-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-compact = " \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-compact-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-compact \
 "
RDEPENDS:ghc9.12-ghc-compact-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghci-devel \
 ghc9.12-hpc-devel \
 ghc9.12-os-string-devel \
 ghc9.12-process-devel \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-stm-devel \
 ghc9.12-time-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-ghc-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-experimental = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-experimental-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-experimental \
 "
RDEPENDS:ghc9.12-ghc-experimental-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-heap = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-heap-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-ghc-heap \
 "
RDEPENDS:ghc9.12-ghc-heap-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-platform = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-platform-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-platform \
 "
RDEPENDS:ghc9.12-ghc-platform-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-toolchain = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-platform \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-toolchain-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-platform-devel \
 ghc9.12-ghc-toolchain \
 ghc9.12-process-devel \
 ghc9.12-text-devel \
 ghc9.12-transformers-devel \
 "
RDEPENDS:ghc9.12-ghc-toolchain-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghci = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-platform \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghci-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghci \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-ghci-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-haddock-api = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-platform \
 ghc9.12-ghci \
 ghc9.12-haddock-library \
 ghc9.12-hpc \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-semaphore-compat \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 ghc9.12-xhtml \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haddock-api-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-devel \
 ghc9.12-haddock-api \
 ghc9.12-haddock-library-devel \
 ghc9.12-mtl-devel \
 ghc9.12-parsec-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 ghc9.12-xhtml-devel \
 "
RDEPENDS:ghc9.12-haddock-api-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-haddock-library = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haddock-library-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-haddock-library \
 ghc9.12-parsec-devel \
 ghc9.12-text-devel \
 "
RDEPENDS:ghc9.12-haddock-library-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-hadrian = " \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.12-haskeline = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-terminfo \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.12-haskeline-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-filepath-devel \
 ghc9.12-haskeline \
 ghc9.12-process-devel \
 ghc9.12-stm-devel \
 ghc9.12-terminfo-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-haskeline-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-hpc = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-hpc-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-hpc \
 ghc9.12-time-devel \
 "
RDEPENDS:ghc9.12-hpc-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-manual = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-mtl = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-mtl-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-mtl \
 ghc9.12-transformers-devel \
 "
RDEPENDS:ghc9.12-mtl-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-os-string = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-os-string-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-os-string \
 ghc9.12-template-haskell-devel \
 "
RDEPENDS:ghc9.12-os-string-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-parsec = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-parsec-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-mtl-devel \
 ghc9.12-parsec \
 ghc9.12-text-devel \
 "
RDEPENDS:ghc9.12-parsec-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-pretty = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-pretty-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-pretty \
 "
RDEPENDS:ghc9.12-pretty-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-process = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-process-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-os-string-devel \
 ghc9.12-process \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-process-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-semaphore-compat = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-semaphore-compat-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-exceptions-devel \
 ghc9.12-semaphore-compat \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-semaphore-compat-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-stm = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-stm-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-stm \
 "
RDEPENDS:ghc9.12-stm-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-template-haskell = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-template-haskell-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-template-haskell \
 "
RDEPENDS:ghc9.12-template-haskell-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-terminfo = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.12-terminfo-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-terminfo \
 ncurses-devel \
 "
RDEPENDS:ghc9.12-terminfo-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-text = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-text-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-template-haskell-devel \
 ghc9.12-text \
 "
RDEPENDS:ghc9.12-text-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-time = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-time-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-template-haskell-devel \
 ghc9.12-time \
 "
RDEPENDS:ghc9.12-time-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-transformers = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-transformers-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-transformers \
 "
RDEPENDS:ghc9.12-transformers-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-unix = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-unix-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-filepath-devel \
 ghc9.12-os-string-devel \
 ghc9.12-time-devel \
 ghc9.12-unix \
 "
RDEPENDS:ghc9.12-unix-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-xhtml = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-xhtml-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-xhtml \
 "
RDEPENDS:ghc9.12-xhtml-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-Cabal-prof = " \
 ghc9.12-Cabal-devel \
 ghc9.12-Cabal-syntax-prof \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-parsec-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-Cabal-syntax-prof = " \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-parsec-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-array-prof = " \
 ghc9.12-array-devel \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-base-prof = " \
 ghc9.12-base-devel \
 ghc9.12-ghc-bignum-prof \
 glibc \
 gmp \
 libffi \
 numactl-libs \
 "
RDEPENDS:ghc9.12-binary-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-bytestring-prof = " \
 ghc9.12-base-prof \
 ghc9.12-bytestring-devel \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-containers-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-deepseq-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-devel \
 ghc9.12-ghc-bignum-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-directory-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-exceptions-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-devel \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-file-io-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-devel \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-filepath-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-bignum-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-boot-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-boot-th-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-pretty-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-compact-prof = " \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-compact-devel \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-experimental-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-experimental-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-heap-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-heap-devel \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-platform-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-platform-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-devel \
 ghc9.12-ghc-heap-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghci-prof \
 ghc9.12-hpc-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-semaphore-compat-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-toolchain-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghc-toolchain-devel \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghci-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-heap-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghci-devel \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haddock-api-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-heap-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghc-prof \
 ghc9.12-ghci-prof \
 ghc9.12-haddock-api-devel \
 ghc9.12-haddock-library-prof \
 ghc9.12-hpc-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-parsec-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-semaphore-compat-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 ghc9.12-xhtml-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haddock-library-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-haddock-library-devel \
 ghc9.12-mtl-prof \
 ghc9.12-parsec-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haskeline-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-haskeline-devel \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-terminfo-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.12-hpc-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-hpc-devel \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-mtl-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-mtl-devel \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-os-string-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-devel \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-parsec-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-parsec-devel \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-pretty-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-pretty-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-process-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-devel \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-prof = " \
 ghc9.12-compiler \
 "
RDEPENDS:ghc9.12-semaphore-compat-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-stm-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-stm-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-template-haskell-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-terminfo-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-terminfo-devel \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.12-text-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-time-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-transformers-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-transformers-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-unix-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-xhtml-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-xhtml-devel \
 glibc \
 gmp \
 "
