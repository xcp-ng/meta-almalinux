# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-repo-zdicts"
PV = "2603.1"
PR = "1.el10_3"
PACKAGES = " \
 fedora-repo-zdicts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-repo-zdicts-2603.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a45be77354c4da3cbbecee7be9c9e689c134f44923f9ee98a96d9fa2773840bf"

URI_x86_64_v2_fedora-repo-zdicts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-repo-zdicts-2603.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-repo-zdicts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-repo-zdicts}"
SRC_URI[x86_64_v2_fedora-repo-zdicts.sha256sum] = "86bf1f3ceee0fa15a78df2c3b4bdf7d6425e0227f5d2329a20703ee4099e261f"

URI_aarch64_fedora-repo-zdicts = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-repo-zdicts-2603.1-1.el10_3.noarch.rpm;name=aarch64_fedora-repo-zdicts;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-repo-zdicts}"
SRC_URI[aarch64_fedora-repo-zdicts.sha256sum] = "2a1f61af003ce8fa48e89f1177d9f05901c89f971b70d6dc471d8c2081c5ee3a"

RDEPENDS:fedora-repo-zdicts = " \
 "
