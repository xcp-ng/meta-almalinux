# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtdeclarative"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtdeclarative \
 qt5-qtdeclarative-devel \
 qt5-qtdeclarative-examples \
 qt5-qtdeclarative-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtdeclarative-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e79691ad2569946bc337db7d42196a5ee9d3b0f7321640275338b87b6eac9b8"

URI_x86_64_v2_qt5-qtdeclarative = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdeclarative-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdeclarative;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdeclarative}"
SRC_URI[x86_64_v2_qt5-qtdeclarative.sha256sum] = "53b5a0538a69f2ddcbd5fb3436bfab6932a068455fd218bb36dae844b28c0596"

URI_x86_64_v2_qt5-qtdeclarative-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdeclarative-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdeclarative-devel}"
SRC_URI[x86_64_v2_qt5-qtdeclarative-devel.sha256sum] = "8d104ee74dfb84f420729aead318a16c4661a5da891d2a9b5e4b61185178cb14"

URI_x86_64_v2_qt5-qtdeclarative-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdeclarative-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdeclarative-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdeclarative-examples}"
SRC_URI[x86_64_v2_qt5-qtdeclarative-examples.sha256sum] = "4886fa94173be60b7a844c23cef8816b732c0ddd3587f3d6c2d8186e29e1c2f0"

URI_x86_64_v2_qt5-qtdeclarative-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdeclarative-static-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdeclarative-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdeclarative-static}"
SRC_URI[x86_64_v2_qt5-qtdeclarative-static.sha256sum] = "839abb5754f78aceaf90eb99436ba1363649603850c12dbda64f97ef32227e7a"

URI_aarch64_qt5-qtdeclarative = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdeclarative-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtdeclarative;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdeclarative}"
SRC_URI[aarch64_qt5-qtdeclarative.sha256sum] = "4ce49b5b40f9141c888bbc8f9c760a8e675613c21af331a7e3f28f69236af512"

URI_aarch64_qt5-qtdeclarative-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdeclarative-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdeclarative-devel}"
SRC_URI[aarch64_qt5-qtdeclarative-devel.sha256sum] = "9747642d2b66c96383907b6fc45f88c5c1489b026ebcc5123d850bb14a9bf3af"

URI_aarch64_qt5-qtdeclarative-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdeclarative-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtdeclarative-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdeclarative-examples}"
SRC_URI[aarch64_qt5-qtdeclarative-examples.sha256sum] = "aab661d00e07c78b43de7301467fd6ce1f9ec40773f8fbe67db46f200e66b23e"

URI_aarch64_qt5-qtdeclarative-static = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdeclarative-static-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtdeclarative-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdeclarative-static}"
SRC_URI[aarch64_qt5-qtdeclarative-static.sha256sum] = "6bde20176d2476b3997ae7adc4ffeea78c3910ec307099f41e9a771ddda03495"

RDEPENDS:qt5-qtdeclarative:x86_64_v2 = " \
 glibc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
"
RDEPENDS:qt5-qtdeclarative:aarch64 = " \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
"
RDEPENDS:qt5-qtdeclarative-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtdeclarative-devel \
 "
RDEPENDS:qt5-qtdeclarative-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtdeclarative-static = " \
 qt5-qtdeclarative-devel \
 "
