# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osmctools"
PV = "0.9"
PR = "16.el10_0"
PACKAGES = " \
 osmctools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/osmctools-0.9-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98270b6824a415f8e715872d001640e160a416703c83a89fc34b4ee834d9a788"

URI_x86_64_v2_osmctools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/osmctools-0.9-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_osmctools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osmctools}"
SRC_URI[x86_64_v2_osmctools.sha256sum] = "c0b58380a60ab625fdb2b65c167817eb06b1ea24a4d976d30a034902d80c2c78"

URI_aarch64_osmctools = "${EPEL_MIRROR}/aarch64/Packages/o/osmctools-0.9-16.el10_0.aarch64.rpm;name=aarch64_osmctools;unpack=0"
SRC_URI:append = " ${URI_aarch64_osmctools}"
SRC_URI[aarch64_osmctools.sha256sum] = "10a36880c5aca0742076695dbe430e912ecde79516202ab483efd4cfa005f40c"

RDEPENDS:osmctools = " \
 glibc \
 wget \
 zlib-ng-compat \
 "
