# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksquares"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 ksquares \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksquares-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5f2190c859916a974ef7668dc8a3ded5c3022bf68d8e4da5e7da5a041f8e560"

URI_x86_64_v2_ksquares = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksquares-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksquares;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksquares}"
SRC_URI[x86_64_v2_ksquares.sha256sum] = "065ba570fbe44202b2c10c9a57fa533de0c712eee809a371c5a8e5a4ad5d951d"

URI_aarch64_ksquares = "${EPEL_MIRROR}/aarch64/Packages/k/ksquares-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ksquares;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksquares}"
SRC_URI[aarch64_ksquares.sha256sum] = "736cd1a89c3b558378b21b5174afd577e9311d34b1199a2e10e7dad3cd337c14"

RDEPENDS:ksquares = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
