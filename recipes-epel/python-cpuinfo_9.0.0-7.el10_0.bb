# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cpuinfo"
PV = "9.0.0"
PR = "7.el10_0"
PACKAGES = " \
 python3-cpuinfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cpuinfo-9.0.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e841ebecb2baedfe4d338050831c07138f39635fc9780f4384553e40e8ebc51b"

URI_x86_64_v2_python3-cpuinfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cpuinfo-9.0.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cpuinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cpuinfo}"
SRC_URI[x86_64_v2_python3-cpuinfo.sha256sum] = "d6d6c287d21ca92f906ee0a63e6e89ead34129903adfa8bde21dc31b42a05352"

URI_aarch64_python3-cpuinfo = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cpuinfo-9.0.0-7.el10_0.noarch.rpm;name=aarch64_python3-cpuinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cpuinfo}"
SRC_URI[aarch64_python3-cpuinfo.sha256sum] = "7329b7ae3e6c67619d4f73091d9236298c6ee0fa46e0154cf098da5bb7e81c49"

RDEPENDS:python3-cpuinfo = " \
 python3 \
 "
