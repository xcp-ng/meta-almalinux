# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-brotli"
PV = "8.0.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-brotli+alloc-stdlib-devel \
 rust-brotli+billing-devel \
 rust-brotli+default-devel \
 rust-brotli+disable-timer-devel \
 rust-brotli+disallow_large_window_size-devel \
 rust-brotli+external-literal-probability-devel \
 rust-brotli+ffi-api-devel \
 rust-brotli+float64-devel \
 rust-brotli+floating_point_context_mixing-devel \
 rust-brotli+no-stdlib-ffi-binding-devel \
 rust-brotli+pass-through-ffi-panics-devel \
 rust-brotli+seccomp-devel \
 rust-brotli+sha2-devel \
 rust-brotli+simd-devel \
 rust-brotli+std-devel \
 rust-brotli+validation-devel \
 rust-brotli+vector_scratch_space-devel \
 rust-brotli-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-brotli-8.0.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a75bacb35c8162ee9c87a376e4a053fd0bd0517b8d062deac362f10e167a129f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+alloc-stdlib-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+alloc-stdlib-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+alloc-stdlib-devel.sha256sum] = "c02ed0208ef8645ba217889526c367f1eb8a581b80db4527cf44d29b2e782454"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+billing-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+billing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+billing-devel.sha256sum] = "ee5a515ffe051d402a29b2c57728ce089c037b85cad52b4506ad8f6dd84eb2f8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+default-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+default-devel.sha256sum] = "43070214aace9aab57c2178ef25fae51fff478ec335cc5661813bb20228ffe45"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+disable-timer-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+disable-timer-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+disable-timer-devel.sha256sum] = "e462527b433f4656d8dec911cd36bac12d934c77ab000a47acb1a769e611e8d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+disallow_large_window_size-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+disallow_large_window_size-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+disallow_large_window_size-devel.sha256sum] = "f91a84cd64bb84dec2969377ea4f0c47023c51183346326b89163ed752c2f10a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+external-literal-probability-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+external-literal-probability-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+external-literal-probability-devel.sha256sum] = "5db2476a9397c174e2338ff60cf8eb647d08806e52b3226d222d7e0b9b037dce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+ffi-api-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+ffi-api-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+ffi-api-devel.sha256sum] = "501ab17cddb03a06b5d1416655fa524ab46487115b364550e9b9ccbc4bd12b89"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+float64-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+float64-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+float64-devel.sha256sum] = "7bfc539715182becbbb19d2e25f67d200f9674543d9bc6f2ad5c2189451e898e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+floating_point_context_mixing-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+floating_point_context_mixing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+floating_point_context_mixing-devel.sha256sum] = "3abae8537b0d8a03d5fc1bf68859c7d4b25badb02136dee9d7975820b7088cc2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+no-stdlib-ffi-binding-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+no-stdlib-ffi-binding-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+no-stdlib-ffi-binding-devel.sha256sum] = "ea51cbc99fb8674657e220ffcf749aa6f8efbbc55f9ceb0be876d24a7ea3f98f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+pass-through-ffi-panics-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+pass-through-ffi-panics-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+pass-through-ffi-panics-devel.sha256sum] = "a234802b6eece1c602d23cb9e7e8e97eaa488540cfb700538e3de8d33579e4fe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+seccomp-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+seccomp-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+seccomp-devel.sha256sum] = "4a52c4435800c5c19395dd66535d11a8ca3d5c76eb22fa8238cbf1dbdcde4707"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+sha2-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+sha2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+sha2-devel.sha256sum] = "5e62542a0655cdda8542f9d01806babce39729e63d9b5cb4430f0a11df64eb0c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+simd-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+simd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+simd-devel.sha256sum] = "6f5ef60a3efa17ed64876e69c233b2f9c15a8195478f7d32852481d06c774387"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+std-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+std-devel.sha256sum] = "c21d6175bb4a7de99c0892c971edec0443f49f59e3818310d6d12aefb1a339b0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+validation-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+validation-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+validation-devel.sha256sum] = "36e14fc68c77029ba177279507104278341852761e332ed9bec060e5eec7000b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+vector_scratch_space-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+vector_scratch_space-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+vector_scratch_space-devel.sha256sum] = "6e4068c2d092cfb35f8e90a1eeeceaaeccf86be4074cf33e820c58131b58d1c3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-devel-8.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-devel.sha256sum] = "26f732240920996f7c032c4002ff30c33beb8127f4f84fe8df1751b5d8c3c63a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+alloc-stdlib-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+alloc-stdlib-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+alloc-stdlib-devel.sha256sum] = "7c4bf6bbdb8017c442c39e397de06d83d61728f940e988e4a7f5a75e7df5aa15"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+billing-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+billing-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+billing-devel.sha256sum] = "73c32a877bc7d79d903c11b631fc2d8d6c82ac8d06d0afc1b11364bb03090395"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+default-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+default-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+default-devel.sha256sum] = "18146200fd8ad36f55d5a992898eb54cad56992bc1fa515053bf5e667bac390f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+disable-timer-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+disable-timer-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+disable-timer-devel.sha256sum] = "454e768da78ca941fa6e4823db17120bbe28041813350334d57ba79cbaf22e75"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+disallow_large_window_size-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+disallow_large_window_size-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+disallow_large_window_size-devel.sha256sum] = "1e2c3112367b6d40eda55aedf56556b5c47ab253c8ec4decc83958a3f8e53e6e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+external-literal-probability-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+external-literal-probability-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+external-literal-probability-devel.sha256sum] = "e68dbeea2268a106fbb74fc3f02dcab21dd59369c8dca53954e2d9e2163c4799"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+ffi-api-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+ffi-api-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+ffi-api-devel.sha256sum] = "6f0b633fb4a3c467586bd89fb7a39345baeb16ec6a64289a270a29fecdbaab9c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+float64-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+float64-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+float64-devel.sha256sum] = "825a4b48f5f4cd5efb058fcf5cbf4d1eb3ebe19419a32f639a1bbb9085abc70a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+floating_point_context_mixing-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+floating_point_context_mixing-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+floating_point_context_mixing-devel.sha256sum] = "e37a1e729ead33de43c12cfb22b3b5f36f6b8406104f400cd5342a829aae6db4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+no-stdlib-ffi-binding-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+no-stdlib-ffi-binding-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+no-stdlib-ffi-binding-devel.sha256sum] = "b385d3291946ef0c77c5cd7d3d5937118d60138a412a72380624165a224478ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+pass-through-ffi-panics-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+pass-through-ffi-panics-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+pass-through-ffi-panics-devel.sha256sum] = "38928cb8f3dec85f9725c160d520aef29bdfd8056f133a434a98c87bf57e4677"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+seccomp-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+seccomp-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+seccomp-devel.sha256sum] = "1f9a9260a763161507144f6bbf79b6c82a5890a71b98761371f3601ac11cad9a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+sha2-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+sha2-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+sha2-devel.sha256sum] = "eeee52002b7110d89ec3caf4a33627c697b4ba064a6e75b2b0a9db717d857844"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+simd-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+simd-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+simd-devel.sha256sum] = "5942427b2ccbcf7aca4a1b5ee8fe19abe7cc97da4e7ca6c67ff29f3b4d23e59f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+std-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+std-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+std-devel.sha256sum] = "c7ba4c8d30682a15e4d599c20dbb7bdace19de66a9ae1f92ec5add4de7859a8c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+validation-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+validation-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+validation-devel.sha256sum] = "81661b088ca1a152e6350ddb3868d43e38e5f35618a2bc979093115562e52a9d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+vector_scratch_space-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli+vector_scratch_space-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+vector_scratch_space-devel.sha256sum] = "192333532004fb3b5f95a2dd3f12e3d0f25d68ccd3c5d6c5316eac12416509ba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-devel-8.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-brotli-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-devel.sha256sum] = "f9006abec81d7c02e51deb6685114268d83fa804260e7fa16265688bc7a072c0"

RDEPENDS:rust-brotli+alloc-stdlib-devel = " \
 cargo \
 rust-alloc-stdlib+default-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+billing-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+default-devel = " \
 cargo \
 rust-brotli+std-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+disable-timer-devel = " \
 cargo \
 rust-brotli-decompressor+disable-timer-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+disallow_large_window_size-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+external-literal-probability-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+ffi-api-devel = " \
 cargo \
 rust-brotli-decompressor+ffi-api-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+float64-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+floating_point_context_mixing-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+no-stdlib-ffi-binding-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+pass-through-ffi-panics-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+seccomp-devel = " \
 cargo \
 rust-brotli-decompressor+seccomp-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+sha2-devel = " \
 cargo \
 rust-brotli-devel \
 rust-sha2_0.10+default-devel \
 "
RDEPENDS:rust-brotli+simd-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+std-devel = " \
 cargo \
 rust-brotli+alloc-stdlib-devel \
 rust-brotli-decompressor+std-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+validation-devel = " \
 cargo \
 rust-brotli+sha2-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+vector_scratch_space-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli-devel = " \
 cargo \
 rust \
 rust-alloc-no-stdlib+default-devel \
 rust-brotli-decompressor-devel \
 "
