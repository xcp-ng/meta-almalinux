# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ambient-authority"
PV = "0.0.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-ambient-authority+default-devel \
 rust-ambient-authority-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ambient-authority-0.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "86ac129138e2926fc3d4dcd7206d1b8503c164eba5a26cb0a16141bbf0fa7619"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-authority+default-devel-0.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-authority+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ambient-authority+default-devel.sha256sum] = "561d502de830300f92c174e72dd9e8d843bd5c5ec086b91f5e0caec080feed41"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-authority-devel-0.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-authority-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ambient-authority-devel.sha256sum] = "6114e2fe966bbeca038c048c5b6d36ef97d987a54a553daa213acb9174e17b09"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-authority+default-devel-0.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-ambient-authority+default-devel;unpack=0"
SRC_URI[aarch64_rust-ambient-authority+default-devel.sha256sum] = "d2698de0435c693de903b0d4f5c879ae3b715e74838a88335a1b12f7246e6eed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-authority-devel-0.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-ambient-authority-devel;unpack=0"
SRC_URI[aarch64_rust-ambient-authority-devel.sha256sum] = "b72c31268720c891d3f4a1ed6c6dd76b8a5f0f714bb9cb05e8bd4fb334e846c8"

RDEPENDS:rust-ambient-authority+default-devel = " \
 cargo \
 rust-ambient-authority-devel \
 "
RDEPENDS:rust-ambient-authority-devel = " \
 cargo \
 "
