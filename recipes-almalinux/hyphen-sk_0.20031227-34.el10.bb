# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-sk"
PV = "0.20031227"
PR = "34.el10"
PACKAGES = " \
 hyphen-sk \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-sk-0.20031227-34.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ff33ec936eab1a9afbfcfb213a260bc054b86812bd918bb7d3c724fd176cc337"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-sk-0.20031227-34.el10.noarch.rpm;name=x86_64_v2_hyphen-sk;unpack=0"
SRC_URI[x86_64_v2_hyphen-sk.sha256sum] = "36f3c54eb67951ec0c0e21a2fa5f6bf0ad8cbfdd2f54bad47612a1eec7da7ede"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-sk-0.20031227-34.el10.noarch.rpm;name=aarch64_hyphen-sk;unpack=0"
SRC_URI[aarch64_hyphen-sk.sha256sum] = "36f3c54eb67951ec0c0e21a2fa5f6bf0ad8cbfdd2f54bad47612a1eec7da7ede"

RDEPENDS:hyphen-sk = " \
 hyphen \
 "
