# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-tomasen-realip"
PV = "0"
PR = "15.20190628gitf0c99a9.el10_0"
PACKAGES = " \
 golang-github-tomasen-realip-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-tomasen-realip-0-15.20190628gitf0c99a9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c6dfd08f9fff8a163c35e3a124ba3f89e8eef61522ce4dfefbb8b7440a3a7f6"

URI_aarch64_golang-github-tomasen-realip-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-tomasen-realip-devel-0-15.20190628gitf0c99a9.el10_0.noarch.rpm;name=aarch64_golang-github-tomasen-realip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-tomasen-realip-devel}"
SRC_URI[aarch64_golang-github-tomasen-realip-devel.sha256sum] = "08a47ac3e8991584904167f0d99ff251915aeee3175f3620535e36eac3c3876f"

RDEPENDS:golang-github-tomasen-realip-devel = " \
 go-filesystem \
 "
