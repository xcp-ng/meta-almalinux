# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iperf3"
PV = "3.17.1"
PR = "4.el10"
PACKAGES = " \
 iperf3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/iperf3-3.17.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8d557a354b63c17851879d0d1e96baf888dd0b7b7e149f06112027607f187dc"

URI_x86_64_v2_iperf3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iperf3-3.17.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_iperf3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iperf3}"
SRC_URI[x86_64_v2_iperf3.sha256sum] = "3666dc9e41e959e774acb672c0e41a142b128124343db0083b95303536fa254a"

URI_aarch64_iperf3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iperf3-3.17.1-4.el10.aarch64.rpm;name=aarch64_iperf3;unpack=0"
SRC_URI:append = " ${URI_aarch64_iperf3}"
SRC_URI[aarch64_iperf3.sha256sum] = "a53f83d51bf434d81fdb24d4c008441acc3efff159d23dc9b9537483b7beb71b"

RDEPENDS:iperf3 = " \
 glibc \
 lksctp-tools \
 openssl-libs \
 "
