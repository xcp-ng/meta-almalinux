# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "meld"
PV = "3.22.2"
PR = "2.el10_1"
PACKAGES = " \
 meld \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/meld-3.22.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd6bcb10246f5eb74ce43e333c2b87bc3d382be9e26e751b8efb371f5e4e5c4a"

URI_x86_64_v2_meld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/meld-3.22.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_meld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_meld}"
SRC_URI[x86_64_v2_meld.sha256sum] = "da5d6b9e93f8cd5101c00773a95c565609c95139db4aa53fba3bdb4ca18e3203"

URI_aarch64_meld = "${EPEL_MIRROR}/aarch64/Packages/m/meld-3.22.2-2.el10_1.noarch.rpm;name=aarch64_meld;unpack=0"
SRC_URI:append = " ${URI_aarch64_meld}"
SRC_URI[aarch64_meld.sha256sum] = "2e64d76c4de2f6927c41e3c961ee33c3c6d19ab6a570854a60ec48ec671035c2"

RDEPENDS:meld = " \
 glib2 \
 gtk3 \
 gtksourceview4 \
 python3 \
 python3-cairo \
 python3-gobject \
 python3-gobject-base \
 "
