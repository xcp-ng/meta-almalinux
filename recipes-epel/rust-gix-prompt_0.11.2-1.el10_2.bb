# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-prompt"
PV = "0.11.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-prompt+default-devel \
 rust-gix-prompt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-prompt-0.11.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b4025725c8ea80ba6d34db0ea87daacc6816d46500d50a0db9b3f6b081ff31f"

URI_x86_64_v2_rust-gix-prompt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-prompt+default-devel-0.11.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-prompt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-prompt+default-devel}"
SRC_URI[x86_64_v2_rust-gix-prompt+default-devel.sha256sum] = "8c511d407c720bbda8d07e68873b25bd8afaf491394ad6e5a28142c227486dbc"

URI_x86_64_v2_rust-gix-prompt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-prompt-devel-0.11.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-prompt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-prompt-devel}"
SRC_URI[x86_64_v2_rust-gix-prompt-devel.sha256sum] = "6b98295a93d1f42ab5aa0a4bd6f812b6a5ec0de5b9d30c7eb4740a3845e56782"

URI_aarch64_rust-gix-prompt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-prompt+default-devel-0.11.2-1.el10_2.noarch.rpm;name=aarch64_rust-gix-prompt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-prompt+default-devel}"
SRC_URI[aarch64_rust-gix-prompt+default-devel.sha256sum] = "e134b44726d3c8567a41108ada833d6936e64a2c91bf6696fac83e8a44be51b4"

URI_aarch64_rust-gix-prompt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-prompt-devel-0.11.2-1.el10_2.noarch.rpm;name=aarch64_rust-gix-prompt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-prompt-devel}"
SRC_URI[aarch64_rust-gix-prompt-devel.sha256sum] = "422172ce1f1f2bf0213ea7d91c849e5044a2bdfb197d5e029319ecae1c80b367"

RDEPENDS:rust-gix-prompt+default-devel = " \
 cargo \
 rust-gix-prompt-devel \
 "
RDEPENDS:rust-gix-prompt-devel = " \
 cargo \
 rust \
 rust-gix-command+default-devel \
 rust-gix-config-value+default-devel \
 rust-parking_lot+default-devel \
 rust-rustix+default-devel \
 rust-rustix+termios-devel \
 rust-thiserror+default-devel \
 "
