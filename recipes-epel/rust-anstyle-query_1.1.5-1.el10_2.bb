# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-query"
PV = "1.1.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-anstyle-query+default-devel \
 rust-anstyle-query-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-query-1.1.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "689285c76814d1e4ed42a1e8199078bbd1b787d62c4a31a0ecb18b50a7907864"

URI_x86_64_v2_rust-anstyle-query+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-query+default-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-query+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-query+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-query+default-devel.sha256sum] = "19cb0a554878afb3601d1f36b0173723d7efdbee0b55d9b221e1423d23f911ec"

URI_x86_64_v2_rust-anstyle-query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-query-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-query-devel}"
SRC_URI[x86_64_v2_rust-anstyle-query-devel.sha256sum] = "0ba4627dd215cbf0e529635a914d5e53ab77e87760d2cd538744e37be69899ff"

URI_aarch64_rust-anstyle-query+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-query+default-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle-query+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-query+default-devel}"
SRC_URI[aarch64_rust-anstyle-query+default-devel.sha256sum] = "45b83fc99612d69f1e861c985131d662f86199453ce2fe2601f636345c3abf46"

URI_aarch64_rust-anstyle-query-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-query-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle-query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-query-devel}"
SRC_URI[aarch64_rust-anstyle-query-devel.sha256sum] = "148bf5f3261483d76568be5426e5a85edd3276e40c6800476e1adadb3d9729b5"

RDEPENDS:rust-anstyle-query+default-devel = " \
 cargo \
 rust-anstyle-query-devel \
 "
RDEPENDS:rust-anstyle-query-devel = " \
 cargo \
 rust \
 "
