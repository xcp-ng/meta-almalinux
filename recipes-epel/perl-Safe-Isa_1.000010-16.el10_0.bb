# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Safe-Isa"
PV = "1.000010"
PR = "16.el10_0"
PACKAGES = " \
 perl-Safe-Isa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Safe-Isa-1.000010-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5016ea754a429a06271f29fbe0846628ef3804bc1821ed952a07e08eaa966e6f"

URI_x86_64_v2_perl-Safe-Isa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Safe-Isa-1.000010-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Safe-Isa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Safe-Isa}"
SRC_URI[x86_64_v2_perl-Safe-Isa.sha256sum] = "5417f52fd43e68ebdc1bc8aa65113c9aaa1bad60a083f5f6a125605d73678f32"

URI_aarch64_perl-Safe-Isa = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Safe-Isa-1.000010-16.el10_0.noarch.rpm;name=aarch64_perl-Safe-Isa;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Safe-Isa}"
SRC_URI[aarch64_perl-Safe-Isa.sha256sum] = "749871ded4fbdda2d4336441ffa28e195ba68072187929c8bfae774f2eef6682"

RDEPENDS:perl-Safe-Isa = " \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-libs \
 "
