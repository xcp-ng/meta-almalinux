# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "BackupPC-XS"
PV = "0.62"
PR = "22.el10_2"
PACKAGES = " \
 BackupPC-XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/BackupPC-XS-0.62-22.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55f5842196ef1f00bf891f524e5cd70a700cec731ab7360d67c945fafe2643d9"

URI_x86_64_v2_BackupPC-XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/BackupPC-XS-0.62-22.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_BackupPC-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_BackupPC-XS}"
SRC_URI[x86_64_v2_BackupPC-XS.sha256sum] = "9a08ec78c0571b03572d030a967a8ea3e11425531b7dda8433be9f3f4e6979dc"

URI_aarch64_BackupPC-XS = "${EPEL_MIRROR}/aarch64/Packages/b/BackupPC-XS-0.62-22.el10_2.aarch64.rpm;name=aarch64_BackupPC-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_BackupPC-XS}"
SRC_URI[aarch64_BackupPC-XS.sha256sum] = "da6fbdc17d7b1de24bbfb7b9cd91c1544f1db7a474c147008ece091cab94d310"

RDEPENDS:BackupPC-XS = " \
 glibc \
 perl-Exporter \
 perl-constant \
 perl-libs \
 perl-vars \
 "
