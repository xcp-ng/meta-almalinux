# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mdns-scan"
PV = "0.5"
PR = "11.el10_0"
PACKAGES = " \
 mdns-scan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mdns-scan-0.5-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ecb92d6168f70c3f7bbe37910d77cfdc1ef08cdd33f134bda72859bb7ae0d48"

URI_x86_64_v2_mdns-scan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mdns-scan-0.5-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mdns-scan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mdns-scan}"
SRC_URI[x86_64_v2_mdns-scan.sha256sum] = "4b6652a8fdd6f7524de13fa7206820e4c2b912f0302ee5718b86e31444cd98bb"

URI_aarch64_mdns-scan = "${EPEL_MIRROR}/aarch64/Packages/m/mdns-scan-0.5-11.el10_0.aarch64.rpm;name=aarch64_mdns-scan;unpack=0"
SRC_URI:append = " ${URI_aarch64_mdns-scan}"
SRC_URI[aarch64_mdns-scan.sha256sum] = "87a8f543b9dcbe4f99134957cc4f91634bf9bf46f4ba5df30578a43af9b2402d"

RDEPENDS:mdns-scan = " \
 glibc \
 "
