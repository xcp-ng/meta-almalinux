# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-SQL-Abstract"
PV = "2.000001"
PR = "21.el10_2"
PACKAGES = " \
 perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough \
 perl-SQL-Abstract \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-SQL-Abstract-2.000001-21.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68976323546756d07a2a23a104752233a2811ace1c1d97db82238379fe579a0d"

URI_x86_64_v2_perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough-2.000001-21.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough}"
SRC_URI[x86_64_v2_perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough.sha256sum] = "ef1e5fb0814e0fbd45f6a3e7cd4c615816e1713b24af1d6e360ab9742d31b8b2"

URI_x86_64_v2_perl-SQL-Abstract = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SQL-Abstract-2.000001-21.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SQL-Abstract;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SQL-Abstract}"
SRC_URI[x86_64_v2_perl-SQL-Abstract.sha256sum] = "6aeae36b36ed01607b2db65fa571fd5d2a0477dda61918ca166bd367201860bf"

URI_aarch64_perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough-2.000001-21.el10_2.noarch.rpm;name=aarch64_perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough}"
SRC_URI[aarch64_perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough.sha256sum] = "3ff2b0bcb2b4590be547bda73c0a10fec913c6be8c823d0657ef4fd81841f8e7"

URI_aarch64_perl-SQL-Abstract = "${EPEL_MIRROR}/aarch64/Packages/p/perl-SQL-Abstract-2.000001-21.el10_2.noarch.rpm;name=aarch64_perl-SQL-Abstract;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SQL-Abstract}"
SRC_URI[aarch64_perl-SQL-Abstract.sha256sum] = "a14e6e9300eb0efe7c15da4bb3a50d749b36cbbc666bbd4ff2e0839200fe5321"

RDEPENDS:perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough = " \
 perl-Role-Tiny \
 perl-libs \
 "
RDEPENDS:perl-SQL-Abstract = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-Hash-Merge \
 perl-Module-Runtime \
 perl-Moo \
 perl-Scalar-List-Utils \
 perl-Sub-Quote \
 perl-Test-Deep \
 perl-Test-Simple \
 perl-Text-Balanced \
 perl-base \
 perl-constant \
 perl-libs \
 perl-mro \
 perl-overload \
 "
