# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxxbridge-flags"
PV = "1.0.199"
PR = "1.el10_3"
PACKAGES = " \
 rust-cxxbridge-flags+c++14-devel \
 rust-cxxbridge-flags+c++17-devel \
 rust-cxxbridge-flags+c++20-devel \
 rust-cxxbridge-flags+default-devel \
 rust-cxxbridge-flags-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxxbridge-flags-1.0.199-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bddbbaaccd484000c88f8320b2df5aaf0f3a03150a2e6c58851b2a073392c944"

URI_x86_64_v2_rust-cxxbridge-flags+c++14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++14-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+c++14-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++14-devel.sha256sum] = "4b1b3af70980218babb7ddd7a7c0bd7f91c5ae1747b8e12fc391b6aa01e0c564"

URI_x86_64_v2_rust-cxxbridge-flags+c++17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++17-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+c++17-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++17-devel.sha256sum] = "8e9413e5e9eb0d3285987f0f2386a4228b3185d6a80ec8f2744ba1889c37cedc"

URI_x86_64_v2_rust-cxxbridge-flags+c++20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++20-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+c++20-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++20-devel.sha256sum] = "19e299be4164286e9c48f5fa5a222ffaf47501c85e6836cd4d5b05d9743b95d0"

URI_x86_64_v2_rust-cxxbridge-flags+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+default-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+default-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+default-devel.sha256sum] = "bb7ff518a0a28a9602d0bfef92a04f774ce8e582aa8acede614e082fd18a14d5"

URI_x86_64_v2_rust-cxxbridge-flags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags-devel.sha256sum] = "c93837b2b22b24ea67fa9bfdf29ab03f0c80d213e67acea47a82eac4597fa652"

URI_aarch64_rust-cxxbridge-flags+c++14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++14-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+c++14-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+c++14-devel.sha256sum] = "95da14292d360cc05d91e9d5fd0509580dbaec52a2ba5c436b20b4c69cd57674"

URI_aarch64_rust-cxxbridge-flags+c++17-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++17-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+c++17-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+c++17-devel.sha256sum] = "5232e86fa5f7037f127fa89351ad37df5ba64518b249a4ecbe4e0e2594b43ae6"

URI_aarch64_rust-cxxbridge-flags+c++20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++20-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+c++20-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+c++20-devel.sha256sum] = "445b6b6c3c338273ededfca351cf55c4c744c5eac0baa7c1770e2260c0a03c94"

URI_aarch64_rust-cxxbridge-flags+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+default-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxxbridge-flags+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+default-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+default-devel.sha256sum] = "0d4b9e6708616d0c944e84386cb27c2b70502598cc4675cbdaa7d85f2423379d"

URI_aarch64_rust-cxxbridge-flags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxxbridge-flags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags-devel.sha256sum] = "be930549fc1f81ed0a4bd757461115c8c6e3cff36fa3119c59dc85e7d9edcee4"

RDEPENDS:rust-cxxbridge-flags+c++14-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+c++17-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+c++20-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+default-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags-devel = " \
 cargo \
 rust \
 "
