# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-daemonize"
PV = "0.5.0"
PR = "5.el10_1"
PACKAGES = " \
 rust-daemonize+default-devel \
 rust-daemonize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-daemonize-0.5.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6078896bf34aca8a6bfe538e3c58c3484259eb87cce69aea8f3bde3efafa18d"

URI_x86_64_v2_rust-daemonize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-daemonize+default-devel-0.5.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-daemonize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-daemonize+default-devel}"
SRC_URI[x86_64_v2_rust-daemonize+default-devel.sha256sum] = "3c018dda4c7f39a036e1fa12c67cb1c51c69dfc80e7868212d2a9a6e1536bb5c"

URI_x86_64_v2_rust-daemonize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-daemonize-devel-0.5.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-daemonize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-daemonize-devel}"
SRC_URI[x86_64_v2_rust-daemonize-devel.sha256sum] = "574ea511d5909b898a64bfc1826f20faed38cf0111bfefad89be0e1b3c20518b"

URI_aarch64_rust-daemonize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-daemonize+default-devel-0.5.0-5.el10_1.noarch.rpm;name=aarch64_rust-daemonize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-daemonize+default-devel}"
SRC_URI[aarch64_rust-daemonize+default-devel.sha256sum] = "08aec17748f63f22d3f5603f68984a61b3c5ff66b8c25be99afc7e59bf19d43f"

URI_aarch64_rust-daemonize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-daemonize-devel-0.5.0-5.el10_1.noarch.rpm;name=aarch64_rust-daemonize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-daemonize-devel}"
SRC_URI[aarch64_rust-daemonize-devel.sha256sum] = "01d02dc839cf86cf566ed1db9ce4e7001f04d1cd481f3402f0daba65a14f80c3"

RDEPENDS:rust-daemonize+default-devel = " \
 cargo \
 rust-daemonize-devel \
 "
RDEPENDS:rust-daemonize-devel = " \
 cargo \
 rust-libc+default-devel \
 "
