# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onenote_parser"
PV = "0.3.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-onenote_parser+backtrace-devel \
 rust-onenote_parser+default-devel \
 rust-onenote_parser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onenote_parser-0.3.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07f96f129ca58c0cbdfbea491a996ca180716bcccf581dd72a63e8e00f275245"

URI_x86_64_v2_rust-onenote_parser+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onenote_parser+backtrace-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onenote_parser+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onenote_parser+backtrace-devel}"
SRC_URI[x86_64_v2_rust-onenote_parser+backtrace-devel.sha256sum] = "e3f5b35bc939983aa6c95322baef4a5817c7011a1f6542dbdd0f0bdde81c4b98"

URI_x86_64_v2_rust-onenote_parser+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onenote_parser+default-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onenote_parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onenote_parser+default-devel}"
SRC_URI[x86_64_v2_rust-onenote_parser+default-devel.sha256sum] = "75cbf1a43ff9eda539a47843d532d4d2e872edbae5e48094251e9f43fcf39f1c"

URI_x86_64_v2_rust-onenote_parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onenote_parser-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onenote_parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onenote_parser-devel}"
SRC_URI[x86_64_v2_rust-onenote_parser-devel.sha256sum] = "c993600e3db701fe3a59c2863a8ca81b04501e13511d7aa8d49e851f9051fe7c"

URI_aarch64_rust-onenote_parser+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onenote_parser+backtrace-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-onenote_parser+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onenote_parser+backtrace-devel}"
SRC_URI[aarch64_rust-onenote_parser+backtrace-devel.sha256sum] = "26fd176ff881ef09854d5b15fcffdf7f2fb20cac6c4554429343e509a541cbf3"

URI_aarch64_rust-onenote_parser+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onenote_parser+default-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-onenote_parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onenote_parser+default-devel}"
SRC_URI[aarch64_rust-onenote_parser+default-devel.sha256sum] = "bd600a342ddb941f310432e1c4f9d844b9f26652095309adc71cfc2a2ace6899"

URI_aarch64_rust-onenote_parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onenote_parser-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-onenote_parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onenote_parser-devel}"
SRC_URI[aarch64_rust-onenote_parser-devel.sha256sum] = "11632469e38a5ee14af7b12ae959df2d70491089ef08d88f8844fd770ea83634"

RDEPENDS:rust-onenote_parser+backtrace-devel = " \
 cargo \
 rust-onenote_parser-devel \
 "
RDEPENDS:rust-onenote_parser+default-devel = " \
 cargo \
 rust-onenote_parser-devel \
 "
RDEPENDS:rust-onenote_parser-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-encoding_rs+default-devel \
 rust-enum-primitive-derive+default-devel \
 rust-itertools0.13+default-devel \
 rust-num-traits+default-devel \
 rust-paste+default-devel \
 rust-thiserror1+default-devel \
 rust-uuid+default-devel \
 rust-widestring+default-devel \
 "
