# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tpm2-tools"
PV = "5.7"
PR = "5.el10"
PACKAGES = " \
 tpm2-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tpm2-tools-5.7-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26c5a89ad44225e1addfbb46d5091bc327d850949bf6309e0a75743c0fe12eb6"

URI_x86_64_v2_tpm2-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tpm2-tools-5.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_tpm2-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tpm2-tools}"
SRC_URI[x86_64_v2_tpm2-tools.sha256sum] = "428139bd6779ba5d36835b211962ea71b73d9f9f81221bf1e5823d6bb63ba867"

URI_aarch64_tpm2-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tpm2-tools-5.7-5.el10.aarch64.rpm;name=aarch64_tpm2-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_tpm2-tools}"
SRC_URI[aarch64_tpm2-tools.sha256sum] = "73a0ecc173347bfc463aaa9f68be7e553c68b41fb95bfad75898dc25802d7508"

RDEPENDS:tpm2-tools = " \
 glibc \
 openssl-libs \
 tpm2-tss \
 tpm2-tss-fapi \
 virtual/libcurl.so.4___64bit_ \
 "
