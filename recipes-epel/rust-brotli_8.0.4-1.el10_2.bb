# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-brotli"
PV = "8.0.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-brotli+alloc-stdlib-devel \
 rust-brotli+billing-devel \
 rust-brotli+default-devel \
 rust-brotli+disable-timer-devel \
 rust-brotli+disallow_large_window_size-devel \
 rust-brotli+external-literal-probability-devel \
 rust-brotli+ffi-api-devel \
 rust-brotli+float64-devel \
 rust-brotli+floating_point_context_mixing-devel \
 rust-brotli+no-stdlib-ffi-binding-devel \
 rust-brotli+pass-through-ffi-panics-devel \
 rust-brotli+seccomp-devel \
 rust-brotli+sha2-devel \
 rust-brotli+simd-devel \
 rust-brotli+std-devel \
 rust-brotli+validation-devel \
 rust-brotli+vector_scratch_space-devel \
 rust-brotli-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-brotli-8.0.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c00598bf82916d0dbf3c6d3509beff179922c81d972a29d7f512841facedb900"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+alloc-stdlib-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+alloc-stdlib-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+alloc-stdlib-devel.sha256sum] = "b157e4fc133457a9eb734517da2dee7fba3e0c95f58cb142646a47a192d6aa12"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+billing-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+billing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+billing-devel.sha256sum] = "aaf08d428c956eb6a7a4011bfc7c6cf2b3157bcd19da7e36ddcbda750fc9ff63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+default-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+default-devel.sha256sum] = "d63966f74cb8ed3cda4b9cb595eb62ad505b8d0440ee5f36456f4bf90917dec4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+disable-timer-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+disable-timer-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+disable-timer-devel.sha256sum] = "6d850ad2c9b2519c5d25176d2af4c7b57e85533a4b674cb29c7fa7ddbb0d11f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+disallow_large_window_size-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+disallow_large_window_size-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+disallow_large_window_size-devel.sha256sum] = "0eda98bc4f7ea392c9b086c3710229f763b2bcb19f061e1d20aa3a550d054566"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+external-literal-probability-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+external-literal-probability-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+external-literal-probability-devel.sha256sum] = "dd931b8143462529f9627c82acd04ef951bcfd1cdb739d96b5de01354fa57744"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+ffi-api-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+ffi-api-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+ffi-api-devel.sha256sum] = "86090b2453214661836d10284d7e4a78b4eaec8479f3f6f4f93652a48152e674"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+float64-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+float64-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+float64-devel.sha256sum] = "d464f9da831a23d789a4e0a995e03208c1e85f1b155689b2cffc3f89828e7145"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+floating_point_context_mixing-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+floating_point_context_mixing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+floating_point_context_mixing-devel.sha256sum] = "9cae8db0e8704a75ede560bcd46cc51a801d9e15155f89d8545829fddb37e1c7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+no-stdlib-ffi-binding-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+no-stdlib-ffi-binding-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+no-stdlib-ffi-binding-devel.sha256sum] = "9c4077375f2db8181084ebfbd4970313451c633758bacf713a2243d590f1d33e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+pass-through-ffi-panics-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+pass-through-ffi-panics-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+pass-through-ffi-panics-devel.sha256sum] = "d2c4b2f475812a0780f479bb0ba0d833a6be5aa22e2fadad1b8d02dc3a9fca87"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+seccomp-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+seccomp-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+seccomp-devel.sha256sum] = "4ffdf92c659d989571ba7a46529c52e95a7b3419f3754ffe87271712c3d4db93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+sha2-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+sha2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+sha2-devel.sha256sum] = "a58982048f1f7cd3f289118b94b071b780a5e30ba5fa47397dbbcd3a7080c319"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+simd-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+simd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+simd-devel.sha256sum] = "4a9e5c07f9f916e2ed28aace9141cc3bce639c36224cb5f126fdc49ff15a2a7d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+std-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+std-devel.sha256sum] = "0543a33eef57b74f22718431087142e8e63943d3391528f97fc53c140e42a0f6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+validation-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+validation-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+validation-devel.sha256sum] = "9205d138fd2ccbfcf076f281acb24eff5fac2d237573a45b48af10c05ba69d63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+vector_scratch_space-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+vector_scratch_space-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli+vector_scratch_space-devel.sha256sum] = "45df20508c1439330fee816cbf9f50361ea649f502e994a8930110666f73b164"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-devel-8.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-devel.sha256sum] = "be4f83a6cd8132b60132e6c7960b52f3ff4bcc6630ed13f3053d429ad83a73d0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+alloc-stdlib-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+alloc-stdlib-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+alloc-stdlib-devel.sha256sum] = "59bbb829a916db42e5d151cb4142ee8f7cb1bd638fc606f4b5bfd0338f68b2f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+billing-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+billing-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+billing-devel.sha256sum] = "3be7a76da53dfac336faff1a1703db8cd72b46159eddf9da1294cd7a044458c1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+default-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+default-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+default-devel.sha256sum] = "07d482bda18fe314d956511b5f02b6c16bb1523ec44b33f1525fb42d9d2e9957"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+disable-timer-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+disable-timer-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+disable-timer-devel.sha256sum] = "2c531932bd3bfe4a75a62a4598e3abadc8f69de53e6555d22f58877971bc01d4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+disallow_large_window_size-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+disallow_large_window_size-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+disallow_large_window_size-devel.sha256sum] = "b00cc15272e99e0dbab86a61cecf44e593c70ea18f2e14a5ff89dbc9267dbe59"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+external-literal-probability-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+external-literal-probability-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+external-literal-probability-devel.sha256sum] = "d623887f3eec91fce11ed36dd794fc06b2c48c3895704c944c6f391d0439b54c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+ffi-api-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+ffi-api-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+ffi-api-devel.sha256sum] = "f47a1f3192b4779e231e7878090ef9b2d7016fdb5d4d26da176ecce01706c772"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+float64-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+float64-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+float64-devel.sha256sum] = "56f57a4dd53add63c03b1b34899bd167645b8c26a7b707d6cdce0e022fa8b5ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+floating_point_context_mixing-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+floating_point_context_mixing-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+floating_point_context_mixing-devel.sha256sum] = "6c719417d97bf173a0b73ac273e284c8fb1133723a2c133c03cfc76d96d18068"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+no-stdlib-ffi-binding-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+no-stdlib-ffi-binding-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+no-stdlib-ffi-binding-devel.sha256sum] = "3d967d0e4e2385e7e96511c5644c1a0b350746154ee9bcbf109ffc2fe1f46f7d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+pass-through-ffi-panics-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+pass-through-ffi-panics-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+pass-through-ffi-panics-devel.sha256sum] = "3fb9c31a1b7b2960bbcb193fac1261427086dc668c7ba2e3872c2aecdce12a23"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+seccomp-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+seccomp-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+seccomp-devel.sha256sum] = "002239b9e0cc20e137e04d69851755d2fa226ff2c4f1918a264b28bb8908feec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+sha2-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+sha2-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+sha2-devel.sha256sum] = "82ee65edca5638024480a3fe6820977c0bad39874992e1b83daf338e0d46cd92"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+simd-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+simd-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+simd-devel.sha256sum] = "3bf181d9c7407370e008f6616a334d4cac50ddf366f67105c1bb29eee663f0f7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+std-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+std-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+std-devel.sha256sum] = "49c2d4a9667f5c75cdacee1a4b72f495a7991941192400fac9be7f2a56d0bbef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+validation-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+validation-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+validation-devel.sha256sum] = "120c5ebe6c37a69c139f329c70be0386d253eddad943389f85edde213ebc89a6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+vector_scratch_space-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli+vector_scratch_space-devel;unpack=0"
SRC_URI[aarch64_rust-brotli+vector_scratch_space-devel.sha256sum] = "9770d391879b898dce79dc93276474bc2f3f360daa0e8cd234832808ffc4b757"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-devel-8.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-devel.sha256sum] = "a1e8be7e98042b66c42d91fed637380ebb51d644dfe59d532c4aa6669b2faec5"

RDEPENDS:rust-brotli+alloc-stdlib-devel = " \
 cargo \
 rust-alloc-stdlib+default-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+billing-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+default-devel = " \
 cargo \
 rust-brotli+std-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+disable-timer-devel = " \
 cargo \
 rust-brotli-decompressor+disable-timer-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+disallow_large_window_size-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+external-literal-probability-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+ffi-api-devel = " \
 cargo \
 rust-brotli-decompressor+ffi-api-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+float64-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+floating_point_context_mixing-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+no-stdlib-ffi-binding-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+pass-through-ffi-panics-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+seccomp-devel = " \
 cargo \
 rust-brotli-decompressor+seccomp-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+sha2-devel = " \
 cargo \
 rust-brotli-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-brotli+simd-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+std-devel = " \
 cargo \
 rust-brotli+alloc-stdlib-devel \
 rust-brotli-decompressor+std-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+validation-devel = " \
 cargo \
 rust-brotli+sha2-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+vector_scratch_space-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli-devel = " \
 cargo \
 rust \
 rust-alloc-no-stdlib+default-devel \
 rust-brotli-decompressor-devel \
 "
