# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pspg"
PV = "5.8.11"
PR = "1.el10_0"
PACKAGES = " \
 pspg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pspg-5.8.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "596d1e8d363ab022a31ca3d79ca028f7df80fa30b9c3bd1c02171caee15483f2"

URI_x86_64_v2_pspg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pspg-5.8.11-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pspg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pspg}"
SRC_URI[x86_64_v2_pspg.sha256sum] = "01abca17bed2f040cfc3ea87e77c8319bdb3aa2f89b8b7e1fd14e7aa6bae1f64"

URI_aarch64_pspg = "${EPEL_MIRROR}/aarch64/Packages/p/pspg-5.8.11-1.el10_0.aarch64.rpm;name=aarch64_pspg;unpack=0"
SRC_URI:append = " ${URI_aarch64_pspg}"
SRC_URI[aarch64_pspg.sha256sum] = "582f1ef9d2591520b49a55f21ddd26ebc7cae3d657d6c2e4127573cd45d465a3"

RDEPENDS:pspg = " \
 glibc \
 ncurses-libs \
 readline \
 "
