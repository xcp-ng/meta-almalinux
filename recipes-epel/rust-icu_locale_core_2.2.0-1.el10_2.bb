# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_locale_core"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_locale_core+alloc-devel \
 rust-icu_locale_core+databake-devel \
 rust-icu_locale_core+default-devel \
 rust-icu_locale_core+serde-devel \
 rust-icu_locale_core+zerovec-devel \
 rust-icu_locale_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_locale_core-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d586252dc5a4d74bff9a14cf30051e63553d9d019de1dd71825209405c152a5c"

URI_x86_64_v2_rust-icu_locale_core+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+alloc-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+alloc-devel.sha256sum] = "a7eb205947677eeaf68f94fcb5d007e9250fe761a35614c20336bb44d523d32e"

URI_x86_64_v2_rust-icu_locale_core+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+databake-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+databake-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+databake-devel.sha256sum] = "4639287c255a329b0fb0d30b7c46d0fc65d4b72d7d55265f6c4fccd8655b9789"

URI_x86_64_v2_rust-icu_locale_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+default-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+default-devel.sha256sum] = "fdd86449ae31bf358463bc513179e009ad6c8e17d049e9173c2eaed19a3290de"

URI_x86_64_v2_rust-icu_locale_core+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+serde-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+serde-devel.sha256sum] = "d23e9a0b8fa2c14dcb6b4047c48d08b01e7ce1d9c785a3528c916b9b2a6b7796"

URI_x86_64_v2_rust-icu_locale_core+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+zerovec-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+zerovec-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+zerovec-devel.sha256sum] = "f17b95212190179be51395967368a6bb27885e56b14aed128e0558697b2dcb20"

URI_x86_64_v2_rust-icu_locale_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core-devel.sha256sum] = "43a695878780f21f37fee0c0aceb5779b46ab88c33b0c45f5e223e20107ce481"

URI_aarch64_rust-icu_locale_core+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+alloc-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_locale_core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+alloc-devel}"
SRC_URI[aarch64_rust-icu_locale_core+alloc-devel.sha256sum] = "bd042009dc0692143b2286cfcef4ec4b71f020c875a817e006e3f796ff1556e3"

URI_aarch64_rust-icu_locale_core+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+databake-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_locale_core+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+databake-devel}"
SRC_URI[aarch64_rust-icu_locale_core+databake-devel.sha256sum] = "7a1bbbfc798aabe0badc3fc476b294b5b30159e1638d91602a88b55569b4a263"

URI_aarch64_rust-icu_locale_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_locale_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+default-devel}"
SRC_URI[aarch64_rust-icu_locale_core+default-devel.sha256sum] = "dc0ddef7d098807c38031a0fda8b5bce5e839e0df87797323c260c8f0f88f292"

URI_aarch64_rust-icu_locale_core+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+serde-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_locale_core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+serde-devel}"
SRC_URI[aarch64_rust-icu_locale_core+serde-devel.sha256sum] = "78d41e552aac63f3a5e0ee1a36851dbb1a1bd9c3ad98c88fd61e612b8b1d7bd9"

URI_aarch64_rust-icu_locale_core+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+zerovec-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_locale_core+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+zerovec-devel}"
SRC_URI[aarch64_rust-icu_locale_core+zerovec-devel.sha256sum] = "1c24f20ee2abf4eb21467609fb77767cfc45299a03d19737c92dff14622cbde8"

URI_aarch64_rust-icu_locale_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_locale_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core-devel}"
SRC_URI[aarch64_rust-icu_locale_core-devel.sha256sum] = "21bf6b975eee665785114f44b906ff1ea238b8ec57ea712ada259fe59c6612d0"

RDEPENDS:rust-icu_locale_core+alloc-devel = " \
 cargo \
 rust-icu_locale_core-devel \
 rust-litemap+alloc-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-tinystr+alloc-devel \
 rust-writeable+alloc-devel \
 "
RDEPENDS:rust-icu_locale_core+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_locale_core+alloc-devel \
 rust-icu_locale_core-devel \
 "
RDEPENDS:rust-icu_locale_core+default-devel = " \
 cargo \
 rust-icu_locale_core-devel \
 "
RDEPENDS:rust-icu_locale_core+serde-devel = " \
 cargo \
 rust-icu_locale_core-devel \
 rust-serde-devel \
 rust-tinystr+serde-devel \
 "
RDEPENDS:rust-icu_locale_core+zerovec-devel = " \
 cargo \
 rust-icu_locale_core-devel \
 rust-tinystr+zerovec-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-icu_locale_core-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-litemap-devel \
 rust-tinystr-devel \
 rust-writeable-devel \
 "
