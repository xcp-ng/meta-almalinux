# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdegames"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 libkdegames \
 libkdegames-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkdegames-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67fd7eee4c38ccebee1097f1428a7c886b4bf044e9dd305f6c99b33b2c63a5d8"

URI_x86_64_v2_libkdegames = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdegames-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdegames;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdegames}"
SRC_URI[x86_64_v2_libkdegames.sha256sum] = "5105d7acbe1147bd7bdcadfb1e7a4a8e506c1a2afed3f36395551d4f1935d7de"

URI_x86_64_v2_libkdegames-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdegames-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdegames-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdegames-devel}"
SRC_URI[x86_64_v2_libkdegames-devel.sha256sum] = "61be4682e27bdfb1b1b742ae840bd48c8098a070bdc359d1f95227fcc3e5add2"

URI_aarch64_libkdegames = "${EPEL_MIRROR}/aarch64/Packages/l/libkdegames-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkdegames;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdegames}"
SRC_URI[aarch64_libkdegames.sha256sum] = "e764cda435578d97bda128f58b562a8e618cad27580dfffc6a7fdb7d0e3eec9b"

URI_aarch64_libkdegames-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkdegames-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkdegames-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdegames-devel}"
SRC_URI[aarch64_libkdegames-devel.sha256sum] = "83a6c5cfadd0ddbe41d4690262882988e5575241c30cdf1aff01196c84d3d3d1"

RDEPENDS:libkdegames = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdnssd \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libsndfile \
 libstdc++ \
 openal-soft \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:libkdegames-devel = " \
 cmake-filesystem \
 kf6-kcompletion-devel \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-ki18n-devel \
 kf6-kwidgetsaddons-devel \
 libkdegames \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
