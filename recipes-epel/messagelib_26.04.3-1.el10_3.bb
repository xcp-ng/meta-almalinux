# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "messagelib"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 messagelib \
 messagelib-devel \
 messagelib-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/messagelib-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3972b22b4c7e4d8e98623e93e3d021698befa88c6f5f5a9f107ec743268b0fc5"

URI_x86_64_v2_messagelib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_messagelib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_messagelib}"
SRC_URI[x86_64_v2_messagelib.sha256sum] = "8b961fcdfff84c1ec45ea797ffbc59a035b7db37da12bbf84e1fd237271bdc7b"

URI_x86_64_v2_messagelib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_messagelib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_messagelib-devel}"
SRC_URI[x86_64_v2_messagelib-devel.sha256sum] = "e6fcd0926c74a26ff26195585391abf5dac111967e874fd9f489d3030c296533"

URI_x86_64_v2_messagelib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_messagelib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_messagelib-doc}"
SRC_URI[x86_64_v2_messagelib-doc.sha256sum] = "8b7d54e976325a44a4d9ee0fa42dbd2aa526175e5e1e81921815cbdc2db97014"

URI_aarch64_messagelib = "${EPEL_MIRROR}/aarch64/Packages/m/messagelib-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_messagelib;unpack=0"
SRC_URI:append = " ${URI_aarch64_messagelib}"
SRC_URI[aarch64_messagelib.sha256sum] = "42c94174c4e964fed6e8809ddebc85c9595a14c8e245af7732521dffdedebe7e"

URI_aarch64_messagelib-devel = "${EPEL_MIRROR}/aarch64/Packages/m/messagelib-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_messagelib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_messagelib-devel}"
SRC_URI[aarch64_messagelib-devel.sha256sum] = "2598856c3b0887f8e970d6705307aed203bd366f0de771dc0b19d26e9f19d6c3"

URI_aarch64_messagelib-doc = "${EPEL_MIRROR}/aarch64/Packages/m/messagelib-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_messagelib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_messagelib-doc}"
SRC_URI[aarch64_messagelib-doc.sha256sum] = "478920e8210d32231018c3400b767891d3f82cfbfa3c246197a724d7a573ebc7"

RDEPENDS:messagelib = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-search \
 akonadi-server \
 glibc \
 gpgme2pp \
 grantleetheme \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kmailtransport \
 kmbox \
 kmime \
 kpimtextedit \
 ktextaddons-qt6 \
 libgcc \
 libgravatar \
 libkdepim \
 libkleo \
 libstdc++ \
 openssl-libs \
 pimcommon \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:messagelib-devel = " \
 akonadi-mime-devel \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcontacts-devel \
 kidentitymanagement-devel \
 kmime-devel \
 libkleo-devel \
 messagelib \
 pimcommon-devel \
 qt6-qtwebengine-devel \
 "
RDEPENDS:messagelib-doc = " \
 "
