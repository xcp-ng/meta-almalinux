# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clock-steering"
PV = "0.2.1"
PR = "3.el10_1"
PACKAGES = " \
 rust-clock-steering+default-devel \
 rust-clock-steering-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-clock-steering-0.2.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "72c4a19a2875aef2503351a04388e2f1a2311c4d31a504f5a8a812d5307cbadb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clock-steering+default-devel-0.2.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clock-steering+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clock-steering+default-devel.sha256sum] = "29f0bcc30862b9a8ed50cb613898bf99cf6ab41e253e40bdf34f8e0db4ea9459"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clock-steering-devel-0.2.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clock-steering-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clock-steering-devel.sha256sum] = "87f0573fe5bf5b6e029067c887522638ca5315f5101fc67c395fb00cb86f6d2e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clock-steering+default-devel-0.2.1-3.el10_1.noarch.rpm;name=aarch64_rust-clock-steering+default-devel;unpack=0"
SRC_URI[aarch64_rust-clock-steering+default-devel.sha256sum] = "32dc2c4c4b73e766f8ec8ee9848876879f400f403094112698c927e2cbadae08"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clock-steering-devel-0.2.1-3.el10_1.noarch.rpm;name=aarch64_rust-clock-steering-devel;unpack=0"
SRC_URI[aarch64_rust-clock-steering-devel.sha256sum] = "1ce8d87c5664f2c33c2bcf08172ef5d683c88086d9e368b6a19bf4c3bb4ed063"

RDEPENDS:rust-clock-steering+default-devel = " \
 cargo \
 rust-clock-steering-devel \
 "
RDEPENDS:rust-clock-steering-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
