# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fish"
PV = "4.0.2"
PR = "1.el10_1"
PACKAGES = " \
 fish \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fish-4.0.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6af869fd6b921b1691a5b67edc739d448fd18e6c47b53c1998957b0dfe06e759"

URI_x86_64_v2_fish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fish-4.0.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fish}"
SRC_URI[x86_64_v2_fish.sha256sum] = "ca9c48e19ca4abf976722f8e13e6deca81d6a10625dc181255bf303f8be7597a"

URI_aarch64_fish = "${EPEL_MIRROR}/aarch64/Packages/f/fish-4.0.2-1.el10_1.aarch64.rpm;name=aarch64_fish;unpack=0"
SRC_URI:append = " ${URI_aarch64_fish}"
SRC_URI[aarch64_fish.sha256sum] = "7a50693a72f73c0ff3ef865de3f23829314edbbf796d9712dbf6023dd4fb62ec"

RDEPENDS:fish = " \
 bash \
 glibc \
 libgcc \
 ncurses-term \
 pcre2 \
 pcre2-utf32 \
 pkgconf-pkg-config \
 python3 \
 "
