# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-cucumber-create-meta"
PV = "6.0.1"
PR = "10.el10_2"
PACKAGES = " \
 rubygem-cucumber-create-meta \
 rubygem-cucumber-create-meta-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-cucumber-create-meta-6.0.1-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da6f715028dea070aa43d416dc924d6d002466b54e86f33cf5f9fefd106166bf"

URI_x86_64_v2_rubygem-cucumber-create-meta = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-create-meta-6.0.1-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-create-meta;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-create-meta}"
SRC_URI[x86_64_v2_rubygem-cucumber-create-meta.sha256sum] = "0c101ccd31fffc08bc96c05b4fa478a8e59f3f116a815341395361e4febbb17e"

URI_x86_64_v2_rubygem-cucumber-create-meta-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-create-meta-doc-6.0.1-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-create-meta-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-create-meta-doc}"
SRC_URI[x86_64_v2_rubygem-cucumber-create-meta-doc.sha256sum] = "e98c493d9ad8a644ab155ab404c4faaf79f9a8a901d3b343c4131213036e597a"

URI_aarch64_rubygem-cucumber-create-meta = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-create-meta-6.0.1-10.el10_2.noarch.rpm;name=aarch64_rubygem-cucumber-create-meta;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-create-meta}"
SRC_URI[aarch64_rubygem-cucumber-create-meta.sha256sum] = "ea05d05738970e0a5346cfad4dbc59ccef3bb4fd80edea5df1d5bd09745c2d1b"

URI_aarch64_rubygem-cucumber-create-meta-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-create-meta-doc-6.0.1-10.el10_2.noarch.rpm;name=aarch64_rubygem-cucumber-create-meta-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-create-meta-doc}"
SRC_URI[aarch64_rubygem-cucumber-create-meta-doc.sha256sum] = "0495bdd6db41230eb43a8188db9fb55a80b14f148f8305a4e9a2bf5144694271"

RDEPENDS:rubygem-cucumber-create-meta = " \
 rubygem-cucumber-messages \
 rubygem-sys-uname \
 rubygems \
 "
RDEPENDS:rubygem-cucumber-create-meta-doc = " \
 rubygem-cucumber-create-meta \
 "
