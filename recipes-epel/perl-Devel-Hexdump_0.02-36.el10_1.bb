# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-Hexdump"
PV = "0.02"
PR = "36.el10_1"
PACKAGES = " \
 perl-Devel-Hexdump \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-Hexdump-0.02-36.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ba2fe2f8b5303c578dd3cecd230f63b7d6252baa07f3aad73ef5739f154c017"

URI_x86_64_v2_perl-Devel-Hexdump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-Hexdump-0.02-36.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Devel-Hexdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-Hexdump}"
SRC_URI[x86_64_v2_perl-Devel-Hexdump.sha256sum] = "ad5b9b3a3bd787c9a31ee110368484003e865309d8f4726ce08d8b5366efe9b6"

URI_aarch64_perl-Devel-Hexdump = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-Hexdump-0.02-36.el10_1.aarch64.rpm;name=aarch64_perl-Devel-Hexdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-Hexdump}"
SRC_URI[aarch64_perl-Devel-Hexdump.sha256sum] = "86d7a371d0591742200855d9f23bb32586081f22ff9e72a608ce1e1d1ecd0699"

RDEPENDS:perl-Devel-Hexdump = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
