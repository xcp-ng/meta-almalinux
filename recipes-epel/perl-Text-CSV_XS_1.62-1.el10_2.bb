# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-CSV_XS"
PV = "1.62"
PR = "1.el10_2"
PACKAGES = " \
 perl-Text-CSV_XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-CSV_XS-1.62-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8e9f076fa80b8036b7bd6956152b12e8dacacc06edaff6ef305149521e61e57"

URI_x86_64_v2_perl-Text-CSV_XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-CSV_XS-1.62-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Text-CSV_XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-CSV_XS}"
SRC_URI[x86_64_v2_perl-Text-CSV_XS.sha256sum] = "f2608b3a823b395578b83cd0ee0c41e59e4f137eb92125e4efdde26d56a9f566"

URI_aarch64_perl-Text-CSV_XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-CSV_XS-1.62-1.el10_2.aarch64.rpm;name=aarch64_perl-Text-CSV_XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-CSV_XS}"
SRC_URI[aarch64_perl-Text-CSV_XS.sha256sum] = "59e3f1f272fdd3dbc8c287abe50a5c28f7876eeb7ad554b239d85eb727cda392"

RDEPENDS:perl-Text-CSV_XS = " \
 glibc \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-IO \
 perl-UNIVERSAL-isa \
 perl-libs \
 perl-vars \
 "
