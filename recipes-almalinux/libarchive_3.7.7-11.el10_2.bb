# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libarchive"
PV = "3.7.7"
PR = "11.el10_2"
PACKAGES = " \
 bsdtar \
 libarchive \
 libarchive-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libarchive-3.7.7-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cd4aaef68c2c305db7c1d3b76cbdc770edc9a7135bb2f634abeec4b0cfb81f5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bsdtar-3.7.7-11.el10_2.x86_64_v2.rpm;name=x86_64_v2_bsdtar;unpack=0"
SRC_URI[x86_64_v2_bsdtar.sha256sum] = "1d154b966e77e51713a0d73f1cf6653e0434612e74e1d2ae545644be91ff2581"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libarchive-3.7.7-11.el10_2.x86_64_v2.rpm;name=x86_64_v2_libarchive;unpack=0"
SRC_URI[x86_64_v2_libarchive.sha256sum] = "92bbcc0e7db1aee3ab3b3364d50aa29cd55fcb51419a693455b63b01b650579d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libarchive-devel-3.7.7-11.el10_2.x86_64_v2.rpm;name=x86_64_v2_libarchive-devel;unpack=0"
SRC_URI[x86_64_v2_libarchive-devel.sha256sum] = "f216da10afe7b41dc9fd389d30ab8e975d1bb88c49db04651caa41b7b98b3253"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bsdtar-3.7.7-11.el10_2.aarch64.rpm;name=aarch64_bsdtar;unpack=0"
SRC_URI[aarch64_bsdtar.sha256sum] = "24f7766155b3e01bfa2872284520a59b0422db9aea74681ea450ff870455709c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libarchive-3.7.7-11.el10_2.aarch64.rpm;name=aarch64_libarchive;unpack=0"
SRC_URI[aarch64_libarchive.sha256sum] = "a57d86bef7272eddb558e16b16ce48ae1f35c671f82275eab54fa46b0779683b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libarchive-devel-3.7.7-11.el10_2.aarch64.rpm;name=aarch64_libarchive-devel;unpack=0"
SRC_URI[aarch64_libarchive-devel.sha256sum] = "2ffab48a66c2eaf05ba64398638177da318530e2ae59301166c1d427c475eb77"

RDEPENDS:bsdtar = " \
 glibc \
 libarchive \
 "
RDEPENDS:libarchive = " \
 bzip2-libs \
 glibc \
 libacl \
 libxml2 \
 libzstd \
 lz4-libs \
 openssl-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libarchive-devel = " \
 libarchive \
 openssl-devel \
 pkgconf-pkg-config \
 "
