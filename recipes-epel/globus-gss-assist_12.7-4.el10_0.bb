# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gss-assist"
PV = "12.7"
PR = "4.el10_0"
PACKAGES = " \
 globus-gss-assist \
 globus-gss-assist-devel \
 globus-gss-assist-doc \
 globus-gss-assist-progs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gss-assist-12.7-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c519aaf550293272a9cba053042ed9484964befe50cd9f33b0b2804271bf1a9b"

URI_x86_64_v2_globus-gss-assist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gss-assist-12.7-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gss-assist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gss-assist}"
SRC_URI[x86_64_v2_globus-gss-assist.sha256sum] = "9fdc1e92f8d98ca2a27c3f10fb7ac1838cdc6df8a02add8075871ceed7bba2c1"

URI_x86_64_v2_globus-gss-assist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gss-assist-devel-12.7-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gss-assist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gss-assist-devel}"
SRC_URI[x86_64_v2_globus-gss-assist-devel.sha256sum] = "818af4264b2186d717b1415619cda087c3ee8ce6be0fd7aea378b2cd8bfd77e2"

URI_x86_64_v2_globus-gss-assist-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gss-assist-doc-12.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gss-assist-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gss-assist-doc}"
SRC_URI[x86_64_v2_globus-gss-assist-doc.sha256sum] = "924798f440a314253dbad3d04828fe09cc4d30dd2206afcaf3a5f382f7f16e15"

URI_x86_64_v2_globus-gss-assist-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gss-assist-progs-12.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gss-assist-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gss-assist-progs}"
SRC_URI[x86_64_v2_globus-gss-assist-progs.sha256sum] = "68528149b48efacf38ff3b1040f231a43e8c27e9f5efaab5811df532d1d268c7"

URI_aarch64_globus-gss-assist = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gss-assist-12.7-4.el10_0.aarch64.rpm;name=aarch64_globus-gss-assist;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gss-assist}"
SRC_URI[aarch64_globus-gss-assist.sha256sum] = "7a1b97e72ca9856348836b0a57e467f8acef66c38396e1784c21010c66282a34"

URI_aarch64_globus-gss-assist-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gss-assist-devel-12.7-4.el10_0.aarch64.rpm;name=aarch64_globus-gss-assist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gss-assist-devel}"
SRC_URI[aarch64_globus-gss-assist-devel.sha256sum] = "ae144f55eb156aa5d8276d72bddb273cfb47fdc577553983d1c0ca363d4d4105"

URI_aarch64_globus-gss-assist-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gss-assist-doc-12.7-4.el10_0.noarch.rpm;name=aarch64_globus-gss-assist-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gss-assist-doc}"
SRC_URI[aarch64_globus-gss-assist-doc.sha256sum] = "f92a673d062395c35d18f3ad129493ea22484ec58b156674851034cc7dcfb457"

URI_aarch64_globus-gss-assist-progs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gss-assist-progs-12.7-4.el10_0.noarch.rpm;name=aarch64_globus-gss-assist-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gss-assist-progs}"
SRC_URI[aarch64_globus-gss-assist-progs.sha256sum] = "3874678e95f54ca20202f3f96c760c76527497549795095d1b360f4ce42d04c9"

RDEPENDS:globus-gss-assist = " \
 glibc \
 globus-callout \
 globus-common \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gsi-sysconfig \
 globus-gssapi-gsi \
 "
RDEPENDS:globus-gss-assist-devel = " \
 globus-callout-devel \
 globus-common-devel \
 globus-gsi-cert-utils-devel \
 globus-gsi-credential-devel \
 globus-gsi-sysconfig-devel \
 globus-gss-assist \
 globus-gssapi-gsi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gss-assist-doc = " \
 "
RDEPENDS:globus-gss-assist-progs = " \
 perl-English \
 perl-Fcntl \
 perl-File-Copy \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 "
