# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-flexmock"
PV = "3.0.2"
PR = "1.el10_2"
PACKAGES = " \
 rubygem-flexmock \
 rubygem-flexmock-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-flexmock-3.0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f850155eb2bda5bd828e8e1d56961eed64b64c534804d7c0832721c840cf6498"

URI_x86_64_v2_rubygem-flexmock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-flexmock-3.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-flexmock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-flexmock}"
SRC_URI[x86_64_v2_rubygem-flexmock.sha256sum] = "e4c5f1dd0349cb3b049752b67a19999efb8b98836d8c41d56e1b38e7b3b7be7b"

URI_x86_64_v2_rubygem-flexmock-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-flexmock-doc-3.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-flexmock-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-flexmock-doc}"
SRC_URI[x86_64_v2_rubygem-flexmock-doc.sha256sum] = "bbbd144d895dfc6a04f0fb47e87c40cfc8186ca9f8cc96b605263ed88b2362a4"

URI_aarch64_rubygem-flexmock = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-flexmock-3.0.2-1.el10_2.noarch.rpm;name=aarch64_rubygem-flexmock;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-flexmock}"
SRC_URI[aarch64_rubygem-flexmock.sha256sum] = "c8b379fa17ee5bbc59b99d65e878d8ab02962b14723cef3060c334f04d699809"

URI_aarch64_rubygem-flexmock-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-flexmock-doc-3.0.2-1.el10_2.noarch.rpm;name=aarch64_rubygem-flexmock-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-flexmock-doc}"
SRC_URI[aarch64_rubygem-flexmock-doc.sha256sum] = "0f1424b1fc62686cef72a28143f321f013fc0af87220f106b0609cb19258ad0c"

RDEPENDS:rubygem-flexmock = " \
 rubygems \
 virtual/ruby_release_ \
 "
RDEPENDS:rubygem-flexmock-doc = " \
 rubygem-flexmock \
 "
