# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radicale"
PV = "3.5.9"
PR = "1.el10_1"
PACKAGES = " \
 python3-radicale3 \
 radicale3 \
 radicale3-InfCloud \
 radicale3-InfCloud-fontware \
 radicale3-httpd \
 radicale3-logwatch \
 radicale3-selinux \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/radicale-3.5.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b6a609fe3c9c64620a2ce198ea970db716814d24a87ddb86809ea2c2ed99ae12"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-radicale3-3.5.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-radicale3;unpack=0"
SRC_URI[x86_64_v2_python3-radicale3.sha256sum] = "d0d6b20d41627e66466d0ad087d4358ecadc46f8589a2ed5516c7749c1475a02"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-3.5.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3;unpack=0"
SRC_URI[x86_64_v2_radicale3.sha256sum] = "791c9c88421333d95095b4a8fb91774844b996ddb3bb4bd58433c92ddb92ed5a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-InfCloud-3.5.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-InfCloud;unpack=0"
SRC_URI[x86_64_v2_radicale3-InfCloud.sha256sum] = "8474f3cff828521e0c94f923eed7049dc3285db26df49175c9c1f5c99d0ccef6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-InfCloud-fontware-3.5.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-InfCloud-fontware;unpack=0"
SRC_URI[x86_64_v2_radicale3-InfCloud-fontware.sha256sum] = "a28b1b48588b4ee6b6a7e244e903041924124ab52cc06fe72e984bae18fa2869"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-httpd-3.5.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-httpd;unpack=0"
SRC_URI[x86_64_v2_radicale3-httpd.sha256sum] = "292c2b25dfb06d0b1242db1604eb948985ba4be8725f6147d660a00e0384c2c8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-logwatch-3.5.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-logwatch;unpack=0"
SRC_URI[x86_64_v2_radicale3-logwatch.sha256sum] = "e64d6131ca606815f727414ac88765799b7452de3ef74954c930f5c6fe0808fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-selinux-3.5.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-selinux;unpack=0"
SRC_URI[x86_64_v2_radicale3-selinux.sha256sum] = "9c9a501875d2c0482ce07b24bccc633827114334135511daa3893ebffa24299a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-radicale3-3.5.9-1.el10_1.noarch.rpm;name=aarch64_python3-radicale3;unpack=0"
SRC_URI[aarch64_python3-radicale3.sha256sum] = "14d06a355f1a707971880c16eed06d26ac090efc85c085b57fe52b4107292424"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/radicale3-3.5.9-1.el10_1.noarch.rpm;name=aarch64_radicale3;unpack=0"
SRC_URI[aarch64_radicale3.sha256sum] = "e291a7aa8dd53153a64479536db7bbd8519efccd0e7171432ffab6794f6d3b15"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/radicale3-InfCloud-3.5.9-1.el10_1.noarch.rpm;name=aarch64_radicale3-InfCloud;unpack=0"
SRC_URI[aarch64_radicale3-InfCloud.sha256sum] = "91f65e51bbd00407f8feb7e8990ea7f5e5e5112e18f65c5c104055e33dc115a2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/radicale3-InfCloud-fontware-3.5.9-1.el10_1.noarch.rpm;name=aarch64_radicale3-InfCloud-fontware;unpack=0"
SRC_URI[aarch64_radicale3-InfCloud-fontware.sha256sum] = "a2e53bc38be8e7903282573d23ff66519c85e4d0c0227cd7194436594c08eef5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/radicale3-httpd-3.5.9-1.el10_1.noarch.rpm;name=aarch64_radicale3-httpd;unpack=0"
SRC_URI[aarch64_radicale3-httpd.sha256sum] = "971fad39c2acf8fddd3ce8ad5f8e66707af0f85e02f6dedc78b8441d629dfa5c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/radicale3-logwatch-3.5.9-1.el10_1.noarch.rpm;name=aarch64_radicale3-logwatch;unpack=0"
SRC_URI[aarch64_radicale3-logwatch.sha256sum] = "a7464ba7d293a02c0068fc8fbdaba794b64c3896adef1e3cc916db801d833d5c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/radicale3-selinux-3.5.9-1.el10_1.noarch.rpm;name=aarch64_radicale3-selinux;unpack=0"
SRC_URI[aarch64_radicale3-selinux.sha256sum] = "c29bd2d83cf5ff487d3a1748c32ba879673c888086c9e2a7381b0354caed6533"

RDEPENDS:python3-radicale3 = " \
 bash \
 python3 \
 python3-defusedxml \
 python3-passlib \
 python3-pika \
 python3-requests \
 python3-vobject \
 "
RDEPENDS:radicale3 = " \
 bash \
 python3 \
 python3-radicale3 \
 shadow-utils \
 systemd \
 "
RDEPENDS:radicale3-InfCloud = " \
 ed \
 python3-radicale3 \
 "
RDEPENDS:radicale3-InfCloud-fontware = " \
 radicale3-InfCloud \
 "
RDEPENDS:radicale3-httpd = " \
 bash \
 httpd \
 python3-mod_wsgi \
 radicale3 \
 "
RDEPENDS:radicale3-logwatch = " \
 logwatch \
 radicale3 \
 "
RDEPENDS:radicale3-selinux = " \
 bash \
 policycoreutils \
 policycoreutils-python-utils \
 radicale3 \
 selinux-policy \
 "
