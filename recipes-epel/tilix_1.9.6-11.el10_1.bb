# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tilix"
PV = "1.9.6"
PR = "11.el10_1"
PACKAGES = " \
 tilix \
 tilix-nautilus \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tilix-1.9.6-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc4193a81bf7654df020450e39044736a19243492d4c4a386dcee02795707eb6"

URI_x86_64_v2_tilix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tilix-1.9.6-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tilix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tilix}"
SRC_URI[x86_64_v2_tilix.sha256sum] = "644e7f30b6c41f5c7f24c8b2cf302fad7065845f00a46e2b8f7c8d23bdc170dc"

URI_x86_64_v2_tilix-nautilus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tilix-nautilus-1.9.6-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tilix-nautilus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tilix-nautilus}"
SRC_URI[x86_64_v2_tilix-nautilus.sha256sum] = "057515266e1c0ca70dec0e72ff53fb65e455d0a1713b92c9bb9fd324933fb304"

URI_aarch64_tilix = "${EPEL_MIRROR}/aarch64/Packages/t/tilix-1.9.6-11.el10_1.aarch64.rpm;name=aarch64_tilix;unpack=0"
SRC_URI:append = " ${URI_aarch64_tilix}"
SRC_URI[aarch64_tilix.sha256sum] = "e70319c6129410b05ba840d5c542337dd3505d7cf52191c538a82e26ff2b8efb"

URI_aarch64_tilix-nautilus = "${EPEL_MIRROR}/aarch64/Packages/t/tilix-nautilus-1.9.6-11.el10_1.aarch64.rpm;name=aarch64_tilix-nautilus;unpack=0"
SRC_URI:append = " ${URI_aarch64_tilix-nautilus}"
SRC_URI[aarch64_tilix-nautilus.sha256sum] = "3a7261f05b69357ef5a94970a0af1ee3c2d0651b9347582a0107c3cdc7dd5476"

RDEPENDS:tilix = " \
 bash \
 dbus \
 glibc \
 gtkd \
 hicolor-icon-theme \
 ldc-libs \
 libX11 \
 libgcc \
 "
RDEPENDS:tilix-nautilus = " \
 nautilus-python \
 tilix \
 "
