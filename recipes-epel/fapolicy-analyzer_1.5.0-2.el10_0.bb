# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fapolicy-analyzer"
PV = "1.5.0"
PR = "2.el10_0"
PACKAGES = " \
 fapolicy-analyzer \
 fapolicy-analyzer-cli \
 fapolicy-analyzer-gui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fapolicy-analyzer-1.5.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "128e96e7fb6b1612d9391691ba4f5b583cf0f28a53b972474def3b03fb8eba69"

URI_x86_64_v2_fapolicy-analyzer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fapolicy-analyzer-1.5.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fapolicy-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicy-analyzer}"
SRC_URI[x86_64_v2_fapolicy-analyzer.sha256sum] = "4afad4225614539febeec5df760d594fdde0da2ad1d43b99469f11843d0d142b"

URI_x86_64_v2_fapolicy-analyzer-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fapolicy-analyzer-cli-1.5.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fapolicy-analyzer-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicy-analyzer-cli}"
SRC_URI[x86_64_v2_fapolicy-analyzer-cli.sha256sum] = "5689f4334f73cc7e8dae7f275504d53e7769a4823c099be8c57b69cb53d48d22"

URI_x86_64_v2_fapolicy-analyzer-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fapolicy-analyzer-gui-1.5.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fapolicy-analyzer-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicy-analyzer-gui}"
SRC_URI[x86_64_v2_fapolicy-analyzer-gui.sha256sum] = "868a4bc71d545915cde2412308da9eac878208af141c87e290d621fa9b341a53"

URI_aarch64_fapolicy-analyzer = "${EPEL_MIRROR}/aarch64/Packages/f/fapolicy-analyzer-1.5.0-2.el10_0.aarch64.rpm;name=aarch64_fapolicy-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicy-analyzer}"
SRC_URI[aarch64_fapolicy-analyzer.sha256sum] = "87d02b2cef379644e863c3b75ecfc231bf6248ef62b0d0755069707bd08eacaf"

URI_aarch64_fapolicy-analyzer-cli = "${EPEL_MIRROR}/aarch64/Packages/f/fapolicy-analyzer-cli-1.5.0-2.el10_0.aarch64.rpm;name=aarch64_fapolicy-analyzer-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicy-analyzer-cli}"
SRC_URI[aarch64_fapolicy-analyzer-cli.sha256sum] = "de77087ac27d51e94efede4fc0e1b2aeff481d24d802b5bfe33b894c33184316"

URI_aarch64_fapolicy-analyzer-gui = "${EPEL_MIRROR}/aarch64/Packages/f/fapolicy-analyzer-gui-1.5.0-2.el10_0.aarch64.rpm;name=aarch64_fapolicy-analyzer-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicy-analyzer-gui}"
SRC_URI[aarch64_fapolicy-analyzer-gui.sha256sum] = "77051e3426e8436b5b0af08be2efd12aaa25eb2322685ca8fcac6359be5c3128"

RDEPENDS:fapolicy-analyzer = " \
 fapolicy-analyzer-cli \
 fapolicy-analyzer-gui \
 "
RDEPENDS:fapolicy-analyzer-cli = " \
 audit-libs \
 dbus-libs \
 glibc \
 libgcc \
 lmdb-libs \
 "
RDEPENDS:fapolicy-analyzer-gui = " \
 audit-libs \
 bash \
 dbus-libs \
 glibc \
 gnome-icon-theme \
 gtk3 \
 gtksourceview3 \
 libgcc \
 lmdb-libs \
 mesa-dri-drivers \
 python3 \
 python3-configargparse \
 python3-gobject \
 python3-more-itertools \
 python3-rx \
 python3-tomli \
 webkit2gtk4.1 \
 "
