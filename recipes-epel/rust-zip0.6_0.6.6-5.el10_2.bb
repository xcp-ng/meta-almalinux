# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zip0.6"
PV = "0.6.6"
PR = "5.el10_2"
PACKAGES = " \
 rust-zip0.6+aes-crypto-devel \
 rust-zip0.6+aes-devel \
 rust-zip0.6+bzip2-devel \
 rust-zip0.6+constant_time_eq-devel \
 rust-zip0.6+default-devel \
 rust-zip0.6+deflate-devel \
 rust-zip0.6+deflate-miniz-devel \
 rust-zip0.6+deflate-zlib-devel \
 rust-zip0.6+flate2-devel \
 rust-zip0.6+hmac-devel \
 rust-zip0.6+pbkdf2-devel \
 rust-zip0.6+sha1-devel \
 rust-zip0.6+time-devel \
 rust-zip0.6+unreserved-devel \
 rust-zip0.6+zstd-devel \
 rust-zip0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zip0.6-0.6.6-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35bbb994dfab794d5381a1b56f9e4d9797af0d7272883113cdc865517d88aa7f"

URI_x86_64_v2_rust-zip0.6+aes-crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+aes-crypto-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+aes-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+aes-crypto-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+aes-crypto-devel.sha256sum] = "b41efdd8156b527af45b57ddba868a7a2e9ff4334ad913a47436ddc0d9cb0362"

URI_x86_64_v2_rust-zip0.6+aes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+aes-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+aes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+aes-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+aes-devel.sha256sum] = "af0fde5f8270f5fa6612de960c6868b0ad228e465584924e4401e9132fcec54d"

URI_x86_64_v2_rust-zip0.6+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+bzip2-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+bzip2-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+bzip2-devel.sha256sum] = "1e18861385c08f4b54f7d6a377465c0da330443397e01575ebbe4a29a5e681fa"
RPROVIDES:rust-zip0.6+bzip2-devel:x86_64_v2 = "virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_9.0.0~"

URI_x86_64_v2_rust-zip0.6+constant_time_eq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+constant_time_eq-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+constant_time_eq-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+constant_time_eq-devel.sha256sum] = "212cb560a21d8964ad345c631c165a309cdddcd7f1435f20f476503b5282cc1a"

URI_x86_64_v2_rust-zip0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+default-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+default-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+default-devel.sha256sum] = "5c24426e3b9965a21438796e2a5db6fe6cbf6fbdbeed2904c929ca5393f5bbfd"

URI_x86_64_v2_rust-zip0.6+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+deflate-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+deflate-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+deflate-devel.sha256sum] = "b29ba6890a1fee5ddc92e4d01a3410ecab092cb2dff81e125ee9aed42a9284d6"
RPROVIDES:rust-zip0.6+deflate-devel:x86_64_v2 = "virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_9.0.0~"

URI_x86_64_v2_rust-zip0.6+deflate-miniz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+deflate-miniz-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+deflate-miniz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+deflate-miniz-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+deflate-miniz-devel.sha256sum] = "a8379ef00e50e3573e5e393c1d9c694ec8726455e1291a9fc2670dcb2d322cf0"

URI_x86_64_v2_rust-zip0.6+deflate-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+deflate-zlib-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+deflate-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+deflate-zlib-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+deflate-zlib-devel.sha256sum] = "bb19a7fbed9af57e691a7663a8d53bf3842a3a94f810bace031218e250788087"

URI_x86_64_v2_rust-zip0.6+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+flate2-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+flate2-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+flate2-devel.sha256sum] = "05a54879ea56823e1dbebdb05421b64b6e802b65865f8fe57ae563e6cd56806b"

URI_x86_64_v2_rust-zip0.6+hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+hmac-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+hmac-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+hmac-devel.sha256sum] = "3cd7f2b956bc0a59eed8ef33543d2a9b2e289b9b225da7ed8f7fa60ae4e82164"

URI_x86_64_v2_rust-zip0.6+pbkdf2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+pbkdf2-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+pbkdf2-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+pbkdf2-devel.sha256sum] = "a2393940c4c78ce6eb28d6388bc2620c9632b2c7b0dc7534d92688c0984a3358"

URI_x86_64_v2_rust-zip0.6+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+sha1-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+sha1-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+sha1-devel.sha256sum] = "6dbb6347de2862a98f3e28f3ec3f3b52246f028aa20af7c1d3488f28a2269399"

URI_x86_64_v2_rust-zip0.6+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+time-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+time-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+time-devel.sha256sum] = "3ddd2533ac8cf9dae3902b67c227127686d8bd91d5a9e12faac107c4ae72feb3"

URI_x86_64_v2_rust-zip0.6+unreserved-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+unreserved-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+unreserved-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+unreserved-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+unreserved-devel.sha256sum] = "79c651cbcd26c27853b32a0961bcb6cec1707f16f98047043308a72633be08f8"

URI_x86_64_v2_rust-zip0.6+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+zstd-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+zstd-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+zstd-devel.sha256sum] = "e847ff737d5ea9deddd37d8087fbf88751ca58423230d2f690897394da59b985"

URI_x86_64_v2_rust-zip0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6-devel-0.6.6-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6-devel}"
SRC_URI[x86_64_v2_rust-zip0.6-devel.sha256sum] = "289935cd066c50da0177a03f2dcc5383726d6aa7c4b432a61be18827ec244912"
RPROVIDES:rust-zip0.6-devel:x86_64_v2 = "virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_9.0.0~"

URI_aarch64_rust-zip0.6+aes-crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+aes-crypto-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+aes-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+aes-crypto-devel}"
SRC_URI[aarch64_rust-zip0.6+aes-crypto-devel.sha256sum] = "b65fd1acc61644c3282846cdbf5a2b0ad6c1210b86f02dbe03b41f4ab6b26e5b"

URI_aarch64_rust-zip0.6+aes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+aes-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+aes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+aes-devel}"
SRC_URI[aarch64_rust-zip0.6+aes-devel.sha256sum] = "a4334903d64f58b5ce34f46c3c070e95d62a1645ecf4139e2ef6bffe5c9a85dc"

URI_aarch64_rust-zip0.6+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+bzip2-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+bzip2-devel}"
SRC_URI[aarch64_rust-zip0.6+bzip2-devel.sha256sum] = "7b0b053690d9dae8c58c3383cbc02970c181b7c20bf7d8260b4f4e96b3eabe51"
RPROVIDES:rust-zip0.6+bzip2-devel:aarch64 = "virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_9.0.0~"

URI_aarch64_rust-zip0.6+constant_time_eq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+constant_time_eq-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+constant_time_eq-devel}"
SRC_URI[aarch64_rust-zip0.6+constant_time_eq-devel.sha256sum] = "0afc5c1a290021878778e120f2536c01837108233942b0754fe1f275b5e59fe3"

URI_aarch64_rust-zip0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+default-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+default-devel}"
SRC_URI[aarch64_rust-zip0.6+default-devel.sha256sum] = "d03fc92375f0bc4312f99f3be9655a733886e137b581c75147d61458cbc26312"

URI_aarch64_rust-zip0.6+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+deflate-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+deflate-devel}"
SRC_URI[aarch64_rust-zip0.6+deflate-devel.sha256sum] = "7632b29b9ed047fab17f61536ce8780993dc25d2be8ea877ec6f12811dc469f3"
RPROVIDES:rust-zip0.6+deflate-devel:aarch64 = "virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_9.0.0~"

URI_aarch64_rust-zip0.6+deflate-miniz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+deflate-miniz-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+deflate-miniz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+deflate-miniz-devel}"
SRC_URI[aarch64_rust-zip0.6+deflate-miniz-devel.sha256sum] = "550b5253e28ba4d9f8683ef11d5fa85b24b5b1c7f89af0efe4c9e0448fbe00d1"

URI_aarch64_rust-zip0.6+deflate-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+deflate-zlib-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+deflate-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+deflate-zlib-devel}"
SRC_URI[aarch64_rust-zip0.6+deflate-zlib-devel.sha256sum] = "d389b385f0b05c5ca363d6bfc6b22970e383c4324c9eb9caeed51062e4190f95"

URI_aarch64_rust-zip0.6+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+flate2-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+flate2-devel}"
SRC_URI[aarch64_rust-zip0.6+flate2-devel.sha256sum] = "4b3c8107b58eac73ee0b92ee3e865652934d109860687f5eb4eaa590745af97c"

URI_aarch64_rust-zip0.6+hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+hmac-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+hmac-devel}"
SRC_URI[aarch64_rust-zip0.6+hmac-devel.sha256sum] = "6c6708aae1f932090ee0ec411807468a5405eba8bdc305ea14f0cda85098b449"

URI_aarch64_rust-zip0.6+pbkdf2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+pbkdf2-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+pbkdf2-devel}"
SRC_URI[aarch64_rust-zip0.6+pbkdf2-devel.sha256sum] = "6d60470b454e67c36aec191b05c9fd948006f637c06564e00aa1a63ea553457e"

URI_aarch64_rust-zip0.6+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+sha1-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+sha1-devel}"
SRC_URI[aarch64_rust-zip0.6+sha1-devel.sha256sum] = "7cdd0cbfa40f10572d7f030fcc7cab9052b5ba27664462020264a31e22b89054"

URI_aarch64_rust-zip0.6+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+time-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+time-devel}"
SRC_URI[aarch64_rust-zip0.6+time-devel.sha256sum] = "70e209690cf61a6c14498cb04609c2ac04546af0014ed13234f571f3a21acbef"

URI_aarch64_rust-zip0.6+unreserved-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+unreserved-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+unreserved-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+unreserved-devel}"
SRC_URI[aarch64_rust-zip0.6+unreserved-devel.sha256sum] = "6cfe4b9edb622d3f284103d8fefaf18922dc3595d722a8e01ca045a72f74bce7"

URI_aarch64_rust-zip0.6+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+zstd-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+zstd-devel}"
SRC_URI[aarch64_rust-zip0.6+zstd-devel.sha256sum] = "5bf563c420ca4af004761e94ccaf4a06b9c828f5cd03b4a161ef778206842d84"

URI_aarch64_rust-zip0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6-devel-0.6.6-5.el10_2.noarch.rpm;name=aarch64_rust-zip0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6-devel}"
SRC_URI[aarch64_rust-zip0.6-devel.sha256sum] = "ced5ce6e1597988bc0f7e74aa7dc0e2dab52e002e48d1aaf3ae860b2a83cca18"
RPROVIDES:rust-zip0.6-devel:aarch64 = "virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_9.0.0~"

RDEPENDS:rust-zip0.6+aes-crypto-devel = " \
 cargo \
 rust-zip0.6+aes-devel \
 rust-zip0.6+constant_time_eq-devel \
 rust-zip0.6+hmac-devel \
 rust-zip0.6+pbkdf2-devel \
 rust-zip0.6+sha1-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+aes-devel = " \
 cargo \
 rust-aes0.8+default-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+constant_time_eq-devel = " \
 cargo \
 rust-constant_time_eq+default-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+default-devel = " \
 cargo \
 rust-zip0.6+aes-crypto-devel \
 rust-zip0.6+bzip2-devel \
 rust-zip0.6+deflate-devel \
 rust-zip0.6+time-devel \
 rust-zip0.6+zstd-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+deflate-devel = " \
 cargo \
 rust-flate2+rust_backend-devel \
 rust-flate2-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+deflate-miniz-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-flate2-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+deflate-zlib-devel = " \
 cargo \
 rust-flate2+zlib-devel \
 rust-flate2-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+flate2-devel = " \
 cargo \
 rust-flate2-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+hmac-devel = " \
 cargo \
 rust-hmac0.12+default-devel \
 rust-hmac0.12+reset-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+pbkdf2-devel = " \
 cargo \
 rust-pbkdf2_0.12+default-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+sha1-devel = " \
 cargo \
 rust-sha1_0.10+default-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+time-devel = " \
 cargo \
 rust-time+std-devel \
 rust-time-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+unreserved-devel = " \
 cargo \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+zstd-devel = " \
 cargo \
 rust-zip0.6-devel \
 rust-zstd+default-devel \
 "
RDEPENDS:rust-zip0.6-devel = " \
 cargo \
 rust \
 rust-byteorder+default-devel \
 rust-crc32fast+default-devel \
 rust-crossbeam-utils+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_9.0.0~ rpm/virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_9.0.0~ rpm/virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_9.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_9.0.0~ rpm/virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_9.0.0~ rpm/virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_9.0.0~"
