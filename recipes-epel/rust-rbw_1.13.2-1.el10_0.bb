# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rbw"
PV = "1.13.2"
PR = "1.el10_0"
PACKAGES = " \
 rbw \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rbw-1.13.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf2c6f3a665321395b1bd83d49b26c50ebfffeae84ad7e3db2ba7c9f6c0838a2"

URI_x86_64_v2_rbw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rbw-1.13.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rbw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rbw}"
SRC_URI[x86_64_v2_rbw.sha256sum] = "ca437d2df882ec838edf5c09e83e7799f2a0aca2c28314c56d95b0bf2fce5210"

URI_aarch64_rbw = "${EPEL_MIRROR}/aarch64/Packages/r/rbw-1.13.2-1.el10_0.aarch64.rpm;name=aarch64_rbw;unpack=0"
SRC_URI:append = " ${URI_aarch64_rbw}"
SRC_URI[aarch64_rbw.sha256sum] = "81ec74218aa21259dfd2803727e4fa4bda7d204090244dd0a14fc5168f4e4ab6"

RDEPENDS:rbw = " \
 glibc \
 libgcc \
 "
