# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand0.8"
PV = "0.8.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-rand0.8+alloc-devel \
 rust-rand0.8+default-devel \
 rust-rand0.8+getrandom-devel \
 rust-rand0.8+libc-devel \
 rust-rand0.8+log-devel \
 rust-rand0.8+min_const_gen-devel \
 rust-rand0.8+rand_chacha-devel \
 rust-rand0.8+serde-devel \
 rust-rand0.8+serde1-devel \
 rust-rand0.8+small_rng-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand0.8-0.8.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09e64faf668addb4ae4bab10ff25772308580d49cea4eec3c5ca185a8231216f"

URI_x86_64_v2_rust-rand0.8+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+alloc-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+alloc-devel.sha256sum] = "ea149a3e37633905aee564f069e557ded05d54d55cb1edfda70fce6f9d28601c"

URI_x86_64_v2_rust-rand0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+default-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+default-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+default-devel.sha256sum] = "595eb7bc487c9f8a81dc78c1488b2b0ac9bd4472ad3016a95e91131f60161138"
RPROVIDES:rust-rand0.8+default-devel:append:x86_64_v2 = " virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"

URI_x86_64_v2_rust-rand0.8+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+getrandom-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+getrandom-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+getrandom-devel.sha256sum] = "915d971d62bdeb33b8f64cd5c414a7809c9b5a076caa1b37011bfcd3cf5ac98f"

URI_x86_64_v2_rust-rand0.8+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+libc-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+libc-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+libc-devel.sha256sum] = "bbbdc09fed8b299b6672dfb7aeafe9bf343d714b0c4b66ce4f2bf5e311c16ebb"

URI_x86_64_v2_rust-rand0.8+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+log-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+log-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+log-devel.sha256sum] = "ed8420909181fda182eddac4ddd9e8b609ac5627dba72dc964120e5d7f26ff39"

URI_x86_64_v2_rust-rand0.8+min_const_gen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+min_const_gen-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+min_const_gen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+min_const_gen-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+min_const_gen-devel.sha256sum] = "742748300f93efa0283fbaf880d9c84cf06df4bb089b66320466d0be2e2be539"

URI_x86_64_v2_rust-rand0.8+rand_chacha-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+rand_chacha-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+rand_chacha-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+rand_chacha-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+rand_chacha-devel.sha256sum] = "1ce961bcd0371e98c9afa8d226ef089544aff1dc8970c6f6966121be39594e66"

URI_x86_64_v2_rust-rand0.8+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+serde-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+serde-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+serde-devel.sha256sum] = "a583fa865bfa8477590e40198d46257ec83a7b15aa8f895dc028be678c8d6a55"

URI_x86_64_v2_rust-rand0.8+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+serde1-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+serde1-devel.sha256sum] = "6a7f733193d1ee4668da1725918670a8910a6ba944ded239fcd20f106c742945"

URI_x86_64_v2_rust-rand0.8+small_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+small_rng-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+small_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+small_rng-devel.sha256sum] = "5e235fdfa359402b97bd5c2fa0fe5e36496c1a386dc156a71aa78633094e23ab"

URI_x86_64_v2_rust-rand0.8+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+std-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+std-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+std-devel.sha256sum] = "fc7bf016c514f3f0667be6c74b42a3344909d1e808e7f7d4495ae7b4305cdf9b"

URI_x86_64_v2_rust-rand0.8+std_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+std_rng-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+std_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+std_rng-devel.sha256sum] = "cf4568f60550663904f5026034b9f2d7a918343e192690858414098a76e94264"

URI_x86_64_v2_rust-rand0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8-devel}"
SRC_URI[x86_64_v2_rust-rand0.8-devel.sha256sum] = "ac74d62786380f0fce06b4b551824a97b6bfbae8c402856b25018027d4be1f8a"

URI_aarch64_rust-rand0.8+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+alloc-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-rand0.8+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+alloc-devel}"
SRC_URI[aarch64_rust-rand0.8+alloc-devel.sha256sum] = "5e1059bbfe23bc5e6a64107081a864e66f200df4cf43d4b902eb8ef67203be3c"

URI_aarch64_rust-rand0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+default-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-rand0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+default-devel}"
SRC_URI[aarch64_rust-rand0.8+default-devel.sha256sum] = "4d12454f94338b96b3d485952221ae29993277bf2a6ec5dc6712fb467a02c531"
RPROVIDES:rust-rand0.8+default-devel:append:aarch64 = " virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"

URI_aarch64_rust-rand0.8+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+getrandom-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-rand0.8+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+getrandom-devel}"
SRC_URI[aarch64_rust-rand0.8+getrandom-devel.sha256sum] = "364e4f544cebfda208509701853c257cf2c17054deda5c0292da67cc8266f5b9"

URI_aarch64_rust-rand0.8+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+libc-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-rand0.8+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+libc-devel}"
SRC_URI[aarch64_rust-rand0.8+libc-devel.sha256sum] = "85a26e62041cf3e3f12c6c27aa9d4a693a6c97b798dc72f32ef95eaa4d3ac6c6"

URI_aarch64_rust-rand0.8+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+log-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-rand0.8+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+log-devel}"
SRC_URI[aarch64_rust-rand0.8+log-devel.sha256sum] = "26c2405f38b0d855af574f000760d6bf45db9d1cad944c9ecb174e386e54fca8"

URI_aarch64_rust-rand0.8+min_const_gen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+min_const_gen-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-rand0.8+min_const_gen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+min_const_gen-devel}"
SRC_URI[aarch64_rust-rand0.8+min_const_gen-devel.sha256sum] = "3d3a055f43912dffc185169132f44f097a9011d8557c86c79e7ac7aa33946476"

URI_aarch64_rust-rand0.8+rand_chacha-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+rand_chacha-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-rand0.8+rand_chacha-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+rand_chacha-devel}"
SRC_URI[aarch64_rust-rand0.8+rand_chacha-devel.sha256sum] = "4622a6362bd5e6493e042dc8c2cefc521e623c441bb1bd3956efb9c12c6506a3"

URI_aarch64_rust-rand0.8+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+serde-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-rand0.8+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+serde-devel}"
SRC_URI[aarch64_rust-rand0.8+serde-devel.sha256sum] = "8877e6c05816c0bdec829fb7efc8fe7993e90b6a3f90c1a6e8d26a48ab67622e"

URI_aarch64_rust-rand0.8+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+serde1-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-rand0.8+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+serde1-devel}"
SRC_URI[aarch64_rust-rand0.8+serde1-devel.sha256sum] = "17746b2c625ef070bf18949a5a9b7f325b9b1e8edfc6cea3d1621b6b884d0251"

URI_aarch64_rust-rand0.8+small_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+small_rng-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-rand0.8+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+small_rng-devel}"
SRC_URI[aarch64_rust-rand0.8+small_rng-devel.sha256sum] = "c98fd45c88d6baccc0f1c099ce6fe921f0e9279aa2aa402f6934e1e66aadb4f1"

URI_aarch64_rust-rand0.8+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+std-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-rand0.8+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+std-devel}"
SRC_URI[aarch64_rust-rand0.8+std-devel.sha256sum] = "3454d2ec791d306bb2daebe0fcf66d2c23420fa39e6af36b522fe66eebb85441"

URI_aarch64_rust-rand0.8+std_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+std_rng-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-rand0.8+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+std_rng-devel}"
SRC_URI[aarch64_rust-rand0.8+std_rng-devel.sha256sum] = "84095d098219f027bc1f74ef6b648b8bd410cc7c760860e9a6aa215ac4ca516e"

URI_aarch64_rust-rand0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-rand0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8-devel}"
SRC_URI[aarch64_rust-rand0.8-devel.sha256sum] = "1e245e8ea2083b2ca4b6fa6391095d44b2d605b4f3ab155e12ffb5785a76bd7c"

RDEPENDS:rust-rand0.8+alloc-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_core0.6+alloc-devel \
 "
RDEPENDS:rust-rand0.8+default-devel = " \
 cargo \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+getrandom-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_core0.6+getrandom-devel \
 "
RDEPENDS:rust-rand0.8+libc-devel = " \
 cargo \
 rust-libc-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+min_const_gen-devel = " \
 cargo \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+rand_chacha-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_chacha0.3-devel \
 "
RDEPENDS:rust-rand0.8+serde-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand0.8+serde1-devel = " \
 cargo \
 rust-rand0.8+serde-devel \
 rust-rand0.8-devel \
 rust-rand_core0.6+serde1-devel \
 "
RDEPENDS:rust-rand0.8+small_rng-devel = " \
 cargo \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+std-devel = " \
 cargo \
 rust-rand0.8+alloc-devel \
 rust-rand0.8+getrandom-devel \
 rust-rand0.8+libc-devel \
 rust-rand0.8-devel \
 rust-rand_chacha0.3+std-devel \
 rust-rand_chacha0.3-devel \
 rust-rand_core0.6+std-devel \
 "
RDEPENDS:rust-rand0.8+std_rng-devel = " \
 cargo \
 rust-rand0.8+rand_chacha-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8-devel = " \
 cargo \
 rust-rand_core0.6+default-devel \
 "
