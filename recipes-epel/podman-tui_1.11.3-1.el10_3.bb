# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "podman-tui"
PV = "1.11.3"
PR = "1.el10_3"
PACKAGES = " \
 podman-tui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/podman-tui-1.11.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3c4eeffd6d2aefb9f9ffa36469485d8d4e42dd395b93f9f8d4fdb10b614a9ac"

URI_x86_64_v2_podman-tui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/podman-tui-1.11.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_podman-tui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-tui}"
SRC_URI[x86_64_v2_podman-tui.sha256sum] = "2297e6f651ef962744355c504837de65eb3e378dd727feb5c17d7cf14a925c0b"

URI_aarch64_podman-tui = "${EPEL_MIRROR}/aarch64/Packages/p/podman-tui-1.11.3-1.el10_3.aarch64.rpm;name=aarch64_podman-tui;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-tui}"
SRC_URI[aarch64_podman-tui.sha256sum] = "e01fa242800b21e1296a8ac286a2ddf997083f1aa4f9ec26daba0bd97a8ec6c4"

RDEPENDS:podman-tui = " \
 glibc \
 "
