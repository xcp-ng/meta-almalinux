# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "svgpart"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 svgpart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/svgpart-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5e9caadd5a303f8670c99216d882eba787120191fff662ffb03279bce796780"

URI_x86_64_v2_svgpart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/svgpart-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_svgpart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_svgpart}"
SRC_URI[x86_64_v2_svgpart.sha256sum] = "93733d89a9fcb6a4098e7511577e10036606b9070b602b4b59ea66c857b84502"

URI_aarch64_svgpart = "${EPEL_MIRROR}/aarch64/Packages/s/svgpart-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_svgpart;unpack=0"
SRC_URI:append = " ${URI_aarch64_svgpart}"
SRC_URI[aarch64_svgpart.sha256sum] = "0757f1e925f18b8c7703d38acda46cc287ac23e15da015d26d72a7d8f098587f"

RDEPENDS:svgpart = " \
 glibc \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kparts \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
