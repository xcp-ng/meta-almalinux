# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-xpass"
PV = "1.2.1"
PR = "2.el10_3"
PACKAGES = " \
 php-pecl-xpass \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-xpass-1.2.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "799098c4c3e20466c6a7f3e74d9c74bdc634fd9e4b1299d50d850cf8843407ed"

URI_x86_64_v2_php-pecl-xpass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-xpass-1.2.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-xpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-xpass}"
SRC_URI[x86_64_v2_php-pecl-xpass.sha256sum] = "3e53b19950a5f637c31e7a6f7ad3f601b66d9dd286b129e8e6f0206b23c01a6c"

URI_aarch64_php-pecl-xpass = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-xpass-1.2.1-2.el10_3.aarch64.rpm;name=aarch64_php-pecl-xpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-xpass}"
SRC_URI[aarch64_php-pecl-xpass.sha256sum] = "80dd79b435d1702f561e9c40acab2c52c247a9d7a8bb10145f0ee8b1fc83b929"

RDEPENDS:php-pecl-xpass = " \
 glibc \
 libxcrypt \
 php-common \
 "
