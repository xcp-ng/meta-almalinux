# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-evmap"
PV = "11.0.0"
PR = "3.el10_3"
PACKAGES = " \
 rust-evmap+default-devel \
 rust-evmap+eviction-devel \
 rust-evmap+indexed-devel \
 rust-evmap+indexmap-devel \
 rust-evmap+rand-devel \
 rust-evmap-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-evmap-11.0.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "59f8997a41f60098c71c4628ffb618616457c2f4ab28a575c14951b81feccce8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-evmap+default-devel-11.0.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-evmap+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-evmap+default-devel.sha256sum] = "a986f85b1fa0817edcfb7cb35f617dd593c9c7d89283b7825d0086d8bdae0eed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-evmap+eviction-devel-11.0.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-evmap+eviction-devel;unpack=0"
SRC_URI[x86_64_v2_rust-evmap+eviction-devel.sha256sum] = "d6873e7424bc3e0abc0da7a5b287d2fc39c25ba8e78075646b89a320d1fc230d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-evmap+indexed-devel-11.0.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-evmap+indexed-devel;unpack=0"
SRC_URI[x86_64_v2_rust-evmap+indexed-devel.sha256sum] = "1d6c9d06d64fb39c6b8e65c2a07fe3a561b74b6f150dafc828cdac00c72a7799"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-evmap+indexmap-devel-11.0.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-evmap+indexmap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-evmap+indexmap-devel.sha256sum] = "f1192bf76f52bd5384c06a7023fe22da6436b1b3da66a37b38cdeda3890a8347"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-evmap+rand-devel-11.0.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-evmap+rand-devel;unpack=0"
SRC_URI[x86_64_v2_rust-evmap+rand-devel.sha256sum] = "497b519cd4444d6fe293b2c40af9372995fe111bc83af917323b1407dfc273d9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-evmap-devel-11.0.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-evmap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-evmap-devel.sha256sum] = "ab2738eb3e6f9f3e6c460d9ea43c2f023f5ed0098c63d3cdd572ce6dcc127118"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-evmap+default-devel-11.0.0-3.el10_3.noarch.rpm;name=aarch64_rust-evmap+default-devel;unpack=0"
SRC_URI[aarch64_rust-evmap+default-devel.sha256sum] = "b2e121c3983e1d4c59aba2472962e4a04d90c9704b81d583fcd8bcb21c960c27"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-evmap+eviction-devel-11.0.0-3.el10_3.noarch.rpm;name=aarch64_rust-evmap+eviction-devel;unpack=0"
SRC_URI[aarch64_rust-evmap+eviction-devel.sha256sum] = "c5c7bf2519bd9bfe04526a183491386d0b51b4a738e2c94ccd6ce42bfc20bdfc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-evmap+indexed-devel-11.0.0-3.el10_3.noarch.rpm;name=aarch64_rust-evmap+indexed-devel;unpack=0"
SRC_URI[aarch64_rust-evmap+indexed-devel.sha256sum] = "78b845866ef90097e3965627e7b0be32c966fbf4ab9c636999fdda0ff12b5b9b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-evmap+indexmap-devel-11.0.0-3.el10_3.noarch.rpm;name=aarch64_rust-evmap+indexmap-devel;unpack=0"
SRC_URI[aarch64_rust-evmap+indexmap-devel.sha256sum] = "5d2bf97422691c4900811c2791000cca129904f199f2adb58a58e851570065da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-evmap+rand-devel-11.0.0-3.el10_3.noarch.rpm;name=aarch64_rust-evmap+rand-devel;unpack=0"
SRC_URI[aarch64_rust-evmap+rand-devel.sha256sum] = "7cf2e4ec7fb8b634414c8dbf0d5b0daa14493ba018478226e95235565c68b57c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-evmap-devel-11.0.0-3.el10_3.noarch.rpm;name=aarch64_rust-evmap-devel;unpack=0"
SRC_URI[aarch64_rust-evmap-devel.sha256sum] = "84c51fa5ac3603d297fd2eaf554dafb2f926d771b48bb8678e9c9a9f0d4efcb9"

RDEPENDS:rust-evmap+default-devel = " \
 cargo \
 rust-evmap-devel \
 "
RDEPENDS:rust-evmap+eviction-devel = " \
 cargo \
 rust-evmap+indexed-devel \
 rust-evmap+rand-devel \
 rust-evmap-devel \
 "
RDEPENDS:rust-evmap+indexed-devel = " \
 cargo \
 rust-evmap+indexmap-devel \
 rust-evmap-devel \
 "
RDEPENDS:rust-evmap+indexmap-devel = " \
 cargo \
 rust-evmap-devel \
 rust-indexmap+default-devel \
 "
RDEPENDS:rust-evmap+rand-devel = " \
 cargo \
 rust-evmap-devel \
 rust-rand0.9+alloc-devel \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-evmap-devel = " \
 cargo \
 rust-hashbag+default-devel \
 rust-left-right+default-devel \
 rust-smallvec+default-devel \
 "
