# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs22"
PE = "1"
PV = "22.23.2"
PR = "1.el10"
PACKAGES = " \
 nodejs \
 nodejs-devel \
 nodejs-docs \
 nodejs-full-i18n \
 nodejs-libs \
 nodejs-npm \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs22-22.23.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c15b89725fce4647ca6b418993761fbd1dc6946437924ae62d798e0521710094"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-22.23.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs;unpack=0"
SRC_URI[x86_64_v2_nodejs.sha256sum] = "a9405d3901e6fc5c8244e17c03bc3c2da6871a0406cf58281f534cb14241889d"
RPROVIDES:nodejs:append:x86_64_v2 = " virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-devel-22.23.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs-devel;unpack=0"
SRC_URI[x86_64_v2_nodejs-devel.sha256sum] = "73ad95d668406fb7936974cf0d1ef0e0aac89c8d58b542d26543994b8cc0f273"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-docs-22.23.2-1.el10.noarch.rpm;name=x86_64_v2_nodejs-docs;unpack=0"
SRC_URI[x86_64_v2_nodejs-docs.sha256sum] = "390c60d2554ba54c024ad601c16eb3a32346740191dfe033a301d0b6da0b4ef4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-full-i18n-22.23.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs-full-i18n;unpack=0"
SRC_URI[x86_64_v2_nodejs-full-i18n.sha256sum] = "4bdad94fcceec65e06948b5574fba997c786c84453bafc138e59aba9f25011df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-libs-22.23.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs-libs;unpack=0"
SRC_URI[x86_64_v2_nodejs-libs.sha256sum] = "a81927ae06d6d4f68e27a8412374255d319cbaa2d60fba05f83d988cbae11516"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-npm-10.9.8-1.22.23.2.1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs-npm;unpack=0"
SRC_URI[x86_64_v2_nodejs-npm.sha256sum] = "4de540f1799a2bc49ec89c80a37835b3f2e851d6abfd6d04067b6ad83110e354"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-22.23.2-1.el10.aarch64.rpm;name=aarch64_nodejs;unpack=0"
SRC_URI[aarch64_nodejs.sha256sum] = "db3c5a3ee990af3a06bcebdc08c7ac1c79f9c5f1413cd0f0ccc9b2f74c6f3012"
RPROVIDES:nodejs:append:aarch64 = " virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-devel-22.23.2-1.el10.aarch64.rpm;name=aarch64_nodejs-devel;unpack=0"
SRC_URI[aarch64_nodejs-devel.sha256sum] = "9a450d7226be3fcb9b82508e4c7be16b0b9ebcc1bda13e9e4e9346f2589ad96e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-docs-22.23.2-1.el10.noarch.rpm;name=aarch64_nodejs-docs;unpack=0"
SRC_URI[aarch64_nodejs-docs.sha256sum] = "390c60d2554ba54c024ad601c16eb3a32346740191dfe033a301d0b6da0b4ef4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-full-i18n-22.23.2-1.el10.aarch64.rpm;name=aarch64_nodejs-full-i18n;unpack=0"
SRC_URI[aarch64_nodejs-full-i18n.sha256sum] = "1651f4d365c2c834600458201042ba947a8e26cfb4bfdde3e3b080c9c75c771f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-libs-22.23.2-1.el10.aarch64.rpm;name=aarch64_nodejs-libs;unpack=0"
SRC_URI[aarch64_nodejs-libs.sha256sum] = "1fb70113237c18ea4c9a70020886dbdede4b9071f1aef55714a5a1e58a71db96"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-npm-10.9.8-1.22.23.2.1.el10.aarch64.rpm;name=aarch64_nodejs-npm;unpack=0"
SRC_URI[aarch64_nodejs-npm.sha256sum] = "a2ebb921238767698c0e686ab26f074236a23bacbed3f81510b01e4361130439"

RDEPENDS:nodejs = " \
 ca-certificates \
 glibc \
 libuv \
 nodejs-libs \
 openssl \
 "
RDEPENDS:nodejs-devel = " \
 bash \
 brotli-devel \
 libuv-devel \
 nodejs \
 nodejs-libs \
 nodejs-packaging \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:nodejs-docs = " \
 nodejs \
 "
RDEPENDS:nodejs-full-i18n = " \
 nodejs \
 "
RDEPENDS:nodejs-libs = " \
 c-ares \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 libuv \
 openssl-libs \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:nodejs-npm = " \
 bash \
 nodejs \
 "
