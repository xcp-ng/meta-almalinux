# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kuserfeedback"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kuserfeedback \
 kf6-kuserfeedback-console \
 kf6-kuserfeedback-devel \
 kf6-kuserfeedback-doc \
 kf6-kuserfeedback-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kuserfeedback-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b4f0d49221f85bca3777f42365fd3922888e5aaf392d8efe6f0823234bb3a42"

URI_x86_64_v2_kf6-kuserfeedback = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback}"
SRC_URI[x86_64_v2_kf6-kuserfeedback.sha256sum] = "5160a9342fd4cfd42944e91045124be2233c2ba20ee8cc32ef3b4f3a462bebe6"

URI_x86_64_v2_kf6-kuserfeedback-console = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-console-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback-console;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback-console}"
SRC_URI[x86_64_v2_kf6-kuserfeedback-console.sha256sum] = "08af865ac80671e2ea073743c422e3675099dc3d341fd173e76539605e31f4c1"

URI_x86_64_v2_kf6-kuserfeedback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback-devel}"
SRC_URI[x86_64_v2_kf6-kuserfeedback-devel.sha256sum] = "2c75e661d244f8968085edc8db55fdaec0bc9ab9bc21f8948bc14f3cfeb999fd"

URI_x86_64_v2_kf6-kuserfeedback-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kuserfeedback-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback-doc}"
SRC_URI[x86_64_v2_kf6-kuserfeedback-doc.sha256sum] = "f33c7725d10f28de0b26f7e82d1c49f66d41ec92594dcbdeaeb5e6935f60b3a9"

URI_x86_64_v2_kf6-kuserfeedback-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kuserfeedback-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback-html}"
SRC_URI[x86_64_v2_kf6-kuserfeedback-html.sha256sum] = "fdc46ca77bb9e511f613baa9c58d1eb025884b279fb8b99f38e30468155e083d"

URI_aarch64_kf6-kuserfeedback = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kuserfeedback;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback}"
SRC_URI[aarch64_kf6-kuserfeedback.sha256sum] = "fa4342bafc63b7df2d54ab6dc112318590c6c4af0e0e3e75c38c8e52c3ff8ee6"

URI_aarch64_kf6-kuserfeedback-console = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-console-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kuserfeedback-console;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback-console}"
SRC_URI[aarch64_kf6-kuserfeedback-console.sha256sum] = "24b808deb0d20c9b4e88977a3bc2f919083bbb359c4c3fe3e4bd8ce15dde3198"

URI_aarch64_kf6-kuserfeedback-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kuserfeedback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback-devel}"
SRC_URI[aarch64_kf6-kuserfeedback-devel.sha256sum] = "ebb8dadedd7e1f62242c61549fa0d7556e9cafb08028c14781f29e795867a328"

URI_aarch64_kf6-kuserfeedback-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kuserfeedback-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback-doc}"
SRC_URI[aarch64_kf6-kuserfeedback-doc.sha256sum] = "0d813368a5d73db750549d2ba3b49b46ee1a6d4c4b64f2ca67b18a17fed76d79"

URI_aarch64_kf6-kuserfeedback-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kuserfeedback-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback-html}"
SRC_URI[aarch64_kf6-kuserfeedback-html.sha256sum] = "d311bee676289e76a752131478bdc1eb867987914c5d0fa7c6c5bb4003ce20fc"

RDEPENDS:kf6-kuserfeedback = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kuserfeedback-console = " \
 glibc \
 kf6-kuserfeedback \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtsvg \
 "
RDEPENDS:kf6-kuserfeedback-devel = " \
 cmake-filesystem \
 kf6-kuserfeedback \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kuserfeedback-doc = " \
 "
RDEPENDS:kf6-kuserfeedback-html = " \
 "
