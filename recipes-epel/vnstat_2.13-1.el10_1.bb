# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vnstat"
PV = "2.13"
PR = "1.el10_1"
PACKAGES = " \
 vnstat \
 vnstat-vnstati \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/vnstat-2.13-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "75fa53a0906e9618e6487f0a8b0fae50c68505c211cc6e9c52fd2bfe8316d518"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vnstat-2.13-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vnstat;unpack=0"
SRC_URI[x86_64_v2_vnstat.sha256sum] = "9313ca8d40f02a90e9749cade95faa637c1c8e43913ffebb22b8cb2397082802"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vnstat-vnstati-2.13-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vnstat-vnstati;unpack=0"
SRC_URI[x86_64_v2_vnstat-vnstati.sha256sum] = "4349cffb21896b7bcb52affd214a2f084c4ee9ca92958b8d6af269c7077f3422"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vnstat-2.13-1.el10_1.aarch64.rpm;name=aarch64_vnstat;unpack=0"
SRC_URI[aarch64_vnstat.sha256sum] = "7a381ce5a8829d30ed1835c2fda306434348eb3dc976c0c323bd1d6b04b509a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vnstat-vnstati-2.13-1.el10_1.aarch64.rpm;name=aarch64_vnstat-vnstati;unpack=0"
SRC_URI[aarch64_vnstat-vnstati.sha256sum] = "05dc6593f5a078f52a6cdd3ead8a7d594aa3ae58fa3aebc5bad312c352c84e96"

RDEPENDS:vnstat = " \
 bash \
 glibc \
 sqlite-libs \
 systemd \
 "
RDEPENDS:vnstat-vnstati = " \
 gd \
 glibc \
 sqlite-libs \
 "
