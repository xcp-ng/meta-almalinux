# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grub2"
PE = "1"
PV = "2.12"
PR = "46.el10_2.alma.1"
PACKAGES:x86_64_v2 = " \
 grub2-common \
 grub2-efi-aa64-modules \
 grub2-efi-x64 \
 grub2-efi-x64-cdboot \
 grub2-efi-x64-modules \
 grub2-pc \
 grub2-pc-modules \
 grub2-tools \
 grub2-tools-efi \
 grub2-tools-extra \
 grub2-tools-minimal \
"
PACKAGES:aarch64 = " \
 grub2-common \
 grub2-efi-aa64 \
 grub2-efi-aa64-cdboot \
 grub2-efi-aa64-modules \
 grub2-efi-x64-modules \
 grub2-tools \
 grub2-tools-extra \
 grub2-tools-minimal \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/grub2-2.12-46.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5eb452d5d9b33557f1fd6fbdef2bc7c2dfb9413eae3c056891519c735bc12f9"

URI_x86_64_v2_grub2-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-common-2.12-46.el10_2.alma.1.noarch.rpm;name=x86_64_v2_grub2-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-common}"
SRC_URI[x86_64_v2_grub2-common.sha256sum] = "808cae3f3be1989408ef502a5146b32fff0bb8c14651fedab1cfdb5575dca768"

URI_x86_64_v2_grub2-efi-aa64-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-aa64-modules-2.12-46.el10_2.alma.1.noarch.rpm;name=x86_64_v2_grub2-efi-aa64-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-aa64-modules}"
SRC_URI[x86_64_v2_grub2-efi-aa64-modules.sha256sum] = "0f42515dc0262c8ee45b349869446ff8256e11661b8fb0a8e1796c2ba3d660e8"

URI_x86_64_v2_grub2-efi-x64 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-2.12-46.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-efi-x64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-x64}"
SRC_URI[x86_64_v2_grub2-efi-x64.sha256sum] = "59de1caadc38147b33fdf625e7ead5306d76b98e49ca30405e7d7e492051d539"

URI_x86_64_v2_grub2-efi-x64-cdboot = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-cdboot-2.12-46.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-efi-x64-cdboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-x64-cdboot}"
SRC_URI[x86_64_v2_grub2-efi-x64-cdboot.sha256sum] = "9fefae6e952ed50cd26e76c6720a05a4165cda82d412a8ae0f6dad3280f5d449"

URI_x86_64_v2_grub2-efi-x64-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-modules-2.12-46.el10_2.alma.1.noarch.rpm;name=x86_64_v2_grub2-efi-x64-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-x64-modules}"
SRC_URI[x86_64_v2_grub2-efi-x64-modules.sha256sum] = "dda8d4e24424ce063805155d2e7286f012d1f732ce4ce75133762a2e334125ad"

URI_x86_64_v2_grub2-pc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-pc-2.12-46.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-pc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-pc}"
SRC_URI[x86_64_v2_grub2-pc.sha256sum] = "20b420bd3902737b1a8abce91ae8daadf80ec7b3b1dbc9911c40289b186dbe59"

URI_x86_64_v2_grub2-pc-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-pc-modules-2.12-46.el10_2.alma.1.noarch.rpm;name=x86_64_v2_grub2-pc-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-pc-modules}"
SRC_URI[x86_64_v2_grub2-pc-modules.sha256sum] = "b0e2cd48d65484d19b03112b805960f7946157cc7f3e93e772be46a9fe0a53a0"

URI_x86_64_v2_grub2-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-2.12-46.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools}"
SRC_URI[x86_64_v2_grub2-tools.sha256sum] = "bee7379138d53e202ed4b84e64c40ace131724435afc782109dac15b89eaeae3"

URI_x86_64_v2_grub2-tools-efi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-efi-2.12-46.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-efi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools-efi}"
SRC_URI[x86_64_v2_grub2-tools-efi.sha256sum] = "c55ba86d8d02416fbee8cdfaab664656ab0b292340de1643ad33d7a81a5d12b0"

URI_x86_64_v2_grub2-tools-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-extra-2.12-46.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools-extra}"
SRC_URI[x86_64_v2_grub2-tools-extra.sha256sum] = "6f6da828b87b723de95e66d64d03b4c11db380c26bfc93e177f74941000af22f"

URI_x86_64_v2_grub2-tools-minimal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-minimal-2.12-46.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools-minimal}"
SRC_URI[x86_64_v2_grub2-tools-minimal.sha256sum] = "0d920a070a39d17fe15aa7e0d7c90545cc6b55c3f84a56397673fd1cd7640293"

URI_aarch64_grub2-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-common-2.12-46.el10_2.alma.1.noarch.rpm;name=aarch64_grub2-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-common}"
SRC_URI[aarch64_grub2-common.sha256sum] = "808cae3f3be1989408ef502a5146b32fff0bb8c14651fedab1cfdb5575dca768"

URI_aarch64_grub2-efi-aa64 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-2.12-46.el10_2.alma.1.aarch64.rpm;name=aarch64_grub2-efi-aa64;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-aa64}"
SRC_URI[aarch64_grub2-efi-aa64.sha256sum] = "e68018c7ce6bad99293fc254057441d4947be082c0bd49759d26f56bc74c1482"

URI_aarch64_grub2-efi-aa64-cdboot = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-cdboot-2.12-46.el10_2.alma.1.aarch64.rpm;name=aarch64_grub2-efi-aa64-cdboot;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-aa64-cdboot}"
SRC_URI[aarch64_grub2-efi-aa64-cdboot.sha256sum] = "f1c3fe90a2f692ab2a41cc6a4fe9f3b040cb4362b87bace89fb96e74169e898e"

URI_aarch64_grub2-efi-aa64-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-modules-2.12-46.el10_2.alma.1.noarch.rpm;name=aarch64_grub2-efi-aa64-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-aa64-modules}"
SRC_URI[aarch64_grub2-efi-aa64-modules.sha256sum] = "0f42515dc0262c8ee45b349869446ff8256e11661b8fb0a8e1796c2ba3d660e8"

URI_aarch64_grub2-efi-x64-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-x64-modules-2.12-46.el10_2.alma.1.noarch.rpm;name=aarch64_grub2-efi-x64-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-x64-modules}"
SRC_URI[aarch64_grub2-efi-x64-modules.sha256sum] = "dda8d4e24424ce063805155d2e7286f012d1f732ce4ce75133762a2e334125ad"

URI_aarch64_grub2-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-2.12-46.el10_2.alma.1.aarch64.rpm;name=aarch64_grub2-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-tools}"
SRC_URI[aarch64_grub2-tools.sha256sum] = "5999353775021936ec7c4c123d077187c025ed2848e57baaebd2493a58d9314f"

URI_aarch64_grub2-tools-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-extra-2.12-46.el10_2.alma.1.aarch64.rpm;name=aarch64_grub2-tools-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-tools-extra}"
SRC_URI[aarch64_grub2-tools-extra.sha256sum] = "d68058d7f2dc6f8c29b7081ac1891e4edb39e9128838f4c35ce63723fea6d85d"

URI_aarch64_grub2-tools-minimal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-minimal-2.12-46.el10_2.alma.1.aarch64.rpm;name=aarch64_grub2-tools-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-tools-minimal}"
SRC_URI[aarch64_grub2-tools-minimal.sha256sum] = "69ad6bbb2fce8ac943fc9044c1e676ad1b9dd866b8ceb1fc6bdd2eefc7e36bd3"

RDEPENDS:grub2-common = " \
 bash \
 grep \
 util-linux-core \
 virtual/coreutils \
 "
RDEPENDS:grub2-efi-aa64-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-efi-x64 = " \
 bash \
 efi-filesystem \
 grub2-common \
 grub2-tools \
 grub2-tools-minimal \
 "
RDEPENDS:grub2-efi-x64-cdboot = " \
 grub2-common \
 "
RDEPENDS:grub2-efi-x64-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-pc = " \
 dracut \
 file \
 gettext-runtime \
 grub2-common \
 grub2-pc-modules \
 grub2-tools \
 grub2-tools-minimal \
 which \
 "
RDEPENDS:grub2-pc-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-tools = " \
 bash \
 device-mapper-libs \
 dracut \
 file \
 gettext-runtime \
 glibc \
 grep \
 grub2-common \
 os-prober \
 sed \
 systemd \
 xz-libs \
 "
RDEPENDS:grub2-tools-efi = " \
 device-mapper-libs \
 file \
 gettext-runtime \
 glibc \
 grub2-common \
 os-prober \
 "
RDEPENDS:grub2-tools-extra = " \
 bash \
 device-mapper-libs \
 file \
 freetype \
 gettext-runtime \
 glibc \
 grub2-common \
 grub2-tools-minimal \
 mtools \
 os-prober \
 xz-libs \
 "
RDEPENDS:grub2-tools-minimal = " \
 bash \
 device-mapper-libs \
 fuse-libs \
 gettext-runtime \
 glibc \
 grub2-common \
 xz-libs \
 "
RDEPENDS:grub2-efi-aa64 = " \
 bash \
 efi-filesystem \
 grub2-common \
 grub2-tools \
 grub2-tools-minimal \
 "
RDEPENDS:grub2-efi-aa64-cdboot = " \
 grub2-common \
 "
