# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mokutil"
PE = "2"
PV = "0.7.2"
PR = "4.el10.alma.1"
PACKAGES = " \
 mokutil \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mokutil-0.7.2-4.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67fc0ee550b09e1cd718c0f217616090c25ff44c0b92691f50b6802266b99a2e"

URI_x86_64_v2_mokutil = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mokutil-0.7.2-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mokutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mokutil}"
SRC_URI[x86_64_v2_mokutil.sha256sum] = "42e1b4154034f835f683db1407485de6ca62915813f47f3accfbdbab2e50ccd2"

URI_aarch64_mokutil = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mokutil-0.7.2-4.el10.alma.1.aarch64.rpm;name=aarch64_mokutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_mokutil}"
SRC_URI[aarch64_mokutil.sha256sum] = "8ec733110a095e624dcddfd43d3df487b67d30dc7a511e2c7e602459ff5de594"

RDEPENDS:mokutil = " \
 efivar-libs \
 glibc \
 keyutils-libs \
 libxcrypt \
 openssl-libs \
 "
