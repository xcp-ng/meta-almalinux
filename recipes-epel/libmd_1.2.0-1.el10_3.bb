# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmd"
PV = "1.2.0"
PR = "1.el10_3"
PACKAGES = " \
 libmd \
 libmd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmd-1.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45cc5f544084c6e4a5324511f013cb4c2c1caa9b53f69e8caa3e751ec839f6b1"

URI_x86_64_v2_libmd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmd-1.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmd}"
SRC_URI[x86_64_v2_libmd.sha256sum] = "302ffb9f0e6179960f9084c6d6d93a7614413b4d55c93aaca7d155e08ce7a190"

URI_x86_64_v2_libmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmd-devel-1.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmd-devel}"
SRC_URI[x86_64_v2_libmd-devel.sha256sum] = "fecee08bde946665063e6950292862b42c7da397085ddde1e986bcd5d4b8357a"

URI_aarch64_libmd = "${EPEL_MIRROR}/aarch64/Packages/l/libmd-1.2.0-1.el10_3.aarch64.rpm;name=aarch64_libmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmd}"
SRC_URI[aarch64_libmd.sha256sum] = "75d341d33625929455b26e2af1a267afe7204ee385894c77d45c05176650c3ce"

URI_aarch64_libmd-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmd-devel-1.2.0-1.el10_3.aarch64.rpm;name=aarch64_libmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmd-devel}"
SRC_URI[aarch64_libmd-devel.sha256sum] = "bfd149349c9a1e1fde2599ba9cd650acb161d3ee8e22719542bd350356b3623d"

RDEPENDS:libmd = " \
 glibc \
 "
RDEPENDS:libmd-devel = " \
 libmd \
 pkgconf-pkg-config \
 "
