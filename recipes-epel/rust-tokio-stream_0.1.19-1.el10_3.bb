# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-stream"
PV = "0.1.19"
PR = "1.el10_3"
PACKAGES = " \
 rust-tokio-stream+default-devel \
 rust-tokio-stream+fs-devel \
 rust-tokio-stream+full-devel \
 rust-tokio-stream+io-util-devel \
 rust-tokio-stream+net-devel \
 rust-tokio-stream+rt-devel \
 rust-tokio-stream+signal-devel \
 rust-tokio-stream+sync-devel \
 rust-tokio-stream+time-devel \
 rust-tokio-stream+tokio-util-devel \
 rust-tokio-stream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-stream-0.1.19-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6a972555d92b979025b1d7fc5e3a53975f69fbd8011a092731c03c456220336"

URI_x86_64_v2_rust-tokio-stream+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+default-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+default-devel.sha256sum] = "ee761e9785304b83aabd518dc3d3b2d693933054365ab26f58ea35deb1af3d2d"

URI_x86_64_v2_rust-tokio-stream+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+fs-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+fs-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+fs-devel.sha256sum] = "538519591164f5149b2a3ab53ec260df2f079e9827a350ca6abd70eba9497867"

URI_x86_64_v2_rust-tokio-stream+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+full-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+full-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+full-devel.sha256sum] = "aa33be844f62cffa9756adf9d8dec3ef6972da1839dd170f5a5d45e5f4b820db"

URI_x86_64_v2_rust-tokio-stream+io-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+io-util-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+io-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+io-util-devel.sha256sum] = "cdfa5ea1326ed6fa6f3662d4e83f6bb72dc30affd87039ae39389d42611834b4"

URI_x86_64_v2_rust-tokio-stream+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+net-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+net-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+net-devel.sha256sum] = "c8239a2efe746fe67ad22f2d91a95f1e40308999e63f9b3f47db2b8df43b024c"

URI_x86_64_v2_rust-tokio-stream+rt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+rt-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+rt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+rt-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+rt-devel.sha256sum] = "4f8b5fded8979786a3bb50a6f632326b089796a2c9a5a46f07eb851fc5620d3d"

URI_x86_64_v2_rust-tokio-stream+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+signal-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+signal-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+signal-devel.sha256sum] = "5a36431e8260bdf38467b7cd49b4e65af3c73e90d12d76e61b415afe86665081"

URI_x86_64_v2_rust-tokio-stream+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+sync-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+sync-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+sync-devel.sha256sum] = "ab0d59bfa218b64856cf2be23f4acbfca357b66226654ba07d27c827d79e80c9"

URI_x86_64_v2_rust-tokio-stream+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+time-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+time-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+time-devel.sha256sum] = "d0d58f4675ceb4d56f75e6fc53f5965f93788895405c51e978cccd545a91a33f"

URI_x86_64_v2_rust-tokio-stream+tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+tokio-util-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+tokio-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+tokio-util-devel.sha256sum] = "a0bf590bb91b7fdbee56322505c567e901ec5cb1166f123d6483385fd46e4679"

URI_x86_64_v2_rust-tokio-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream-devel.sha256sum] = "f5d47efcc6242d9af3163af49b2f4561701c06574e85651f84cf4bea5118c04b"

URI_aarch64_rust-tokio-stream+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+default-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+default-devel}"
SRC_URI[aarch64_rust-tokio-stream+default-devel.sha256sum] = "66afefd26e5939888732f3fa23bc1a83a3b22dfd544efe4a674b0920c256bb7d"

URI_aarch64_rust-tokio-stream+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+fs-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-stream+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+fs-devel}"
SRC_URI[aarch64_rust-tokio-stream+fs-devel.sha256sum] = "8d92001ad9347d614a1149613fbbb68753fd3687e75a5cabdd5950506445e0fc"

URI_aarch64_rust-tokio-stream+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+full-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-stream+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+full-devel}"
SRC_URI[aarch64_rust-tokio-stream+full-devel.sha256sum] = "588f2fd7cedd1e822df014dd05ee3370e376f36dbcd88fba35bd2944417adc5a"

URI_aarch64_rust-tokio-stream+io-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+io-util-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-stream+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+io-util-devel}"
SRC_URI[aarch64_rust-tokio-stream+io-util-devel.sha256sum] = "3c4fedb3eb2cb00b78cd5dfebaeaafe46ba456c0cd8d7768bbb8719aebe95d67"

URI_aarch64_rust-tokio-stream+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+net-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-stream+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+net-devel}"
SRC_URI[aarch64_rust-tokio-stream+net-devel.sha256sum] = "5cd2df5766bfea295eb3bb7aad5d910280850a2d91984dd49b0a283ca1c3ae40"

URI_aarch64_rust-tokio-stream+rt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+rt-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-stream+rt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+rt-devel}"
SRC_URI[aarch64_rust-tokio-stream+rt-devel.sha256sum] = "8775d56015889f90039f10d3fae95382d27aa0bf6e6cf1e2a8e4037b7d58f8c0"

URI_aarch64_rust-tokio-stream+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+signal-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-stream+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+signal-devel}"
SRC_URI[aarch64_rust-tokio-stream+signal-devel.sha256sum] = "62c671a0c9a59209b8f74be7ab70504270ac009ebfea66288fa354fe48306a00"

URI_aarch64_rust-tokio-stream+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+sync-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-stream+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+sync-devel}"
SRC_URI[aarch64_rust-tokio-stream+sync-devel.sha256sum] = "d2e2e132262852b9a74c8666eaa9cfd359dd759461d3b1b4336fec4997091993"

URI_aarch64_rust-tokio-stream+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+time-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-stream+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+time-devel}"
SRC_URI[aarch64_rust-tokio-stream+time-devel.sha256sum] = "bbe32d2e41273e5507eea5b6c333a2aada7897b45a29a0891c637cb4c93df24f"

URI_aarch64_rust-tokio-stream+tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+tokio-util-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-stream+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+tokio-util-devel}"
SRC_URI[aarch64_rust-tokio-stream+tokio-util-devel.sha256sum] = "b17ebee6619abce485eeb09c3527c71b6ab430edf25fd4680241631d08459db4"

URI_aarch64_rust-tokio-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream-devel}"
SRC_URI[aarch64_rust-tokio-stream-devel.sha256sum] = "bf572b2cc9ae6dff045faceea14d2cff1d17eda9cb4ea1a638b9ee68872c5761"

RDEPENDS:rust-tokio-stream+default-devel = " \
 cargo \
 rust-tokio-stream+time-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+fs-devel = " \
 cargo \
 rust-tokio+fs-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+full-devel = " \
 cargo \
 rust-tokio-stream+fs-devel \
 rust-tokio-stream+io-util-devel \
 rust-tokio-stream+net-devel \
 rust-tokio-stream+rt-devel \
 rust-tokio-stream+signal-devel \
 rust-tokio-stream+sync-devel \
 rust-tokio-stream+time-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+io-util-devel = " \
 cargo \
 rust-tokio+io-util-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+net-devel = " \
 cargo \
 rust-tokio+net-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+rt-devel = " \
 cargo \
 rust-tokio+rt-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+signal-devel = " \
 cargo \
 rust-tokio+signal-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+sync-devel = " \
 cargo \
 rust-tokio+sync-devel \
 rust-tokio-stream+tokio-util-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+time-devel = " \
 cargo \
 rust-tokio+time-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+tokio-util-devel = " \
 cargo \
 rust-tokio-stream-devel \
 rust-tokio-util+default-devel \
 "
RDEPENDS:rust-tokio-stream-devel = " \
 cargo \
 rust \
 rust-futures-core+default-devel \
 rust-pin-project-lite+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
