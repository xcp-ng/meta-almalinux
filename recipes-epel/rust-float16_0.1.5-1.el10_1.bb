# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-float16"
PV = "0.1.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-float16+default-devel \
 rust-float16+std-devel \
 rust-float16-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-float16-0.1.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1de52157c2ce5e599dea2b2a26aed750e9764bdd3dba587d8d42c395ca1c4f91"

URI_x86_64_v2_rust-float16+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float16+default-devel-0.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float16+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float16+default-devel}"
SRC_URI[x86_64_v2_rust-float16+default-devel.sha256sum] = "d120fc19ca9f8b014eb43da260018bc525417091da3062af7cb8ed7bb37495e1"

URI_x86_64_v2_rust-float16+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float16+std-devel-0.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float16+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float16+std-devel}"
SRC_URI[x86_64_v2_rust-float16+std-devel.sha256sum] = "3618bcc1025993b1c50d64decdd85c6f2ab9be4cdc991c4f1d762f2237d54457"

URI_x86_64_v2_rust-float16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float16-devel-0.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float16-devel}"
SRC_URI[x86_64_v2_rust-float16-devel.sha256sum] = "0af0dbc0f21c5a4428c65d43db6d7beb76cdee3e975e61787ab9bd5edd6a75d8"

URI_aarch64_rust-float16+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float16+default-devel-0.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-float16+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float16+default-devel}"
SRC_URI[aarch64_rust-float16+default-devel.sha256sum] = "4864aafb3ea9cbc74a266d148f210b521b8857640eebe947b9a346300d3591a8"

URI_aarch64_rust-float16+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float16+std-devel-0.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-float16+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float16+std-devel}"
SRC_URI[aarch64_rust-float16+std-devel.sha256sum] = "ea5ce45b40b1ad4fc00800bc1eac6c8046c609f1dcd07586e9dad75b458770e2"

URI_aarch64_rust-float16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float16-devel-0.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-float16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float16-devel}"
SRC_URI[aarch64_rust-float16-devel.sha256sum] = "6305c05c5d4ddaa11f0292d762f868549127c206a0ed8fe99b1e9049b63da925"

RDEPENDS:rust-float16+default-devel = " \
 cargo \
 rust-float16+std-devel \
 rust-float16-devel \
 "
RDEPENDS:rust-float16+std-devel = " \
 cargo \
 rust-float16-devel \
 "
RDEPENDS:rust-float16-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-rustc_version+default-devel \
 "
