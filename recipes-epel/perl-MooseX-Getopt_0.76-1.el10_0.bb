# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MooseX-Getopt"
PV = "0.76"
PR = "1.el10_0"
PACKAGES = " \
 perl-MooseX-Getopt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MooseX-Getopt-0.76-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9c51ef132440191c8400d03faf2d7d9ea1b1d436d29f580ea0e288603a0e64e"

URI_x86_64_v2_perl-MooseX-Getopt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MooseX-Getopt-0.76-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MooseX-Getopt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MooseX-Getopt}"
SRC_URI[x86_64_v2_perl-MooseX-Getopt.sha256sum] = "3f1bb4aff5b518e6a8a4350dbf1bcea524ead2ff657e455fafcb1e06e1601239"

URI_aarch64_perl-MooseX-Getopt = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MooseX-Getopt-0.76-1.el10_0.noarch.rpm;name=aarch64_perl-MooseX-Getopt;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MooseX-Getopt}"
SRC_URI[aarch64_perl-MooseX-Getopt.sha256sum] = "e1e4ee64e88df1b91f3a59f594c3f4feaf9ba606bed68df314621e8a5298ed6e"

RDEPENDS:perl-MooseX-Getopt = " \
 perl-Carp \
 perl-Getopt-Long \
 perl-Getopt-Long-Descriptive \
 perl-Moose \
 perl-MooseX-Getopt \
 perl-MooseX-Role-Parameterized \
 perl-Scalar-List-Utils \
 perl-Try-Tiny \
 perl-libs \
 perl-namespace-autoclean \
 "
