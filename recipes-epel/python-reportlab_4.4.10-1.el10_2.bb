# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-reportlab"
PV = "4.4.10"
PR = "1.el10_2"
PACKAGES = " \
 python3-reportlab \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-reportlab-4.4.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2e16ac2ba4582a9e0745e67be6557b41e3ff01f3a101ee1a41dc9aa12d694d1"

URI_x86_64_v2_python3-reportlab = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-reportlab-4.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-reportlab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-reportlab}"
SRC_URI[x86_64_v2_python3-reportlab.sha256sum] = "c7079b645927d6d39c672818fc093665abc1f7d166ec47dfc1fa1f9814e7e439"

URI_aarch64_python3-reportlab = "${EPEL_MIRROR}/aarch64/Packages/p/python3-reportlab-4.4.10-1.el10_2.noarch.rpm;name=aarch64_python3-reportlab;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-reportlab}"
SRC_URI[aarch64_python3-reportlab.sha256sum] = "6fea6792c9728263051f7c9595e27d01719ecbbd11dcb78f74e5d8c1e99bf369"

RDEPENDS:python3-reportlab = " \
 dejavu-sans-fonts \
 python3 \
 python3-charset-normalizer \
 python3-pillow \
 "
