# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "amiri-fonts"
PV = "1.003"
PR = "1.el10_1"
PACKAGES = " \
 amiri-fonts \
 amiri-fonts-all \
 amiri-quran-colored-fonts \
 amiri-quran-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/amiri-fonts-1.003-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3096c312319c9110b33b00c02178abfff6d629a6034059fee3ada6f229b0ff5"

URI_x86_64_v2_amiri-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amiri-fonts-1.003-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_amiri-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amiri-fonts}"
SRC_URI[x86_64_v2_amiri-fonts.sha256sum] = "68b082e715b697dd0d5fef09fc1355a2ccd62f082d34b8c8588e64ac4cf1d7f2"

URI_x86_64_v2_amiri-fonts-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amiri-fonts-all-1.003-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_amiri-fonts-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amiri-fonts-all}"
SRC_URI[x86_64_v2_amiri-fonts-all.sha256sum] = "642203de346882af5e7cd28ede04044df68f26dd71e8ea389939b927ad970874"

URI_x86_64_v2_amiri-quran-colored-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amiri-quran-colored-fonts-1.003-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_amiri-quran-colored-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amiri-quran-colored-fonts}"
SRC_URI[x86_64_v2_amiri-quran-colored-fonts.sha256sum] = "6b5f8a35db6fe491e435c74c4777f560f9b7c6cd0b8541d84974b76e8676bf3f"

URI_x86_64_v2_amiri-quran-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amiri-quran-fonts-1.003-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_amiri-quran-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amiri-quran-fonts}"
SRC_URI[x86_64_v2_amiri-quran-fonts.sha256sum] = "d35295ab47b9214bbaee4a38ebdafb88a62e657499b2df5b648d01d3190ae301"

URI_aarch64_amiri-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/amiri-fonts-1.003-1.el10_1.noarch.rpm;name=aarch64_amiri-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_amiri-fonts}"
SRC_URI[aarch64_amiri-fonts.sha256sum] = "cc51962a4c04ca93f0ea1f523a4323734c9cf95fdb0bb8332c34d459720151b1"

URI_aarch64_amiri-fonts-all = "${EPEL_MIRROR}/aarch64/Packages/a/amiri-fonts-all-1.003-1.el10_1.noarch.rpm;name=aarch64_amiri-fonts-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_amiri-fonts-all}"
SRC_URI[aarch64_amiri-fonts-all.sha256sum] = "64d650705d596e0b2041de41943034c43b250a1a046fa423e1ce8fcf75c8ebe9"

URI_aarch64_amiri-quran-colored-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/amiri-quran-colored-fonts-1.003-1.el10_1.noarch.rpm;name=aarch64_amiri-quran-colored-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_amiri-quran-colored-fonts}"
SRC_URI[aarch64_amiri-quran-colored-fonts.sha256sum] = "074a98b127c0bc0274386c3feaf8ba634dcfd316c96ba19684acc7aa08f317fd"

URI_aarch64_amiri-quran-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/amiri-quran-fonts-1.003-1.el10_1.noarch.rpm;name=aarch64_amiri-quran-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_amiri-quran-fonts}"
SRC_URI[aarch64_amiri-quran-fonts.sha256sum] = "9c6d968f50ed0af9e204903eedee006af0def735ab358435fcbd998c96b3418c"

RDEPENDS:amiri-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:amiri-fonts-all = " \
 amiri-fonts \
 amiri-quran-colored-fonts \
 amiri-quran-fonts \
 "
RDEPENDS:amiri-quran-colored-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:amiri-quran-fonts = " \
 fonts-filesystem \
 "
