# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-os_display"
PV = "0.1.4"
PR = "3.el10_3"
PACKAGES = " \
 rust-os_display+alloc-devel \
 rust-os_display+default-devel \
 rust-os_display+native-devel \
 rust-os_display+std-devel \
 rust-os_display+unix-devel \
 rust-os_display+windows-devel \
 rust-os_display-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-os_display-0.1.4-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ac5fecf2bfe0803dcf739e0aa26d8d40f94147d3ceb53823b8155d8def6be60"

URI_x86_64_v2_rust-os_display+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_display+alloc-devel-0.1.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_display+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_display+alloc-devel}"
SRC_URI[x86_64_v2_rust-os_display+alloc-devel.sha256sum] = "e72b7e3c00d907f74089dfba226cad002e165544db8e03aa056c96fca0529444"

URI_x86_64_v2_rust-os_display+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_display+default-devel-0.1.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_display+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_display+default-devel}"
SRC_URI[x86_64_v2_rust-os_display+default-devel.sha256sum] = "4aedc688df30ecade454df62d56e23d1147e00235a9f908848402f83624e44ac"

URI_x86_64_v2_rust-os_display+native-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_display+native-devel-0.1.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_display+native-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_display+native-devel}"
SRC_URI[x86_64_v2_rust-os_display+native-devel.sha256sum] = "91e0adf162801035c9e6d3b004d61463d5b0daf68693d6a711b2521f7c4143e7"

URI_x86_64_v2_rust-os_display+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_display+std-devel-0.1.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_display+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_display+std-devel}"
SRC_URI[x86_64_v2_rust-os_display+std-devel.sha256sum] = "c23f2f485225eb18e07b9e88e9ccc2ae4fab6b0d2fd6e4c71f7089392df5f4bc"

URI_x86_64_v2_rust-os_display+unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_display+unix-devel-0.1.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_display+unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_display+unix-devel}"
SRC_URI[x86_64_v2_rust-os_display+unix-devel.sha256sum] = "e7587f7093a3192eebff0a5ff7b20eb6e321d6ea928e8b1baabe7c70586e43aa"

URI_x86_64_v2_rust-os_display+windows-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_display+windows-devel-0.1.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_display+windows-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_display+windows-devel}"
SRC_URI[x86_64_v2_rust-os_display+windows-devel.sha256sum] = "9bbc35cf3b57a8fdc1efe7a4edc226291933ae7b9055ff7e7955e4de4942a306"

URI_x86_64_v2_rust-os_display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_display-devel-0.1.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_display-devel}"
SRC_URI[x86_64_v2_rust-os_display-devel.sha256sum] = "cb1ff34daefb7e66e12868750d507fb166836893f4d6f0fc63d36312f6e6c405"

URI_aarch64_rust-os_display+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_display+alloc-devel-0.1.4-3.el10_3.noarch.rpm;name=aarch64_rust-os_display+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_display+alloc-devel}"
SRC_URI[aarch64_rust-os_display+alloc-devel.sha256sum] = "883edcdca916d270e28fe200677d410418c43d0a48c14a30ba1621c52aafd23f"

URI_aarch64_rust-os_display+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_display+default-devel-0.1.4-3.el10_3.noarch.rpm;name=aarch64_rust-os_display+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_display+default-devel}"
SRC_URI[aarch64_rust-os_display+default-devel.sha256sum] = "49ddc800a04a7ce24f2193985c40747b42e4fa410f69beca5422c871015dd31e"

URI_aarch64_rust-os_display+native-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_display+native-devel-0.1.4-3.el10_3.noarch.rpm;name=aarch64_rust-os_display+native-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_display+native-devel}"
SRC_URI[aarch64_rust-os_display+native-devel.sha256sum] = "e8d439f291ec957a75030240395c4467ce7f3379ed0390ef2e5aa0cfa8d2fbed"

URI_aarch64_rust-os_display+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_display+std-devel-0.1.4-3.el10_3.noarch.rpm;name=aarch64_rust-os_display+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_display+std-devel}"
SRC_URI[aarch64_rust-os_display+std-devel.sha256sum] = "920ba54e09337a790e09c24e156a07733de28c8b686bed3213b298fe5f79d75b"

URI_aarch64_rust-os_display+unix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_display+unix-devel-0.1.4-3.el10_3.noarch.rpm;name=aarch64_rust-os_display+unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_display+unix-devel}"
SRC_URI[aarch64_rust-os_display+unix-devel.sha256sum] = "38b38f888a17934814988581ae7826e832c30409d78a60e8f861acb5b2df7769"

URI_aarch64_rust-os_display+windows-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_display+windows-devel-0.1.4-3.el10_3.noarch.rpm;name=aarch64_rust-os_display+windows-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_display+windows-devel}"
SRC_URI[aarch64_rust-os_display+windows-devel.sha256sum] = "29fcd8240e1b41320a0bc15bd4983ae9a4b36acfb4cf4d40969b4bd88f3dc46e"

URI_aarch64_rust-os_display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_display-devel-0.1.4-3.el10_3.noarch.rpm;name=aarch64_rust-os_display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_display-devel}"
SRC_URI[aarch64_rust-os_display-devel.sha256sum] = "8f325c7e8ca4b5deb6b3e208ec338655937e225e1ef7917e328359c398786c3d"

RDEPENDS:rust-os_display+alloc-devel = " \
 cargo \
 rust-os_display-devel \
 "
RDEPENDS:rust-os_display+default-devel = " \
 cargo \
 rust-os_display+alloc-devel \
 rust-os_display+native-devel \
 rust-os_display+std-devel \
 rust-os_display-devel \
 "
RDEPENDS:rust-os_display+native-devel = " \
 cargo \
 rust-os_display-devel \
 "
RDEPENDS:rust-os_display+std-devel = " \
 cargo \
 rust-os_display+alloc-devel \
 rust-os_display-devel \
 "
RDEPENDS:rust-os_display+unix-devel = " \
 cargo \
 rust-os_display-devel \
 "
RDEPENDS:rust-os_display+windows-devel = " \
 cargo \
 rust-os_display-devel \
 "
RDEPENDS:rust-os_display-devel = " \
 cargo \
 rust \
 rust-unicode-width-devel \
 "
