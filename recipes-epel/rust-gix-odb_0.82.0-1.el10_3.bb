# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-odb"
PV = "0.82.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-odb+default-devel \
 rust-gix-odb+document-features-devel \
 rust-gix-odb+parallel-devel \
 rust-gix-odb+serde-devel \
 rust-gix-odb+sha1-devel \
 rust-gix-odb+sha256-devel \
 rust-gix-odb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-odb-0.82.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51bc7f66fa5c5589fec7bee1e40b9913b44e367c657ce8d87f384fc505908764"

URI_x86_64_v2_rust-gix-odb+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+default-devel-0.82.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+default-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+default-devel.sha256sum] = "f6262648a87795143f1817c9ebc2b9e89a278e8cafe7764875bf7ca5df434ea3"

URI_x86_64_v2_rust-gix-odb+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+document-features-devel-0.82.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+document-features-devel.sha256sum] = "1b1e84d7bf2c7935507b7eddbde374d30a680dc69eeba2a80ade117a630e2e35"

URI_x86_64_v2_rust-gix-odb+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+parallel-devel-0.82.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+parallel-devel.sha256sum] = "86f8e27b4764ca963a524b116cf3b11000d32b4814784ed53ec5c5d2879d8164"

URI_x86_64_v2_rust-gix-odb+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+serde-devel-0.82.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+serde-devel.sha256sum] = "50a9a49effbbce112f328e1335009505cf345e3e334f5d15a460c99aa6dc637a"

URI_x86_64_v2_rust-gix-odb+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+sha1-devel-0.82.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+sha1-devel.sha256sum] = "9d705a36a47d83c015a14eb11e2b689d3a0e93dda1247a703ecde2dfa280f74f"

URI_x86_64_v2_rust-gix-odb+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+sha256-devel-0.82.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+sha256-devel.sha256sum] = "d8d22005dac5e4709d0978c95852fe596777369d32088c14f1b3172b39fec600"

URI_x86_64_v2_rust-gix-odb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb-devel-0.82.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb-devel}"
SRC_URI[x86_64_v2_rust-gix-odb-devel.sha256sum] = "3ef237a7182ac45ffe362e6dd2ef4d99e442c79d3831a8d554056d30d23ddfce"

URI_aarch64_rust-gix-odb+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+default-devel-0.82.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-odb+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+default-devel}"
SRC_URI[aarch64_rust-gix-odb+default-devel.sha256sum] = "4c76e010fb100f1a18f620e9f298da0a81834b874242810174b347e6dcb939d3"

URI_aarch64_rust-gix-odb+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+document-features-devel-0.82.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-odb+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+document-features-devel}"
SRC_URI[aarch64_rust-gix-odb+document-features-devel.sha256sum] = "c013d13247e4044e8185ec010b2afb7495504e3785cc7a4061de5118e93ece42"

URI_aarch64_rust-gix-odb+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+parallel-devel-0.82.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-odb+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+parallel-devel}"
SRC_URI[aarch64_rust-gix-odb+parallel-devel.sha256sum] = "f02ba5394b3ec1cf1a4bef8701a0b598d5f4b790f969a3e6ab42bd52130e4a14"

URI_aarch64_rust-gix-odb+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+serde-devel-0.82.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-odb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+serde-devel}"
SRC_URI[aarch64_rust-gix-odb+serde-devel.sha256sum] = "1f8865d7784046dca3a6371dbeb4973847a07ded7917e586c91abdf999eb210f"

URI_aarch64_rust-gix-odb+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+sha1-devel-0.82.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-odb+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+sha1-devel}"
SRC_URI[aarch64_rust-gix-odb+sha1-devel.sha256sum] = "9f007ccb9ac66eb877257c6b4dba9bd0859d71e34267b7ccf9dacc11b7cf7bce"

URI_aarch64_rust-gix-odb+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+sha256-devel-0.82.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-odb+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+sha256-devel}"
SRC_URI[aarch64_rust-gix-odb+sha256-devel.sha256sum] = "d0b9deb341cade135095358a7209d4b6e49efeddc6c992beae9c1a9a9d534194"

URI_aarch64_rust-gix-odb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb-devel-0.82.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-odb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb-devel}"
SRC_URI[aarch64_rust-gix-odb-devel.sha256sum] = "538f709988dc3d580dde92ee36430710aa4eea842029d72059292845e372e2c7"

RDEPENDS:rust-gix-odb+default-devel = " \
 cargo \
 rust-gix-odb-devel \
 "
RDEPENDS:rust-gix-odb+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-odb-devel \
 "
RDEPENDS:rust-gix-odb+parallel-devel = " \
 cargo \
 rust-gix-features+parallel-devel \
 rust-gix-odb-devel \
 "
RDEPENDS:rust-gix-odb+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-odb-devel \
 rust-gix-pack+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-odb+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-odb-devel \
 rust-gix-pack+sha1-devel \
 "
RDEPENDS:rust-gix-odb+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-odb-devel \
 rust-gix-pack+sha256-devel \
 "
RDEPENDS:rust-gix-odb-devel = " \
 cargo \
 rust \
 rust-arc-swap+default-devel \
 rust-gix-features+crc32-devel \
 rust-gix-features+default-devel \
 rust-gix-features+walkdir-devel \
 rust-gix-features+zlib-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-object+default-devel \
 rust-gix-pack-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-memmap2+default-devel \
 rust-parking_lot+default-devel \
 rust-tempfile+default-devel \
 rust-thiserror+default-devel \
 "
