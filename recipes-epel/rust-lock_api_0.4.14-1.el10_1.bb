# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lock_api"
PV = "0.4.14"
PR = "1.el10_1"
PACKAGES = " \
 rust-lock_api+arc_lock-devel \
 rust-lock_api+atomic_usize-devel \
 rust-lock_api+default-devel \
 rust-lock_api+nightly-devel \
 rust-lock_api+owning_ref-devel \
 rust-lock_api+serde-devel \
 rust-lock_api-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lock_api-0.4.14-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eff56211a9f06216ed0efa3a07ee07511523387bf111893de600b80d7c835167"

URI_x86_64_v2_rust-lock_api+arc_lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+arc_lock-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+arc_lock-devel}"
SRC_URI[x86_64_v2_rust-lock_api+arc_lock-devel.sha256sum] = "8e37685b732e9242fc3050f490b3e718879f0d0f6188f276965b938a3adcc589"

URI_x86_64_v2_rust-lock_api+atomic_usize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+atomic_usize-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+atomic_usize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+atomic_usize-devel}"
SRC_URI[x86_64_v2_rust-lock_api+atomic_usize-devel.sha256sum] = "a9fa97033b1538e75b689c10150b6f0bf42c954b7d4c440c867b5230e16c9cab"

URI_x86_64_v2_rust-lock_api+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+default-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+default-devel}"
SRC_URI[x86_64_v2_rust-lock_api+default-devel.sha256sum] = "aee645f923b5bbec22e227af0889bbbaab641d72e5cdad497742ccd96138fa41"

URI_x86_64_v2_rust-lock_api+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+nightly-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+nightly-devel}"
SRC_URI[x86_64_v2_rust-lock_api+nightly-devel.sha256sum] = "0a8d3e1d53fac37b14e38a1a86a1a9ebc1e7dfe6b91a8008e83cb5968ce4215a"

URI_x86_64_v2_rust-lock_api+owning_ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+owning_ref-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+owning_ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+owning_ref-devel}"
SRC_URI[x86_64_v2_rust-lock_api+owning_ref-devel.sha256sum] = "d15b864cf2c9b487ce8c366b7308f824456728c2c93a85f0f4e597bf0a148293"

URI_x86_64_v2_rust-lock_api+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+serde-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+serde-devel}"
SRC_URI[x86_64_v2_rust-lock_api+serde-devel.sha256sum] = "167de67c2bf5ce4208de1f3b128db5ce738ac0268859c7ff79bb0c9699d64763"

URI_x86_64_v2_rust-lock_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api-devel}"
SRC_URI[x86_64_v2_rust-lock_api-devel.sha256sum] = "5d5ba94098cc181e4a3a4996ec685f5af5567e6fd74a73f5a965f9eefb78cb43"

URI_aarch64_rust-lock_api+arc_lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+arc_lock-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-lock_api+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+arc_lock-devel}"
SRC_URI[aarch64_rust-lock_api+arc_lock-devel.sha256sum] = "e95fa790bb91cb9b8e80ee75bf1b539a2b1b00327f023215dea5b1020f050b02"

URI_aarch64_rust-lock_api+atomic_usize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+atomic_usize-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-lock_api+atomic_usize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+atomic_usize-devel}"
SRC_URI[aarch64_rust-lock_api+atomic_usize-devel.sha256sum] = "e9def0a0374238e3b80d4add22d2c48d7caa7c045e8da23945c71735dee41779"

URI_aarch64_rust-lock_api+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+default-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-lock_api+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+default-devel}"
SRC_URI[aarch64_rust-lock_api+default-devel.sha256sum] = "af4778cdf918cb37442d47043a519b6cec4a85eba53cfdcf3d123d5fe5c457b5"

URI_aarch64_rust-lock_api+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+nightly-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-lock_api+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+nightly-devel}"
SRC_URI[aarch64_rust-lock_api+nightly-devel.sha256sum] = "c7992cf4ac62d8758e3a83bc2596edd3acead228631b8d545b7ba647f5778d47"

URI_aarch64_rust-lock_api+owning_ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+owning_ref-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-lock_api+owning_ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+owning_ref-devel}"
SRC_URI[aarch64_rust-lock_api+owning_ref-devel.sha256sum] = "4a0b6086765e99ec309e9b10c49451328c1ff355083ce0ed85bb19d1743e91d1"

URI_aarch64_rust-lock_api+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+serde-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-lock_api+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+serde-devel}"
SRC_URI[aarch64_rust-lock_api+serde-devel.sha256sum] = "9744c154e4b85d6d1e04e9923b68c3968ee6b07ffac0e7cb3edcb72057d7f09a"

URI_aarch64_rust-lock_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api-devel}"
SRC_URI[aarch64_rust-lock_api-devel.sha256sum] = "b4cc1191612cefd8efce20467ae35e0661d9016374b75f0a802f219c6fedc518"

RDEPENDS:rust-lock_api+arc_lock-devel = " \
 cargo \
 rust-lock_api-devel \
 "
RDEPENDS:rust-lock_api+atomic_usize-devel = " \
 cargo \
 rust-lock_api-devel \
 "
RDEPENDS:rust-lock_api+default-devel = " \
 cargo \
 rust-lock_api+atomic_usize-devel \
 rust-lock_api-devel \
 "
RDEPENDS:rust-lock_api+nightly-devel = " \
 cargo \
 rust-lock_api-devel \
 "
RDEPENDS:rust-lock_api+owning_ref-devel = " \
 cargo \
 rust-lock_api-devel \
 rust-owning_ref+default-devel \
 "
RDEPENDS:rust-lock_api+serde-devel = " \
 cargo \
 rust-lock_api-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-lock_api-devel = " \
 cargo \
 rust \
 rust-scopeguard-devel \
 "
