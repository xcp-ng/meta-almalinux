# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-native-tls"
PV = "0.2.18"
PR = "1.el10_3"
PACKAGES = " \
 rust-native-tls+alpn-accept-devel \
 rust-native-tls+alpn-devel \
 rust-native-tls+default-devel \
 rust-native-tls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-native-tls-0.2.18-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d86168344f4e7918b552a080b06e9214832e719a5ba45d88546b281c763e61a"

URI_x86_64_v2_rust-native-tls+alpn-accept-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-native-tls+alpn-accept-devel-0.2.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-native-tls+alpn-accept-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-native-tls+alpn-accept-devel}"
SRC_URI[x86_64_v2_rust-native-tls+alpn-accept-devel.sha256sum] = "c2dd4a02005dc823eca29c065292f0859126dc66738421bdc357e0ca5dc6b415"

URI_x86_64_v2_rust-native-tls+alpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-native-tls+alpn-devel-0.2.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-native-tls+alpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-native-tls+alpn-devel}"
SRC_URI[x86_64_v2_rust-native-tls+alpn-devel.sha256sum] = "fc5d601ea16bbd5394684897573beb34a5371de548a4be138405cd984a5ad7f1"

URI_x86_64_v2_rust-native-tls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-native-tls+default-devel-0.2.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-native-tls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-native-tls+default-devel}"
SRC_URI[x86_64_v2_rust-native-tls+default-devel.sha256sum] = "505779dcd966a3e4da16d7faa7b4317cd73c769f018bf37e9588bc799f1ba3cf"

URI_x86_64_v2_rust-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-native-tls-devel-0.2.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-native-tls-devel}"
SRC_URI[x86_64_v2_rust-native-tls-devel.sha256sum] = "0ec25938e79ff5e3d3539d178283d8942fdb2e59ad00a258b0316dd6a3a76d50"

URI_aarch64_rust-native-tls+alpn-accept-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-native-tls+alpn-accept-devel-0.2.18-1.el10_3.noarch.rpm;name=aarch64_rust-native-tls+alpn-accept-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-native-tls+alpn-accept-devel}"
SRC_URI[aarch64_rust-native-tls+alpn-accept-devel.sha256sum] = "a59e20eb2f065eb6bff90fd9b1202e8081d341c9f8fb86d0019585a2b1fd058b"

URI_aarch64_rust-native-tls+alpn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-native-tls+alpn-devel-0.2.18-1.el10_3.noarch.rpm;name=aarch64_rust-native-tls+alpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-native-tls+alpn-devel}"
SRC_URI[aarch64_rust-native-tls+alpn-devel.sha256sum] = "999356f7818d6d9a97b9bbb0207ed586c8f0a93f6584ae05afc64aeb36455af7"

URI_aarch64_rust-native-tls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-native-tls+default-devel-0.2.18-1.el10_3.noarch.rpm;name=aarch64_rust-native-tls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-native-tls+default-devel}"
SRC_URI[aarch64_rust-native-tls+default-devel.sha256sum] = "a1bdab9be54365d39576e71abc2b08554503ded03f0435ab60682f379f0956dd"

URI_aarch64_rust-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-native-tls-devel-0.2.18-1.el10_3.noarch.rpm;name=aarch64_rust-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-native-tls-devel}"
SRC_URI[aarch64_rust-native-tls-devel.sha256sum] = "ead03a913e9a0dc7735eb901d93c5fa3adb443bfd2d6e67c8faac53e9e33786d"

RDEPENDS:rust-native-tls+alpn-accept-devel = " \
 cargo \
 rust-native-tls-devel \
 "
RDEPENDS:rust-native-tls+alpn-devel = " \
 cargo \
 rust-native-tls-devel \
 "
RDEPENDS:rust-native-tls+default-devel = " \
 cargo \
 rust-native-tls-devel \
 "
RDEPENDS:rust-native-tls-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-openssl+default-devel \
 rust-openssl-probe+default-devel \
 rust-openssl-sys+default-devel \
 "
