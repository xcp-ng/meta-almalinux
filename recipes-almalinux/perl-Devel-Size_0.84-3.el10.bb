# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-Size"
PV = "0.84"
PR = "3.el10"
PACKAGES = " \
 perl-Devel-Size \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Devel-Size-0.84-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "908ecee073d0aaea387674797373d763626781e62a91e4eda5afac99cbfa3a6b"

URI_x86_64_v2_perl-Devel-Size = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Devel-Size-0.84-3.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Devel-Size;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-Size}"
SRC_URI[x86_64_v2_perl-Devel-Size.sha256sum] = "242cd59e19bee5b440ea293acd84b2455b8bb6e947e7f11327b2f3378bc63e62"

URI_aarch64_perl-Devel-Size = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Devel-Size-0.84-3.el10.aarch64.rpm;name=aarch64_perl-Devel-Size;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-Size}"
SRC_URI[aarch64_perl-Devel-Size.sha256sum] = "fa9e02f243e24ce5b60644e94b3366a89da0f3079aa64a8f54eaf43d35fe14d2"

RDEPENDS:perl-Devel-Size = " \
 glibc \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
