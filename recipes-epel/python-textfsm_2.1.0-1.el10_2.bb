# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-textfsm"
PV = "2.1.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-textfsm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-textfsm-2.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "108e6a0ccacdd69b6b2a6c84d8ffc9dda7de94e6d321e00dc8e051f5fa2f24a2"

URI_x86_64_v2_python3-textfsm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-textfsm-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-textfsm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-textfsm}"
SRC_URI[x86_64_v2_python3-textfsm.sha256sum] = "f34127ee07cca2d45c5ee6ec006ad4e287a9b78d7e35c1e011b7451536c4279a"

URI_aarch64_python3-textfsm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-textfsm-2.1.0-1.el10_2.noarch.rpm;name=aarch64_python3-textfsm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-textfsm}"
SRC_URI[aarch64_python3-textfsm.sha256sum] = "8957e034f01dd0d2c624e4a975e6d5e9ee66d3eef6b9d3f82a288c7e9d4b3d3c"

RDEPENDS:python3-textfsm = " \
 python3 \
 "
