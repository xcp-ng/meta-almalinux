# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libblockdev"
PV = "3.4.0"
PR = "2.el10.alma.1"
PACKAGES = " \
 libblockdev \
 libblockdev-btrfs \
 libblockdev-crypto \
 libblockdev-dm \
 libblockdev-fs \
 libblockdev-loop \
 libblockdev-lvm \
 libblockdev-lvm-dbus \
 libblockdev-mdraid \
 libblockdev-mpath \
 libblockdev-nvdimm \
 libblockdev-nvme \
 libblockdev-part \
 libblockdev-plugins-all \
 libblockdev-smart \
 libblockdev-smartmontools \
 libblockdev-swap \
 libblockdev-tools \
 libblockdev-utils \
 python3-blockdev \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libblockdev-3.4.0-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10872c501638c3005f32e8d4e7b35ef2f7a26a6f820776644280c318ca6693dd"

URI_x86_64_v2_libblockdev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev}"
SRC_URI[x86_64_v2_libblockdev.sha256sum] = "dd291a7187f53b20ef6e4a73ad460e6211a95e1ea296f607451d4bd97c5e774c"

URI_x86_64_v2_libblockdev-btrfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-btrfs-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-btrfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-btrfs}"
SRC_URI[x86_64_v2_libblockdev-btrfs.sha256sum] = "6b414de8d4d59737ffaf8254df1347fd321194a4570f2366c7b654634a27c596"

URI_x86_64_v2_libblockdev-crypto = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-crypto-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-crypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-crypto}"
SRC_URI[x86_64_v2_libblockdev-crypto.sha256sum] = "968013334c3eb86866e54edcf045030f55848f1c9cb12ad1673e01976a5c18b5"

URI_x86_64_v2_libblockdev-dm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-dm-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-dm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-dm}"
SRC_URI[x86_64_v2_libblockdev-dm.sha256sum] = "b16945fe43695909bd5d6974bd46051a28b66c2230e5221e6013951ff34cc602"

URI_x86_64_v2_libblockdev-fs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-fs-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-fs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-fs}"
SRC_URI[x86_64_v2_libblockdev-fs.sha256sum] = "2a337098a56d13c247ed69709f7919e9873998e77b9d838e8f661bc266a08559"

URI_x86_64_v2_libblockdev-loop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-loop-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-loop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-loop}"
SRC_URI[x86_64_v2_libblockdev-loop.sha256sum] = "dee0874539c87f5676dc96336e29c4df40fbb33ab1b94494d1079bf89d569c8a"

URI_x86_64_v2_libblockdev-lvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-lvm-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-lvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-lvm}"
SRC_URI[x86_64_v2_libblockdev-lvm.sha256sum] = "a50ffd0e02041cfd150b2551767d1136d9f059c3d76669eb0720da714678c235"

URI_x86_64_v2_libblockdev-lvm-dbus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-lvm-dbus-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-lvm-dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-lvm-dbus}"
SRC_URI[x86_64_v2_libblockdev-lvm-dbus.sha256sum] = "082a0ede602bc233438f98b1833a5d30017642fae92a5cae39b107c717373542"

URI_x86_64_v2_libblockdev-mdraid = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-mdraid-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-mdraid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-mdraid}"
SRC_URI[x86_64_v2_libblockdev-mdraid.sha256sum] = "89a246943ad25c36dbd159d3332e92619c7e0cce39e624dfaf34b3e9487d185e"

URI_x86_64_v2_libblockdev-mpath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-mpath-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-mpath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-mpath}"
SRC_URI[x86_64_v2_libblockdev-mpath.sha256sum] = "056b494bd0e52ad9027edb8d4d871a9f350db6b72a89ceb113d65c5b0e182491"

URI_x86_64_v2_libblockdev-nvdimm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-nvdimm-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-nvdimm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-nvdimm}"
SRC_URI[x86_64_v2_libblockdev-nvdimm.sha256sum] = "a568561e2145e17816612511d682bf6dd5f84cbefc899acfcf375b22291bdfda"

URI_x86_64_v2_libblockdev-nvme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-nvme-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-nvme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-nvme}"
SRC_URI[x86_64_v2_libblockdev-nvme.sha256sum] = "e61bc1a48005607da76cf3ae55f614df5244304a5b0611a678d23429ceaad7e5"

URI_x86_64_v2_libblockdev-part = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-part-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-part;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-part}"
SRC_URI[x86_64_v2_libblockdev-part.sha256sum] = "8c808ae994d865823ae0bec656fce39caf6183860cdf93eca40a0c2cdb1f6bf1"

URI_x86_64_v2_libblockdev-plugins-all = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-plugins-all-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-plugins-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-plugins-all}"
SRC_URI[x86_64_v2_libblockdev-plugins-all.sha256sum] = "edc3508f2ce1bdac11a12576c7ea75c6adeeb7ea4e07eab695bcd73bcad3a78d"

URI_x86_64_v2_libblockdev-smart = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-smart-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-smart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-smart}"
SRC_URI[x86_64_v2_libblockdev-smart.sha256sum] = "a3624bb327cb21c40b181140612e32e83a9b4d0a137611c7b6c3b8ee943d4335"

URI_x86_64_v2_libblockdev-smartmontools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-smartmontools-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-smartmontools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-smartmontools}"
SRC_URI[x86_64_v2_libblockdev-smartmontools.sha256sum] = "d61723e387fe4b94fa6abe4c38f4999e8dcf74402c102f371ca020796bf724f0"

URI_x86_64_v2_libblockdev-swap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-swap-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-swap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-swap}"
SRC_URI[x86_64_v2_libblockdev-swap.sha256sum] = "4cd2bd4755462bbc268e44c79ca6b69ca18f3a45abab19d1da70494e0c418654"

URI_x86_64_v2_libblockdev-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-tools-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-tools}"
SRC_URI[x86_64_v2_libblockdev-tools.sha256sum] = "d1e586e75c65f3f436b2140ff70b1f95f8d020eecfc03041d2f2b71386fb3886"

URI_x86_64_v2_libblockdev-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-utils-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libblockdev-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-utils}"
SRC_URI[x86_64_v2_libblockdev-utils.sha256sum] = "4861b124dbd9bd597125ac09e10a9470fcba43d78493d16092ae02a23e7ca7c3"

URI_x86_64_v2_python3-blockdev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-blockdev-3.4.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-blockdev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-blockdev}"
SRC_URI[x86_64_v2_python3-blockdev.sha256sum] = "7f57e76735974c6cf672b3dc8cdeb3ee20846a9e8ca54bb5c87894e67d712be1"

URI_aarch64_libblockdev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev}"
SRC_URI[aarch64_libblockdev.sha256sum] = "0774b5b7adf75bc1dcaf3adb56857ad6ffe8aff3ffe5bf6be830a803c95b8f0c"

URI_aarch64_libblockdev-btrfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-btrfs-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-btrfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-btrfs}"
SRC_URI[aarch64_libblockdev-btrfs.sha256sum] = "5a49393f92bfca122d142cf3ba77556d6ba5672b154f1ef8439d17ba9d72bbc9"

URI_aarch64_libblockdev-crypto = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-crypto-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-crypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-crypto}"
SRC_URI[aarch64_libblockdev-crypto.sha256sum] = "7b77323b2cf4337a72f34fdb38e11be5931276f7697edf2e575c93a641ecc159"

URI_aarch64_libblockdev-dm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-dm-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-dm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-dm}"
SRC_URI[aarch64_libblockdev-dm.sha256sum] = "733d9614611e7376bfe588c5bf1869fe612bc7918c69634af6307ea9b5621140"

URI_aarch64_libblockdev-fs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-fs-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-fs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-fs}"
SRC_URI[aarch64_libblockdev-fs.sha256sum] = "a6f0acf92d9fed0f6cc0f0a9c18e91f13e5f824a4722fe20806b3c15d8537e1f"

URI_aarch64_libblockdev-loop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-loop-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-loop;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-loop}"
SRC_URI[aarch64_libblockdev-loop.sha256sum] = "8a4c88f52c86168b7c5caf5cd742c0e494e56756fd37a92e3b5bdf157e3cedb3"

URI_aarch64_libblockdev-lvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-lvm-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-lvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-lvm}"
SRC_URI[aarch64_libblockdev-lvm.sha256sum] = "a1c2ee83fca85f5dfdf39124d50eda97ba2892d11c3847ec864bd8c8c9aca10d"

URI_aarch64_libblockdev-lvm-dbus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-lvm-dbus-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-lvm-dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-lvm-dbus}"
SRC_URI[aarch64_libblockdev-lvm-dbus.sha256sum] = "4cc87133f6fab363aa5b81a0dee5b7bdd964c64f7d2f6df75305413f4e54a583"

URI_aarch64_libblockdev-mdraid = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-mdraid-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-mdraid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-mdraid}"
SRC_URI[aarch64_libblockdev-mdraid.sha256sum] = "12d8582385fe1b14abcdb3f2ee4854c343cec5616cb8a83d5cdabcf5aba58e49"

URI_aarch64_libblockdev-mpath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-mpath-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-mpath;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-mpath}"
SRC_URI[aarch64_libblockdev-mpath.sha256sum] = "5c101cf85b4ef1e70c1c332cb7c6978cc7d57a7905a0e9e8068793be0580e663"

URI_aarch64_libblockdev-nvdimm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-nvdimm-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-nvdimm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-nvdimm}"
SRC_URI[aarch64_libblockdev-nvdimm.sha256sum] = "d4c7a324b46c45d60ae39e784cd3cfda0418984f0854d1148678945623ca2620"

URI_aarch64_libblockdev-nvme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-nvme-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-nvme;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-nvme}"
SRC_URI[aarch64_libblockdev-nvme.sha256sum] = "d5a5f1fa1395552226cb23fe464e65697cdbc25e7dcc4327e4bcfc4c17339348"

URI_aarch64_libblockdev-part = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-part-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-part;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-part}"
SRC_URI[aarch64_libblockdev-part.sha256sum] = "ca4a228b5bb3684204d252f7486769058a438fd69883919a84d8783c5b5208ca"

URI_aarch64_libblockdev-plugins-all = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-plugins-all-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-plugins-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-plugins-all}"
SRC_URI[aarch64_libblockdev-plugins-all.sha256sum] = "348c1da658ec5e8b9f9786580f9c769332654a35af67c0cb7a878ff0a32ceeb6"

URI_aarch64_libblockdev-smart = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-smart-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-smart;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-smart}"
SRC_URI[aarch64_libblockdev-smart.sha256sum] = "c44526a302d3c41848c0fb54003e53c68a9175edde4cab3b4d524790cc2dbdff"

URI_aarch64_libblockdev-smartmontools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-smartmontools-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-smartmontools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-smartmontools}"
SRC_URI[aarch64_libblockdev-smartmontools.sha256sum] = "025d24d1528c4895851878d3c4571d15ecd562fbea33fa32ffb9a62900cd35d0"

URI_aarch64_libblockdev-swap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-swap-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-swap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-swap}"
SRC_URI[aarch64_libblockdev-swap.sha256sum] = "b6a401ee84131bd226f02804e9292589c642a4f82c42c6778ec61ee37afb981a"

URI_aarch64_libblockdev-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-tools-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-tools}"
SRC_URI[aarch64_libblockdev-tools.sha256sum] = "ecdd7932a627097f79e6f8f117298cebf10bb3bc8f5af6832da8757129cf226e"

URI_aarch64_libblockdev-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-utils-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_libblockdev-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-utils}"
SRC_URI[aarch64_libblockdev-utils.sha256sum] = "7fd9653c108a8ec2aa29b7d25754284926cf01cf08fd057429b7f7e95d2fa906"

URI_aarch64_python3-blockdev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-blockdev-3.4.0-2.el10.alma.1.aarch64.rpm;name=aarch64_python3-blockdev;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-blockdev}"
SRC_URI[aarch64_python3-blockdev.sha256sum] = "ab70641714d5bcf4700ed26977712ee8dfa72a871967a1ae0eb2a7575ea6b131"

RDEPENDS:libblockdev = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 systemd-libs \
 "
RDEPENDS:libblockdev-btrfs = " \
 btrfs-progs \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libbytesize \
 systemd-libs \
 "
RDEPENDS:libblockdev-crypto = " \
 cryptsetup-libs \
 glib2 \
 glibc \
 keyutils-libs \
 kmod-libs \
 libblkid \
 libblockdev-utils \
 libgcc \
 nspr \
 nss \
 nss-util \
 systemd-libs \
 volume_key-libs \
 "
RDEPENDS:libblockdev-dm = " \
 device-mapper \
 device-mapper-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 systemd-libs \
 "
RDEPENDS:libblockdev-fs = " \
 e2fsprogs-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblkid \
 libblockdev-utils \
 libgcc \
 libmount \
 libuuid \
 systemd-libs \
 "
RDEPENDS:libblockdev-loop = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libgcc \
 systemd-libs \
 "
RDEPENDS:libblockdev-lvm = " \
 device-mapper-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libgcc \
 libyaml \
 lvm2 \
 systemd-libs \
 "
RDEPENDS:libblockdev-lvm-dbus = " \
 device-mapper-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libgcc \
 libyaml \
 lvm2-dbusd \
 systemd-libs \
 "
RDEPENDS:libblockdev-mdraid = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libbytesize \
 libgcc \
 mdadm \
 systemd-libs \
 "
RDEPENDS:libblockdev-mpath = " \
 device-mapper-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 systemd-libs \
 "
RDEPENDS:libblockdev-nvdimm = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libuuid \
 ndctl \
 ndctl-libs \
 systemd-libs \
 "
RDEPENDS:libblockdev-nvme = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libnvme \
 systemd-libs \
 "
RDEPENDS:libblockdev-part = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libfdisk \
 systemd-libs \
 util-linux \
 "
RDEPENDS:libblockdev-plugins-all = " \
 libblockdev \
 libblockdev-btrfs \
 libblockdev-crypto \
 libblockdev-dm \
 libblockdev-fs \
 libblockdev-loop \
 libblockdev-lvm \
 libblockdev-mdraid \
 libblockdev-mpath \
 libblockdev-nvdimm \
 libblockdev-nvme \
 libblockdev-part \
 libblockdev-smart \
 libblockdev-smartmontools \
 libblockdev-swap \
 "
RDEPENDS:libblockdev-smart = " \
 glib2 \
 glibc \
 kmod-libs \
 libatasmart \
 libblockdev-utils \
 systemd-libs \
 "
RDEPENDS:libblockdev-smartmontools = " \
 glib2 \
 glibc \
 json-glib \
 kmod-libs \
 libblockdev-utils \
 smartmontools \
 systemd-libs \
 "
RDEPENDS:libblockdev-swap = " \
 glib2 \
 glibc \
 kmod-libs \
 libblkid \
 libblockdev-utils \
 libgcc \
 libuuid \
 systemd-libs \
 util-linux \
 "
RDEPENDS:libblockdev-tools = " \
 glib2 \
 glibc \
 libblockdev \
 libblockdev-lvm \
 libbytesize \
 parted \
 "
RDEPENDS:libblockdev-utils = " \
 glib2 \
 glibc \
 kmod-libs \
 systemd-libs \
 "
RDEPENDS:python3-blockdev = " \
 libblockdev \
 python3 \
 python3-bytesize \
 python3-gobject-base \
 "
