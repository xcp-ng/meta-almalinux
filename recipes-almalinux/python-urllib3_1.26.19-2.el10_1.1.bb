# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-urllib3"
PV = "1.26.19"
PR = "2.el10_1.1"
PACKAGES = " \
 python3-urllib3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-urllib3-1.26.19-2.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8acbc2d38a367fc28c47d2f31581999d3bd003b9c78ba2c5ee21e324fb3b4fc6"

URI_x86_64_v2_python3-urllib3 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-urllib3-1.26.19-2.el10_1.1.noarch.rpm;name=x86_64_v2_python3-urllib3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-urllib3}"
SRC_URI[x86_64_v2_python3-urllib3.sha256sum] = "bf0f21402205aa6e92224b45d8d0a5577bd6d724cb23b2de5a7e6c2a4c32f9f8"

URI_aarch64_python3-urllib3 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-urllib3-1.26.19-2.el10_1.1.noarch.rpm;name=aarch64_python3-urllib3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-urllib3}"
SRC_URI[aarch64_python3-urllib3.sha256sum] = "bf0f21402205aa6e92224b45d8d0a5577bd6d724cb23b2de5a7e6c2a4c32f9f8"

RDEPENDS:python3-urllib3 = " \
 ca-certificates \
 python3 \
 python3-idna \
 "
