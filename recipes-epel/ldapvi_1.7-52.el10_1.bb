# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ldapvi"
PV = "1.7"
PR = "52.el10_1"
PACKAGES = " \
 ldapvi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/ldapvi-1.7-52.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d48660e1346fde5850252d304a45dbc85ed040a082106d2aa4784b1ecab0ec1c"

URI_x86_64_v2_ldapvi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ldapvi-1.7-52.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ldapvi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldapvi}"
SRC_URI[x86_64_v2_ldapvi.sha256sum] = "3651006dadd2e5f1005f4b9ac61a31da4d13fb3de736befbb8ef81ba76e42b71"

URI_aarch64_ldapvi = "${EPEL_MIRROR}/aarch64/Packages/l/ldapvi-1.7-52.el10_1.aarch64.rpm;name=aarch64_ldapvi;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldapvi}"
SRC_URI[aarch64_ldapvi.sha256sum] = "f9b3db7d6c6be27209854f8a84750b800b37fa44519ee56331a44101c7bd4903"

RDEPENDS:ldapvi = " \
 glib2 \
 glibc \
 libxcrypt \
 ncurses-libs \
 openldap \
 openssl-libs \
 popt \
 readline \
 "
