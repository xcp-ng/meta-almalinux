# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTML-Format"
PV = "2.16"
PR = "26.el10_0"
PACKAGES = " \
 perl-HTML-Formatter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTML-Format-2.16-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b31829d3d120602d904c4c3363675aee5bce10a59fd5c43289520f4d0b05375"

URI_x86_64_v2_perl-HTML-Formatter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTML-Formatter-2.16-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTML-Formatter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTML-Formatter}"
SRC_URI[x86_64_v2_perl-HTML-Formatter.sha256sum] = "b6d45c4df14a93d3e3c5e715917080d3457a5ed0ef5de48df7d526e624752103"

URI_aarch64_perl-HTML-Formatter = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTML-Formatter-2.16-26.el10_0.noarch.rpm;name=aarch64_perl-HTML-Formatter;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTML-Formatter}"
SRC_URI[aarch64_perl-HTML-Formatter.sha256sum] = "2a0af82762afa16e2a3daa55daddab35c08e7551538ef3e41f8f7a75499eea09"

RDEPENDS:perl-HTML-Formatter = " \
 perl-Carp \
 perl-Encode \
 perl-Font-AFM \
 perl-HTML-Formatter \
 perl-HTML-Tree \
 perl-IO \
 perl-base \
 perl-libs \
 perl-parent \
 "
