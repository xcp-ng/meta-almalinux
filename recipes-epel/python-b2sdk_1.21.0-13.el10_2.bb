# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-b2sdk"
PV = "1.21.0"
PR = "13.el10_2"
PACKAGES = " \
 python3-b2sdk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-b2sdk-1.21.0-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf39d20e5fabc0b2bf24edbf55fd9cd22d0b3b37db991535e3fc9beaadc7710a"

URI_x86_64_v2_python3-b2sdk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-b2sdk-1.21.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-b2sdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-b2sdk}"
SRC_URI[x86_64_v2_python3-b2sdk.sha256sum] = "5dea68bf723b810137dc9c4af7bfeb9fa2c2e246fbdcf2452e127b996ee8f326"

URI_aarch64_python3-b2sdk = "${EPEL_MIRROR}/aarch64/Packages/p/python3-b2sdk-1.21.0-13.el10_2.noarch.rpm;name=aarch64_python3-b2sdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-b2sdk}"
SRC_URI[aarch64_python3-b2sdk.sha256sum] = "f52c4260f5faea31d3e76e98869345f45d9aa936d27a5566d1c6cc552daeb5bb"

RDEPENDS:python3-b2sdk = " \
 python3 \
 python3-logfury \
 python3-requests \
 python3-tqdm \
 "
