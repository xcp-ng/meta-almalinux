# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-copilot-language"
PV = "3.19.1"
PR = "2.el10_0"
PACKAGES = " \
 ghc-copilot-language \
 ghc-copilot-language-devel \
 ghc-copilot-language-doc \
 ghc-copilot-language-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-copilot-language-3.19.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e099f614232a9116198f5ee8704c03108cab0dac039dca07e47630a695cfaab"

URI_x86_64_v2_ghc-copilot-language = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-language-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-language;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-language}"
SRC_URI[x86_64_v2_ghc-copilot-language.sha256sum] = "4557912ec3c5423689e1c648e37a5d0c66d6e14a4dec99ca30b908827d7fcdf1"

URI_x86_64_v2_ghc-copilot-language-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-language-devel-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-language-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-language-devel}"
SRC_URI[x86_64_v2_ghc-copilot-language-devel.sha256sum] = "50de1c3fbd402a659bac5c1e417df7b4f673ff3380d6c69d794ec73a5c4f349f"

URI_x86_64_v2_ghc-copilot-language-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-language-doc-3.19.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-copilot-language-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-language-doc}"
SRC_URI[x86_64_v2_ghc-copilot-language-doc.sha256sum] = "c6b9fd6a44d55dd7f90934b20d597907aee522d7fc4ea1b4383acb6794c1f4d6"

URI_x86_64_v2_ghc-copilot-language-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-language-prof-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-language-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-language-prof}"
SRC_URI[x86_64_v2_ghc-copilot-language-prof.sha256sum] = "2754d2e6204fb5448c5484440a7bd337e54e3ae6c30c87ed08ab36a023e203d9"

URI_aarch64_ghc-copilot-language = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-language-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-language;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-language}"
SRC_URI[aarch64_ghc-copilot-language.sha256sum] = "587caa8e6c4855b5efc9e12871b1311a5fad5ac4191ffbf0ef963468fea93efa"

URI_aarch64_ghc-copilot-language-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-language-devel-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-language-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-language-devel}"
SRC_URI[aarch64_ghc-copilot-language-devel.sha256sum] = "45b7057c094b69d553a7fa09235b7ae97b3c370ee120458b5e64257d03c7d983"

URI_aarch64_ghc-copilot-language-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-language-doc-3.19.1-2.el10_0.noarch.rpm;name=aarch64_ghc-copilot-language-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-language-doc}"
SRC_URI[aarch64_ghc-copilot-language-doc.sha256sum] = "98701ea514c6752eec1a90243e7291c77be5b5e7797ba87b6e5ecea2fed0f90c"

URI_aarch64_ghc-copilot-language-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-language-prof-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-language-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-language-prof}"
SRC_URI[aarch64_ghc-copilot-language-prof.sha256sum] = "d2aa743bd333fdaede8a676ac807ee0dcbad8ec13d9613c5a0e8a709072669c1"

RDEPENDS:ghc-copilot-language = " \
 ghc-BoundedChan \
 ghc-OneTuple \
 ghc-StateVar \
 ghc-adjunctions \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-bimap \
 ghc-binary \
 ghc-bitwise \
 ghc-boring \
 ghc-bv-sized \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-comonad \
 ghc-concurrent-extra \
 ghc-config-value \
 ghc-constraints \
 ghc-containers \
 ghc-contravariant \
 ghc-copilot-core \
 ghc-copilot-interpreter \
 ghc-copilot-prettyprinter \
 ghc-copilot-theorem \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-reify \
 ghc-deepseq \
 ghc-deriving-compat \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-fingertree \
 ghc-free \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-gitrev \
 ghc-hashable \
 ghc-hashtables \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-invariant \
 ghc-io-streams \
 ghc-kan-extensions \
 ghc-lens \
 ghc-libBF \
 ghc-megaparsec \
 ghc-mtl \
 ghc-network \
 ghc-old-locale \
 ghc-ordered-containers \
 ghc-os-string \
 ghc-panic \
 ghc-parallel \
 ghc-parameterized-utils \
 ghc-parsec \
 ghc-parser-combinators \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-primitive \
 ghc-process \
 ghc-profunctors \
 ghc-random \
 ghc-reflection \
 ghc-s-cargot \
 ghc-safe-exceptions \
 ghc-scientific \
 ghc-semigroupoids \
 ghc-semigroups \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-temporary \
 ghc-text \
 ghc-th-abstraction \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-unbounded-delays \
 ghc-unix \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-vector \
 ghc-vector-stream \
 ghc-versions \
 ghc-void \
 ghc-what4 \
 ghc-xml \
 ghc-zenc \
 ghc-zlib \
 ghc-zlib-bindings \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-copilot-language-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-copilot-core-devel \
 ghc-copilot-interpreter-devel \
 ghc-copilot-language \
 ghc-copilot-theorem-devel \
 ghc-data-reify-devel \
 ghc-mtl-devel \
 "
RDEPENDS:ghc-copilot-language-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-copilot-language-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-copilot-core-prof \
 ghc-copilot-interpreter-prof \
 ghc-copilot-language-devel \
 ghc-copilot-theorem-prof \
 ghc-data-reify-prof \
 ghc-mtl-prof \
 "
