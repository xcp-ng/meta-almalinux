# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linux-firmware"
PV = "20260812"
PR = "26.el10"
PACKAGES = " \
 amd-gpu-firmware \
 amd-ucode-firmware \
 atheros-firmware \
 brcmfmac-firmware \
 cirrus-audio-firmware \
 dvb-firmware \
 intel-audio-firmware \
 intel-gpu-firmware \
 intel-vsc-firmware \
 iwlegacy-firmware \
 iwlwifi-dvm-firmware \
 iwlwifi-mvm-firmware \
 libertas-firmware \
 linux-firmware \
 linux-firmware-whence \
 mlxsw_spectrum-firmware \
 mrvlprestera-firmware \
 mt7xxx-firmware \
 netronome-firmware \
 nvidia-gpu-firmware \
 nxpwireless-firmware \
 qcom-firmware \
 realtek-firmware \
 tiwilink-firmware \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/linux-firmware-20260812-26.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c8bd90e8f2151c0dc96ba9bbc3793147450cca15e8eebaafb45de5ff26c2fa80"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/amd-gpu-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_amd-gpu-firmware;unpack=0"
SRC_URI[x86_64_v2_amd-gpu-firmware.sha256sum] = "52c7b4557d92295530c49c8ca22612fa94dc9ddf61fc5c65c132e9641344ca6e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/amd-ucode-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_amd-ucode-firmware;unpack=0"
SRC_URI[x86_64_v2_amd-ucode-firmware.sha256sum] = "4301ece1ebc83bb5fac51ccdcbb52b7cb48d83fb8a1b8eb83c332b01796ee8ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/atheros-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_atheros-firmware;unpack=0"
SRC_URI[x86_64_v2_atheros-firmware.sha256sum] = "3cdb5b536eb22883be7e1005f04bfd239bc77c8012c3fb0d5632ffebb1c8890a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/brcmfmac-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_brcmfmac-firmware;unpack=0"
SRC_URI[x86_64_v2_brcmfmac-firmware.sha256sum] = "c339831d5fe370a7630bc2e57aa6ebe708e1c1d2af798a2bc36af8151c645e03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cirrus-audio-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_cirrus-audio-firmware;unpack=0"
SRC_URI[x86_64_v2_cirrus-audio-firmware.sha256sum] = "53fd769a73b0d548684b244b4201180c17807bc7976406f0656eeb5090f77cfd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dvb-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_dvb-firmware;unpack=0"
SRC_URI[x86_64_v2_dvb-firmware.sha256sum] = "2de9bcf8da1035dc36e04d46b08d91a889c1e2d921139837ac34c3039a790c0c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-audio-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_intel-audio-firmware;unpack=0"
SRC_URI[x86_64_v2_intel-audio-firmware.sha256sum] = "cb28a060b6d9280591a9d411c5f2529a11e9cb74b017c4c1fece3b109231dd9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/intel-gpu-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_intel-gpu-firmware;unpack=0"
SRC_URI[x86_64_v2_intel-gpu-firmware.sha256sum] = "f08ac8fa57ba7d5d0a7ba082fde78ebca089624a8b726817a0d5578ff7cac07a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-vsc-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_intel-vsc-firmware;unpack=0"
SRC_URI[x86_64_v2_intel-vsc-firmware.sha256sum] = "ba7bb4e9cf37771c5f9553a74e95f5d019554b8bca1a349d404073c10c385c55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlegacy-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_iwlegacy-firmware;unpack=0"
SRC_URI[x86_64_v2_iwlegacy-firmware.sha256sum] = "0530007ca80921bbf96f7800cdb7447c6fa8d9665cc8ef30f6eb226fc92b06b9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlwifi-dvm-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_iwlwifi-dvm-firmware;unpack=0"
SRC_URI[x86_64_v2_iwlwifi-dvm-firmware.sha256sum] = "3e6effda5ad89ca05b47a4c1f24e8670ebcca2e6fd85fdc693616aa84d09cb9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlwifi-mvm-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_iwlwifi-mvm-firmware;unpack=0"
SRC_URI[x86_64_v2_iwlwifi-mvm-firmware.sha256sum] = "20d4a4c97db50065de2577b01596ce807adf8d613df082e06a228484e6d8786d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libertas-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_libertas-firmware;unpack=0"
SRC_URI[x86_64_v2_libertas-firmware.sha256sum] = "191c8aadcc4b6315171de1f320588bf597213d6c62da8291ba7d584d19df81a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/linux-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_linux-firmware;unpack=0"
SRC_URI[x86_64_v2_linux-firmware.sha256sum] = "bf0cf5f547b2c75af066994db176e91c1594ad5eed0f6e29726144c9997a816a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/linux-firmware-whence-20260812-26.el10.noarch.rpm;name=x86_64_v2_linux-firmware-whence;unpack=0"
SRC_URI[x86_64_v2_linux-firmware-whence.sha256sum] = "41d7fc340e798235ae315024c4e827ad0649039460510ad70d2075757b622a8d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mlxsw_spectrum-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_mlxsw_spectrum-firmware;unpack=0"
SRC_URI[x86_64_v2_mlxsw_spectrum-firmware.sha256sum] = "40496b863c8728bde99982e5a98914e51dc176ffdb609463f9ccffd2423b5019"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mrvlprestera-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_mrvlprestera-firmware;unpack=0"
SRC_URI[x86_64_v2_mrvlprestera-firmware.sha256sum] = "2b91e3abf9156f881e83cf1bd7297e548db91bceaad877caf9a9444d1fe426d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mt7xxx-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_mt7xxx-firmware;unpack=0"
SRC_URI[x86_64_v2_mt7xxx-firmware.sha256sum] = "72ac7cf1e96b6a7bf6629eda8dbdcd5eee9be5828eefaf2d71b939df5e232ce2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/netronome-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_netronome-firmware;unpack=0"
SRC_URI[x86_64_v2_netronome-firmware.sha256sum] = "6df0cbc201d25f3656962fd2caf7a7686e161e4fa5364546e199a7dd19631948"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nvidia-gpu-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_nvidia-gpu-firmware;unpack=0"
SRC_URI[x86_64_v2_nvidia-gpu-firmware.sha256sum] = "996c233b830e55d60ff3e5ca0703fb42852d2d5733a163444b132671504accc0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nxpwireless-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_nxpwireless-firmware;unpack=0"
SRC_URI[x86_64_v2_nxpwireless-firmware.sha256sum] = "acb86e3c2aaad5793a6c0e95b26e8367cee16ad321f8fe7d7b5bc3aff4f1e91f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/qcom-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_qcom-firmware;unpack=0"
SRC_URI[x86_64_v2_qcom-firmware.sha256sum] = "26777ced80291ae4b9e483903690334ff68aa8e2b25932ec778a1121998e8809"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/realtek-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_realtek-firmware;unpack=0"
SRC_URI[x86_64_v2_realtek-firmware.sha256sum] = "28ae98ced0f003f36fc29b743e3f6ec11fd2aa452367699713e8361edc081f4a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tiwilink-firmware-20260812-26.el10.noarch.rpm;name=x86_64_v2_tiwilink-firmware;unpack=0"
SRC_URI[x86_64_v2_tiwilink-firmware.sha256sum] = "bac2797fb7a6c309408d1db8a5c3c1d03be49b6d95925a76c81f6d11a34abcda"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/amd-gpu-firmware-20260812-26.el10.noarch.rpm;name=aarch64_amd-gpu-firmware;unpack=0"
SRC_URI[aarch64_amd-gpu-firmware.sha256sum] = "52c7b4557d92295530c49c8ca22612fa94dc9ddf61fc5c65c132e9641344ca6e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/amd-ucode-firmware-20260812-26.el10.noarch.rpm;name=aarch64_amd-ucode-firmware;unpack=0"
SRC_URI[aarch64_amd-ucode-firmware.sha256sum] = "4301ece1ebc83bb5fac51ccdcbb52b7cb48d83fb8a1b8eb83c332b01796ee8ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/atheros-firmware-20260812-26.el10.noarch.rpm;name=aarch64_atheros-firmware;unpack=0"
SRC_URI[aarch64_atheros-firmware.sha256sum] = "3cdb5b536eb22883be7e1005f04bfd239bc77c8012c3fb0d5632ffebb1c8890a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/brcmfmac-firmware-20260812-26.el10.noarch.rpm;name=aarch64_brcmfmac-firmware;unpack=0"
SRC_URI[aarch64_brcmfmac-firmware.sha256sum] = "c339831d5fe370a7630bc2e57aa6ebe708e1c1d2af798a2bc36af8151c645e03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cirrus-audio-firmware-20260812-26.el10.noarch.rpm;name=aarch64_cirrus-audio-firmware;unpack=0"
SRC_URI[aarch64_cirrus-audio-firmware.sha256sum] = "53fd769a73b0d548684b244b4201180c17807bc7976406f0656eeb5090f77cfd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dvb-firmware-20260812-26.el10.noarch.rpm;name=aarch64_dvb-firmware;unpack=0"
SRC_URI[aarch64_dvb-firmware.sha256sum] = "2de9bcf8da1035dc36e04d46b08d91a889c1e2d921139837ac34c3039a790c0c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/intel-audio-firmware-20260812-26.el10.noarch.rpm;name=aarch64_intel-audio-firmware;unpack=0"
SRC_URI[aarch64_intel-audio-firmware.sha256sum] = "cb28a060b6d9280591a9d411c5f2529a11e9cb74b017c4c1fece3b109231dd9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/intel-gpu-firmware-20260812-26.el10.noarch.rpm;name=aarch64_intel-gpu-firmware;unpack=0"
SRC_URI[aarch64_intel-gpu-firmware.sha256sum] = "f08ac8fa57ba7d5d0a7ba082fde78ebca089624a8b726817a0d5578ff7cac07a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/intel-vsc-firmware-20260812-26.el10.noarch.rpm;name=aarch64_intel-vsc-firmware;unpack=0"
SRC_URI[aarch64_intel-vsc-firmware.sha256sum] = "ba7bb4e9cf37771c5f9553a74e95f5d019554b8bca1a349d404073c10c385c55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlegacy-firmware-20260812-26.el10.noarch.rpm;name=aarch64_iwlegacy-firmware;unpack=0"
SRC_URI[aarch64_iwlegacy-firmware.sha256sum] = "0530007ca80921bbf96f7800cdb7447c6fa8d9665cc8ef30f6eb226fc92b06b9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlwifi-dvm-firmware-20260812-26.el10.noarch.rpm;name=aarch64_iwlwifi-dvm-firmware;unpack=0"
SRC_URI[aarch64_iwlwifi-dvm-firmware.sha256sum] = "3e6effda5ad89ca05b47a4c1f24e8670ebcca2e6fd85fdc693616aa84d09cb9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlwifi-mvm-firmware-20260812-26.el10.noarch.rpm;name=aarch64_iwlwifi-mvm-firmware;unpack=0"
SRC_URI[aarch64_iwlwifi-mvm-firmware.sha256sum] = "20d4a4c97db50065de2577b01596ce807adf8d613df082e06a228484e6d8786d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libertas-firmware-20260812-26.el10.noarch.rpm;name=aarch64_libertas-firmware;unpack=0"
SRC_URI[aarch64_libertas-firmware.sha256sum] = "191c8aadcc4b6315171de1f320588bf597213d6c62da8291ba7d584d19df81a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/linux-firmware-20260812-26.el10.noarch.rpm;name=aarch64_linux-firmware;unpack=0"
SRC_URI[aarch64_linux-firmware.sha256sum] = "bf0cf5f547b2c75af066994db176e91c1594ad5eed0f6e29726144c9997a816a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/linux-firmware-whence-20260812-26.el10.noarch.rpm;name=aarch64_linux-firmware-whence;unpack=0"
SRC_URI[aarch64_linux-firmware-whence.sha256sum] = "41d7fc340e798235ae315024c4e827ad0649039460510ad70d2075757b622a8d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mlxsw_spectrum-firmware-20260812-26.el10.noarch.rpm;name=aarch64_mlxsw_spectrum-firmware;unpack=0"
SRC_URI[aarch64_mlxsw_spectrum-firmware.sha256sum] = "40496b863c8728bde99982e5a98914e51dc176ffdb609463f9ccffd2423b5019"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mrvlprestera-firmware-20260812-26.el10.noarch.rpm;name=aarch64_mrvlprestera-firmware;unpack=0"
SRC_URI[aarch64_mrvlprestera-firmware.sha256sum] = "2b91e3abf9156f881e83cf1bd7297e548db91bceaad877caf9a9444d1fe426d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mt7xxx-firmware-20260812-26.el10.noarch.rpm;name=aarch64_mt7xxx-firmware;unpack=0"
SRC_URI[aarch64_mt7xxx-firmware.sha256sum] = "72ac7cf1e96b6a7bf6629eda8dbdcd5eee9be5828eefaf2d71b939df5e232ce2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/netronome-firmware-20260812-26.el10.noarch.rpm;name=aarch64_netronome-firmware;unpack=0"
SRC_URI[aarch64_netronome-firmware.sha256sum] = "6df0cbc201d25f3656962fd2caf7a7686e161e4fa5364546e199a7dd19631948"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nvidia-gpu-firmware-20260812-26.el10.noarch.rpm;name=aarch64_nvidia-gpu-firmware;unpack=0"
SRC_URI[aarch64_nvidia-gpu-firmware.sha256sum] = "996c233b830e55d60ff3e5ca0703fb42852d2d5733a163444b132671504accc0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nxpwireless-firmware-20260812-26.el10.noarch.rpm;name=aarch64_nxpwireless-firmware;unpack=0"
SRC_URI[aarch64_nxpwireless-firmware.sha256sum] = "acb86e3c2aaad5793a6c0e95b26e8367cee16ad321f8fe7d7b5bc3aff4f1e91f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/qcom-firmware-20260812-26.el10.noarch.rpm;name=aarch64_qcom-firmware;unpack=0"
SRC_URI[aarch64_qcom-firmware.sha256sum] = "26777ced80291ae4b9e483903690334ff68aa8e2b25932ec778a1121998e8809"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/realtek-firmware-20260812-26.el10.noarch.rpm;name=aarch64_realtek-firmware;unpack=0"
SRC_URI[aarch64_realtek-firmware.sha256sum] = "28ae98ced0f003f36fc29b743e3f6ec11fd2aa452367699713e8361edc081f4a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tiwilink-firmware-20260812-26.el10.noarch.rpm;name=aarch64_tiwilink-firmware;unpack=0"
SRC_URI[aarch64_tiwilink-firmware.sha256sum] = "bac2797fb7a6c309408d1db8a5c3c1d03be49b6d95925a76c81f6d11a34abcda"

RDEPENDS:amd-gpu-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:amd-ucode-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:atheros-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:brcmfmac-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:cirrus-audio-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:dvb-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-audio-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-gpu-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-vsc-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlegacy-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlwifi-dvm-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlwifi-mvm-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:libertas-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:linux-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:linux-firmware-whence = " \
 "
RDEPENDS:mlxsw_spectrum-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:mrvlprestera-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:mt7xxx-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:netronome-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:nvidia-gpu-firmware = " \
 linux-firmware \
 linux-firmware-whence \
 "
RDEPENDS:nxpwireless-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:qcom-firmware = " \
 atheros-firmware \
 linux-firmware-whence \
 "
RDEPENDS:realtek-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:tiwilink-firmware = " \
 linux-firmware-whence \
 "
