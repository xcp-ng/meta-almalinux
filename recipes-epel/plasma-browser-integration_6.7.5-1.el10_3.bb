# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-browser-integration"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-browser-integration \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-browser-integration-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1169dc565e8f5aaf8d748404ad9acfb862ff8cf8c31a5645631cb3a71bde03d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-browser-integration-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-browser-integration;unpack=0"
SRC_URI[x86_64_v2_plasma-browser-integration.sha256sum] = "1ddcbcacfb07e6b23c0a272d101ef2a6eadd1a3ed9d85375a3a084b043b8f214"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-browser-integration-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-browser-integration;unpack=0"
SRC_URI[aarch64_plasma-browser-integration.sha256sum] = "f77ab9df5dc6be130df32b002990a3dab70c38e886713bab5218d408d8a0930d"

RDEPENDS:plasma-browser-integration = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-purpose \
 libstdc++ \
 plasma-activities \
 plasma-workspace-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
