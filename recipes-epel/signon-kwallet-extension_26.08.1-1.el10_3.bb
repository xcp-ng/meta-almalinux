# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "signon-kwallet-extension"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 signon-kwallet-extension \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/signon-kwallet-extension-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3f36eb70cefa1bf8dbe1e77713cf6665aaafa8a666fbfff923894b8514e0f0b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-kwallet-extension-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signon-kwallet-extension;unpack=0"
SRC_URI[x86_64_v2_signon-kwallet-extension.sha256sum] = "b539810ef34a24cd41cf0b259e5db4e0d0ee865c3512612094f1bb5c135396ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/signon-kwallet-extension-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_signon-kwallet-extension;unpack=0"
SRC_URI[aarch64_signon-kwallet-extension.sha256sum] = "3c29d8d4fe85d2b1a8009a9abf442ca63403106dd068ea116bada1ae02be3c90"

RDEPENDS:signon-kwallet-extension = " \
 glibc \
 kf6-kwallet-libs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 signon \
 "
