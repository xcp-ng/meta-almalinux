# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-material-extensions"
PV = "1.3.1"
PR = "9.el10_2"
PACKAGES = " \
 python3-mkdocs-material-extensions \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-material-extensions-1.3.1-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5ffbb89959a18fade7d92850e1caf0c222532730130d09df07e928df4b7b9a0"

URI_x86_64_v2_python3-mkdocs-material-extensions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-material-extensions-1.3.1-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-material-extensions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-material-extensions}"
SRC_URI[x86_64_v2_python3-mkdocs-material-extensions.sha256sum] = "095c465374e2759deeaf412c17b6a7c6112983f1cbfd71b5b29e1ae260f59cea"

URI_aarch64_python3-mkdocs-material-extensions = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-material-extensions-1.3.1-9.el10_2.noarch.rpm;name=aarch64_python3-mkdocs-material-extensions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-material-extensions}"
SRC_URI[aarch64_python3-mkdocs-material-extensions.sha256sum] = "fb26dd4fdd8eaa010231b1480e11301ce319b43a1bae91d40596d551c441c2db"

RDEPENDS:python3-mkdocs-material-extensions = " \
 python3 \
 "
