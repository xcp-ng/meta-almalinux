# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pdfgrep"
PV = "2.2.0"
PR = "3.el10_0"
PACKAGES = " \
 pdfgrep \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pdfgrep-2.2.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3975ab4095078d0b6da843208d185cccb0b0d3a9b7ab71246de8fd5078bd89e2"

URI_x86_64_v2_pdfgrep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdfgrep-2.2.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdfgrep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdfgrep}"
SRC_URI[x86_64_v2_pdfgrep.sha256sum] = "00a530a8ecb9137901a75f459839972733ba6859a44d4d3be3bdbe74385b9d7c"

URI_aarch64_pdfgrep = "${EPEL_MIRROR}/aarch64/Packages/p/pdfgrep-2.2.0-3.el10_0.aarch64.rpm;name=aarch64_pdfgrep;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdfgrep}"
SRC_URI[aarch64_pdfgrep.sha256sum] = "a247fd1520060cff95f76341d18b813b35ef49b7f2c93e5471fc000e9b2c4a8d"

RDEPENDS:pdfgrep = " \
 glibc \
 libgcc \
 libgcrypt \
 libstdc++ \
 pcre2 \
 poppler-cpp \
 "
