# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc-toolset-16-binutils"
PV = "2.46"
PR = "2.el10.alma.1"
PACKAGES = " \
 gcc-toolset-16-binutils \
 gcc-toolset-16-binutils-devel \
 gcc-toolset-16-binutils-gold \
 gcc-toolset-16-binutils-gprofng \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gcc-toolset-16-binutils-2.46-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "763fb015b26572b1417a13db3606f8cb1837e559e11210d29497920ba7bebe97"

URI_x86_64_v2_gcc-toolset-16-binutils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-binutils-2.46-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-binutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-16-binutils}"
SRC_URI[x86_64_v2_gcc-toolset-16-binutils.sha256sum] = "3259de9b456a316383f0963b4d19f291feda10e221d83384701525ddc2371143"
RPROVIDES:gcc-toolset-16-binutils:x86_64_v2 = "virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_"

URI_x86_64_v2_gcc-toolset-16-binutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-binutils-devel-2.46-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-binutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-16-binutils-devel}"
SRC_URI[x86_64_v2_gcc-toolset-16-binutils-devel.sha256sum] = "026c98ac2f45763d5a7df48dfbaa9c213bc7f499f900666eea5e798a38f729af"

URI_x86_64_v2_gcc-toolset-16-binutils-gold = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-binutils-gold-2.46-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-binutils-gold;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-16-binutils-gold}"
SRC_URI[x86_64_v2_gcc-toolset-16-binutils-gold.sha256sum] = "72a246ae96c9dfc5225e13c4bdce3d9a17ac3d6e61f7d24dc87a4f39806cf5ce"

URI_x86_64_v2_gcc-toolset-16-binutils-gprofng = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-binutils-gprofng-2.46-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-binutils-gprofng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-16-binutils-gprofng}"
SRC_URI[x86_64_v2_gcc-toolset-16-binutils-gprofng.sha256sum] = "e9350d812951073ac0e22ea07767b8c2fe85777736b48ed139dbb22862d77424"
RPROVIDES:gcc-toolset-16-binutils-gprofng:x86_64_v2 = "virtual/libgprofng.so.0___64bit_"

URI_aarch64_gcc-toolset-16-binutils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-binutils-2.46-2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-binutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-16-binutils}"
SRC_URI[aarch64_gcc-toolset-16-binutils.sha256sum] = "068ff3d030d80deec9239cebd1e998b1e86d4230fac0736ef34d76b84ea99edb"
RPROVIDES:gcc-toolset-16-binutils:aarch64 = "virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_"

URI_aarch64_gcc-toolset-16-binutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-binutils-devel-2.46-2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-binutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-16-binutils-devel}"
SRC_URI[aarch64_gcc-toolset-16-binutils-devel.sha256sum] = "3f8af2950d9e9f34960910fe5c8eca39a3c948516a30d7eea29823d83b94cb76"

URI_aarch64_gcc-toolset-16-binutils-gold = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-binutils-gold-2.46-2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-binutils-gold;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-16-binutils-gold}"
SRC_URI[aarch64_gcc-toolset-16-binutils-gold.sha256sum] = "e4939cd644cbaa36b33fcfcc0b9c6e9537462338c45ab03602c510060d2155a2"

URI_aarch64_gcc-toolset-16-binutils-gprofng = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-binutils-gprofng-2.46-2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-binutils-gprofng;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-16-binutils-gprofng}"
SRC_URI[aarch64_gcc-toolset-16-binutils-gprofng.sha256sum] = "e8a2cc6b5463fe84f9e57fcdf7ca801b3ba4cdf9c094cb3a2169bf56fc716518"
RPROVIDES:gcc-toolset-16-binutils-gprofng:aarch64 = "virtual/libgprofng.so.0___64bit_"

RDEPENDS:gcc-toolset-16-binutils = " \
 alternatives \
 bash \
 elfutils-debuginfod-client \
 gcc-toolset-16-runtime \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 libzstd \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-16-binutils-devel = " \
 bash \
 gcc-toolset-16-binutils \
 virtual/coreutils \
 zlib-ng-compat-devel \
 "
RDEPENDS:gcc-toolset-16-binutils-gold = " \
 bash \
 gcc-toolset-16-binutils \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 libzstd \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-16-binutils-gprofng = " \
 bash \
 gcc-toolset-16-binutils \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 virtual//usr/bin/env \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libctf.so.0_LIBCTF_1.0__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.1__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.2__64bit_ rpm/virtual/libctf.so.0___64bit_ rpm/virtual/libgprofng.so.0___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libctf.so.0_LIBCTF_1.0__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.1__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.2__64bit_ rpm/virtual/libctf.so.0___64bit_ rpm/virtual/libgprofng.so.0___64bit_"
