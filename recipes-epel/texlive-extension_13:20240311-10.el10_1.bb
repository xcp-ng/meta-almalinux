# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "texlive-extension"
PE = "13"
PV = "20240311"
PR = "10.el10_1"
PACKAGES = " \
 texlive-adobemapping \
 texlive-ascmac \
 texlive-atenddvi \
 texlive-auto-pst-pdf \
 texlive-babel-french \
 texlive-babel-german \
 texlive-bibunits \
 texlive-boondox \
 texlive-chemformula \
 texlive-chemgreek \
 texlive-chktex \
 texlive-cjk \
 texlive-cjkpunct \
 texlive-convbkmk \
 texlive-ctex \
 texlive-ctie \
 texlive-cweb \
 texlive-ellipse \
 texlive-emulateapj \
 texlive-everyhook \
 texlive-fandol \
 texlive-filemod \
 texlive-fltpoint \
 texlive-fontaxes \
 texlive-german \
 texlive-germbib \
 texlive-gincltex \
 texlive-glossaries-english \
 texlive-glossaries-french \
 texlive-glossaries-german \
 texlive-hyphen-german \
 texlive-ieeetran \
 texlive-ipaex \
 texlive-japanese-otf \
 texlive-kantlipsum \
 texlive-lacheck \
 texlive-latex-base-dev \
 texlive-latex-firstaid-dev \
 texlive-lipsum \
 texlive-listingsutf8 \
 texlive-ltablex \
 texlive-luatexja \
 texlive-mdframed \
 texlive-media9 \
 texlive-mhchem \
 texlive-newtx \
 texlive-nomencl \
 texlive-ntheorem \
 texlive-ocgx2 \
 texlive-opensans \
 texlive-pgfplots \
 texlive-picinpar \
 texlive-pict2e \
 texlive-picture \
 texlive-platex \
 texlive-platex-tools \
 texlive-ps2eps \
 texlive-ptex \
 texlive-ptex-base \
 texlive-ptex-fonts \
 texlive-revtex4 \
 texlive-selinput \
 texlive-sidecap \
 texlive-siunitx \
 texlive-slantsc \
 texlive-standalone \
 texlive-sttools \
 texlive-supertabular \
 texlive-tcolorbox \
 texlive-tie \
 texlive-tikzfill \
 texlive-ttfutils \
 texlive-units \
 texlive-uplatex \
 texlive-uptex \
 texlive-uptex-base \
 texlive-uptex-fonts \
 texlive-web \
 texlive-xcjk2uni \
 texlive-xecjk \
 texlive-xltabular \
 texlive-xpinyin \
 texlive-zhmetrics \
 texlive-zhmetrics-uptex \
 texlive-zhnumber \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/texlive-extension-20240311-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c4c661be54d3d41f25b2c3fec69e9619058078e0d0772ffc9157fce3ac0039b"

URI_x86_64_v2_texlive-adobemapping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-adobemapping-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-adobemapping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-adobemapping}"
SRC_URI[x86_64_v2_texlive-adobemapping.sha256sum] = "2594585509bbcd069ac3b1ff5469a0aa2a7b3f8443848a41b4eeebbdcdc8e786"

URI_x86_64_v2_texlive-ascmac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ascmac-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ascmac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ascmac}"
SRC_URI[x86_64_v2_texlive-ascmac.sha256sum] = "69e6f8fbdaddf9c7b05f37cdaa0d85dc7e1817003ed9d01efed5e11f4c79e4ae"

URI_x86_64_v2_texlive-atenddvi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-atenddvi-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-atenddvi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-atenddvi}"
SRC_URI[x86_64_v2_texlive-atenddvi.sha256sum] = "16b02a5d507d0d81affdb2b58523e4d069ab0fbd689cc96f7e97a56c4c0d373f"

URI_x86_64_v2_texlive-auto-pst-pdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-auto-pst-pdf-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-auto-pst-pdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-auto-pst-pdf}"
SRC_URI[x86_64_v2_texlive-auto-pst-pdf.sha256sum] = "9f38fc94d8c28863be825a1da2b9946b2275fa234e2999aca27e40c6219db426"

URI_x86_64_v2_texlive-babel-french = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-babel-french-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-babel-french;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-babel-french}"
SRC_URI[x86_64_v2_texlive-babel-french.sha256sum] = "62e3dad58d4517d970b4a7cad8ab8d5648cc2c9df4406cb300bdbefdc02611b4"

URI_x86_64_v2_texlive-babel-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-babel-german-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-babel-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-babel-german}"
SRC_URI[x86_64_v2_texlive-babel-german.sha256sum] = "70130cba295bfb62faf47df537405574006027204d7f10c6b245cb702072a105"

URI_x86_64_v2_texlive-bibunits = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-bibunits-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-bibunits;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bibunits}"
SRC_URI[x86_64_v2_texlive-bibunits.sha256sum] = "644d05806046c8b3f1d46d60a64cafe8b6f9df8b65f97925888df0e3f225ba93"

URI_x86_64_v2_texlive-boondox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-boondox-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-boondox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-boondox}"
SRC_URI[x86_64_v2_texlive-boondox.sha256sum] = "456cde9b6b1d73812a5f6be54d46daee4047522b610bdb31f31e608e1db58588"

URI_x86_64_v2_texlive-chemformula = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-chemformula-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-chemformula;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-chemformula}"
SRC_URI[x86_64_v2_texlive-chemformula.sha256sum] = "7665fc900f155fd1dc6d6d180fb6eb01f87956cb116f31b1b1c668da97911539"

URI_x86_64_v2_texlive-chemgreek = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-chemgreek-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-chemgreek;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-chemgreek}"
SRC_URI[x86_64_v2_texlive-chemgreek.sha256sum] = "9aa75775296bf25a2fcdba35eb2667a491ac8a8fbcf2bd71c7ddc49e3d218248"

URI_x86_64_v2_texlive-chktex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-chktex-20240311-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-chktex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-chktex}"
SRC_URI[x86_64_v2_texlive-chktex.sha256sum] = "4e76883023deff888791ece301c2641dd6d965d618c0994ffcc6661560516c2f"

URI_x86_64_v2_texlive-cjk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-cjk-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-cjk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cjk}"
SRC_URI[x86_64_v2_texlive-cjk.sha256sum] = "cd0f26e71041d115b76aafd45b96b3d8089b322dd5fdbe23cbeb5e0e42eb118f"

URI_x86_64_v2_texlive-cjkpunct = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-cjkpunct-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-cjkpunct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cjkpunct}"
SRC_URI[x86_64_v2_texlive-cjkpunct.sha256sum] = "b4647b2b576f7fc06c2dbf3802f44cd6503602b30614869e859e6fa6aa7c52fa"

URI_x86_64_v2_texlive-convbkmk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-convbkmk-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-convbkmk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-convbkmk}"
SRC_URI[x86_64_v2_texlive-convbkmk.sha256sum] = "f5f28a3c3b168a4986a4796ce6f16380c555c3b5bb5aacc2933f845ec1b58a07"

URI_x86_64_v2_texlive-ctex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ctex-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ctex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ctex}"
SRC_URI[x86_64_v2_texlive-ctex.sha256sum] = "00f6cb97c64eab922e442c0f3e5a2889ae0a843df3c4eb2f45e7cffe5591d092"

URI_x86_64_v2_texlive-ctie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ctie-20240311-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ctie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ctie}"
SRC_URI[x86_64_v2_texlive-ctie.sha256sum] = "dba9b5d417e748f7cf02240f8cb7f70f4977384bc22f74c915be98ff15c32c84"

URI_x86_64_v2_texlive-cweb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-cweb-20240311-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-cweb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cweb}"
SRC_URI[x86_64_v2_texlive-cweb.sha256sum] = "ae49fe96831cfeb98003fe9a72390e9134796c47fc1c6fc9d05d87a388f0178b"

URI_x86_64_v2_texlive-ellipse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ellipse-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ellipse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ellipse}"
SRC_URI[x86_64_v2_texlive-ellipse.sha256sum] = "87b21f2501190d1dfb86a4ae53fb46f567c0680ef8236b2ab43e2dbe5e89b250"

URI_x86_64_v2_texlive-emulateapj = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-emulateapj-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-emulateapj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-emulateapj}"
SRC_URI[x86_64_v2_texlive-emulateapj.sha256sum] = "cb9f4f9b92dc038a4295807c89294c0763a7ef52634833f6d9ebbc50f8615c02"

URI_x86_64_v2_texlive-everyhook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-everyhook-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-everyhook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-everyhook}"
SRC_URI[x86_64_v2_texlive-everyhook.sha256sum] = "ac1d26a3b3ccc3c47150ffc5034dbe12d225b173f41c080fa19ac51479a88193"

URI_x86_64_v2_texlive-fandol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-fandol-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-fandol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fandol}"
SRC_URI[x86_64_v2_texlive-fandol.sha256sum] = "888443a0980562a57efa0a3e0bdbc93524c4fd5b0e3b3a4b5f5363bb9a856695"

URI_x86_64_v2_texlive-filemod = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-filemod-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-filemod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-filemod}"
SRC_URI[x86_64_v2_texlive-filemod.sha256sum] = "d396cc5eeace85a79c50bfbf2edbccc82942bf835a9b56836dc6d116c8e3532c"

URI_x86_64_v2_texlive-fltpoint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-fltpoint-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-fltpoint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fltpoint}"
SRC_URI[x86_64_v2_texlive-fltpoint.sha256sum] = "ae451cf8474a6d02e7e15e6fc38c83fdc94b0eeaf1401d260ca528a794cc17fa"

URI_x86_64_v2_texlive-fontaxes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-fontaxes-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-fontaxes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fontaxes}"
SRC_URI[x86_64_v2_texlive-fontaxes.sha256sum] = "0da27a58b83a2c1f9145fe42f87ed8de95330deb58fc9dfe96c07c633381f54f"

URI_x86_64_v2_texlive-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-german-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-german}"
SRC_URI[x86_64_v2_texlive-german.sha256sum] = "8112945b2a83506d2e3a1ade6b372d236e025dc3f224167f544efe3f78f8dff0"

URI_x86_64_v2_texlive-germbib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-germbib-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-germbib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-germbib}"
SRC_URI[x86_64_v2_texlive-germbib.sha256sum] = "759b43b1461f72688737c0d4bbd8d6f957391314ae68f88b873ea56b5bb179f5"

URI_x86_64_v2_texlive-gincltex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-gincltex-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-gincltex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-gincltex}"
SRC_URI[x86_64_v2_texlive-gincltex.sha256sum] = "cc4195354d10c44928f8c51a860d2f05c8408ef0583f390f6ae3d73018b694aa"

URI_x86_64_v2_texlive-glossaries-english = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-glossaries-english-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-glossaries-english;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-glossaries-english}"
SRC_URI[x86_64_v2_texlive-glossaries-english.sha256sum] = "d28ac8af5bcc8da2aab0cd6e8742693cafe060fa0e9e58782964546449e15dfd"

URI_x86_64_v2_texlive-glossaries-french = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-glossaries-french-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-glossaries-french;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-glossaries-french}"
SRC_URI[x86_64_v2_texlive-glossaries-french.sha256sum] = "78bffe3dc244454da61232c850c3319aecc7a75301ae8f8aa488cf37bdf2ae2e"

URI_x86_64_v2_texlive-glossaries-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-glossaries-german-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-glossaries-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-glossaries-german}"
SRC_URI[x86_64_v2_texlive-glossaries-german.sha256sum] = "82ec7433d2b7d37274774e201c7eaf1528667ec882a5fc241737d6e6b931e5c0"

URI_x86_64_v2_texlive-hyphen-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-hyphen-german-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-hyphen-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hyphen-german}"
SRC_URI[x86_64_v2_texlive-hyphen-german.sha256sum] = "efb62817610596672f087d13d089b8d435606ca9ae644c8a4b2b3d47b91358fa"

URI_x86_64_v2_texlive-ieeetran = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ieeetran-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ieeetran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ieeetran}"
SRC_URI[x86_64_v2_texlive-ieeetran.sha256sum] = "9579349926d9ff4a76f1e1d274454ed44e0114a1719047a92a6090c5b859e752"

URI_x86_64_v2_texlive-ipaex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ipaex-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ipaex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ipaex}"
SRC_URI[x86_64_v2_texlive-ipaex.sha256sum] = "59d11fc1ae26be3f5a3a3370163131bbd6c19438e53fb1e5ee68278aae4c6eb9"

URI_x86_64_v2_texlive-japanese-otf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-japanese-otf-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-japanese-otf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-japanese-otf}"
SRC_URI[x86_64_v2_texlive-japanese-otf.sha256sum] = "5d11277ae2d3039baaa45a1821efb0816d7b876493cdc993c095c1000f7c065d"

URI_x86_64_v2_texlive-kantlipsum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-kantlipsum-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-kantlipsum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kantlipsum}"
SRC_URI[x86_64_v2_texlive-kantlipsum.sha256sum] = "02b18dacef82b29449dcd8153ebb2c86e7864f495620a554f6888e0786031067"

URI_x86_64_v2_texlive-lacheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-lacheck-20240311-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-lacheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lacheck}"
SRC_URI[x86_64_v2_texlive-lacheck.sha256sum] = "083e13a4ed09bd6b428ca83f2094ec8a6b392f32c7b6d1fba6bbda8b8f8b69b6"

URI_x86_64_v2_texlive-latex-base-dev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-latex-base-dev-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-latex-base-dev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latex-base-dev}"
SRC_URI[x86_64_v2_texlive-latex-base-dev.sha256sum] = "9389b6a61a99598f3e3752103806441069a666c2358fb38c9310c30af898aa52"
RPROVIDES:texlive-latex-base-dev:x86_64_v2 = "virtual/tex_alltt.sty_ virtual/tex_article.cls_ virtual/tex_doc.sty_ virtual/tex_exscale.sty_ virtual/tex_fix-cm.sty_ virtual/tex_fixltx2e.sty_ virtual/tex_flafter.sty_ virtual/tex_fontenc.sty_ virtual/tex_ifthen.sty_ virtual/tex_inputenc.sty_ virtual/tex_latexsym.sty_ virtual/tex_makeidx.sty_ virtual/tex_oldlfont.sty_ virtual/tex_shortvrb.sty_ virtual/tex_t1cmr.fd_ virtual/tex_textcomp.sty_"

URI_x86_64_v2_texlive-latex-firstaid-dev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-latex-firstaid-dev-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-latex-firstaid-dev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latex-firstaid-dev}"
SRC_URI[x86_64_v2_texlive-latex-firstaid-dev.sha256sum] = "1f9525ce03acc7efd35b699cd87b9cd569c1061cfe9780b81788b14eb667fd6c"

URI_x86_64_v2_texlive-lipsum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-lipsum-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-lipsum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lipsum}"
SRC_URI[x86_64_v2_texlive-lipsum.sha256sum] = "585190ba6344cea487d1de512f585e2bc1954dae0ec542980b7662f8f943cfff"

URI_x86_64_v2_texlive-listingsutf8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-listingsutf8-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-listingsutf8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-listingsutf8}"
SRC_URI[x86_64_v2_texlive-listingsutf8.sha256sum] = "0606d13b93d16b3cdd7cf45379f931a3996fca0fe2ed4d1a3e4437d2b471bc3c"

URI_x86_64_v2_texlive-ltablex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ltablex-20240311-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ltablex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ltablex}"
SRC_URI[x86_64_v2_texlive-ltablex.sha256sum] = "09eb172d54c377c6426910dc70303ae90c03d24a5dc97ccc2b40be3703e5b94d"

URI_x86_64_v2_texlive-luatexja = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-luatexja-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-luatexja;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-luatexja}"
SRC_URI[x86_64_v2_texlive-luatexja.sha256sum] = "6e79bde67c36572e5fdb371e14208687d31b71863e6831bf01f90196f4ad5eb8"

URI_x86_64_v2_texlive-mdframed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-mdframed-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-mdframed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mdframed}"
SRC_URI[x86_64_v2_texlive-mdframed.sha256sum] = "4a5e359cd0b12b73aa6751962048fbe8ff28a8e4766c957f343638502b5501b9"

URI_x86_64_v2_texlive-media9 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-media9-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-media9;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-media9}"
SRC_URI[x86_64_v2_texlive-media9.sha256sum] = "079ddeea732edabe43bee14b61c8ba6c4c3c02feae32301e905657f95b0a2465"

URI_x86_64_v2_texlive-mhchem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-mhchem-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-mhchem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mhchem}"
SRC_URI[x86_64_v2_texlive-mhchem.sha256sum] = "2282619b5905367c6e7ed8532e8f3581787e9f90452169f148d6d8dfd6d03b56"

URI_x86_64_v2_texlive-newtx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-newtx-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-newtx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-newtx}"
SRC_URI[x86_64_v2_texlive-newtx.sha256sum] = "c3deed896c895b996c7824483dfabd5142631ee5f2c6d0a09bd1077fbb7d95b2"

URI_x86_64_v2_texlive-nomencl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-nomencl-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-nomencl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-nomencl}"
SRC_URI[x86_64_v2_texlive-nomencl.sha256sum] = "f177743fc0c35cc9633c84a7a3bd5025e25c791a36955482103d47a0818baff4"

URI_x86_64_v2_texlive-ntheorem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ntheorem-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ntheorem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ntheorem}"
SRC_URI[x86_64_v2_texlive-ntheorem.sha256sum] = "fe270df997b902272c2361d3f9f720a0bfc8a9b6cc88719cd96c72a0ceccc5b0"

URI_x86_64_v2_texlive-ocgx2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ocgx2-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ocgx2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ocgx2}"
SRC_URI[x86_64_v2_texlive-ocgx2.sha256sum] = "c318052edf65808d59d71746186f93a78760480454e6cb00527a6aca362c35dc"

URI_x86_64_v2_texlive-opensans = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-opensans-20240311-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-opensans;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-opensans}"
SRC_URI[x86_64_v2_texlive-opensans.sha256sum] = "82617bdeda08d53782ba44e2f9902a12cd89600c7cd367bb84af2d9f6fe298c5"

URI_x86_64_v2_texlive-pgfplots = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-pgfplots-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-pgfplots;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pgfplots}"
SRC_URI[x86_64_v2_texlive-pgfplots.sha256sum] = "2ba857aa32807537e7c1770616115389f81b92dd3267fdbda8e17e20b1fd73ca"

URI_x86_64_v2_texlive-picinpar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-picinpar-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-picinpar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-picinpar}"
SRC_URI[x86_64_v2_texlive-picinpar.sha256sum] = "d5d38a760fb401b5e4c4d1ce23bef686738c625c87c2f7841b1a071f337c4d05"

URI_x86_64_v2_texlive-pict2e = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-pict2e-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-pict2e;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pict2e}"
SRC_URI[x86_64_v2_texlive-pict2e.sha256sum] = "395f478fbba06ef662f05755cf08fc1c6c4827a37721f49b66359a908e673c60"

URI_x86_64_v2_texlive-picture = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-picture-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-picture;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-picture}"
SRC_URI[x86_64_v2_texlive-picture.sha256sum] = "237c5aa72c7219b339b39a709833f33e6dc0fa635b5108f959f868a1e39f2fef"

URI_x86_64_v2_texlive-platex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-platex-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-platex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-platex}"
SRC_URI[x86_64_v2_texlive-platex.sha256sum] = "614817b70fdea0b6c794f1b2f4df99c19f7fecaf5e05fa422e04600a2704ce47"

URI_x86_64_v2_texlive-platex-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-platex-tools-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-platex-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-platex-tools}"
SRC_URI[x86_64_v2_texlive-platex-tools.sha256sum] = "cec2b27614674dbf9b7fd760e8f26352d227e823f281635e6dd24022850d922c"

URI_x86_64_v2_texlive-ps2eps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ps2eps-20240311-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ps2eps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ps2eps}"
SRC_URI[x86_64_v2_texlive-ps2eps.sha256sum] = "c29a9b9c423d1d21e6c5a51661c1acf0b457da756f92a35e8289504910e8cbd9"

URI_x86_64_v2_texlive-ptex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ptex-20240311-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ptex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ptex}"
SRC_URI[x86_64_v2_texlive-ptex.sha256sum] = "bdb6a293a91a2326cbc3bed44909f2e47a29d7ea57234bc66471dc0a5e6f010a"

URI_x86_64_v2_texlive-ptex-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ptex-base-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ptex-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ptex-base}"
SRC_URI[x86_64_v2_texlive-ptex-base.sha256sum] = "fa19394c33349a38abd6bc1b1df913a09fe0ab4925ae24cb34a3c88f5bf3fc84"

URI_x86_64_v2_texlive-ptex-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ptex-fonts-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ptex-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ptex-fonts}"
SRC_URI[x86_64_v2_texlive-ptex-fonts.sha256sum] = "a11a82e5b553a0c2217894676ef8b985a71e9dc0758361341ccf474db5b0e65b"

URI_x86_64_v2_texlive-revtex4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-revtex4-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-revtex4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-revtex4}"
SRC_URI[x86_64_v2_texlive-revtex4.sha256sum] = "8ba1a43a25eb29ae3924c51b901b2937a53bed2de8408e3b2f67a6e9a877d954"

URI_x86_64_v2_texlive-selinput = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-selinput-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-selinput;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-selinput}"
SRC_URI[x86_64_v2_texlive-selinput.sha256sum] = "9a4e557c1f9881c8f9e900521da6161d5b6c53f539f46aea872644076edcb28b"

URI_x86_64_v2_texlive-sidecap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-sidecap-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-sidecap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sidecap}"
SRC_URI[x86_64_v2_texlive-sidecap.sha256sum] = "b370707e139312ef51d6bb8aec66fcb03b1d10a05dcadf49e62fc2df074c50d2"

URI_x86_64_v2_texlive-siunitx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-siunitx-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-siunitx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-siunitx}"
SRC_URI[x86_64_v2_texlive-siunitx.sha256sum] = "a27d0e9f2d243572996aab955d2f03b53c12b433c9311ad61722dd47f6266350"

URI_x86_64_v2_texlive-slantsc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-slantsc-20240311-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-slantsc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-slantsc}"
SRC_URI[x86_64_v2_texlive-slantsc.sha256sum] = "2a1751bca58fe4eeee898e41711ed77ccadaed9cbdbd2b637b7b6fddfe7babc5"

URI_x86_64_v2_texlive-standalone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-standalone-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-standalone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-standalone}"
SRC_URI[x86_64_v2_texlive-standalone.sha256sum] = "1762857f12e184591749e71dedeefcffb06701036c3023386f6e85bae5415625"

URI_x86_64_v2_texlive-sttools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-sttools-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-sttools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sttools}"
SRC_URI[x86_64_v2_texlive-sttools.sha256sum] = "3b88cf243f24ad95b243caa6b79b38036ab993fe7a48b9e8a7c2e9458ce0c58a"

URI_x86_64_v2_texlive-supertabular = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-supertabular-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-supertabular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-supertabular}"
SRC_URI[x86_64_v2_texlive-supertabular.sha256sum] = "511a705253aedcaec71c214c4ec1b8fb449d2dfb9d7a45c0141df9ce09daeaaa"

URI_x86_64_v2_texlive-tcolorbox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-tcolorbox-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-tcolorbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tcolorbox}"
SRC_URI[x86_64_v2_texlive-tcolorbox.sha256sum] = "f93f16c357768156ac8dc83c1b428f22d58cea99caf58c64592d830383c95d82"

URI_x86_64_v2_texlive-tie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-tie-20240311-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-tie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tie}"
SRC_URI[x86_64_v2_texlive-tie.sha256sum] = "dc071aa31497b46698371d7405216b219bee6ef17b4482a574ed1959b471c0b9"

URI_x86_64_v2_texlive-tikzfill = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-tikzfill-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-tikzfill;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tikzfill}"
SRC_URI[x86_64_v2_texlive-tikzfill.sha256sum] = "1dc00a2b822a6e7a1d52df72b1749f83395ab80ad013a62b98638914fddc0be2"

URI_x86_64_v2_texlive-ttfutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ttfutils-20240311-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ttfutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ttfutils}"
SRC_URI[x86_64_v2_texlive-ttfutils.sha256sum] = "17823dd9c89f871c0c1973fd53ec52cd5ced058102fc96517d611ccb8efa3514"

URI_x86_64_v2_texlive-units = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-units-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-units;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-units}"
SRC_URI[x86_64_v2_texlive-units.sha256sum] = "a4edb4f0bd3a2d02911d25293ccfa2cae9514515c24960a26a7463bbf02c7ade"

URI_x86_64_v2_texlive-uplatex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uplatex-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-uplatex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uplatex}"
SRC_URI[x86_64_v2_texlive-uplatex.sha256sum] = "94a12db6f1dd9fe3b385f93b28a2cc91c6874509144620670089b45f134d6471"

URI_x86_64_v2_texlive-uptex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uptex-20240311-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-uptex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uptex}"
SRC_URI[x86_64_v2_texlive-uptex.sha256sum] = "33c0db797e1f8ec9ad9e48cf8a39ae22884b8451150b0b71adc2f8e04f70197d"

URI_x86_64_v2_texlive-uptex-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uptex-base-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-uptex-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uptex-base}"
SRC_URI[x86_64_v2_texlive-uptex-base.sha256sum] = "6061bb330f09b6c93d48792b8f3f22992409085c848168add897928c9cc9bffe"

URI_x86_64_v2_texlive-uptex-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uptex-fonts-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-uptex-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uptex-fonts}"
SRC_URI[x86_64_v2_texlive-uptex-fonts.sha256sum] = "5c1d20aedf9f7219d33556917accc62898923320a03d9a8b343aaa3ffde63744"

URI_x86_64_v2_texlive-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-web-20240311-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-web}"
SRC_URI[x86_64_v2_texlive-web.sha256sum] = "fd71eda35b72f0681f4acd337e353ebab3086deaa2839f4c9f8d02dcd1bc1fc4"

URI_x86_64_v2_texlive-xcjk2uni = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xcjk2uni-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-xcjk2uni;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xcjk2uni}"
SRC_URI[x86_64_v2_texlive-xcjk2uni.sha256sum] = "a48c9e14b5fce57c4c04af39528b67fda3ba5984f28a6146ab84319e9b6997d5"

URI_x86_64_v2_texlive-xecjk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xecjk-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-xecjk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xecjk}"
SRC_URI[x86_64_v2_texlive-xecjk.sha256sum] = "4be4873afe308bed0c43ac15a91f73a2ee5fc0689f2231b51eacda4e0ce67f0b"

URI_x86_64_v2_texlive-xltabular = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xltabular-20240311-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-xltabular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xltabular}"
SRC_URI[x86_64_v2_texlive-xltabular.sha256sum] = "0660245851b69fba2a702b64031dcadabed2315e6a36807cabf52b3b303de357"

URI_x86_64_v2_texlive-xpinyin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xpinyin-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-xpinyin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xpinyin}"
SRC_URI[x86_64_v2_texlive-xpinyin.sha256sum] = "f17f64a7920c626fa9d62fc1bfbc86d54c295bcc0a21cbc37046668d453065e7"

URI_x86_64_v2_texlive-zhmetrics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-zhmetrics-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-zhmetrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zhmetrics}"
SRC_URI[x86_64_v2_texlive-zhmetrics.sha256sum] = "c5b7cf6f50304953e9e6aecbc88fe789e9020af095e7a6c2e8db0815794bf3dc"

URI_x86_64_v2_texlive-zhmetrics-uptex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-zhmetrics-uptex-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-zhmetrics-uptex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zhmetrics-uptex}"
SRC_URI[x86_64_v2_texlive-zhmetrics-uptex.sha256sum] = "e93d5e99aee9af7858545d9b04ac719d14f26a32415d42f87389c467dcb317be"

URI_x86_64_v2_texlive-zhnumber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-zhnumber-20240311-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-zhnumber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zhnumber}"
SRC_URI[x86_64_v2_texlive-zhnumber.sha256sum] = "737325be5a400ef9c493b12bf231a993d43553c09f8470eded1d3b63ec87497c"

URI_aarch64_texlive-adobemapping = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-adobemapping-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-adobemapping;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-adobemapping}"
SRC_URI[aarch64_texlive-adobemapping.sha256sum] = "3c8d85352ded251c57ea2607f42965948fbd4f8a2d4195a77a5a205c7762fe87"

URI_aarch64_texlive-ascmac = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ascmac-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-ascmac;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ascmac}"
SRC_URI[aarch64_texlive-ascmac.sha256sum] = "5ec53f191a39e9363c679dce95ffc8de0721954471a76c4f4d599c6e2be976dc"

URI_aarch64_texlive-atenddvi = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-atenddvi-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-atenddvi;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-atenddvi}"
SRC_URI[aarch64_texlive-atenddvi.sha256sum] = "8463dab065f0f9a7c3a0e8710c89c1971e18ac2aed6646a9a861a1f6c5fe2e57"

URI_aarch64_texlive-auto-pst-pdf = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-auto-pst-pdf-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-auto-pst-pdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-auto-pst-pdf}"
SRC_URI[aarch64_texlive-auto-pst-pdf.sha256sum] = "773a940dbfb443b6e721b04d53a3811593db3ae537e76b844b398a20dd520327"

URI_aarch64_texlive-babel-french = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-babel-french-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-babel-french;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-babel-french}"
SRC_URI[aarch64_texlive-babel-french.sha256sum] = "6502a76d28fcb22ad096bc9af352a06e581a6d29acb1cfb93820b3b7a67d1558"

URI_aarch64_texlive-babel-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-babel-german-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-babel-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-babel-german}"
SRC_URI[aarch64_texlive-babel-german.sha256sum] = "620b65002b03d8435423191c35bf33149801006603172475dd4f2dfb7426f4c6"

URI_aarch64_texlive-bibunits = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-bibunits-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-bibunits;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bibunits}"
SRC_URI[aarch64_texlive-bibunits.sha256sum] = "8a98c926e2f5688e9230720cd2dae6bc8c93826355eeaa1ba14caaf734232074"

URI_aarch64_texlive-boondox = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-boondox-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-boondox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-boondox}"
SRC_URI[aarch64_texlive-boondox.sha256sum] = "7ea531dd1794761d7c00c897bf13af379fea2c78ce49df8026ac9b7490f87033"

URI_aarch64_texlive-chemformula = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-chemformula-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-chemformula;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-chemformula}"
SRC_URI[aarch64_texlive-chemformula.sha256sum] = "af22c9f4069a7152d3f1082ba1a9531a4150c062f8ee44b055efc7df0382bdd8"

URI_aarch64_texlive-chemgreek = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-chemgreek-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-chemgreek;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-chemgreek}"
SRC_URI[aarch64_texlive-chemgreek.sha256sum] = "21ba5b611dfaf66dfb2204c6926cd2cdeff1f260a8c4b18cf822a2142e746b1d"

URI_aarch64_texlive-chktex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-chktex-20240311-10.el10_1.aarch64.rpm;name=aarch64_texlive-chktex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-chktex}"
SRC_URI[aarch64_texlive-chktex.sha256sum] = "04d8f67521d312d5472e8abb23d1f7fd70be405095428d2eed7e04b136239aa0"

URI_aarch64_texlive-cjk = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-cjk-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-cjk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cjk}"
SRC_URI[aarch64_texlive-cjk.sha256sum] = "24ef85c8e5f081c32abfd03c3e4618f18b8d5bada497d0e8083286e2b25154c6"

URI_aarch64_texlive-cjkpunct = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-cjkpunct-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-cjkpunct;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cjkpunct}"
SRC_URI[aarch64_texlive-cjkpunct.sha256sum] = "fb1ddb449056741781eb8a0a47fbab632fd514a8be3b908d424bfd5615c398c8"

URI_aarch64_texlive-convbkmk = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-convbkmk-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-convbkmk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-convbkmk}"
SRC_URI[aarch64_texlive-convbkmk.sha256sum] = "fb84a989ba92195ed1356a57a6514e78c9433a1210191a0e0cf764f26f7556a4"

URI_aarch64_texlive-ctex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ctex-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-ctex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ctex}"
SRC_URI[aarch64_texlive-ctex.sha256sum] = "5b9f303fc2bed3536b2ffbb686528c14e9eea82342b6dd7f0af427b6783e5a43"

URI_aarch64_texlive-ctie = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ctie-20240311-10.el10_1.aarch64.rpm;name=aarch64_texlive-ctie;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ctie}"
SRC_URI[aarch64_texlive-ctie.sha256sum] = "7f69740def52acc5ec2b890444a9ee4facce45348075ce7b6aa36d6cf60806c0"

URI_aarch64_texlive-cweb = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-cweb-20240311-10.el10_1.aarch64.rpm;name=aarch64_texlive-cweb;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cweb}"
SRC_URI[aarch64_texlive-cweb.sha256sum] = "4b5ed9482ba79794399e517a6966ab98d4367d37bf613764ab4cb7c7ef1abbb5"

URI_aarch64_texlive-ellipse = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ellipse-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-ellipse;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ellipse}"
SRC_URI[aarch64_texlive-ellipse.sha256sum] = "c9b40359f24fdbc5c5ebad2ad7e30ca9d29462728edfaaba19bcfe08cf6e0e97"

URI_aarch64_texlive-emulateapj = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-emulateapj-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-emulateapj;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-emulateapj}"
SRC_URI[aarch64_texlive-emulateapj.sha256sum] = "5edc0b8237806178ab9062b7f42595098f26559184f3fde31665ca91a14203d5"

URI_aarch64_texlive-everyhook = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-everyhook-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-everyhook;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-everyhook}"
SRC_URI[aarch64_texlive-everyhook.sha256sum] = "ca982a103a06f492286b7e664417ee93a9a5540bfafb0d5c531bb46dc6d65868"

URI_aarch64_texlive-fandol = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-fandol-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-fandol;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fandol}"
SRC_URI[aarch64_texlive-fandol.sha256sum] = "0c2aaa3dbe3690cdc2795c8f6bad7b85bd2c6fd30d87afe216863e8e17f3691f"

URI_aarch64_texlive-filemod = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-filemod-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-filemod;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-filemod}"
SRC_URI[aarch64_texlive-filemod.sha256sum] = "202555df01f771a73461d90f6e344e87c6515dd236408701228c10244942743c"

URI_aarch64_texlive-fltpoint = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-fltpoint-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-fltpoint;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fltpoint}"
SRC_URI[aarch64_texlive-fltpoint.sha256sum] = "94b3b57eda20160caa2d355d672c6e1d078ff3c01e8bf88d1520d5db8e729fdc"

URI_aarch64_texlive-fontaxes = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-fontaxes-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-fontaxes;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fontaxes}"
SRC_URI[aarch64_texlive-fontaxes.sha256sum] = "d6c2a5cbc2fba7c2c225a976df5a045e24cb85b1fcbec48fa6770fd35ccf718f"

URI_aarch64_texlive-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-german-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-german}"
SRC_URI[aarch64_texlive-german.sha256sum] = "dc0cc1c7271c7e73783b7cd82a587bae6dc1a87864883bc8724bed7c619fd71f"

URI_aarch64_texlive-germbib = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-germbib-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-germbib;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-germbib}"
SRC_URI[aarch64_texlive-germbib.sha256sum] = "2bb034c91cd3fca2d87f7e64131f875335c128c12cab2bfbf1fcd75d4e481e17"

URI_aarch64_texlive-gincltex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-gincltex-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-gincltex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-gincltex}"
SRC_URI[aarch64_texlive-gincltex.sha256sum] = "22cbd1803901f46b8adebe3385bc98d340f15227eede31eee86afb4c685a3152"

URI_aarch64_texlive-glossaries-english = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-glossaries-english-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-glossaries-english;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-glossaries-english}"
SRC_URI[aarch64_texlive-glossaries-english.sha256sum] = "a6d7cc2fc998d0490ff1a217bc73edeaec3c544faeea369b43a2344a288bed65"

URI_aarch64_texlive-glossaries-french = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-glossaries-french-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-glossaries-french;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-glossaries-french}"
SRC_URI[aarch64_texlive-glossaries-french.sha256sum] = "3f098efdb5d9e65e0da7eb0e10abcb61aef3dc41a81619ca22e7d7bcf7b6bd93"

URI_aarch64_texlive-glossaries-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-glossaries-german-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-glossaries-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-glossaries-german}"
SRC_URI[aarch64_texlive-glossaries-german.sha256sum] = "24ae050503588f3c49933be9f1472cad1013bc765d740fdd43418228097d8ca1"

URI_aarch64_texlive-hyphen-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-hyphen-german-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-hyphen-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hyphen-german}"
SRC_URI[aarch64_texlive-hyphen-german.sha256sum] = "8c00e2f5e35504e800f4557170390aebf2662eaacc9295d7433d55c8c8383c3c"

URI_aarch64_texlive-ieeetran = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ieeetran-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-ieeetran;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ieeetran}"
SRC_URI[aarch64_texlive-ieeetran.sha256sum] = "06c310ff3683899596d53676cf971d74ab5c8f68cebca403a656d5c390916331"

URI_aarch64_texlive-ipaex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ipaex-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-ipaex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ipaex}"
SRC_URI[aarch64_texlive-ipaex.sha256sum] = "36f88e5ca61f1e07260776175b271cc0fac909608b4aec113ce3c29ccb0f1e22"

URI_aarch64_texlive-japanese-otf = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-japanese-otf-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-japanese-otf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-japanese-otf}"
SRC_URI[aarch64_texlive-japanese-otf.sha256sum] = "d7000d51efce9d327a3656f450a57ebe75c90c71bf0248d7d1940792612ec823"

URI_aarch64_texlive-kantlipsum = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-kantlipsum-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-kantlipsum;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kantlipsum}"
SRC_URI[aarch64_texlive-kantlipsum.sha256sum] = "72a13c1ebda4cd85cd649304dfd38fd89bcd9ec843feef010d94e2c9e4112143"

URI_aarch64_texlive-lacheck = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-lacheck-20240311-10.el10_1.aarch64.rpm;name=aarch64_texlive-lacheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lacheck}"
SRC_URI[aarch64_texlive-lacheck.sha256sum] = "18b6088220281559cacf8682f0f4576af2ed5c36c7345dbf75cda79c57fdf3f3"

URI_aarch64_texlive-latex-base-dev = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-latex-base-dev-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-latex-base-dev;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latex-base-dev}"
SRC_URI[aarch64_texlive-latex-base-dev.sha256sum] = "00f82122967e9118d58ad74eee0511ba1d505d4b07f460fbe551950b6ca8b88f"
RPROVIDES:texlive-latex-base-dev:aarch64 = "virtual/tex_alltt.sty_ virtual/tex_article.cls_ virtual/tex_doc.sty_ virtual/tex_exscale.sty_ virtual/tex_fix-cm.sty_ virtual/tex_fixltx2e.sty_ virtual/tex_flafter.sty_ virtual/tex_fontenc.sty_ virtual/tex_ifthen.sty_ virtual/tex_inputenc.sty_ virtual/tex_latexsym.sty_ virtual/tex_makeidx.sty_ virtual/tex_oldlfont.sty_ virtual/tex_shortvrb.sty_ virtual/tex_t1cmr.fd_ virtual/tex_textcomp.sty_"

URI_aarch64_texlive-latex-firstaid-dev = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-latex-firstaid-dev-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-latex-firstaid-dev;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latex-firstaid-dev}"
SRC_URI[aarch64_texlive-latex-firstaid-dev.sha256sum] = "d9ef6f365e403327ce9da3ac68a2c93e95b0dd25d570178ab714adfe31a5ef0b"

URI_aarch64_texlive-lipsum = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-lipsum-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-lipsum;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lipsum}"
SRC_URI[aarch64_texlive-lipsum.sha256sum] = "547e22801e77d4977594bc83815f3b1f6ae49144ec0312d79904b7ecc4df2b6c"

URI_aarch64_texlive-listingsutf8 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-listingsutf8-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-listingsutf8;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-listingsutf8}"
SRC_URI[aarch64_texlive-listingsutf8.sha256sum] = "228289318fd6a0f5273a3b3fe84615fa46102cf438272cb9028fc954bff1e5fc"

URI_aarch64_texlive-ltablex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ltablex-20240311-10.el10_1.aarch64.rpm;name=aarch64_texlive-ltablex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ltablex}"
SRC_URI[aarch64_texlive-ltablex.sha256sum] = "a1f2f86fc168d41fa5ed45f6b8143a18122a2ea0ba7a4c847cab1ee6848a0e8d"

URI_aarch64_texlive-luatexja = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-luatexja-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-luatexja;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-luatexja}"
SRC_URI[aarch64_texlive-luatexja.sha256sum] = "45cfd4c2f6349ee4c2546d2cd2e814153cf1d974abd4a08a6abedece5e88b17c"

URI_aarch64_texlive-mdframed = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-mdframed-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-mdframed;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mdframed}"
SRC_URI[aarch64_texlive-mdframed.sha256sum] = "e1c7c05f92601e28957491fc071fcad7bb4940e87886967df37d7a75dc06fd59"

URI_aarch64_texlive-media9 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-media9-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-media9;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-media9}"
SRC_URI[aarch64_texlive-media9.sha256sum] = "2edb99b4ae3d5ad968bddd2410e7f8a7765b498fe19c9a645a5b46edc49d3941"

URI_aarch64_texlive-mhchem = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-mhchem-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-mhchem;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mhchem}"
SRC_URI[aarch64_texlive-mhchem.sha256sum] = "96334eb85f661860f9615c3857ef2401f7571f5440d2f906676d0f890a48312c"

URI_aarch64_texlive-newtx = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-newtx-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-newtx;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-newtx}"
SRC_URI[aarch64_texlive-newtx.sha256sum] = "5e77c4bea67a320a30c620febb6dfee05e3581712c10ee6b06c320fb05f35750"

URI_aarch64_texlive-nomencl = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-nomencl-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-nomencl;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-nomencl}"
SRC_URI[aarch64_texlive-nomencl.sha256sum] = "8c87b8bee3fa501e95852782fdd5ff5019447e813c6a84260dd17c1374c33fee"

URI_aarch64_texlive-ntheorem = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ntheorem-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-ntheorem;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ntheorem}"
SRC_URI[aarch64_texlive-ntheorem.sha256sum] = "3c60f2daebc1bc1cfd7e7f065f27dfcb67139ef932317df3d4056652c3b48275"

URI_aarch64_texlive-ocgx2 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ocgx2-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-ocgx2;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ocgx2}"
SRC_URI[aarch64_texlive-ocgx2.sha256sum] = "c898c0bdd3a1760c39dc7e890d2a9d2ddeab3c0f66f850a9db1e5748f0841bd8"

URI_aarch64_texlive-opensans = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-opensans-20240311-10.el10_1.aarch64.rpm;name=aarch64_texlive-opensans;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-opensans}"
SRC_URI[aarch64_texlive-opensans.sha256sum] = "09f75a4cb4e6d70cfaa0f13bd3538aad7af01712afe1ad91f7c156c3ff1eebfb"

URI_aarch64_texlive-pgfplots = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-pgfplots-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-pgfplots;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pgfplots}"
SRC_URI[aarch64_texlive-pgfplots.sha256sum] = "ab4c3781944cd8c86ae752d1b23827d3c9121a533c9b9bfde14bc556929ac939"

URI_aarch64_texlive-picinpar = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-picinpar-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-picinpar;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-picinpar}"
SRC_URI[aarch64_texlive-picinpar.sha256sum] = "459434bed5eea514fa26a4875c5eadfa38bb7dbdf3a0a725f0c4acf34a098d7a"

URI_aarch64_texlive-pict2e = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-pict2e-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-pict2e;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pict2e}"
SRC_URI[aarch64_texlive-pict2e.sha256sum] = "04d1469e5ea0e290e3a5fc065446b42f903831d1a477878972bf2efbd87bf5aa"

URI_aarch64_texlive-picture = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-picture-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-picture;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-picture}"
SRC_URI[aarch64_texlive-picture.sha256sum] = "56a607a2d638a56b8dedca2dc123fb6fdfac5f20192905d1d5237e29e68d18d2"

URI_aarch64_texlive-platex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-platex-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-platex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-platex}"
SRC_URI[aarch64_texlive-platex.sha256sum] = "c310a762c06c95856c336bd27112c4f128b969ead85dad6ac902f61d016d06b2"

URI_aarch64_texlive-platex-tools = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-platex-tools-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-platex-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-platex-tools}"
SRC_URI[aarch64_texlive-platex-tools.sha256sum] = "12e9a009358b8f492dfaf000c0a58a406c133be918b27b0490e9e52efc7f1307"

URI_aarch64_texlive-ps2eps = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ps2eps-20240311-10.el10_1.aarch64.rpm;name=aarch64_texlive-ps2eps;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ps2eps}"
SRC_URI[aarch64_texlive-ps2eps.sha256sum] = "659eaf4925f5dce0c94dd5b557fc0a1031722b9c25317fd8744658c5150c2eb4"

URI_aarch64_texlive-ptex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ptex-20240311-10.el10_1.aarch64.rpm;name=aarch64_texlive-ptex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ptex}"
SRC_URI[aarch64_texlive-ptex.sha256sum] = "e68f518b3ae7a854eacf9d2664d24d8b64f40e6193476884a1f8b33aafb23203"

URI_aarch64_texlive-ptex-base = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ptex-base-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-ptex-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ptex-base}"
SRC_URI[aarch64_texlive-ptex-base.sha256sum] = "59f0ed0df4458cf111905a36c4f6ad22c40ede9b03b736b0fd8cf2e78bb73c9c"

URI_aarch64_texlive-ptex-fonts = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ptex-fonts-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-ptex-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ptex-fonts}"
SRC_URI[aarch64_texlive-ptex-fonts.sha256sum] = "b094842581b6135a63a9ff556cec00f3ac3daf4eb478712e029f47c36c25779b"

URI_aarch64_texlive-revtex4 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-revtex4-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-revtex4;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-revtex4}"
SRC_URI[aarch64_texlive-revtex4.sha256sum] = "f211fdb5560f090a6ce4c7d3f105b7c3ea0f13f175a2d9c2c3b2a51644b3499e"

URI_aarch64_texlive-selinput = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-selinput-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-selinput;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-selinput}"
SRC_URI[aarch64_texlive-selinput.sha256sum] = "d5e4e96b67cf0fdaa13c2aeb103df4e55d91d60471a7de0eb3f4e7b69caa32a2"

URI_aarch64_texlive-sidecap = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-sidecap-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-sidecap;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sidecap}"
SRC_URI[aarch64_texlive-sidecap.sha256sum] = "b6fec8689345a4a586e22e5bb5bec8c432812c1063e1d58861260c4276a7944c"

URI_aarch64_texlive-siunitx = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-siunitx-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-siunitx;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-siunitx}"
SRC_URI[aarch64_texlive-siunitx.sha256sum] = "fe7e4c1edd72afd5b627cd828384b2848f6c154627d1ddb4921f27defead00b2"

URI_aarch64_texlive-slantsc = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-slantsc-20240311-10.el10_1.aarch64.rpm;name=aarch64_texlive-slantsc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-slantsc}"
SRC_URI[aarch64_texlive-slantsc.sha256sum] = "96bfc495c1b6343cadbb0fc4b363d63dbdf24386d89e5e0c59e446dcea6e6665"

URI_aarch64_texlive-standalone = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-standalone-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-standalone;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-standalone}"
SRC_URI[aarch64_texlive-standalone.sha256sum] = "d013564cb39b6c0aa0d814548150fb7307e41332c21fb911038f63cc41cbfe96"

URI_aarch64_texlive-sttools = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-sttools-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-sttools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sttools}"
SRC_URI[aarch64_texlive-sttools.sha256sum] = "475102cacf48d31ea9f723a0b80a78034c47c9eb9105e929aadc8039ad0ecfd2"

URI_aarch64_texlive-supertabular = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-supertabular-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-supertabular;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-supertabular}"
SRC_URI[aarch64_texlive-supertabular.sha256sum] = "27b6458e4d3a0e3fc86a1e06c586e0a84b1b98ce701e0695452f8ae6fabb2362"

URI_aarch64_texlive-tcolorbox = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-tcolorbox-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-tcolorbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tcolorbox}"
SRC_URI[aarch64_texlive-tcolorbox.sha256sum] = "905237479691cb3dace12d2197ed51f9c981bafca869dc33972734cc615f546d"

URI_aarch64_texlive-tie = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-tie-20240311-10.el10_1.aarch64.rpm;name=aarch64_texlive-tie;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tie}"
SRC_URI[aarch64_texlive-tie.sha256sum] = "a61c049c49091ac92ff7b2150b72e8add82cfc17c869bfa9f685be0d7c64db44"

URI_aarch64_texlive-tikzfill = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-tikzfill-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-tikzfill;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tikzfill}"
SRC_URI[aarch64_texlive-tikzfill.sha256sum] = "4c7b80f9ef8fe839e5ff927f497a4c8a46f6c9b8a42c3f334dee74eb6742092f"

URI_aarch64_texlive-ttfutils = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ttfutils-20240311-10.el10_1.aarch64.rpm;name=aarch64_texlive-ttfutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ttfutils}"
SRC_URI[aarch64_texlive-ttfutils.sha256sum] = "63529d50097c43085a9ea053d0b5bec7b314da8525a591b4905684e08b59dddb"

URI_aarch64_texlive-units = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-units-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-units;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-units}"
SRC_URI[aarch64_texlive-units.sha256sum] = "50f1ff1345b5bc7edef4e26ed980bd2117b8889610b95cbfa512738a3ae3aa1b"

URI_aarch64_texlive-uplatex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uplatex-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-uplatex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uplatex}"
SRC_URI[aarch64_texlive-uplatex.sha256sum] = "98bcf32f67cabff44acf5503d2a0ea17709b2b41dc8a8f0659226bc1fcd743a3"

URI_aarch64_texlive-uptex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uptex-20240311-10.el10_1.aarch64.rpm;name=aarch64_texlive-uptex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uptex}"
SRC_URI[aarch64_texlive-uptex.sha256sum] = "db87fb7fb91b08e7ada1f54f22c2229c7f723889df1be7b0bf6406ce9ea25c07"

URI_aarch64_texlive-uptex-base = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uptex-base-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-uptex-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uptex-base}"
SRC_URI[aarch64_texlive-uptex-base.sha256sum] = "73af1f3c2c347fca47bdcddb08cda5601f7c6fadff2ac2bd5e1c3bba948c95f6"

URI_aarch64_texlive-uptex-fonts = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uptex-fonts-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-uptex-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uptex-fonts}"
SRC_URI[aarch64_texlive-uptex-fonts.sha256sum] = "0e8ed8ae4cc4f64c082f9069a9537f60f1d9b534a8562e1e3fcdaf97007cdc83"

URI_aarch64_texlive-web = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-web-20240311-10.el10_1.aarch64.rpm;name=aarch64_texlive-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-web}"
SRC_URI[aarch64_texlive-web.sha256sum] = "516ace599d1b7d96f5d1e20b3afa906282a1daef2686750e0a6a2832da4d2867"

URI_aarch64_texlive-xcjk2uni = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xcjk2uni-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-xcjk2uni;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xcjk2uni}"
SRC_URI[aarch64_texlive-xcjk2uni.sha256sum] = "af61f21ca955c4d97e502d0efdf3e519ebbc564fa232c12ab3448fa1719258d2"

URI_aarch64_texlive-xecjk = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xecjk-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-xecjk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xecjk}"
SRC_URI[aarch64_texlive-xecjk.sha256sum] = "b1442239ab051a26540039272020d510d41c3c56f2262025ccdefeba3d40ce32"

URI_aarch64_texlive-xltabular = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xltabular-20240311-10.el10_1.aarch64.rpm;name=aarch64_texlive-xltabular;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xltabular}"
SRC_URI[aarch64_texlive-xltabular.sha256sum] = "c981897906bceb4c2f028ad4c06bc0d569b77556ca72970ba9536fd2b0c38abe"

URI_aarch64_texlive-xpinyin = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xpinyin-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-xpinyin;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xpinyin}"
SRC_URI[aarch64_texlive-xpinyin.sha256sum] = "4d8b7c44e03cf424da6ec484bc8e1fa60fc980b38ebbf7ba63bdc264faf28539"

URI_aarch64_texlive-zhmetrics = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-zhmetrics-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-zhmetrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zhmetrics}"
SRC_URI[aarch64_texlive-zhmetrics.sha256sum] = "71c1b86ddb56b410474bb4d1d5fa741ebb822156b26bd687d7351e40a088ebae"

URI_aarch64_texlive-zhmetrics-uptex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-zhmetrics-uptex-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-zhmetrics-uptex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zhmetrics-uptex}"
SRC_URI[aarch64_texlive-zhmetrics-uptex.sha256sum] = "744d728131eec30ac421795799546a258353db99888b2ab957007b4df099113f"

URI_aarch64_texlive-zhnumber = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-zhnumber-20240311-10.el10_1.noarch.rpm;name=aarch64_texlive-zhnumber;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zhnumber}"
SRC_URI[aarch64_texlive-zhnumber.sha256sum] = "c8e4a1fd0836e1dd4f3a43996d8558fb31ddca36bc3295004e2c7151d9999c2f"

RDEPENDS:texlive-adobemapping = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ascmac = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-atenddvi = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-auto-pst-pdf = " \
 texlive-base \
 texlive-ifplatform \
 texlive-iftex \
 texlive-kpathsea \
 texlive-xkeyval \
 "
RDEPENDS:texlive-babel-french = " \
 texlive-base \
 texlive-carlisle \
 texlive-graphics \
 texlive-kpathsea \
 texlive-luatexbase \
 "
RDEPENDS:texlive-babel-german = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-bibunits = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-boondox = " \
 texlive-base \
 texlive-kpathsea \
 texlive-xkeyval \
 "
RDEPENDS:texlive-chemformula = " \
 texlive-amsmath \
 texlive-base \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-pgf \
 texlive-units \
 texlive-xfrac \
 "
RDEPENDS:texlive-chemgreek = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "
RDEPENDS:texlive-chktex = " \
 bash \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-cjk = " \
 texlive-arphic \
 texlive-base \
 texlive-cns \
 texlive-garuda-c90 \
 texlive-graphics \
 texlive-iftex \
 texlive-kpathsea \
 texlive-norasi-c90 \
 texlive-uhc \
 texlive-ulem \
 texlive-wadalab \
 virtual/tex_fontenc.sty_ \
 virtual/tex_inputenc.sty_ \
 "
RDEPENDS:texlive-cjkpunct = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-convbkmk = " \
 ruby \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-ctex = " \
 texlive-adobemapping \
 texlive-atbegshi \
 texlive-base \
 texlive-beamer \
 texlive-cjk \
 texlive-cjkpunct \
 texlive-count1to \
 texlive-ctex \
 texlive-ec \
 texlive-epstopdf-pkg \
 texlive-etoolbox \
 texlive-everyhook \
 texlive-everysel \
 texlive-fancyhdr \
 texlive-fandol \
 texlive-fontspec \
 texlive-hyperref \
 texlive-iftex \
 texlive-infwarerr \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-kvsetkeys \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex \
 texlive-ltxcmds \
 texlive-luatexja \
 texlive-mptopdf \
 texlive-multitoc \
 texlive-pdftexcmds \
 texlive-platex-tools \
 texlive-svn-prov \
 texlive-tipa \
 texlive-tools \
 texlive-ttfutils \
 texlive-ulem \
 texlive-uplatex \
 texlive-xcjk2uni \
 texlive-xecjk \
 texlive-xetex \
 texlive-xkeyval \
 texlive-xpinyin \
 texlive-xunicode \
 texlive-zhmetrics \
 texlive-zhmetrics-uptex \
 texlive-zhnumber \
 virtual/tex_fix-cm.sty_ \
 "
RDEPENDS:texlive-ctie = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-cweb = " \
 glibc \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-Pod-Usage \
 perl-libs \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-lib \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-ellipse = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-emulateapj = " \
 texlive-amsfonts \
 texlive-base \
 texlive-epsf \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tools \
 virtual/tex_latexsym.sty_ \
 "
RDEPENDS:texlive-everyhook = " \
 texlive-base \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-svn-prov \
 "
RDEPENDS:texlive-fandol = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-filemod = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pdftexcmds \
 "
RDEPENDS:texlive-fltpoint = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fontaxes = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-german = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-germbib = " \
 texlive-base \
 texlive-german \
 texlive-kpathsea \
 "
RDEPENDS:texlive-gincltex = " \
 texlive-adjustbox \
 texlive-base \
 texlive-kpathsea \
 texlive-svn-prov \
 "
RDEPENDS:texlive-glossaries-english = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-glossaries-french = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-glossaries-german = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hyphen-german = " \
 bash \
 texlive-base \
 texlive-dehyph \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-kpathsea \
 virtual/coreutils \
 "
RDEPENDS:texlive-ieeetran = " \
 texlive-base \
 texlive-kpathsea \
 texlive-newtx \
 "
RDEPENDS:texlive-ipaex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-japanese-otf = " \
 texlive-base \
 texlive-japanese-otf \
 texlive-kpathsea \
 "
RDEPENDS:texlive-kantlipsum = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "
RDEPENDS:texlive-lacheck = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-latex-base-dev = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-latex-firstaid-dev = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-lipsum = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-listingsutf8 = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ltablex = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-luatexja = " \
 texlive-ascmac \
 texlive-atbegshi \
 texlive-base \
 texlive-everyhook \
 texlive-everysel \
 texlive-filehook \
 texlive-fontspec \
 texlive-footmisc \
 texlive-iftex \
 texlive-infwarerr \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-listings \
 texlive-ltxcmds \
 texlive-luaotfload \
 texlive-luatexbase \
 texlive-luatexja \
 texlive-pdftexcmds \
 texlive-sttools \
 texlive-unicode-math \
 texlive-xkeyval \
 texlive-xunicode \
 "
RDEPENDS:texlive-mdframed = " \
 texlive-amsmath \
 texlive-base \
 texlive-bera \
 texlive-booktabs \
 texlive-csquotes \
 texlive-enumitem \
 texlive-eso-pic \
 texlive-etoolbox \
 texlive-fontspec \
 texlive-geometry \
 texlive-graphics \
 texlive-hypdoc \
 texlive-iftex \
 texlive-kantlipsum \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-lipsum \
 texlive-listings \
 texlive-microtype \
 texlive-needspace \
 texlive-ntheorem \
 texlive-pgf \
 texlive-selinput \
 texlive-tools \
 texlive-xcolor \
 texlive-zref \
 virtual/tex_fontenc.sty_ \
 "
RDEPENDS:texlive-media9 = " \
 texlive-atbegshi \
 texlive-atenddvi \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-ocgx2 \
 texlive-pdftexcmds \
 texlive-pgf \
 "
RDEPENDS:texlive-mhchem = " \
 texlive-amsmath \
 texlive-babel \
 texlive-base \
 texlive-chemgreek \
 texlive-graphics \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-oberdiek \
 texlive-pgf \
 texlive-tools \
 virtual/tex_ifthen.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-newtx = " \
 texlive-amsmath \
 texlive-base \
 texlive-boondox \
 texlive-fontaxes \
 texlive-iftex \
 texlive-kastrup \
 texlive-kpathsea \
 texlive-xkeyval \
 virtual/tex_fontenc.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-nomencl = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ntheorem = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-ocgx2 = " \
 texlive-atenddvi \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-l3packages \
 texlive-media9 \
 texlive-pgf \
 "
RDEPENDS:texlive-opensans = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-slantsc \
 "
RDEPENDS:texlive-pgfplots = " \
 bash \
 texlive-base \
 texlive-graphics \
 texlive-hyperref \
 texlive-kpathsea \
 texlive-listings \
 texlive-luatex \
 texlive-luatexbase \
 texlive-pgf \
 texlive-tools \
 "
RDEPENDS:texlive-picinpar = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pict2e = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-picture = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-platex = " \
 texlive-atbegshi \
 texlive-atveryend \
 texlive-babel \
 texlive-base \
 texlive-cm \
 texlive-everyshi \
 texlive-firstaid \
 texlive-hyphen-base \
 texlive-kpathsea \
 texlive-l3backend \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex-base-dev \
 texlive-latex-firstaid-dev \
 texlive-latex-fonts \
 texlive-ptex \
 texlive-ptex-fonts \
 texlive-tex-ini-files \
 texlive-unicode-data \
 virtual/texlive-latex \
 "
RDEPENDS:texlive-platex-tools = " \
 texlive-base \
 texlive-kpathsea \
 texlive-platex \
 "
RDEPENDS:texlive-ps2eps = " \
 glibc \
 perl-Getopt-Long \
 perl-POSIX \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-ptex = " \
 cairo \
 glibc \
 gmp \
 libpng \
 mpfr \
 pixman \
 texlive-adobemapping \
 texlive-base \
 texlive-cm \
 texlive-etex \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-ipaex \
 texlive-japanese-otf \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-plain \
 texlive-ptex-base \
 texlive-ptex-fonts \
 texlive-tex \
 virtual/coreutils \
 virtual/tex_oldlfont.sty_ \
 virtual/tex_shortvrb.sty_ \
 virtual/texlive-latex \
 zlib-ng-compat \
 "
RDEPENDS:texlive-ptex-base = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ptex-fonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-revtex4 = " \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-base \
 texlive-kpathsea \
 texlive-natbib \
 texlive-url \
 "
RDEPENDS:texlive-selinput = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-sidecap = " \
 texlive-base \
 texlive-kpathsea \
 texlive-ragged2e \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-siunitx = " \
 texlive-amsmath \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-tools \
 texlive-translator \
 "
RDEPENDS:texlive-slantsc = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-standalone = " \
 texlive-adjustbox \
 texlive-base \
 texlive-currfile \
 texlive-filemod \
 texlive-gincltex \
 texlive-iftex \
 texlive-kpathsea \
 texlive-multido \
 texlive-pgf \
 texlive-pstricks \
 texlive-varwidth \
 texlive-xkeyval \
 "
RDEPENDS:texlive-sttools = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-supertabular = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-tcolorbox = " \
 texlive-base \
 texlive-environ \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-listingsutf8 \
 texlive-pdfcol \
 texlive-pgf \
 texlive-tikzfill \
 texlive-tools \
 "
RDEPENDS:texlive-tie = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-tikzfill = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ttfutils = " \
 freetype \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-units = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-uplatex = " \
 texlive-atbegshi \
 texlive-atveryend \
 texlive-babel \
 texlive-base \
 texlive-cm \
 texlive-everyshi \
 texlive-firstaid \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-kpathsea \
 texlive-l3backend \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex-base-dev \
 texlive-latex-firstaid-dev \
 texlive-latex-fonts \
 texlive-platex \
 texlive-tex-ini-files \
 texlive-unicode-data \
 texlive-uptex \
 texlive-uptex-fonts \
 virtual/texlive-latex \
 "
RDEPENDS:texlive-uptex = " \
 cairo \
 glibc \
 gmp \
 libicu \
 libpng \
 mpfr \
 pixman \
 texlive-base \
 texlive-convbkmk \
 texlive-etex \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-ipaex \
 texlive-japanese-otf \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-plain \
 texlive-ptex-base \
 texlive-uptex-base \
 texlive-uptex-fonts \
 zlib-ng-compat \
 "
RDEPENDS:texlive-uptex-base = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-uptex-fonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-web = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-xcjk2uni = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 "
RDEPENDS:texlive-xecjk = " \
 texlive-base \
 texlive-cjk \
 texlive-environ \
 texlive-fontspec \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-listings \
 texlive-tools \
 texlive-ulem \
 texlive-xunicode \
 "
RDEPENDS:texlive-xltabular = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xpinyin = " \
 texlive-base \
 texlive-cjk \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-xcjk2uni \
 texlive-xecjk \
 "
RDEPENDS:texlive-zhmetrics = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-zhmetrics-uptex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-zhnumber = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/tex_alltt.sty_ rpm/virtual/tex_article.cls_ rpm/virtual/tex_doc.sty_ rpm/virtual/tex_exscale.sty_ rpm/virtual/tex_fix-cm.sty_ rpm/virtual/tex_fixltx2e.sty_ rpm/virtual/tex_flafter.sty_ rpm/virtual/tex_fontenc.sty_ rpm/virtual/tex_ifthen.sty_ rpm/virtual/tex_inputenc.sty_ rpm/virtual/tex_latexsym.sty_ rpm/virtual/tex_makeidx.sty_ rpm/virtual/tex_oldlfont.sty_ rpm/virtual/tex_shortvrb.sty_ rpm/virtual/tex_t1cmr.fd_ rpm/virtual/tex_textcomp.sty_"

PROVIDES:append:aarch64 = " rpm/virtual/tex_alltt.sty_ rpm/virtual/tex_article.cls_ rpm/virtual/tex_doc.sty_ rpm/virtual/tex_exscale.sty_ rpm/virtual/tex_fix-cm.sty_ rpm/virtual/tex_fixltx2e.sty_ rpm/virtual/tex_flafter.sty_ rpm/virtual/tex_fontenc.sty_ rpm/virtual/tex_ifthen.sty_ rpm/virtual/tex_inputenc.sty_ rpm/virtual/tex_latexsym.sty_ rpm/virtual/tex_makeidx.sty_ rpm/virtual/tex_oldlfont.sty_ rpm/virtual/tex_shortvrb.sty_ rpm/virtual/tex_t1cmr.fd_ rpm/virtual/tex_textcomp.sty_"
