# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scrypt"
PV = "0.12.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-scrypt+alloc-devel \
 rust-scrypt+default-devel \
 rust-scrypt+getrandom-devel \
 rust-scrypt+kdf-devel \
 rust-scrypt+mcf-devel \
 rust-scrypt+parallel-devel \
 rust-scrypt+password-hash-devel \
 rust-scrypt+phc-devel \
 rust-scrypt+rand_core-devel \
 rust-scrypt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scrypt-0.12.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09be0043d2f2c7e823bf37991c5c89fe190487aee8196b7e047089dcf63ad882"

URI_x86_64_v2_rust-scrypt+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt+alloc-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt+alloc-devel}"
SRC_URI[x86_64_v2_rust-scrypt+alloc-devel.sha256sum] = "4055d3e0bd3559da7b4e957f7b868fa4ffd27cb9af49edd8534504010e0d06ef"

URI_x86_64_v2_rust-scrypt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt+default-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt+default-devel}"
SRC_URI[x86_64_v2_rust-scrypt+default-devel.sha256sum] = "dfdba9da9ae75a825236b4c0a80654b5cadede2e5c43c2c5ad66a1227544030a"

URI_x86_64_v2_rust-scrypt+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt+getrandom-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt+getrandom-devel}"
SRC_URI[x86_64_v2_rust-scrypt+getrandom-devel.sha256sum] = "e3c382ca44644fbd48a62c0f7be652621780bf04b3e2771499ed6c8c1c4e1711"

URI_x86_64_v2_rust-scrypt+kdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt+kdf-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt+kdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt+kdf-devel}"
SRC_URI[x86_64_v2_rust-scrypt+kdf-devel.sha256sum] = "5580c4ce183ea7cf9402878bece5c89bf135cdd5a8f095bb8f9b731b1e582036"

URI_x86_64_v2_rust-scrypt+mcf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt+mcf-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt+mcf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt+mcf-devel}"
SRC_URI[x86_64_v2_rust-scrypt+mcf-devel.sha256sum] = "86b5f6b263eca56f0ecc888ee29078e97d13d84e9e50078721c3489f08de236b"

URI_x86_64_v2_rust-scrypt+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt+parallel-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt+parallel-devel}"
SRC_URI[x86_64_v2_rust-scrypt+parallel-devel.sha256sum] = "d065f3e263113962ec79eb17ce87bee6c1baa3c1909836b9be5540fb4f7ec0f8"

URI_x86_64_v2_rust-scrypt+password-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt+password-hash-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt+password-hash-devel}"
SRC_URI[x86_64_v2_rust-scrypt+password-hash-devel.sha256sum] = "ba20128f9fd20c700c60200b739ab86b5d9802de614b86905891f441ae4f3ad1"

URI_x86_64_v2_rust-scrypt+phc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt+phc-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt+phc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt+phc-devel}"
SRC_URI[x86_64_v2_rust-scrypt+phc-devel.sha256sum] = "c100bd8622a632f2be0290cf55ac3652eecc973b097cd86643aecd5571e859cf"

URI_x86_64_v2_rust-scrypt+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt+rand_core-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt+rand_core-devel}"
SRC_URI[x86_64_v2_rust-scrypt+rand_core-devel.sha256sum] = "b4391b94e7f821d483c5758c423693bc0427ec726b4f2b1b8bd33fc60c9933a8"

URI_x86_64_v2_rust-scrypt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt-devel}"
SRC_URI[x86_64_v2_rust-scrypt-devel.sha256sum] = "ffe2795b102c61ce1d9bead276a9431fa635d83054ae1064e4f30065568d0ace"

URI_aarch64_rust-scrypt+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt+alloc-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt+alloc-devel}"
SRC_URI[aarch64_rust-scrypt+alloc-devel.sha256sum] = "264697d5e92c7ddf852568e8600a9b774ba09b73d5a64c3fc8a42c6dc1a753b1"

URI_aarch64_rust-scrypt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt+default-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt+default-devel}"
SRC_URI[aarch64_rust-scrypt+default-devel.sha256sum] = "c1149c400ba6577ec2d5d279a7938deab645044b01cab3219aa1c0cfc4f1c15d"

URI_aarch64_rust-scrypt+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt+getrandom-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt+getrandom-devel}"
SRC_URI[aarch64_rust-scrypt+getrandom-devel.sha256sum] = "9c4b9a7196cbbcee55991487f6a296bcb6c03217b97adc0583b55b7b6c67de8f"

URI_aarch64_rust-scrypt+kdf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt+kdf-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt+kdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt+kdf-devel}"
SRC_URI[aarch64_rust-scrypt+kdf-devel.sha256sum] = "513d4f369c49f6aff3e330ac65f85cd7f470c256cd6c6fe69b7427a88b3f6dd8"

URI_aarch64_rust-scrypt+mcf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt+mcf-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt+mcf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt+mcf-devel}"
SRC_URI[aarch64_rust-scrypt+mcf-devel.sha256sum] = "6b274a994aa38a221a7ceccea6a383e9b93baf8708419021c0bae18f47a8b05d"

URI_aarch64_rust-scrypt+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt+parallel-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt+parallel-devel}"
SRC_URI[aarch64_rust-scrypt+parallel-devel.sha256sum] = "2db28cb3e3091c48fec0eec79e9231fb9d9a928b9c0479d750f9db9a1b4d3a22"

URI_aarch64_rust-scrypt+password-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt+password-hash-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt+password-hash-devel}"
SRC_URI[aarch64_rust-scrypt+password-hash-devel.sha256sum] = "1e2335a480f164517d743b4b49cb25e0f7a11d5dcc5fd0e9a7a1c8fb186ca0e5"

URI_aarch64_rust-scrypt+phc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt+phc-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt+phc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt+phc-devel}"
SRC_URI[aarch64_rust-scrypt+phc-devel.sha256sum] = "befca613d1aad3719bc6742c39831f92da3d42c685a843032ded15ccaa9b99bc"

URI_aarch64_rust-scrypt+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt+rand_core-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt+rand_core-devel}"
SRC_URI[aarch64_rust-scrypt+rand_core-devel.sha256sum] = "65df070874357d1ebc3b27b930004f583f8a95e23e28fcb7c32b455f7500b205"

URI_aarch64_rust-scrypt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt-devel}"
SRC_URI[aarch64_rust-scrypt-devel.sha256sum] = "12bd93484cf0b5d32b5a62444e24066d29b29e17b4d99e18b40022dc0eb9f38c"

RDEPENDS:rust-scrypt+alloc-devel = " \
 cargo \
 rust-password-hash+alloc-devel \
 rust-password-hash-devel \
 rust-scrypt-devel \
 "
RDEPENDS:rust-scrypt+default-devel = " \
 cargo \
 rust-scrypt-devel \
 "
RDEPENDS:rust-scrypt+getrandom-devel = " \
 cargo \
 rust-password-hash+getrandom-devel \
 rust-password-hash-devel \
 rust-scrypt+password-hash-devel \
 rust-scrypt-devel \
 "
RDEPENDS:rust-scrypt+kdf-devel = " \
 cargo \
 rust-kdf+default-devel \
 rust-scrypt+alloc-devel \
 rust-scrypt-devel \
 "
RDEPENDS:rust-scrypt+mcf-devel = " \
 cargo \
 rust-ctutils+default-devel \
 rust-mcf+default-devel \
 rust-scrypt+alloc-devel \
 rust-scrypt+phc-devel \
 rust-scrypt-devel \
 "
RDEPENDS:rust-scrypt+parallel-devel = " \
 cargo \
 rust-rayon+default-devel \
 rust-scrypt-devel \
 "
RDEPENDS:rust-scrypt+password-hash-devel = " \
 cargo \
 rust-password-hash-devel \
 rust-scrypt-devel \
 "
RDEPENDS:rust-scrypt+phc-devel = " \
 cargo \
 rust-password-hash+phc-devel \
 rust-password-hash-devel \
 rust-scrypt-devel \
 "
RDEPENDS:rust-scrypt+rand_core-devel = " \
 cargo \
 rust-password-hash+rand_core-devel \
 rust-password-hash-devel \
 rust-scrypt-devel \
 "
RDEPENDS:rust-scrypt-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-pbkdf2+default-devel \
 rust-salsa20-devel \
 rust-sha2-devel \
 "
