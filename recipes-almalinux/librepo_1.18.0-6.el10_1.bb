# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librepo"
PV = "1.18.0"
PR = "6.el10_1"
PACKAGES = " \
 librepo \
 librepo-devel \
 python3-librepo \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/librepo-1.18.0-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa9936b8e2fc0b7c61dbf6388a1c053c3a62f8e32920b1f33dc4fc28c8669d95"

URI_x86_64_v2_librepo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/librepo-1.18.0-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_librepo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librepo}"
SRC_URI[x86_64_v2_librepo.sha256sum] = "7a4da9b0a83ee756955f0b6768486e1dd883a4d2682293c8546d7a09dba21d31"

URI_x86_64_v2_librepo-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/librepo-devel-1.18.0-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_librepo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librepo-devel}"
SRC_URI[x86_64_v2_librepo-devel.sha256sum] = "d5323b69b9be2adc1048c7c6cc06d9e7c0fc898e9d02bff7b389016c8358415e"

URI_x86_64_v2_python3-librepo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-librepo-1.18.0-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-librepo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-librepo}"
SRC_URI[x86_64_v2_python3-librepo.sha256sum] = "4218d72443cfd11d9b9871aed38e23e8929ac6da8f81eaffed233f9395b93a8f"

URI_aarch64_librepo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/librepo-1.18.0-6.el10_1.aarch64.rpm;name=aarch64_librepo;unpack=0"
SRC_URI:append = " ${URI_aarch64_librepo}"
SRC_URI[aarch64_librepo.sha256sum] = "f85ac1e05d9236dde51de850f08613b7cdcc7c1210f13e560b3a703ca66f8cd0"

URI_aarch64_librepo-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/librepo-devel-1.18.0-6.el10_1.aarch64.rpm;name=aarch64_librepo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librepo-devel}"
SRC_URI[aarch64_librepo-devel.sha256sum] = "54bbb6119e8a4ded054381d23f2bb3d383dfaa24ddae1ccc3d213c0be8beb22c"

URI_aarch64_python3-librepo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-librepo-1.18.0-6.el10_1.aarch64.rpm;name=aarch64_python3-librepo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-librepo}"
SRC_URI[aarch64_python3-librepo.sha256sum] = "d512069e2e0adc93317130132bb8188930be28b4efed10cbfec4eac66cc6f0e2"

RDEPENDS:librepo:x86_64_v2 = " \
 glib2 \
 glibc \
 libgcc \
 libxml2 \
 openssl-libs \
 rpm-libs \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__ge_7.52.0 \
"
RDEPENDS:librepo:aarch64 = " \
 glib2 \
 glibc \
 libgcc \
 libxml2 \
 openssl-libs \
 rpm-libs \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__ge_7.52.0 \
"
RDEPENDS:librepo-devel = " \
 glib2-devel \
 libcurl-devel \
 librepo \
 libxml2-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-librepo = " \
 glib2 \
 glibc \
 libgcc \
 librepo \
 python3 \
 python3-libs \
 "
