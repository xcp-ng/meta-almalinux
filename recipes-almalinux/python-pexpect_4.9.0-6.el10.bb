# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pexpect"
PV = "4.9.0"
PR = "6.el10"
PACKAGES = " \
 python3-pexpect \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-pexpect-4.9.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40d0c74ad89a73350303486b498523dcb9e8700e5bc9cb546dca02accaa3be50"

URI_x86_64_v2_python3-pexpect = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-pexpect-4.9.0-6.el10.noarch.rpm;name=x86_64_v2_python3-pexpect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pexpect}"
SRC_URI[x86_64_v2_python3-pexpect.sha256sum] = "b43581504f359e89eabce8d8b54f7f4e63ea9299500d839e5d38839d3150dc86"

URI_aarch64_python3-pexpect = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-pexpect-4.9.0-6.el10.noarch.rpm;name=aarch64_python3-pexpect;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pexpect}"
SRC_URI[aarch64_python3-pexpect.sha256sum] = "b43581504f359e89eabce8d8b54f7f4e63ea9299500d839e5d38839d3150dc86"

RDEPENDS:python3-pexpect = " \
 python3 \
 python3-ptyprocess \
 "
