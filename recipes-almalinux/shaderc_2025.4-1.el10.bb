# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shaderc"
PV = "2025.4"
PR = "1.el10"
PACKAGES = " \
 glslc \
 libshaderc \
 libshaderc-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/shaderc-2025.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d4ae2768ec6bb40d766bb376c0f0f6ec122b7b8f56648ef709c28c4ea6775f1"

URI_x86_64_v2_glslc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glslc-2025.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_glslc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glslc}"
SRC_URI[x86_64_v2_glslc.sha256sum] = "72b8dcdbf0a5dcebfc7558a3b8cdbcb92763cef4c0c452caf78fe8db0fdb9ddb"

URI_x86_64_v2_libshaderc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libshaderc-2025.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_libshaderc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libshaderc}"
SRC_URI[x86_64_v2_libshaderc.sha256sum] = "23e954e02d29e14840b832520eca1f2dd4e42a66ce9a17a9ddebf950f5ef7624"

URI_x86_64_v2_libshaderc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libshaderc-devel-2025.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_libshaderc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libshaderc-devel}"
SRC_URI[x86_64_v2_libshaderc-devel.sha256sum] = "3167608a04a2d52b56959bd61068ca1fb3a21c9396d3780c7f766a12b0a44444"

URI_aarch64_glslc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glslc-2025.4-1.el10.aarch64.rpm;name=aarch64_glslc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glslc}"
SRC_URI[aarch64_glslc.sha256sum] = "b18a1143e9e0e62a2218068da9576d1fc470b4b67852c1be8d20ff2f32eb59a4"

URI_aarch64_libshaderc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libshaderc-2025.4-1.el10.aarch64.rpm;name=aarch64_libshaderc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libshaderc}"
SRC_URI[aarch64_libshaderc.sha256sum] = "24cbc5c4d69867320f2223176f2607731c7ba33a82b37b2b9131dbb2ecfdf272"

URI_aarch64_libshaderc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libshaderc-devel-2025.4-1.el10.aarch64.rpm;name=aarch64_libshaderc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libshaderc-devel}"
SRC_URI[aarch64_libshaderc-devel.sha256sum] = "b3d550bf67957058830ba5e3c5b5cd9cf51e602e89f3420142acec95fb3b422d"

RDEPENDS:glslc = " \
 glibc \
 libgcc \
 libstdc++ \
 spirv-tools-libs \
 "
RDEPENDS:libshaderc = " \
 glibc \
 libgcc \
 libstdc++ \
 spirv-tools-libs \
 "
RDEPENDS:libshaderc-devel = " \
 libshaderc \
 pkgconf-pkg-config \
 "
