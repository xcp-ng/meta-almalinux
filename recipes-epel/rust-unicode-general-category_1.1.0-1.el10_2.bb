# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-general-category"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-unicode-general-category+default-devel \
 rust-unicode-general-category-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-general-category-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1b5e32e55310f6324da393f8aba874fab043852d69959d7fef91dc02ffb8460"

URI_x86_64_v2_rust-unicode-general-category+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-general-category+default-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-general-category+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-general-category+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-general-category+default-devel.sha256sum] = "45f5138630552361386d1f3cc804b1f28c502dc09afc0ef0eb5051de05c54808"

URI_x86_64_v2_rust-unicode-general-category-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-general-category-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-general-category-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-general-category-devel}"
SRC_URI[x86_64_v2_rust-unicode-general-category-devel.sha256sum] = "c56b78ce23765d382e3dcc6b58061c86c3b1f90b4d7b61b673fb0e5e8030b679"

URI_aarch64_rust-unicode-general-category+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-general-category+default-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-unicode-general-category+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-general-category+default-devel}"
SRC_URI[aarch64_rust-unicode-general-category+default-devel.sha256sum] = "74603cc3e01182aad02605a70493af4d19d1e06301c557406d882a996858489c"

URI_aarch64_rust-unicode-general-category-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-general-category-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-unicode-general-category-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-general-category-devel}"
SRC_URI[aarch64_rust-unicode-general-category-devel.sha256sum] = "888974963305e99f63b07d6f26887b102552d32a298d7e3287fb6fd8f6be3040"

RDEPENDS:rust-unicode-general-category+default-devel = " \
 cargo \
 rust-unicode-general-category-devel \
 "
RDEPENDS:rust-unicode-general-category-devel = " \
 cargo \
 "
