# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libssh2-sys"
PV = "0.3.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-libssh2-sys+default-devel \
 rust-libssh2-sys-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libssh2-sys-0.3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "210eaaf8ef816348e7faa0e7b63302514169bff07bfed6697be65d2b1a5537fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libssh2-sys+default-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libssh2-sys+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libssh2-sys+default-devel.sha256sum] = "ebfd0182aae26542c0b226e90cb21963e2aebfa5f4e49f93ce121157eb668bd8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libssh2-sys-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libssh2-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libssh2-sys-devel.sha256sum] = "fffb6ce6870fbd8299615a042f786c21b462187f6fe70a67cc176ba3dac8777a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libssh2-sys+default-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-libssh2-sys+default-devel;unpack=0"
SRC_URI[aarch64_rust-libssh2-sys+default-devel.sha256sum] = "3e1cb2918d43188be7e9d344158282a5ebdf0a442e3ff09361ae22ba1fa443e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libssh2-sys-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-libssh2-sys-devel;unpack=0"
SRC_URI[aarch64_rust-libssh2-sys-devel.sha256sum] = "c1fc009daefdc2338ba059c85a60dff17ac5c717aa551d975c1c56747f6fd20e"

RDEPENDS:rust-libssh2-sys+default-devel = " \
 cargo \
 rust-libssh2-sys-devel \
 "
RDEPENDS:rust-libssh2-sys-devel = " \
 cargo \
 libssh2-devel \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-openssl-sys+default-devel \
 rust-pkg-config+default-devel \
 "
