# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-Cover"
PV = "1.44"
PR = "5.el10_0"
PACKAGES = " \
 perl-Devel-Cover \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-Cover-1.44-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9880029793ffdab6f648e4facea9ab35c72aec6aa371fa07d465276d3e4e97d6"

URI_x86_64_v2_perl-Devel-Cover = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-Cover-1.44-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Devel-Cover;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-Cover}"
SRC_URI[x86_64_v2_perl-Devel-Cover.sha256sum] = "9edc511c735613b512b1da31a3857dea7ae085bb74b34c6f0a2072f851e87a24"

URI_aarch64_perl-Devel-Cover = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-Cover-1.44-5.el10_0.aarch64.rpm;name=aarch64_perl-Devel-Cover;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-Cover}"
SRC_URI[aarch64_perl-Devel-Cover.sha256sum] = "a121423f70e9346caadc28a782e745e8984df048f9e123a13d83babece37de5d"

RDEPENDS:perl-Devel-Cover = " \
 glibc \
 perl-B \
 perl-CPAN-DistnameInfo \
 perl-CPAN-Meta \
 perl-Carp \
 perl-Class-XSAccessor \
 perl-Data-Dumper \
 perl-Devel-Cover \
 perl-Digest-MD5 \
 perl-DynaLoader \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-HTML-Parser \
 perl-JSON \
 perl-JSON-MaybeXS \
 perl-Moo \
 perl-POSIX \
 perl-Parallel-Iterator \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Sereal-Decoder \
 perl-Sereal-Encoder \
 perl-Storable \
 perl-Template-Toolkit \
 perl-Test-Simple \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-namespace-clean \
 "
