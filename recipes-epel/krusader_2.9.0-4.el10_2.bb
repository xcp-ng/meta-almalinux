# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krusader"
PV = "2.9.0"
PR = "4.el10_2"
PACKAGES = " \
 krusader \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krusader-2.9.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab63769e876b3840415e1a219b43397b033e8437ed8382cccb2e228bf06fb064"

URI_x86_64_v2_krusader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krusader-2.9.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krusader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krusader}"
SRC_URI[x86_64_v2_krusader.sha256sum] = "985a9625c49d00ba20b459012b8f90bcbabfc57b2a3405483420bf376b2737ca"

URI_aarch64_krusader = "${EPEL_MIRROR}/aarch64/Packages/k/krusader-2.9.0-4.el10_2.aarch64.rpm;name=aarch64_krusader;unpack=0"
SRC_URI:append = " ${URI_aarch64_krusader}"
SRC_URI[aarch64_krusader.sha256sum] = "92dde3c7641f177615851465b41283f84d067ea8a87ef0f2c5bd67c83d16c2d3"

RDEPENDS:krusader:x86_64_v2 = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 libacl \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 zlib-ng-compat \
"
RDEPENDS:krusader:aarch64 = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 libacl \
 libgcc \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 zlib-ng-compat \
"
