# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtk4"
PV = "4.16.7"
PR = "1.el10"
PACKAGES = " \
 gtk4 \
 gtk4-devel \
 gtk4-devel-docs \
 gtk4-devel-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gtk4-4.16.7-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5199b0c168cb06530556acbff9527c6e9f761e9b1ffc6adabcbaa5c8f6ef30f8"

URI_x86_64_v2_gtk4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk4-4.16.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk4}"
SRC_URI[x86_64_v2_gtk4.sha256sum] = "0fa32ee940c95ae9aae0a8168d37a52a8c3a463278a32270cf1893eb53967a59"

URI_x86_64_v2_gtk4-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk4-devel-4.16.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk4-devel}"
SRC_URI[x86_64_v2_gtk4-devel.sha256sum] = "573a7116d67890d90ad3af5405a33ec83d3209df21a01a6438d828ef522b5eec"

URI_x86_64_v2_gtk4-devel-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gtk4-devel-docs-4.16.7-1.el10.noarch.rpm;name=x86_64_v2_gtk4-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk4-devel-docs}"
SRC_URI[x86_64_v2_gtk4-devel-docs.sha256sum] = "44ed3f9320d4556b9752534a1c605995f97b4813d05ee782733d65bdd41e567c"

URI_x86_64_v2_gtk4-devel-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gtk4-devel-tools-4.16.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_gtk4-devel-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk4-devel-tools}"
SRC_URI[x86_64_v2_gtk4-devel-tools.sha256sum] = "19226a8554b0f42ce517319bb3fd47afa11a5d478264a3cb49f3ad57087a9bda"

URI_aarch64_gtk4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk4-4.16.7-1.el10.aarch64.rpm;name=aarch64_gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk4}"
SRC_URI[aarch64_gtk4.sha256sum] = "7b5c007d306ba0e832f717eb02c10b411fd488a8b786226f34964060c6894056"

URI_aarch64_gtk4-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk4-devel-4.16.7-1.el10.aarch64.rpm;name=aarch64_gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk4-devel}"
SRC_URI[aarch64_gtk4-devel.sha256sum] = "45a4b8d84c21b89eead2b05649f68acce153c80cf9293403ab9e286dbf5dc8d5"

URI_aarch64_gtk4-devel-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gtk4-devel-docs-4.16.7-1.el10.noarch.rpm;name=aarch64_gtk4-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk4-devel-docs}"
SRC_URI[aarch64_gtk4-devel-docs.sha256sum] = "44ed3f9320d4556b9752534a1c605995f97b4813d05ee782733d65bdd41e567c"

URI_aarch64_gtk4-devel-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gtk4-devel-tools-4.16.7-1.el10.aarch64.rpm;name=aarch64_gtk4-devel-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk4-devel-tools}"
SRC_URI[aarch64_gtk4-devel-tools.sha256sum] = "97aeb3795d943637cd63ef846ad0f6ddf21979d42b8db9c43a8b7e1c50831d19"

RDEPENDS:gtk4 = " \
 adwaita-icon-theme \
 cairo \
 cairo-gobject \
 colord-libs \
 cups-libs \
 fontconfig \
 fribidi \
 gdk-pixbuf2 \
 gdk-pixbuf2-modules \
 glib2 \
 glibc \
 graphene \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk-update-icon-cache \
 harfbuzz \
 hicolor-icon-theme \
 libX11 \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libepoxy \
 libjpeg-turbo \
 libpng \
 libtiff \
 libtracker-sparql \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxkbcommon \
 pango \
 vulkan-loader \
 "
RDEPENDS:gtk4-devel = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 cairo-gobject-devel \
 fontconfig \
 fribidi \
 gdk-pixbuf2 \
 gdk-pixbuf2-devel \
 glib2 \
 glib2-devel \
 glibc \
 graphene \
 graphene-devel \
 gtk4 \
 gtk4-devel \
 harfbuzz \
 libX11 \
 libX11-devel \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libepoxy \
 libjpeg-turbo \
 libpng \
 libtiff \
 libtracker-sparql \
 libwayland-client \
 libwayland-egl \
 libxkbcommon \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 vulkan-loader \
 vulkan-loader-devel \
 wayland-devel \
 "
RDEPENDS:gtk4-devel-docs = " \
 gtk4 \
 "
RDEPENDS:gtk4-devel-tools = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 harfbuzz \
 libepoxy \
 pango \
 "
