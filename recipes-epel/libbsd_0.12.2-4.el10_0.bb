# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libbsd"
PV = "0.12.2"
PR = "4.el10_0"
PACKAGES = " \
 libbsd \
 libbsd-ctor-static \
 libbsd-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libbsd-0.12.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f8efe2c6e0271ff734e7444d4f80acd999b3ed0d2c408fca15870e906204676c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbsd-0.12.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbsd;unpack=0"
SRC_URI[x86_64_v2_libbsd.sha256sum] = "37114b48cf77053bed118e45814b6b7ac9c930d6be7e7e2c47145df7ef283883"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbsd-ctor-static-0.12.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbsd-ctor-static;unpack=0"
SRC_URI[x86_64_v2_libbsd-ctor-static.sha256sum] = "2c4f577fe8a942f3846e894f81c0f71d933dc966c778c637ffb10e87c12da2a4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbsd-devel-0.12.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbsd-devel;unpack=0"
SRC_URI[x86_64_v2_libbsd-devel.sha256sum] = "c5d373f00a9117b25b2576ff584ffc0437f198c3bb8abc37b44096a8ec81a363"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libbsd-0.12.2-4.el10_0.aarch64.rpm;name=aarch64_libbsd;unpack=0"
SRC_URI[aarch64_libbsd.sha256sum] = "5c83367c81a9bd1968cdd68dca839a393dc597c32fb3ee4f8397f6fddbbac292"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libbsd-ctor-static-0.12.2-4.el10_0.aarch64.rpm;name=aarch64_libbsd-ctor-static;unpack=0"
SRC_URI[aarch64_libbsd-ctor-static.sha256sum] = "761ceb8ed9e9e0f7bae68db678c6774277deb6f930447787ba32fdb40c705a63"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libbsd-devel-0.12.2-4.el10_0.aarch64.rpm;name=aarch64_libbsd-devel;unpack=0"
SRC_URI[aarch64_libbsd-devel.sha256sum] = "18c68af7baa6d1634181c6c530733f12a7fdc9fed5d66fbf7d7d177e540778fd"

RDEPENDS:libbsd = " \
 glibc \
 libmd \
 "
RDEPENDS:libbsd-ctor-static = " \
 libbsd \
 libbsd-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libbsd-devel = " \
 libbsd \
 libmd-devel \
 pkgconf-pkg-config \
 "
