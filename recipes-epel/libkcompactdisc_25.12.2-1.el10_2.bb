# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkcompactdisc"
PV = "25.12.2"
PR = "1.el10_2"
PACKAGES = " \
 libkcompactdisc \
 libkcompactdisc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkcompactdisc-25.12.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d89ead7ddc69966f75e265d6b0ab15d9d70d14b90f28d20c8e27117ea92d33d8"

URI_x86_64_v2_libkcompactdisc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcompactdisc-25.12.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcompactdisc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcompactdisc}"
SRC_URI[x86_64_v2_libkcompactdisc.sha256sum] = "7149354d1b19fbc7a560d5d395c22788f876fac677acf7427ccc2228d50c265d"

URI_x86_64_v2_libkcompactdisc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcompactdisc-devel-25.12.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcompactdisc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcompactdisc-devel}"
SRC_URI[x86_64_v2_libkcompactdisc-devel.sha256sum] = "1e19213d03366ae699ed73318ed39f6f60395e732b05dc29fbfd3360c8e32ba7"

URI_aarch64_libkcompactdisc = "${EPEL_MIRROR}/aarch64/Packages/l/libkcompactdisc-25.12.2-1.el10_2.aarch64.rpm;name=aarch64_libkcompactdisc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcompactdisc}"
SRC_URI[aarch64_libkcompactdisc.sha256sum] = "a4c8751dfe49112f4ab85f06b0e76f14ad75b2cc8ddb3f533f654030d3f80ded"

URI_aarch64_libkcompactdisc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkcompactdisc-devel-25.12.2-1.el10_2.aarch64.rpm;name=aarch64_libkcompactdisc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcompactdisc-devel}"
SRC_URI[aarch64_libkcompactdisc-devel.sha256sum] = "fb540aea42a1141bb1fc9470bacb78b0f667dacdc7fe6a561ad16e3afd8387cf"

RDEPENDS:libkcompactdisc = " \
 alsa-lib \
 glibc \
 kf6-ki18n \
 kf6-solid \
 libstdc++ \
 phonon-qt6 \
 qt6-qtbase \
 "
RDEPENDS:libkcompactdisc-devel = " \
 cmake-filesystem \
 libkcompactdisc \
 "
