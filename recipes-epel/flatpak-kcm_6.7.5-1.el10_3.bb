# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak-kcm"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 flatpak-kcm \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/flatpak-kcm-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "88ad86bacd018796d2c5a310bdc702d302ed03a5c7c7d4de79e43e0be02308c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flatpak-kcm-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flatpak-kcm;unpack=0"
SRC_URI[x86_64_v2_flatpak-kcm.sha256sum] = "dbc25b3aebd6b2abb4040c0a4e545feab876e271c9acfc296dfe3880b233e9ee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/flatpak-kcm-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_flatpak-kcm;unpack=0"
SRC_URI[aarch64_flatpak-kcm.sha256sum] = "efc0c28b96defceba3709fd3ff6583691183dc15abf6f28e194ff1f3dbbf0979"

RDEPENDS:flatpak-kcm = " \
 flatpak-libs \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
