# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-machines"
PV = "354"
PR = "1.el10"
PACKAGES = " \
 cockpit-machines \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-machines-354-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "494d174420c882a65f3ed1ed9871151f2cfb1a49192e994b79b77dc6895ab6ec"

URI_x86_64_v2_cockpit-machines = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-machines-354-1.el10.noarch.rpm;name=x86_64_v2_cockpit-machines;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-machines}"
SRC_URI[x86_64_v2_cockpit-machines.sha256sum] = "abbfc80891a184440547cecd2585211fe236fbb76ea000f30aa027a311f5e601"

URI_aarch64_cockpit-machines = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-machines-354-1.el10.noarch.rpm;name=aarch64_cockpit-machines;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-machines}"
SRC_URI[aarch64_cockpit-machines.sha256sum] = "abbfc80891a184440547cecd2585211fe236fbb76ea000f30aa027a311f5e601"

RDEPENDS:cockpit-machines = " \
 cockpit-bridge \
 libvirt-client \
 libvirt-daemon-config-network \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-storage-core \
 libvirt-dbus \
 qemu-kvm \
 virt-install \
 "
