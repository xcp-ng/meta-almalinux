# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf"
PV = "4.20.0"
PR = "14.el10_0.alma.1"
PACKAGES = " \
 dnf \
 dnf-automatic \
 dnf-bootc \
 dnf-data \
 python3-dnf \
 yum \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dnf-4.20.0-14.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b57f5a0d900de3b81f9aa038e0bcf0567c794c7168a6d1a8f5d99e3079a8eb97"

URI_x86_64_v2_dnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-4.20.0-14.el10_0.alma.1.noarch.rpm;name=x86_64_v2_dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf}"
SRC_URI[x86_64_v2_dnf.sha256sum] = "441c575feef3a6a26fb7b294248efaa03c98293fb066f0d47be05eacb582fa84"

URI_x86_64_v2_dnf-automatic = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-automatic-4.20.0-14.el10_0.alma.1.noarch.rpm;name=x86_64_v2_dnf-automatic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-automatic}"
SRC_URI[x86_64_v2_dnf-automatic.sha256sum] = "d24c0bc6d8abd364904a74b45de95a8d55f120e02c1da7579c88157a3503fa86"

URI_x86_64_v2_dnf-bootc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnf-bootc-4.20.0-14.el10_0.alma.1.noarch.rpm;name=x86_64_v2_dnf-bootc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-bootc}"
SRC_URI[x86_64_v2_dnf-bootc.sha256sum] = "6741e74408702ae89ba4332781b631422b2857654c7737114afc5e0f0b191f4b"

URI_x86_64_v2_dnf-data = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-data-4.20.0-14.el10_0.alma.1.noarch.rpm;name=x86_64_v2_dnf-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-data}"
SRC_URI[x86_64_v2_dnf-data.sha256sum] = "ead127c692f2d1fa2ceec591783e1c9b55e789bca637ceea83685bdfea4646fd"

URI_x86_64_v2_python3-dnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-4.20.0-14.el10_0.alma.1.noarch.rpm;name=x86_64_v2_python3-dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf}"
SRC_URI[x86_64_v2_python3-dnf.sha256sum] = "b176a04a3112cef26ddd9e9e8696218e289f8349ebfc8cd8d46aeaf62ef3f649"

URI_x86_64_v2_yum = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/yum-4.20.0-14.el10_0.alma.1.noarch.rpm;name=x86_64_v2_yum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yum}"
SRC_URI[x86_64_v2_yum.sha256sum] = "b294e9dc801aeb27c54f8d3a822a5c463d9ead50701ef524a27bd6ad3be4796b"

URI_aarch64_dnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-4.20.0-14.el10_0.alma.1.noarch.rpm;name=aarch64_dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf}"
SRC_URI[aarch64_dnf.sha256sum] = "441c575feef3a6a26fb7b294248efaa03c98293fb066f0d47be05eacb582fa84"

URI_aarch64_dnf-automatic = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-automatic-4.20.0-14.el10_0.alma.1.noarch.rpm;name=aarch64_dnf-automatic;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-automatic}"
SRC_URI[aarch64_dnf-automatic.sha256sum] = "d24c0bc6d8abd364904a74b45de95a8d55f120e02c1da7579c88157a3503fa86"

URI_aarch64_dnf-bootc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnf-bootc-4.20.0-14.el10_0.alma.1.noarch.rpm;name=aarch64_dnf-bootc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-bootc}"
SRC_URI[aarch64_dnf-bootc.sha256sum] = "6741e74408702ae89ba4332781b631422b2857654c7737114afc5e0f0b191f4b"

URI_aarch64_dnf-data = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-data-4.20.0-14.el10_0.alma.1.noarch.rpm;name=aarch64_dnf-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-data}"
SRC_URI[aarch64_dnf-data.sha256sum] = "ead127c692f2d1fa2ceec591783e1c9b55e789bca637ceea83685bdfea4646fd"

URI_aarch64_python3-dnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-4.20.0-14.el10_0.alma.1.noarch.rpm;name=aarch64_python3-dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf}"
SRC_URI[aarch64_python3-dnf.sha256sum] = "b176a04a3112cef26ddd9e9e8696218e289f8349ebfc8cd8d46aeaf62ef3f649"

URI_aarch64_yum = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/yum-4.20.0-14.el10_0.alma.1.noarch.rpm;name=aarch64_yum;unpack=0"
SRC_URI:append = " ${URI_aarch64_yum}"
SRC_URI[aarch64_yum.sha256sum] = "b294e9dc801aeb27c54f8d3a822a5c463d9ead50701ef524a27bd6ad3be4796b"

RDEPENDS:dnf = " \
 bash \
 python3-dnf \
 virtual/coreutils \
 "
RDEPENDS:dnf-automatic = " \
 bash \
 python3 \
 python3-dnf \
 systemd \
 "
RDEPENDS:dnf-bootc = " \
 ostree \
 ostree-libs \
 python3-dnf \
 python3-gobject-base \
 util-linux-core \
 "
RDEPENDS:dnf-data = " \
 "
RDEPENDS:python3-dnf = " \
 dnf-data \
 libmodulemd \
 python3 \
 python3-hawkey \
 python3-libcomps \
 python3-libdnf \
 python3-rpm \
 "
RDEPENDS:yum = " \
 dnf \
 "
