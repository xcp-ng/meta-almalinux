# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clircle"
PV = "0.6.1"
PR = "3.el10_3"
PACKAGES = " \
 rust-clircle+default-devel \
 rust-clircle+serde-devel \
 rust-clircle+test-close-again-devel \
 rust-clircle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clircle-0.6.1-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e08af3263620c2a2c935bd568ce90e2c740710eeaeaa8e76941bd5de33df3e68"

URI_x86_64_v2_rust-clircle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clircle+default-devel-0.6.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clircle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clircle+default-devel}"
SRC_URI[x86_64_v2_rust-clircle+default-devel.sha256sum] = "f2248febfe61687da868068c6370772cc163af58f74e42b0e79eed5a52cfc2fa"

URI_x86_64_v2_rust-clircle+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clircle+serde-devel-0.6.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clircle+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clircle+serde-devel}"
SRC_URI[x86_64_v2_rust-clircle+serde-devel.sha256sum] = "caa6fa69075e31a243df3f69ffa95b9e84065755c4244913bdc4e9d459701936"

URI_x86_64_v2_rust-clircle+test-close-again-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clircle+test-close-again-devel-0.6.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clircle+test-close-again-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clircle+test-close-again-devel}"
SRC_URI[x86_64_v2_rust-clircle+test-close-again-devel.sha256sum] = "bec37c44f27422366970f72b5aded9c14c05f18beb92a6167d4a74d2a0a92d3b"

URI_x86_64_v2_rust-clircle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clircle-devel-0.6.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clircle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clircle-devel}"
SRC_URI[x86_64_v2_rust-clircle-devel.sha256sum] = "04dd022aa27053831262a3a9799128bfb9338748771b5cdb5db049fff525f6d5"

URI_aarch64_rust-clircle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clircle+default-devel-0.6.1-3.el10_3.noarch.rpm;name=aarch64_rust-clircle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clircle+default-devel}"
SRC_URI[aarch64_rust-clircle+default-devel.sha256sum] = "495022ed329c04df6fd79a5986f59d24ffceec06f22a192f97d19b43e2c19a71"

URI_aarch64_rust-clircle+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clircle+serde-devel-0.6.1-3.el10_3.noarch.rpm;name=aarch64_rust-clircle+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clircle+serde-devel}"
SRC_URI[aarch64_rust-clircle+serde-devel.sha256sum] = "dff3a415723d3a9d37081a8b98c525fe99577b6c881fe76a5dfb88d7b45d2508"

URI_aarch64_rust-clircle+test-close-again-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clircle+test-close-again-devel-0.6.1-3.el10_3.noarch.rpm;name=aarch64_rust-clircle+test-close-again-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clircle+test-close-again-devel}"
SRC_URI[aarch64_rust-clircle+test-close-again-devel.sha256sum] = "b4087e154c2c0de4c8135bd5c4918489cd4fcc0686214181e622ced1f8a2c3f4"

URI_aarch64_rust-clircle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clircle-devel-0.6.1-3.el10_3.noarch.rpm;name=aarch64_rust-clircle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clircle-devel}"
SRC_URI[aarch64_rust-clircle-devel.sha256sum] = "37dcfce88c47dfb0a8f835736ef6b1193f7a9079dc2fc5fabab7477cfbb108ee"

RDEPENDS:rust-clircle+default-devel = " \
 cargo \
 rust-clircle+serde-devel \
 rust-clircle-devel \
 "
RDEPENDS:rust-clircle+serde-devel = " \
 cargo \
 rust-clircle-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-clircle+test-close-again-devel = " \
 cargo \
 rust-clircle-devel \
 "
RDEPENDS:rust-clircle-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "
