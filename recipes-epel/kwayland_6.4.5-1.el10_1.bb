# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwayland"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 kwayland \
 kwayland-devel \
 kwayland-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwayland-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9394adba5f8d026fc9653ea0dfccbc6a9ba5c88d598e9c1f324ed00f3ad47103"

URI_x86_64_v2_kwayland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwayland}"
SRC_URI[x86_64_v2_kwayland.sha256sum] = "c6c0a052a0bf6841bb7f6633c599a358c2a5c833310e0360a9b0989bdda2297d"

URI_x86_64_v2_kwayland-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-devel-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwayland-devel}"
SRC_URI[x86_64_v2_kwayland-devel.sha256sum] = "3ba699080f666a090e5cf0da649ab21765eb04533874f9933912e7bc929ffa88"

URI_x86_64_v2_kwayland-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-doc-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kwayland-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwayland-doc}"
SRC_URI[x86_64_v2_kwayland-doc.sha256sum] = "2b2d1025891fc8fac3dad1307a644822e500ff625edb806164b7426ef3d0ae86"

URI_aarch64_kwayland = "${EPEL_MIRROR}/aarch64/Packages/k/kwayland-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_kwayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwayland}"
SRC_URI[aarch64_kwayland.sha256sum] = "15aa95ac8c8da9c4b55308aa76956a8f3e7348752a5969fdd27161e7ffa996f6"

URI_aarch64_kwayland-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kwayland-devel-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_kwayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwayland-devel}"
SRC_URI[aarch64_kwayland-devel.sha256sum] = "b4c2d865a37286e86bf733cf41e5f6c47d767393bcedc876c40b71f2997638ca"

URI_aarch64_kwayland-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kwayland-doc-6.4.5-1.el10_1.noarch.rpm;name=aarch64_kwayland-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwayland-doc}"
SRC_URI[aarch64_kwayland-doc.sha256sum] = "75b59d4f3aeddc6d31a19c2a0698af91290cc9da863c47defe496b2d55a7a7d4"

RDEPENDS:kwayland = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwayland \
 "
RDEPENDS:kwayland-devel = " \
 cmake-filesystem \
 kwayland \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kwayland-doc = " \
 "
