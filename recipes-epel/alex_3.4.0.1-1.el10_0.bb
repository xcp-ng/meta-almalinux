# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alex"
PV = "3.4.0.1"
PR = "1.el10_0"
PACKAGES = " \
 alex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/alex-3.4.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "292e5c902fbd371e0b47c883872ef62cfca3d88289964f18b334932a40e495af"

URI_x86_64_v2_alex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alex-3.4.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alex}"
SRC_URI[x86_64_v2_alex.sha256sum] = "4325c9ecbc0a634ab6e19d30963c40c02caa8ce3e90d3cf0a6825d4cb73854e7"

URI_aarch64_alex = "${EPEL_MIRROR}/aarch64/Packages/a/alex-3.4.0.1-1.el10_0.aarch64.rpm;name=aarch64_alex;unpack=0"
SRC_URI:append = " ${URI_aarch64_alex}"
SRC_URI[aarch64_alex.sha256sum] = "f4c168be12619c4d4712a21eb49e359dac3bfaa7c8f23cac561fdd414825a28f"

RDEPENDS:alex = " \
 glibc \
 gmp \
 libffi \
 "
