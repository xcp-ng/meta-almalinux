# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalgebra"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kalgebra \
 kalgebra-plasma-applet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kalgebra-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c5a95990e2b176223c13c523a9b09f5452acfee67a17a0960de835c5d0cdbd6"

URI_x86_64_v2_kalgebra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalgebra-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalgebra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalgebra}"
SRC_URI[x86_64_v2_kalgebra.sha256sum] = "5856e4363d4615beebb55fd5115cc5732e56141cd2fbd30731dfbe7f0496b95e"

URI_x86_64_v2_kalgebra-plasma-applet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalgebra-plasma-applet-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalgebra-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalgebra-plasma-applet}"
SRC_URI[x86_64_v2_kalgebra-plasma-applet.sha256sum] = "dda28f8cf2305efd25ff6b70c428254d02a4a8665627f364abb762837958d5db"

URI_aarch64_kalgebra = "${EPEL_MIRROR}/aarch64/Packages/k/kalgebra-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kalgebra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalgebra}"
SRC_URI[aarch64_kalgebra.sha256sum] = "4a413cb19a496ea8f0c3eb5e47f71f67391917653c8dec3ba719be2540f374e4"

URI_aarch64_kalgebra-plasma-applet = "${EPEL_MIRROR}/aarch64/Packages/k/kalgebra-plasma-applet-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kalgebra-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalgebra-plasma-applet}"
SRC_URI[aarch64_kalgebra-plasma-applet.sha256sum] = "764065da1aacb30061a6da67cbe83a0d5b8282e431ae1c4b5135d3a2191f8109"

RDEPENDS:kalgebra = " \
 analitza \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 readline \
 "
RDEPENDS:kalgebra-plasma-applet = " \
 kalgebra \
 libplasma \
 "
