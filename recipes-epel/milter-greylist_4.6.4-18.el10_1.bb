# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "milter-greylist"
PV = "4.6.4"
PR = "18.el10_1"
PACKAGES = " \
 milter-greylist \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/milter-greylist-4.6.4-18.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e3b9b6ab76fa5a4fdfb19ffce47183905b6473f5e37facbb29662a2b0a84dcf"

URI_x86_64_v2_milter-greylist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/milter-greylist-4.6.4-18.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_milter-greylist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_milter-greylist}"
SRC_URI[x86_64_v2_milter-greylist.sha256sum] = "5f24bee8048adf7b522371f86db3b2c630ff71f522c400d665c4ea275402535e"

URI_aarch64_milter-greylist = "${EPEL_MIRROR}/aarch64/Packages/m/milter-greylist-4.6.4-18.el10_1.aarch64.rpm;name=aarch64_milter-greylist;unpack=0"
SRC_URI:append = " ${URI_aarch64_milter-greylist}"
SRC_URI[aarch64_milter-greylist.sha256sum] = "5979098912a261813aad9611f4662a7443482b402cb112b9c896e0352072af55"

RDEPENDS:milter-greylist = " \
 bash \
 glibc \
 libmaxminddb \
 libspf2 \
 sendmail-milter \
 shadow-utils \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
