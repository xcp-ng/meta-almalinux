# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-lossy"
PV = "1.1.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-anstyle-lossy+default-devel \
 rust-anstyle-lossy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-lossy-1.1.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "731eccdf6a10bd774283a7f173978160d2f433a85e778b77aabd1f3a086d5167"

URI_x86_64_v2_rust-anstyle-lossy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-lossy+default-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-lossy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-lossy+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-lossy+default-devel.sha256sum] = "083f08585e841dfe96c421c0e412b93c2219ae39d184fc299bb8a337893d10b4"

URI_x86_64_v2_rust-anstyle-lossy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-lossy-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-lossy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-lossy-devel}"
SRC_URI[x86_64_v2_rust-anstyle-lossy-devel.sha256sum] = "0d27a414d69d64b5c6cbd1b7a5770ee79b343ae0fbf3fa827a352764ba11e7ed"

URI_aarch64_rust-anstyle-lossy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-lossy+default-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle-lossy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-lossy+default-devel}"
SRC_URI[aarch64_rust-anstyle-lossy+default-devel.sha256sum] = "79c5b85370466e0dd2d1e12719330ab235c4fb23250a2753c4d464d9e9d1f570"

URI_aarch64_rust-anstyle-lossy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-lossy-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle-lossy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-lossy-devel}"
SRC_URI[aarch64_rust-anstyle-lossy-devel.sha256sum] = "efb7f697e87c386bc3a9b8d94842b200675c06af80fa1a54975834fb56c954d6"

RDEPENDS:rust-anstyle-lossy+default-devel = " \
 cargo \
 rust-anstyle-lossy-devel \
 "
RDEPENDS:rust-anstyle-lossy-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 "
