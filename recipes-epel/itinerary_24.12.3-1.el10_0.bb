# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "itinerary"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 itinerary \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/itinerary-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "294d2a15fc8d6d8c9a5837221bb8ecbf77761c354af14e7665c8f4d3ff1a8401"

URI_x86_64_v2_itinerary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/itinerary-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_itinerary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_itinerary}"
SRC_URI[x86_64_v2_itinerary.sha256sum] = "f272227645b4374b1c7e5ab0eb142b1ed392c135b9ec669509b9d33fe9c7af9b"

URI_aarch64_itinerary = "${EPEL_MIRROR}/aarch64/Packages/i/itinerary-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_itinerary;unpack=0"
SRC_URI:append = " ${URI_aarch64_itinerary}"
SRC_URI[aarch64_itinerary.sha256sum] = "67abd381ad1dd6727caaff87acd2d32331fe8ea8c14daf71f7eb62ed28a9f7f8"

RDEPENDS:itinerary = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kunitconversion \
 kf6-kwindowsystem \
 kf6-networkmanager-qt \
 kf6-prison \
 khealthcertificate \
 kitinerary \
 kosmindoormap \
 kpkpass \
 kpublictransport \
 libquotient-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qtkeychain-qt6 \
 zlib-ng-compat \
 "
