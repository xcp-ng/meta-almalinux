# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-nm"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-nm \
 plasma-nm-l2tp \
 plasma-nm-openconnect \
 plasma-nm-openswan \
 plasma-nm-openvpn \
 plasma-nm-pptp \
 plasma-nm-strongswan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-nm-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75d914055cc09c53b89e1a22a47175b880cf59b9b7fcbc40f83205c80b2a2181"

URI_x86_64_v2_plasma-nm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm}"
SRC_URI[x86_64_v2_plasma-nm.sha256sum] = "25b42f9bcc59bb0ecf6e36573a33bb01d2e9de9905f978f742a69e16cd07cff9"

URI_x86_64_v2_plasma-nm-l2tp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-l2tp-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-l2tp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-l2tp}"
SRC_URI[x86_64_v2_plasma-nm-l2tp.sha256sum] = "f79d691311c49d8fdefc6665780825823d894a648303cbd69a74dc572bebb098"

URI_x86_64_v2_plasma-nm-openconnect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openconnect-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openconnect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-openconnect}"
SRC_URI[x86_64_v2_plasma-nm-openconnect.sha256sum] = "8c90eca9ed56e8877745d9bda6e9a2ac2d8d21ae2e2563ec458ad60046c50e22"

URI_x86_64_v2_plasma-nm-openswan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openswan-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-openswan}"
SRC_URI[x86_64_v2_plasma-nm-openswan.sha256sum] = "625b472dd7116de1621f0c6bc2770accbcb62f0cc0c694024f7eec93948293d8"

URI_x86_64_v2_plasma-nm-openvpn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openvpn-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openvpn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-openvpn}"
SRC_URI[x86_64_v2_plasma-nm-openvpn.sha256sum] = "549c844644690a789c82cd14c638ba79f5fb883e7991f1c42715738e39e53b7b"

URI_x86_64_v2_plasma-nm-pptp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-pptp-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-pptp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-pptp}"
SRC_URI[x86_64_v2_plasma-nm-pptp.sha256sum] = "8ed855fb19a5ccd26af8f109abfb45b485a511c7a3ea58d43a86c9c466630821"

URI_x86_64_v2_plasma-nm-strongswan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-strongswan-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-strongswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-strongswan}"
SRC_URI[x86_64_v2_plasma-nm-strongswan.sha256sum] = "23e7eef72a9ef1ad09341ffc93fefe035ee6baee627602c1a2b3710c6c49dd9f"

URI_aarch64_plasma-nm = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-nm;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm}"
SRC_URI[aarch64_plasma-nm.sha256sum] = "ac50814531367a8c8991ffb8ea2f22e67028f8c4b1715b6b0cc6e2b7a6d2a9ea"

URI_aarch64_plasma-nm-l2tp = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-l2tp-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-nm-l2tp;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-l2tp}"
SRC_URI[aarch64_plasma-nm-l2tp.sha256sum] = "e697fc9a4024a3d4a3e83303cad723ab5d0f8c17dc8f82592332df9ac50209c0"

URI_aarch64_plasma-nm-openconnect = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openconnect-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-nm-openconnect;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-openconnect}"
SRC_URI[aarch64_plasma-nm-openconnect.sha256sum] = "c85635d2d511e2ede3fdd9fee613ba7c0480809c3fb69f4b67f9178d0a7a8045"

URI_aarch64_plasma-nm-openswan = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openswan-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-nm-openswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-openswan}"
SRC_URI[aarch64_plasma-nm-openswan.sha256sum] = "6dfe8531f35f493e457c003c8244773bbd2bd74e483bd96f98fb478341185118"

URI_aarch64_plasma-nm-openvpn = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openvpn-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-nm-openvpn;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-openvpn}"
SRC_URI[aarch64_plasma-nm-openvpn.sha256sum] = "9b2be70ebcf1a0a5e7b5788554105f319c02d6dbeac661d66f5ba487828ba234"

URI_aarch64_plasma-nm-pptp = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-pptp-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-nm-pptp;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-pptp}"
SRC_URI[aarch64_plasma-nm-pptp.sha256sum] = "140395b870758414a2186aeaf8f1a643d5148960a8a332ebf9306797234988a7"

URI_aarch64_plasma-nm-strongswan = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-strongswan-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-nm-strongswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-strongswan}"
SRC_URI[aarch64_plasma-nm-strongswan.sha256sum] = "84e6728c60cf205d00ee4bd02797468888a73dcda560c318ca6d7a2b7cbf6b30"

RDEPENDS:plasma-nm = " \
 NetworkManager \
 NetworkManager-libnm \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-knotifications \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-modemmanager-qt \
 kf6-networkmanager-qt \
 kf6-prison \
 kf6-solid \
 libstdc++ \
 qca-qt6 \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-nm-l2tp = " \
 NetworkManager-l2tp \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-openconnect = " \
 NetworkManager-openconnect \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 openconnect \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:plasma-nm-openswan = " \
 NetworkManager-libreswan \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-openvpn = " \
 NetworkManager-libnm \
 NetworkManager-openvpn \
 glib2 \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-pptp = " \
 NetworkManager-pptp \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-strongswan = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 strongswan \
 "
