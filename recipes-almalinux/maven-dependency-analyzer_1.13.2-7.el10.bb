# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-dependency-analyzer"
PV = "1.13.2"
PR = "7.el10"
PACKAGES = " \
 maven-dependency-analyzer \
 maven-dependency-analyzer-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/maven-dependency-analyzer-1.13.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f37960c6a0772b15b3b8e59c7a544f51c845798926aef4724ddd10b68ee48551"

URI_x86_64_v2_maven-dependency-analyzer = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-dependency-analyzer-1.13.2-7.el10.noarch.rpm;name=x86_64_v2_maven-dependency-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-dependency-analyzer}"
SRC_URI[x86_64_v2_maven-dependency-analyzer.sha256sum] = "0c0b7f751aba060a74e32a852df0a66788d5298ff4411984ed2b5736ff5a0dc8"

URI_x86_64_v2_maven-dependency-analyzer-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-dependency-analyzer-javadoc-1.13.2-7.el10.noarch.rpm;name=x86_64_v2_maven-dependency-analyzer-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-dependency-analyzer-javadoc}"
SRC_URI[x86_64_v2_maven-dependency-analyzer-javadoc.sha256sum] = "d91d776c6146cccb6bd622bf02c9ff74c23c47785b5d8250e6a138f3a3e0f4e8"

URI_aarch64_maven-dependency-analyzer = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-dependency-analyzer-1.13.2-7.el10.noarch.rpm;name=aarch64_maven-dependency-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-dependency-analyzer}"
SRC_URI[aarch64_maven-dependency-analyzer.sha256sum] = "0c0b7f751aba060a74e32a852df0a66788d5298ff4411984ed2b5736ff5a0dc8"

URI_aarch64_maven-dependency-analyzer-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-dependency-analyzer-javadoc-1.13.2-7.el10.noarch.rpm;name=aarch64_maven-dependency-analyzer-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-dependency-analyzer-javadoc}"
SRC_URI[aarch64_maven-dependency-analyzer-javadoc.sha256sum] = "d91d776c6146cccb6bd622bf02c9ff74c23c47785b5d8250e6a138f3a3e0f4e8"

RDEPENDS:maven-dependency-analyzer = " \
 apache-commons-io \
 atinject \
 javapackages-filesystem \
 maven-lib \
 objectweb-asm \
 slf4j \
 "
RDEPENDS:maven-dependency-analyzer-javadoc = " \
 javapackages-filesystem \
 "
