# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ledmon"
PV = "1.1.0"
PR = "1.el10_0.1"
PACKAGES = " \
 ledmon \
 ledmon-devel \
 ledmon-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ledmon-1.1.0-1.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fdb8f27430db9a1f405eae0d81098ecaf38c9e1f19b25b76b0e903c169fbbfc"

URI_x86_64_v2_ledmon = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ledmon-1.1.0-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_ledmon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ledmon}"
SRC_URI[x86_64_v2_ledmon.sha256sum] = "84ffba80473d64c366cb5f8b0cce8d6d49493f0e38e0b7b68c3a8bb2a53f33d3"

URI_x86_64_v2_ledmon-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ledmon-devel-1.1.0-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_ledmon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ledmon-devel}"
SRC_URI[x86_64_v2_ledmon-devel.sha256sum] = "83ea56bd2014ec6938fdf3dff77af5c26b85df8036dd704a1aefd9cc4f804c82"

URI_x86_64_v2_ledmon-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ledmon-libs-1.1.0-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_ledmon-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ledmon-libs}"
SRC_URI[x86_64_v2_ledmon-libs.sha256sum] = "9938e13c4c60e38371a0c0adf318eac3c17aed683d86dc3efc5fd08da2c2f714"

URI_aarch64_ledmon = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ledmon-1.1.0-1.el10_0.1.aarch64.rpm;name=aarch64_ledmon;unpack=0"
SRC_URI:append = " ${URI_aarch64_ledmon}"
SRC_URI[aarch64_ledmon.sha256sum] = "049b2778fdc011f479cb5767175fd4ddc28cf0737d8725531f8f453a44958812"

URI_aarch64_ledmon-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ledmon-devel-1.1.0-1.el10_0.1.aarch64.rpm;name=aarch64_ledmon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ledmon-devel}"
SRC_URI[aarch64_ledmon-devel.sha256sum] = "81a9d12bcd72e2dcdb79b3b89d6c50455ab7fe76a3a89b4d623ea2f52f00ea18"

URI_aarch64_ledmon-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ledmon-libs-1.1.0-1.el10_0.1.aarch64.rpm;name=aarch64_ledmon-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ledmon-libs}"
SRC_URI[aarch64_ledmon-libs.sha256sum] = "7fd11adf490b2d78c3e966cfa07450d44e59ba98a4ababc45982ea74f14daa39"

RDEPENDS:ledmon = " \
 bash \
 glibc \
 pciutils-libs \
 sg3_utils-libs \
 systemd-libs \
 "
RDEPENDS:ledmon-devel = " \
 ledmon-libs \
 pciutils-devel \
 pkgconf-pkg-config \
 sg3_utils-devel \
 "
RDEPENDS:ledmon-libs = " \
 glibc \
 pciutils-libs \
 sg3_utils-libs \
 "
