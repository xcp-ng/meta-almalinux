# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXNVCtrl"
PV = "565.57.01"
PR = "1.el10_0"
PACKAGES = " \
 libXNVCtrl \
 libXNVCtrl-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libXNVCtrl-565.57.01-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "34fe6f2868357b78878a4132ef74cb55223b63ffa961f5a39a9197aa279a24f8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXNVCtrl-565.57.01-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXNVCtrl;unpack=0"
SRC_URI[x86_64_v2_libXNVCtrl.sha256sum] = "3dc3cad60330e6e6864c93f5a1fe2bf81b8f8c3d2774f8fa44b059f8d9891b90"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXNVCtrl-devel-565.57.01-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXNVCtrl-devel;unpack=0"
SRC_URI[x86_64_v2_libXNVCtrl-devel.sha256sum] = "e080eed6c9196a4eddb8fae2807ae146865c05cbebdae3ebf8fa37f476809508"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libXNVCtrl-565.57.01-1.el10_0.aarch64.rpm;name=aarch64_libXNVCtrl;unpack=0"
SRC_URI[aarch64_libXNVCtrl.sha256sum] = "faa5b1415a3cdfccb0bda9379a97ffb9ad79ac4c1067e5d51cb9ab82ee49bdcb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libXNVCtrl-devel-565.57.01-1.el10_0.aarch64.rpm;name=aarch64_libXNVCtrl-devel;unpack=0"
SRC_URI[aarch64_libXNVCtrl-devel.sha256sum] = "96c253a62c94bdc6b68ffc04b6ce53c57cdc26d1dad7f5f1a81e4755153df94f"

RDEPENDS:libXNVCtrl = " \
 glibc \
 libX11 \
 libXext \
 "
RDEPENDS:libXNVCtrl-devel = " \
 libX11-devel \
 libXNVCtrl \
 "
