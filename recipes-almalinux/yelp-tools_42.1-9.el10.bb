# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yelp-tools"
PV = "42.1"
PR = "9.el10"
PACKAGES = " \
 yelp-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yelp-tools-42.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4b76fbb3212dd3f7a607b6a1348d586e577af7c2507668fc36e7863e27c1c14f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yelp-tools-42.1-9.el10.noarch.rpm;name=x86_64_v2_yelp-tools;unpack=0"
SRC_URI[x86_64_v2_yelp-tools.sha256sum] = "6f055343a7b37b3637cb12408fb5d306052fc07393cf2e589cbacc4938644b8b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yelp-tools-42.1-9.el10.noarch.rpm;name=aarch64_yelp-tools;unpack=0"
SRC_URI[aarch64_yelp-tools.sha256sum] = "6f055343a7b37b3637cb12408fb5d306052fc07393cf2e589cbacc4938644b8b"

RDEPENDS:yelp-tools = " \
 itstool \
 libxml2 \
 libxslt \
 mallard-rng \
 python3 \
 python3-lxml \
 yelp-xsl \
 "
