# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-nokogiri"
PV = "1.16.7"
PR = "1.el10_0"
PACKAGES = " \
 rubygem-nokogiri \
 rubygem-nokogiri-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rubygem-nokogiri-1.16.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e3b66a962728410157f19163e2380c8a265e4751dadd531e4132e9ac82fd5aec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-nokogiri-1.16.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rubygem-nokogiri;unpack=0"
SRC_URI[x86_64_v2_rubygem-nokogiri.sha256sum] = "8c85d783346964275b73b684cce380430cc14c0b77f152c1a7a634cf5a1e17e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-nokogiri-doc-1.16.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rubygem-nokogiri-doc;unpack=0"
SRC_URI[x86_64_v2_rubygem-nokogiri-doc.sha256sum] = "42800edcab9cc297aeb68c3802ae46f39953b6e6ec92000a54792e658568f16b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rubygem-nokogiri-1.16.7-1.el10_0.aarch64.rpm;name=aarch64_rubygem-nokogiri;unpack=0"
SRC_URI[aarch64_rubygem-nokogiri.sha256sum] = "043e16a88b22c658dda7ab667201c5508f76600ee983492d9a29008f14a5d227"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rubygem-nokogiri-doc-1.16.7-1.el10_0.aarch64.rpm;name=aarch64_rubygem-nokogiri-doc;unpack=0"
SRC_URI[aarch64_rubygem-nokogiri-doc.sha256sum] = "8f6a0b66a6d50dba1391b8bcb44fa08e2f4f96f7a32b0a16f501b22afa14b9ec"

RDEPENDS:rubygem-nokogiri = " \
 glibc \
 libxml2 \
 libxslt \
 ruby \
 ruby-libs \
 rubygem-racc \
 rubygems \
 virtual//usr/bin/env \
 "
RDEPENDS:rubygem-nokogiri-doc = " \
 rubygem-nokogiri \
 "
