# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libbpf-rs"
PV = "0.24.4"
PR = "3.el10_1"
PACKAGES = " \
 rust-libbpf-rs+default-devel \
 rust-libbpf-rs+dont-generate-test-files-devel \
 rust-libbpf-rs+generate-test-files-devel \
 rust-libbpf-rs+libbpf-sys-devel \
 rust-libbpf-rs+static-devel \
 rust-libbpf-rs+vendored-devel \
 rust-libbpf-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libbpf-rs-0.24.4-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d83ace8bf28ea363bb816953be386a6916ed5008ac884b19bc8ac513bc70f76d"

URI_x86_64_v2_rust-libbpf-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+default-devel-0.24.4-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+default-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+default-devel.sha256sum] = "fde160c4656b3184764d0d16ea4537f245e48bd1f1ea21410aaea607d69ccdfa"

URI_x86_64_v2_rust-libbpf-rs+dont-generate-test-files-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+dont-generate-test-files-devel-0.24.4-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+dont-generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+dont-generate-test-files-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+dont-generate-test-files-devel.sha256sum] = "7e8329b15882998e4f1ea4e681ea9d2b342ff1818b06b8a2996cbf3f4c062e85"

URI_x86_64_v2_rust-libbpf-rs+generate-test-files-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+generate-test-files-devel-0.24.4-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+generate-test-files-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+generate-test-files-devel.sha256sum] = "f53b20ff246df5d39b84a1c6f651023ad92a3902e52b18dbc9e0684dc0deed81"

URI_x86_64_v2_rust-libbpf-rs+libbpf-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+libbpf-sys-devel-0.24.4-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+libbpf-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+libbpf-sys-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+libbpf-sys-devel.sha256sum] = "263bd410e1ca59691aec1081111cc7aefc6368997ba325947795fdc59aaf9c2c"

URI_x86_64_v2_rust-libbpf-rs+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+static-devel-0.24.4-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+static-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+static-devel.sha256sum] = "17fea2ab59c1326a715a53cd59e72db81611ee8d7bc5e0a8f2f50fde99b169d1"

URI_x86_64_v2_rust-libbpf-rs+vendored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+vendored-devel-0.24.4-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+vendored-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+vendored-devel.sha256sum] = "5ef4827de04585db6700bfb2e1e58ccafd76ef2f34c0a04aa78f785879998350"

URI_x86_64_v2_rust-libbpf-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs-devel-0.24.4-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs-devel.sha256sum] = "9f1e9e9475dcee5387e4622caaad9593f463ff897bcff1dcc5c34f0fc51719d7"

URI_aarch64_rust-libbpf-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+default-devel-0.24.4-3.el10_1.noarch.rpm;name=aarch64_rust-libbpf-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+default-devel}"
SRC_URI[aarch64_rust-libbpf-rs+default-devel.sha256sum] = "d3e64d7c7af82a315cf018b7d61bff4ae685e3711f74161b13840058715f6af6"

URI_aarch64_rust-libbpf-rs+dont-generate-test-files-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+dont-generate-test-files-devel-0.24.4-3.el10_1.noarch.rpm;name=aarch64_rust-libbpf-rs+dont-generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+dont-generate-test-files-devel}"
SRC_URI[aarch64_rust-libbpf-rs+dont-generate-test-files-devel.sha256sum] = "e15fb50370519735f91cb08330694d7d015af07c4ce0de29ac9fa23224427952"

URI_aarch64_rust-libbpf-rs+generate-test-files-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+generate-test-files-devel-0.24.4-3.el10_1.noarch.rpm;name=aarch64_rust-libbpf-rs+generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+generate-test-files-devel}"
SRC_URI[aarch64_rust-libbpf-rs+generate-test-files-devel.sha256sum] = "994faaa373aabdc25863fd474b11a993b49bd4480ccb1b6b3daef9256a4e9dae"

URI_aarch64_rust-libbpf-rs+libbpf-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+libbpf-sys-devel-0.24.4-3.el10_1.noarch.rpm;name=aarch64_rust-libbpf-rs+libbpf-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+libbpf-sys-devel}"
SRC_URI[aarch64_rust-libbpf-rs+libbpf-sys-devel.sha256sum] = "dfcf10072483400cf86918aafa905ea2146bb0de2e0b6f43805a3a5194d3f447"

URI_aarch64_rust-libbpf-rs+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+static-devel-0.24.4-3.el10_1.noarch.rpm;name=aarch64_rust-libbpf-rs+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+static-devel}"
SRC_URI[aarch64_rust-libbpf-rs+static-devel.sha256sum] = "c25448bd4f082a004be21fb18465817e3ab3f233495b5c3a7a306b7dd33a3d32"

URI_aarch64_rust-libbpf-rs+vendored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+vendored-devel-0.24.4-3.el10_1.noarch.rpm;name=aarch64_rust-libbpf-rs+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+vendored-devel}"
SRC_URI[aarch64_rust-libbpf-rs+vendored-devel.sha256sum] = "8008d0a457f8530fcca8c601d28c9fa88d25cb75ad080599c40eab46eced9d23"

URI_aarch64_rust-libbpf-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs-devel-0.24.4-3.el10_1.noarch.rpm;name=aarch64_rust-libbpf-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs-devel}"
SRC_URI[aarch64_rust-libbpf-rs-devel.sha256sum] = "5c1312e375ab16ae1c22ac5b953c85a9b05bee38489cdfcd1ac608140e28ebff"

RDEPENDS:rust-libbpf-rs+default-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs+dont-generate-test-files-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 "
RDEPENDS:rust-libbpf-rs+generate-test-files-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys-devel \
 rust-tempfile+default-devel \
 "
RDEPENDS:rust-libbpf-rs+libbpf-sys-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs+static-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys+static-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs+vendored-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys+vendored-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-libbpf-sys-devel \
 rust-libc+default-devel \
 rust-vsprintf+default-devel \
 "
