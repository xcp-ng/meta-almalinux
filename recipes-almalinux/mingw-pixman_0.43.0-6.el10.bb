# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-pixman"
PV = "0.43.0"
PR = "6.el10"
PACKAGES:x86_64_v2 = " \
 mingw32-pixman \
 mingw64-pixman \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-pixman-0.43.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a2b0c2b43f211b3e55e2a597be6ea65b2289e8e0136a27482f92b60340a9f31"

URI_x86_64_v2_mingw32-pixman = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-pixman-0.43.0-6.el10.noarch.rpm;name=x86_64_v2_mingw32-pixman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-pixman}"
SRC_URI[x86_64_v2_mingw32-pixman.sha256sum] = "df64156812c13fbdb981bf92c9131f8d7ff9199238fb21ad02b4df4af29ad55e"

URI_x86_64_v2_mingw64-pixman = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-pixman-0.43.0-6.el10.noarch.rpm;name=x86_64_v2_mingw64-pixman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-pixman}"
SRC_URI[x86_64_v2_mingw64-pixman.sha256sum] = "95e6a65b28f505ec8c521e4d53f34a56c8bcda892d5fa542c483aae9dac90954"

RDEPENDS:mingw32-pixman = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
 "
RDEPENDS:mingw64-pixman = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-libgcc \
 "
