# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-procfs-core"
PV = "0.18.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-procfs-core+backtrace-devel \
 rust-procfs-core+chrono-devel \
 rust-procfs-core+default-devel \
 rust-procfs-core+serde-devel \
 rust-procfs-core+serde1-devel \
 rust-procfs-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-procfs-core-0.18.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12c787197af9c8d04d9b24b72539bcf34c0d61192c83bf3252256ca23aa28e39"

URI_x86_64_v2_rust-procfs-core+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs-core+backtrace-devel-0.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs-core+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs-core+backtrace-devel}"
SRC_URI[x86_64_v2_rust-procfs-core+backtrace-devel.sha256sum] = "773b509f6fdd85fa6652c0e3969fc96955bdedf9c04f0ec7c4422d2975206b07"

URI_x86_64_v2_rust-procfs-core+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs-core+chrono-devel-0.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs-core+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs-core+chrono-devel}"
SRC_URI[x86_64_v2_rust-procfs-core+chrono-devel.sha256sum] = "2fce311e7713ba64d57d4342cdcfa6561ca52940dca46891193e364bea42ffc6"

URI_x86_64_v2_rust-procfs-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs-core+default-devel-0.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs-core+default-devel}"
SRC_URI[x86_64_v2_rust-procfs-core+default-devel.sha256sum] = "f030b3cc16e69e0cd8c6a9d0f402a40d3112541f1aa0d1053f24728730f654af"

URI_x86_64_v2_rust-procfs-core+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs-core+serde-devel-0.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs-core+serde-devel}"
SRC_URI[x86_64_v2_rust-procfs-core+serde-devel.sha256sum] = "f94de9993d2bc4008c17fa393e8a9491f049da293954b8e4d80b04fc475c634b"

URI_x86_64_v2_rust-procfs-core+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs-core+serde1-devel-0.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs-core+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs-core+serde1-devel}"
SRC_URI[x86_64_v2_rust-procfs-core+serde1-devel.sha256sum] = "790debef2d2e2c03297158d1079cb4cd80d99f2f91fd9255d5eb653fa3ad2b48"

URI_x86_64_v2_rust-procfs-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs-core-devel-0.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs-core-devel}"
SRC_URI[x86_64_v2_rust-procfs-core-devel.sha256sum] = "9970920e9666a08a753df9d524d249e3d1ddd1d1c2cd6c6c79d51517891665c1"

URI_aarch64_rust-procfs-core+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs-core+backtrace-devel-0.18.0-1.el10_2.noarch.rpm;name=aarch64_rust-procfs-core+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs-core+backtrace-devel}"
SRC_URI[aarch64_rust-procfs-core+backtrace-devel.sha256sum] = "729aad664e68388fc50bf3b8ede3dd17381185857f8c0a47b6bcbf8489803d7f"

URI_aarch64_rust-procfs-core+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs-core+chrono-devel-0.18.0-1.el10_2.noarch.rpm;name=aarch64_rust-procfs-core+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs-core+chrono-devel}"
SRC_URI[aarch64_rust-procfs-core+chrono-devel.sha256sum] = "46174d8679e83d53f0db4e90fb6ea466824a12be798fd9fc9d7e1a9598ca4554"

URI_aarch64_rust-procfs-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs-core+default-devel-0.18.0-1.el10_2.noarch.rpm;name=aarch64_rust-procfs-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs-core+default-devel}"
SRC_URI[aarch64_rust-procfs-core+default-devel.sha256sum] = "8dfc772a8da8411b5d63446d255e47817ad627c3160afee8431a4edda07b573d"

URI_aarch64_rust-procfs-core+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs-core+serde-devel-0.18.0-1.el10_2.noarch.rpm;name=aarch64_rust-procfs-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs-core+serde-devel}"
SRC_URI[aarch64_rust-procfs-core+serde-devel.sha256sum] = "13a7d62f1a4f79dbceb5a5eccc7156b3e2e3d417f58a3c57492c1a22b31a220f"

URI_aarch64_rust-procfs-core+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs-core+serde1-devel-0.18.0-1.el10_2.noarch.rpm;name=aarch64_rust-procfs-core+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs-core+serde1-devel}"
SRC_URI[aarch64_rust-procfs-core+serde1-devel.sha256sum] = "1adffb953da1bb5c394a57faebd7adba01ae94e6df6f5966c17d0fe7cfb16d59"

URI_aarch64_rust-procfs-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs-core-devel-0.18.0-1.el10_2.noarch.rpm;name=aarch64_rust-procfs-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs-core-devel}"
SRC_URI[aarch64_rust-procfs-core-devel.sha256sum] = "1e8ca31ee24d3f709d8fc1430166f9629b9a29b88330af4e02e57b5201a6888d"

RDEPENDS:rust-procfs-core+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-procfs-core-devel \
 "
RDEPENDS:rust-procfs-core+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-procfs-core-devel \
 "
RDEPENDS:rust-procfs-core+default-devel = " \
 cargo \
 rust-procfs-core+chrono-devel \
 rust-procfs-core-devel \
 "
RDEPENDS:rust-procfs-core+serde-devel = " \
 cargo \
 rust-procfs-core-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-procfs-core+serde1-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-procfs-core+serde-devel \
 rust-procfs-core-devel \
 "
RDEPENDS:rust-procfs-core-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-hex+default-devel \
 "
