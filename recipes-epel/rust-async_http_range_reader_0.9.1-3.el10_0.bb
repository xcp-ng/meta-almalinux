# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async_http_range_reader"
PV = "0.9.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-async_http_range_reader+default-devel \
 rust-async_http_range_reader-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async_http_range_reader-0.9.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04776d956dbe2e3ad4606abd95881d705a970eeca6f3793884bfa4fb0a07a4dd"

URI_x86_64_v2_rust-async_http_range_reader+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_http_range_reader+default-devel-0.9.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_http_range_reader+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_http_range_reader+default-devel}"
SRC_URI[x86_64_v2_rust-async_http_range_reader+default-devel.sha256sum] = "3a09e4374722485f80a387073e75f5887d2619cd30bcd497df17f68a9fb0d2c3"

URI_x86_64_v2_rust-async_http_range_reader-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_http_range_reader-devel-0.9.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_http_range_reader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_http_range_reader-devel}"
SRC_URI[x86_64_v2_rust-async_http_range_reader-devel.sha256sum] = "82e382eee125fd2692f664eb68f17a7e507701e3bfa8eeff980dd28d5ba58af6"

URI_aarch64_rust-async_http_range_reader+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_http_range_reader+default-devel-0.9.1-3.el10_0.noarch.rpm;name=aarch64_rust-async_http_range_reader+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_http_range_reader+default-devel}"
SRC_URI[aarch64_rust-async_http_range_reader+default-devel.sha256sum] = "412202857a6ea7c722838d5c2e9669c41d7e712dbacd148f81ce92958ea2b74e"

URI_aarch64_rust-async_http_range_reader-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_http_range_reader-devel-0.9.1-3.el10_0.noarch.rpm;name=aarch64_rust-async_http_range_reader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_http_range_reader-devel}"
SRC_URI[aarch64_rust-async_http_range_reader-devel.sha256sum] = "b0ee58f440e238859318eda77117d0b75c6945169ee52a224a0e7042169cd453"

RDEPENDS:rust-async_http_range_reader+default-devel = " \
 cargo \
 rust-async_http_range_reader-devel \
 "
RDEPENDS:rust-async_http_range_reader-devel = " \
 cargo \
 rust-bisection+default-devel \
 rust-futures+default-devel \
 rust-http-content-range+default-devel \
 rust-itertools0.13+default-devel \
 rust-memmap2+default-devel \
 rust-reqwest+stream-devel \
 rust-reqwest-devel \
 rust-reqwest-middleware+default-devel \
 rust-thiserror1+default-devel \
 rust-tokio-devel \
 rust-tokio-stream+default-devel \
 rust-tokio-stream+sync-devel \
 rust-tokio-util+default-devel \
 rust-tracing+default-devel \
 "
