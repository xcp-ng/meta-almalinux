# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tower"
PV = "0.5.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-tower+__common-devel \
 rust-tower+balance-devel \
 rust-tower+buffer-devel \
 rust-tower+default-devel \
 rust-tower+discover-devel \
 rust-tower+filter-devel \
 rust-tower+full-devel \
 rust-tower+futures-core-devel \
 rust-tower+futures-util-devel \
 rust-tower+hdrhistogram-devel \
 rust-tower+hedge-devel \
 rust-tower+indexmap-devel \
 rust-tower+limit-devel \
 rust-tower+load-devel \
 rust-tower+load-shed-devel \
 rust-tower+log-devel \
 rust-tower+make-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower+ready-cache-devel \
 rust-tower+reconnect-devel \
 rust-tower+retry-devel \
 rust-tower+slab-devel \
 rust-tower+spawn-ready-devel \
 rust-tower+steer-devel \
 rust-tower+sync_wrapper-devel \
 rust-tower+timeout-devel \
 rust-tower+tokio-devel \
 rust-tower+tokio-stream-devel \
 rust-tower+tokio-util-devel \
 rust-tower+tracing-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tower-0.5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a359ce032f84cb99f47cdb1754b12e511b19e51f0cadec7bfea874a58120a273"

URI_x86_64_v2_rust-tower+__common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+__common-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+__common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+__common-devel}"
SRC_URI[x86_64_v2_rust-tower+__common-devel.sha256sum] = "b0322859227820564f0e7ffc5a5001e06f3e793aa09a43d75045317148b737ce"

URI_x86_64_v2_rust-tower+balance-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+balance-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+balance-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+balance-devel}"
SRC_URI[x86_64_v2_rust-tower+balance-devel.sha256sum] = "fb83b26eea5ddb83d8bae09bbb916c8a93bfbb5cfad47ec2c0e682b25b09ceb5"

URI_x86_64_v2_rust-tower+buffer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+buffer-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+buffer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+buffer-devel}"
SRC_URI[x86_64_v2_rust-tower+buffer-devel.sha256sum] = "e6fec7c7581dae3a5b97a2865090f95c05229cda625b5aea2ae54588963c387b"

URI_x86_64_v2_rust-tower+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+default-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+default-devel}"
SRC_URI[x86_64_v2_rust-tower+default-devel.sha256sum] = "eccf668f3f69a46e32f2ac6d980336fd6b46925dfcbb26dd92a050d2025f2b17"

URI_x86_64_v2_rust-tower+discover-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+discover-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+discover-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+discover-devel}"
SRC_URI[x86_64_v2_rust-tower+discover-devel.sha256sum] = "8aa74d896da7509d25268d8ec2292ac4517661bbd7926cd1da363646845c678c"

URI_x86_64_v2_rust-tower+filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+filter-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+filter-devel}"
SRC_URI[x86_64_v2_rust-tower+filter-devel.sha256sum] = "7770135ef1aa708a55802171482806cc555a81454386b7ff763e2b1d3566c737"

URI_x86_64_v2_rust-tower+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+full-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+full-devel}"
SRC_URI[x86_64_v2_rust-tower+full-devel.sha256sum] = "afb47e42ab93fa5a79b6f2e9cddc0870a5c11f49a64b578ed06aeec61cb03838"

URI_x86_64_v2_rust-tower+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+futures-core-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+futures-core-devel}"
SRC_URI[x86_64_v2_rust-tower+futures-core-devel.sha256sum] = "7474b7573845b537b9b837ad06f80b30dba44d069133dd785daa1651cf5a9152"

URI_x86_64_v2_rust-tower+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+futures-util-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+futures-util-devel}"
SRC_URI[x86_64_v2_rust-tower+futures-util-devel.sha256sum] = "308b2d31fb99805e5c2212c34fb87162c02b51a494fe2b841f2ce96528c47f41"

URI_x86_64_v2_rust-tower+hdrhistogram-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+hdrhistogram-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+hdrhistogram-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+hdrhistogram-devel}"
SRC_URI[x86_64_v2_rust-tower+hdrhistogram-devel.sha256sum] = "dcb50e29933cf2a14912a343bbd53c5e10f9783f7a5859328416ee5a7e420294"

URI_x86_64_v2_rust-tower+hedge-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+hedge-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+hedge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+hedge-devel}"
SRC_URI[x86_64_v2_rust-tower+hedge-devel.sha256sum] = "3ed2466d72d1b3bc6f2acaef2e2e43d9b30e1c69319893a24b2a271dc85f83f4"

URI_x86_64_v2_rust-tower+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+indexmap-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+indexmap-devel}"
SRC_URI[x86_64_v2_rust-tower+indexmap-devel.sha256sum] = "045d16e2518cfbe716327d7b4d7c890eb42a392f3cd2f60c165b972e1e4b466e"

URI_x86_64_v2_rust-tower+limit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+limit-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+limit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+limit-devel}"
SRC_URI[x86_64_v2_rust-tower+limit-devel.sha256sum] = "30f39de102dd80027e851faa26b7ee6bc67c4891bad4256758f69f520a7d613f"

URI_x86_64_v2_rust-tower+load-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+load-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+load-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+load-devel}"
SRC_URI[x86_64_v2_rust-tower+load-devel.sha256sum] = "1ff7ead05d380f140ed071a02dcf5b2158817f9d10fd54935f16e430910e5d73"

URI_x86_64_v2_rust-tower+load-shed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+load-shed-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+load-shed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+load-shed-devel}"
SRC_URI[x86_64_v2_rust-tower+load-shed-devel.sha256sum] = "9e91814116878b5b6a0e9b5d49345151db8a4572be630e8ec67096cf6e8e4509"

URI_x86_64_v2_rust-tower+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+log-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+log-devel}"
SRC_URI[x86_64_v2_rust-tower+log-devel.sha256sum] = "94fedf6e7316b2f47227bb3e5ea95d16b61bde11144a3b843c2d3213855fc07d"

URI_x86_64_v2_rust-tower+make-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+make-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+make-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+make-devel}"
SRC_URI[x86_64_v2_rust-tower+make-devel.sha256sum] = "8df21732b446ec6d3ffdb8428550d154c604d6e22fc19cef2730eb1b6796a65a"

URI_x86_64_v2_rust-tower+pin-project-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+pin-project-lite-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+pin-project-lite-devel}"
SRC_URI[x86_64_v2_rust-tower+pin-project-lite-devel.sha256sum] = "b0c866926725e4f449715c6589380abc038eaff1055bd05e33bbd91e8bb4b405"

URI_x86_64_v2_rust-tower+ready-cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+ready-cache-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+ready-cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+ready-cache-devel}"
SRC_URI[x86_64_v2_rust-tower+ready-cache-devel.sha256sum] = "aeb966562459888e24a0f732e8213fc14e2dcf3858adc29a327a3ad07af633e9"

URI_x86_64_v2_rust-tower+reconnect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+reconnect-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+reconnect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+reconnect-devel}"
SRC_URI[x86_64_v2_rust-tower+reconnect-devel.sha256sum] = "68d4d81bb9529bc207200da976bca964522e77b9a1aecc3f1bb50d5cf1b09ea5"

URI_x86_64_v2_rust-tower+retry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+retry-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+retry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+retry-devel}"
SRC_URI[x86_64_v2_rust-tower+retry-devel.sha256sum] = "6914746ae54d6e81651b0de17ac2ea06df968ca3f434fd60e629a50154c885ab"

URI_x86_64_v2_rust-tower+slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+slab-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+slab-devel}"
SRC_URI[x86_64_v2_rust-tower+slab-devel.sha256sum] = "cf46219a8812d86256d7dd64518dac82f601e6a5c0bb47b25eb4626d5ef3e3e0"

URI_x86_64_v2_rust-tower+spawn-ready-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+spawn-ready-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+spawn-ready-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+spawn-ready-devel}"
SRC_URI[x86_64_v2_rust-tower+spawn-ready-devel.sha256sum] = "49a7b9aebc83e991970f5a03b62773f07e0a9189f2137a52df7a8979f37022e3"

URI_x86_64_v2_rust-tower+steer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+steer-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+steer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+steer-devel}"
SRC_URI[x86_64_v2_rust-tower+steer-devel.sha256sum] = "75cef0fbbbcc74e116671c96366e8fc0a2aa81da436c628ecd3b7eda62d7002e"

URI_x86_64_v2_rust-tower+sync_wrapper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+sync_wrapper-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+sync_wrapper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+sync_wrapper-devel}"
SRC_URI[x86_64_v2_rust-tower+sync_wrapper-devel.sha256sum] = "52b3560640014fb88bf872be0d1e5120273a204c4b19bc725ced4da4346ccce4"

URI_x86_64_v2_rust-tower+timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+timeout-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+timeout-devel}"
SRC_URI[x86_64_v2_rust-tower+timeout-devel.sha256sum] = "d4948d22aaf891cccf8b5795737c149228e75b17780e6ecde721b57e57f8203d"

URI_x86_64_v2_rust-tower+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+tokio-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+tokio-devel}"
SRC_URI[x86_64_v2_rust-tower+tokio-devel.sha256sum] = "5d8c78f5aa81e99ba9e7771c7b3ca86c7c353ae202182934b1d22b531c00f98d"

URI_x86_64_v2_rust-tower+tokio-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+tokio-stream-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+tokio-stream-devel}"
SRC_URI[x86_64_v2_rust-tower+tokio-stream-devel.sha256sum] = "bbb3f51151caf2d942d8910681ecac3111be65d2f718cf33e33179c33d2ae994"

URI_x86_64_v2_rust-tower+tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+tokio-util-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+tokio-util-devel}"
SRC_URI[x86_64_v2_rust-tower+tokio-util-devel.sha256sum] = "fcb289e41cbd831e6d74729eb8aceef7d6ec98b35644e84d6f6ea2634a377582"

URI_x86_64_v2_rust-tower+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+tracing-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+tracing-devel}"
SRC_URI[x86_64_v2_rust-tower+tracing-devel.sha256sum] = "3c735028dfbe1889801705419eaaf9424d2ed74699ee4d219bb9bc35bb519c26"

URI_x86_64_v2_rust-tower+util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+util-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower+util-devel}"
SRC_URI[x86_64_v2_rust-tower+util-devel.sha256sum] = "cc00d9ddf488ba3c630ad8e7085b638f30d4b6ae3e0fe1600fe2554ebe26a964"

URI_x86_64_v2_rust-tower-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-devel}"
SRC_URI[x86_64_v2_rust-tower-devel.sha256sum] = "113ec39dee9d6ccc243ffd0176c6410c270bfc1e09096cd9779946aea0e9ec0c"

URI_aarch64_rust-tower+__common-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+__common-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+__common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+__common-devel}"
SRC_URI[aarch64_rust-tower+__common-devel.sha256sum] = "efd74c9ae90b65e6d1337269802ee74c2453aa172dd8ad81d534ce2ec5d6d350"

URI_aarch64_rust-tower+balance-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+balance-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+balance-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+balance-devel}"
SRC_URI[aarch64_rust-tower+balance-devel.sha256sum] = "a6eb89e20a702b0081b553244151feafbb337fce1cb2dffc31e96e611e3059f6"

URI_aarch64_rust-tower+buffer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+buffer-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+buffer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+buffer-devel}"
SRC_URI[aarch64_rust-tower+buffer-devel.sha256sum] = "f7991076c914843402eab8d64cd6cbfb326de9b1093f3aa83de5ea72845bcd91"

URI_aarch64_rust-tower+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+default-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+default-devel}"
SRC_URI[aarch64_rust-tower+default-devel.sha256sum] = "aaa0e7c3c03c027ff56116ebe459b73bfb633c95d622e75e639caa851d45c0cf"

URI_aarch64_rust-tower+discover-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+discover-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+discover-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+discover-devel}"
SRC_URI[aarch64_rust-tower+discover-devel.sha256sum] = "33b50d3879bc925dbeb1450c4331e8c6b26ca082d95882f8c021e872cd3eba39"

URI_aarch64_rust-tower+filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+filter-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+filter-devel}"
SRC_URI[aarch64_rust-tower+filter-devel.sha256sum] = "b15429f0e3c3d4eee51dcd61c6f029be39c86c84fc14fec178f00cc360b6d21a"

URI_aarch64_rust-tower+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+full-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+full-devel}"
SRC_URI[aarch64_rust-tower+full-devel.sha256sum] = "14e71445fe40161130d11d7d36d699478f07373dceb0e69253e0dc95d34bd74f"

URI_aarch64_rust-tower+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+futures-core-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+futures-core-devel}"
SRC_URI[aarch64_rust-tower+futures-core-devel.sha256sum] = "a2c3554afbc5a679e92faa67b8a0a572489f322e7c4581c72194e75439a6e7f5"

URI_aarch64_rust-tower+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+futures-util-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+futures-util-devel}"
SRC_URI[aarch64_rust-tower+futures-util-devel.sha256sum] = "229e6966acf0955716602382a3c72b96f52aca81345ab0bc9dc38d83c62f1a3e"

URI_aarch64_rust-tower+hdrhistogram-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+hdrhistogram-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+hdrhistogram-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+hdrhistogram-devel}"
SRC_URI[aarch64_rust-tower+hdrhistogram-devel.sha256sum] = "89dbea71b4df5c20d733fb83c2487e081c5b8dff52ecbc5a3534bd0c114de91b"

URI_aarch64_rust-tower+hedge-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+hedge-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+hedge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+hedge-devel}"
SRC_URI[aarch64_rust-tower+hedge-devel.sha256sum] = "eea7d8f11477b18401f6ed23a6ed191fc4b0d7f2824bacb8ffe29af672e3090b"

URI_aarch64_rust-tower+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+indexmap-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+indexmap-devel}"
SRC_URI[aarch64_rust-tower+indexmap-devel.sha256sum] = "a3b0a9f1c5c858aaeff707cf0ef2181035a889e966662ad206c452585f70eeee"

URI_aarch64_rust-tower+limit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+limit-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+limit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+limit-devel}"
SRC_URI[aarch64_rust-tower+limit-devel.sha256sum] = "d461de9f110271692de76638a542ca1b96610ba73aeef5c7393182aea0c59090"

URI_aarch64_rust-tower+load-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+load-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+load-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+load-devel}"
SRC_URI[aarch64_rust-tower+load-devel.sha256sum] = "8bf8299bee95023b5385e054a2d80f6ed3521fa5c7f8517a9f07f5ebcf983ad1"

URI_aarch64_rust-tower+load-shed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+load-shed-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+load-shed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+load-shed-devel}"
SRC_URI[aarch64_rust-tower+load-shed-devel.sha256sum] = "ad1230709cbf5a250091616270ff05e3fb5d6bcc99eb1607ad466a2a1e7fee8d"

URI_aarch64_rust-tower+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+log-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+log-devel}"
SRC_URI[aarch64_rust-tower+log-devel.sha256sum] = "dc05a9f8dbf0809b5b29a6de926bcde3d95cccae88e77362c4188644b5662204"

URI_aarch64_rust-tower+make-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+make-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+make-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+make-devel}"
SRC_URI[aarch64_rust-tower+make-devel.sha256sum] = "fd2d692434faefd34ddc2b889743f18dfe806eb4a401fe5ed2b139730cd36cd1"

URI_aarch64_rust-tower+pin-project-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+pin-project-lite-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+pin-project-lite-devel}"
SRC_URI[aarch64_rust-tower+pin-project-lite-devel.sha256sum] = "3f8790b1744907eb4d27ea790d58403b763676948ff4dd874495393185c17bd3"

URI_aarch64_rust-tower+ready-cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+ready-cache-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+ready-cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+ready-cache-devel}"
SRC_URI[aarch64_rust-tower+ready-cache-devel.sha256sum] = "95da3687fd1acc3d84a4d10512e06dfe9356f0e3c9991854c22699980dc129cc"

URI_aarch64_rust-tower+reconnect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+reconnect-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+reconnect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+reconnect-devel}"
SRC_URI[aarch64_rust-tower+reconnect-devel.sha256sum] = "bb45fb1190e64dad7c4ba936dca859f06c1d808ea7f3f36af4194675453d18cd"

URI_aarch64_rust-tower+retry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+retry-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+retry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+retry-devel}"
SRC_URI[aarch64_rust-tower+retry-devel.sha256sum] = "4269a5c45c15ea560c8387ac14687818cf1943298487afd7ba8343ff6b50132c"

URI_aarch64_rust-tower+slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+slab-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+slab-devel}"
SRC_URI[aarch64_rust-tower+slab-devel.sha256sum] = "0011ba3baa5a789e52aee1425c5623403438933ec3ea8b5ec4e046b4239750d6"

URI_aarch64_rust-tower+spawn-ready-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+spawn-ready-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+spawn-ready-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+spawn-ready-devel}"
SRC_URI[aarch64_rust-tower+spawn-ready-devel.sha256sum] = "e9b6e689f35931f1f6c6097a556ed13196aaafb7434392c57c745e17850a70d8"

URI_aarch64_rust-tower+steer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+steer-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+steer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+steer-devel}"
SRC_URI[aarch64_rust-tower+steer-devel.sha256sum] = "54545fbe8bfcbe289d0be3db6513d89582b77ab07066f509e30661b8461ed1b6"

URI_aarch64_rust-tower+sync_wrapper-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+sync_wrapper-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+sync_wrapper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+sync_wrapper-devel}"
SRC_URI[aarch64_rust-tower+sync_wrapper-devel.sha256sum] = "fab319706c207cd095a05f858d827070a5442001271dbe8c478178754ce58a1f"

URI_aarch64_rust-tower+timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+timeout-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+timeout-devel}"
SRC_URI[aarch64_rust-tower+timeout-devel.sha256sum] = "0ece304926dd2cb71889b67791614402d97131859713c4f652167212bdcb7cf6"

URI_aarch64_rust-tower+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+tokio-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+tokio-devel}"
SRC_URI[aarch64_rust-tower+tokio-devel.sha256sum] = "80e6fd74ea68c23944e897fcf7682af0f70dac9fbaf17e889a0d9b23cdfdd31e"

URI_aarch64_rust-tower+tokio-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+tokio-stream-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+tokio-stream-devel}"
SRC_URI[aarch64_rust-tower+tokio-stream-devel.sha256sum] = "84d558b9bd0426673c784046a0ad8d9acda33be6b2e76ddc1f180f7d52cadc1d"

URI_aarch64_rust-tower+tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+tokio-util-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+tokio-util-devel}"
SRC_URI[aarch64_rust-tower+tokio-util-devel.sha256sum] = "9ec64ece37faab052543c1ef8c2af3f55347bbfe2599670fb69c5ac2f99ede3f"

URI_aarch64_rust-tower+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+tracing-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+tracing-devel}"
SRC_URI[aarch64_rust-tower+tracing-devel.sha256sum] = "be2cd2fd2fd551a3e89b059c86e0904679d16f6c93a85528104983d330d02891"

URI_aarch64_rust-tower+util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+util-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower+util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower+util-devel}"
SRC_URI[aarch64_rust-tower+util-devel.sha256sum] = "3cec6de3f36af162790a6e4c94f2be4c4f20ac5fb38dc95e696832cb2dc4f3f0"

URI_aarch64_rust-tower-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tower-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-devel}"
SRC_URI[aarch64_rust-tower-devel.sha256sum] = "2f1cf9d898a141d285b30ecd3e81ceb96f93fb139534ccf7a8d4a61772edb8ef"

RDEPENDS:rust-tower+__common-devel = " \
 cargo \
 rust-tower+futures-core-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+balance-devel = " \
 cargo \
 rust-tower+discover-devel \
 rust-tower+load-devel \
 rust-tower+make-devel \
 rust-tower+ready-cache-devel \
 rust-tower+slab-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+buffer-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tower+__common-devel \
 rust-tower+tokio-util-devel \
 rust-tower+tracing-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+default-devel = " \
 cargo \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+discover-devel = " \
 cargo \
 rust-tower+__common-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+filter-devel = " \
 cargo \
 rust-tower+__common-devel \
 rust-tower+futures-util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+full-devel = " \
 cargo \
 rust-tower+balance-devel \
 rust-tower+buffer-devel \
 rust-tower+discover-devel \
 rust-tower+filter-devel \
 rust-tower+hedge-devel \
 rust-tower+limit-devel \
 rust-tower+load-devel \
 rust-tower+load-shed-devel \
 rust-tower+make-devel \
 rust-tower+ready-cache-devel \
 rust-tower+reconnect-devel \
 rust-tower+retry-devel \
 rust-tower+spawn-ready-devel \
 rust-tower+steer-devel \
 rust-tower+timeout-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+futures-core-devel = " \
 cargo \
 rust-futures-core+default-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+futures-util-devel = " \
 cargo \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+hdrhistogram-devel = " \
 cargo \
 rust-hdrhistogram-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+hedge-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tower+filter-devel \
 rust-tower+futures-util-devel \
 rust-tower+hdrhistogram-devel \
 rust-tower+tracing-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+limit-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tower+__common-devel \
 rust-tower+tokio-util-devel \
 rust-tower+tracing-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+load-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tower+__common-devel \
 rust-tower+tracing-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+load-shed-devel = " \
 cargo \
 rust-tower+__common-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+log-devel = " \
 cargo \
 rust-tower-devel \
 rust-tracing+log-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tower+make-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+io-std-devel \
 rust-tokio+sync-devel \
 rust-tower+futures-util-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+pin-project-lite-devel = " \
 cargo \
 rust-pin-project-lite+default-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+ready-cache-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tower+futures-core-devel \
 rust-tower+futures-util-devel \
 rust-tower+indexmap-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower+tracing-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+reconnect-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+io-std-devel \
 rust-tokio+sync-devel \
 rust-tower+make-devel \
 rust-tower+tracing-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+retry-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tower+__common-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+slab-devel = " \
 cargo \
 rust-slab+default-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+spawn-ready-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tower+__common-devel \
 rust-tower+futures-util-devel \
 rust-tower+tracing-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+steer-devel = " \
 cargo \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+sync_wrapper-devel = " \
 cargo \
 rust-sync_wrapper+default-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+timeout-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+tokio-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+tokio-stream-devel = " \
 cargo \
 rust-tokio-stream+default-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+tokio-util-devel = " \
 cargo \
 rust-tokio-util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+tracing-devel = " \
 cargo \
 rust-tower-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tower+util-devel = " \
 cargo \
 rust-tower+__common-devel \
 rust-tower+futures-util-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower+sync_wrapper-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower-devel = " \
 cargo \
 rust \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
