# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ephem"
PV = "4.2.1"
PR = "1.el10_3"
PACKAGES = " \
 python-ephem-doc \
 python3-ephem \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ephem-4.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0f5591b9b8576a6a199c45a3f1bbf36bb4c83e7d16909372939cff780f7414b"

URI_x86_64_v2_python-ephem-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-ephem-doc-4.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-ephem-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-ephem-doc}"
SRC_URI[x86_64_v2_python-ephem-doc.sha256sum] = "4cb25d3e63a52be11070e767962c1d4448dcc8d400b1fc371c14c8cc0c1f2bfb"

URI_x86_64_v2_python3-ephem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ephem-4.2.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-ephem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ephem}"
SRC_URI[x86_64_v2_python3-ephem.sha256sum] = "5ec25ece82d7a140885fab22e285ce4194360a632d526db58b263b43b52325bc"

URI_aarch64_python-ephem-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-ephem-doc-4.2.1-1.el10_3.noarch.rpm;name=aarch64_python-ephem-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-ephem-doc}"
SRC_URI[aarch64_python-ephem-doc.sha256sum] = "7469b58c59da636f94fcb791f6bc8b75065d761ba13c63da04c1a65acc9f704c"

URI_aarch64_python3-ephem = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ephem-4.2.1-1.el10_3.aarch64.rpm;name=aarch64_python3-ephem;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ephem}"
SRC_URI[aarch64_python3-ephem.sha256sum] = "96235885009b2369a0d43494682cb8ea8209da74721aa1be44e55383622302a5"

RDEPENDS:python-ephem-doc = " \
 "
RDEPENDS:python3-ephem = " \
 glibc \
 python3 \
 "
