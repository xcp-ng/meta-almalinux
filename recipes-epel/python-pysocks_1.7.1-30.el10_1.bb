# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pysocks"
PV = "1.7.1"
PR = "30.el10_1"
PACKAGES = " \
 python3-pysocks \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-pysocks-1.7.1-30.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "770a535e9e8bcba1c4fedb95a4695e2a9d9c1da5ca3003fdfada5b1404fa75f8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pysocks-1.7.1-30.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pysocks;unpack=0"
SRC_URI[x86_64_v2_python3-pysocks.sha256sum] = "c5c402f462042996ce19191c076137145765f1135d8d89792adf6e19ba6ed772"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pysocks-1.7.1-30.el10_1.noarch.rpm;name=aarch64_python3-pysocks;unpack=0"
SRC_URI[aarch64_python3-pysocks.sha256sum] = "8c8cf579b594c360996af2069305a735b234dae4a81b0f1f222671ded35eac52"

RDEPENDS:python3-pysocks = " \
 python3 \
 "
