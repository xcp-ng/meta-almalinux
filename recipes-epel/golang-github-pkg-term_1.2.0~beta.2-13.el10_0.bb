# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-pkg-term"
PV = "1.2.0~beta.2"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-pkg-term-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-pkg-term-1.2.0~beta.2-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffa902932f10b3efd43680b0690433911fca3eb0c84d954bb323609b311d4bee"

URI_x86_64_v2_golang-github-pkg-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-pkg-term-devel-1.2.0~beta.2-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-pkg-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-pkg-term-devel}"
SRC_URI[x86_64_v2_golang-github-pkg-term-devel.sha256sum] = "9aef1b1eb0e60ebea1c0b0b43b3f29bc6c6f6b0104f8b2d8dbabadc49a99195b"

URI_aarch64_golang-github-pkg-term-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-pkg-term-devel-1.2.0~beta.2-13.el10_0.noarch.rpm;name=aarch64_golang-github-pkg-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-pkg-term-devel}"
SRC_URI[aarch64_golang-github-pkg-term-devel.sha256sum] = "8685b01b1db109bd055aa4a56f35652b25fd602bad69fc6dce78106b6a6f972c"

RDEPENDS:golang-github-pkg-term-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
