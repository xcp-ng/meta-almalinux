# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-uk"
PV = "0.20030903"
PR = "32.el10"
PACKAGES = " \
 hyphen-uk \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-uk-0.20030903-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cac49068980d393af0a12237bb4822cecd4dd3ba99c5408157adb728b5a2f35"

URI_x86_64_v2_hyphen-uk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-uk-0.20030903-32.el10.noarch.rpm;name=x86_64_v2_hyphen-uk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-uk}"
SRC_URI[x86_64_v2_hyphen-uk.sha256sum] = "8be5d8a873527abc8489bd4c6f33332ade47dd40dc49ec5aeb10ac448c9cb42b"

URI_aarch64_hyphen-uk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-uk-0.20030903-32.el10.noarch.rpm;name=aarch64_hyphen-uk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-uk}"
SRC_URI[aarch64_hyphen-uk.sha256sum] = "8be5d8a873527abc8489bd4c6f33332ade47dd40dc49ec5aeb10ac448c9cb42b"

RDEPENDS:hyphen-uk = " \
 hyphen \
 "
