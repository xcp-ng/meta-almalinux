# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-maxminddb"
PV = "2.6.3"
PR = "2.el10_2"
PACKAGES = " \
 python-maxminddb-doc \
 python3-maxminddb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-maxminddb-2.6.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26b554ab14948636ee2b56ae5d1fc8b455fb36f880692adfd7336e05fb520d71"

URI_x86_64_v2_python-maxminddb-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-maxminddb-doc-2.6.3-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python-maxminddb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-maxminddb-doc}"
SRC_URI[x86_64_v2_python-maxminddb-doc.sha256sum] = "4adf58cac476bb3f343417c194c781ad8075d3330894a34c0c98e2d18ac6bce6"

URI_x86_64_v2_python3-maxminddb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-maxminddb-2.6.3-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-maxminddb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-maxminddb}"
SRC_URI[x86_64_v2_python3-maxminddb.sha256sum] = "e0567b8180d0a0875f53e5a70a583ac2b06bc8ba6e40279894bb9b7e5b53bff3"

URI_aarch64_python-maxminddb-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-maxminddb-doc-2.6.3-2.el10_2.aarch64.rpm;name=aarch64_python-maxminddb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-maxminddb-doc}"
SRC_URI[aarch64_python-maxminddb-doc.sha256sum] = "edd3833ddb36895c3ee3efe9960e91409e2cf456483a4decbedb505db4e5b8fa"

URI_aarch64_python3-maxminddb = "${EPEL_MIRROR}/aarch64/Packages/p/python3-maxminddb-2.6.3-2.el10_2.aarch64.rpm;name=aarch64_python3-maxminddb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-maxminddb}"
SRC_URI[aarch64_python3-maxminddb.sha256sum] = "3fcca055aa58f0ac3bff2c1b90b64421087ee8d5dad67b89c6bf629d27071051"

RDEPENDS:python-maxminddb-doc = " \
 "
RDEPENDS:python3-maxminddb = " \
 glibc \
 libmaxminddb \
 python3 \
 "
