# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "epel-release"
PV = "10"
PR = "8.el10_2"
PACKAGES = " \
 epel-release \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/epel-release-10-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4563c2bd4bda97f441bf084e74d53b165d15bed1fcb895101cace14a70929048"

URI_aarch64_epel-release = "${EPEL_MIRROR}/aarch64/Packages/e/epel-release-10-8.el10_2.noarch.rpm;name=aarch64_epel-release;unpack=0"
SRC_URI:append = " ${URI_aarch64_epel-release}"
SRC_URI[aarch64_epel-release.sha256sum] = "8ff46bb59651203a801759627c8c1829c6fe610e031f93c83747ba0832bb97ed"

RDEPENDS:epel-release = " \
 almalinux-release \
 bash \
 "
