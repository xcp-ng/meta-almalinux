# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uv"
PV = "0.10.2"
PR = "4.el10_2"
PACKAGES = " \
 python3-uv \
 uv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uv-0.10.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8098830cb006d8080d7f6b9ea7251ea83f7389363d976e34da0cd4dc47ca900e"

URI_x86_64_v2_python3-uv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-uv-0.10.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-uv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-uv}"
SRC_URI[x86_64_v2_python3-uv.sha256sum] = "e99bb9e3cbf9a96622385efd0ec8ebd71801f0ae62dc812761c103d8b08e1117"

URI_x86_64_v2_uv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uv-0.10.2-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uv}"
SRC_URI[x86_64_v2_uv.sha256sum] = "193131d6977352db9bdf8fadf7e7b728e8c62f70f9e2048ac9c3d841c8ba857d"

URI_aarch64_python3-uv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-uv-0.10.2-4.el10_2.noarch.rpm;name=aarch64_python3-uv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-uv}"
SRC_URI[aarch64_python3-uv.sha256sum] = "1254c2d3970b9998cf5a68b837e05365ebf414cd3f7188a900a002abf0e06925"

URI_aarch64_uv = "${EPEL_MIRROR}/aarch64/Packages/u/uv-0.10.2-4.el10_2.aarch64.rpm;name=aarch64_uv;unpack=0"
SRC_URI:append = " ${URI_aarch64_uv}"
SRC_URI[aarch64_uv.sha256sum] = "202ff447a12a9e00ba45a51be267175898efd46a47f5a88f26e019bc63ea65cf"

RDEPENDS:python3-uv = " \
 python3 \
 uv \
 "
RDEPENDS:uv = " \
 glibc \
 jemalloc \
 libgcc \
 libzstd \
 xz-libs \
 "
