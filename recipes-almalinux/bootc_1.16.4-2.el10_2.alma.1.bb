# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bootc"
PV = "1.16.4"
PR = "2.el10_2.alma.1"
PACKAGES = " \
 bootc \
 system-reinstall-bootc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bootc-1.16.4-2.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "eb5e784ab0318bfaa124f92d886f239ea67c7084a1e614f3cd2005cf385480f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bootc-1.16.4-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_bootc;unpack=0"
SRC_URI[x86_64_v2_bootc.sha256sum] = "d70a816f175e4b5ca9d6cf685ce948fe17d101d0bf64e606fcb5d2d512616e10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/system-reinstall-bootc-1.16.4-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_system-reinstall-bootc;unpack=0"
SRC_URI[x86_64_v2_system-reinstall-bootc.sha256sum] = "735a4e3dc2b9147384be2039cd2edc1e0bde315bfae3bcad172413beeaeca3a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bootc-1.16.4-2.el10_2.alma.1.aarch64.rpm;name=aarch64_bootc;unpack=0"
SRC_URI[aarch64_bootc.sha256sum] = "4de1af7ed1ebdbc5807ec190fcbb37504e024768cf2799040971e19cc48ec96b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/system-reinstall-bootc-1.16.4-2.el10_2.alma.1.aarch64.rpm;name=aarch64_system-reinstall-bootc;unpack=0"
SRC_URI[aarch64_system-reinstall-bootc.sha256sum] = "74fdbd331c14605aa86570363c628bef24b7ca2ec596d5ca4b0bfbb2a92cd936"

RDEPENDS:bootc = " \
 bash \
 composefs \
 glib2 \
 glibc \
 libgcc \
 libzstd \
 openssl-libs \
 ostree \
 ostree-libs \
 pcre2 \
 podman \
 skopeo \
 util-linux-core \
 virtual//usr/bin/chcon \
 zlib-ng-compat \
 "
RDEPENDS:system-reinstall-bootc = " \
 bash \
 glibc \
 libgcc \
 "
