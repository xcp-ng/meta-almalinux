# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros0.23"
PV = "0.23.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyo3-macros0.23+default-devel \
 rust-pyo3-macros0.23+experimental-async-devel \
 rust-pyo3-macros0.23+multiple-pymethods-devel \
 rust-pyo3-macros0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros0.23-0.23.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0b220f97c2af80a3fc06dc6cc60e4d5b585d884ad1e4ca2d1a7ecdcf93d8d8e"

URI_x86_64_v2_rust-pyo3-macros0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.23+default-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.23+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.23+default-devel.sha256sum] = "76555cbd731eac95454234b3df2f49f48e7a677075caff9a94d8269c3faa906d"

URI_x86_64_v2_rust-pyo3-macros0.23+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.23+experimental-async-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.23+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.23+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.23+experimental-async-devel.sha256sum] = "3386fff774386dedc4815e687d233cadfcf7c7fb981f690318ea018c79807a81"

URI_x86_64_v2_rust-pyo3-macros0.23+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.23+multiple-pymethods-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.23+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.23+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.23+multiple-pymethods-devel.sha256sum] = "4ec5163ccd178d58859419faa7371074e0b1a9c13975c7b9a65903d08258c66f"

URI_x86_64_v2_rust-pyo3-macros0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.23-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.23-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.23-devel.sha256sum] = "c78e592fe6a979109a9e4dd5ed925128b682e4a1bab66d813626e6a804985235"

URI_aarch64_rust-pyo3-macros0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.23+default-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.23+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.23+default-devel.sha256sum] = "ca59c47e54403bfeb6b3f980f83b4c6eac3f698df61a0d0c1346caa3541132e0"

URI_aarch64_rust-pyo3-macros0.23+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.23+experimental-async-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros0.23+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.23+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.23+experimental-async-devel.sha256sum] = "f10d6fa3771550555e0847bae0dd0ce928870fe155f1f6cda4e8a9b09c982feb"

URI_aarch64_rust-pyo3-macros0.23+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.23+multiple-pymethods-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros0.23+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.23+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.23+multiple-pymethods-devel.sha256sum] = "c2e194611706a117dcbf5b4482fbbf05528fe217ee163ae63f54eb821b7b32a7"

URI_aarch64_rust-pyo3-macros0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.23-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.23-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.23-devel.sha256sum] = "94b3b4c1c1201bcd910daa319974f97665ea444361e005eb3b961bb4cf242584"

RDEPENDS:rust-pyo3-macros0.23+default-devel = " \
 cargo \
 rust-pyo3-macros0.23-devel \
 "
RDEPENDS:rust-pyo3-macros0.23+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend0.23+experimental-async-devel \
 rust-pyo3-macros0.23-devel \
 "
RDEPENDS:rust-pyo3-macros0.23+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros0.23-devel \
 "
RDEPENDS:rust-pyo3-macros0.23-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-pyo3-macros-backend0.23+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 "
