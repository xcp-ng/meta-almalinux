# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Lchown"
PV = "1.01"
PR = "31.el10_0"
PACKAGES = " \
 perl-Lchown \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Lchown-1.01-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee391993304de50a107f0c22796c5f4a2b781cc24600beb0d0eaba3e2497fb28"

URI_x86_64_v2_perl-Lchown = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Lchown-1.01-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Lchown;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Lchown}"
SRC_URI[x86_64_v2_perl-Lchown.sha256sum] = "ca22351a6d6d1ca2004dcbd7861a6ff9536b4eb37e06277ef79ebfae0a5bde16"

URI_aarch64_perl-Lchown = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Lchown-1.01-31.el10_0.aarch64.rpm;name=aarch64_perl-Lchown;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Lchown}"
SRC_URI[aarch64_perl-Lchown.sha256sum] = "a0e19b66900c82811eec128b6ceafb363caa241a3e50cd721d9c9b02b7af393c"

RDEPENDS:perl-Lchown = " \
 glibc \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
