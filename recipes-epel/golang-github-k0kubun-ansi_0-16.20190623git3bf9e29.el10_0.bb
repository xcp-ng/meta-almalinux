# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-k0kubun-ansi"
PV = "0"
PR = "16.20190623git3bf9e29.el10_0"
PACKAGES = " \
 golang-github-k0kubun-ansi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-k0kubun-ansi-0-16.20190623git3bf9e29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "449635b5081a4aba93d776aaf13e9dfb71a7673d89d39b970f1b9ce5b8379334"

URI_aarch64_golang-github-k0kubun-ansi-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-k0kubun-ansi-devel-0-16.20190623git3bf9e29.el10_0.noarch.rpm;name=aarch64_golang-github-k0kubun-ansi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-k0kubun-ansi-devel}"
SRC_URI[aarch64_golang-github-k0kubun-ansi-devel.sha256sum] = "775da07c560d1161da44cd911fa72d79df4f90e257bbc4ff0a83976b2d96f17d"

RDEPENDS:golang-github-k0kubun-ansi-devel = " \
 go-filesystem \
 "
