# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kglobalaccel"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kglobalaccel \
 kf6-kglobalaccel-devel \
 kf6-kglobalaccel-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kglobalaccel-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3003c1b35cc58550a0f083ac35d81776d69ae8763c6f60a8e87cebd7c74ba542"

URI_x86_64_v2_kf6-kglobalaccel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kglobalaccel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel}"
SRC_URI[x86_64_v2_kf6-kglobalaccel.sha256sum] = "c85f74613cda6afdf9cd37c9444031fa2e36f1c238bb9f122c4fb18a3cb52e2b"

URI_x86_64_v2_kf6-kglobalaccel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kglobalaccel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel-devel}"
SRC_URI[x86_64_v2_kf6-kglobalaccel-devel.sha256sum] = "8606f8669208c8370a3f573c77fd0b879c4c4f57c9e3c9b0a73be03315ecf37c"

URI_x86_64_v2_kf6-kglobalaccel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kglobalaccel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel-doc}"
SRC_URI[x86_64_v2_kf6-kglobalaccel-doc.sha256sum] = "fad1e28e65889d2773aa632c0c71da23ccf6ec5bd21f100f4c5496873e772bb2"

URI_aarch64_kf6-kglobalaccel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kglobalaccel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel}"
SRC_URI[aarch64_kf6-kglobalaccel.sha256sum] = "eea3cd6de30dd7b24085c94754c7142061bd32f08c75eb040fc1d1b24d40386d"

URI_aarch64_kf6-kglobalaccel-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kglobalaccel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel-devel}"
SRC_URI[aarch64_kf6-kglobalaccel-devel.sha256sum] = "fb249714f9285430493c44cbb06196c222f8b50b7160f5edeb40aed8e7e4613a"

URI_aarch64_kf6-kglobalaccel-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kglobalaccel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel-doc}"
SRC_URI[aarch64_kf6-kglobalaccel-doc.sha256sum] = "b75fef7a95ac6d47e0d14d1d1d0019914ad16cd012452bfb278740e8f1a0bcdb"

RDEPENDS:kf6-kglobalaccel = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kglobalaccel-devel = " \
 cmake-filesystem \
 kf6-kglobalaccel \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kglobalaccel-doc = " \
 "
