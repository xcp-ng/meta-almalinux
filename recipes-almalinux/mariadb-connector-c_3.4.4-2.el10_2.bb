# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mariadb-connector-c"
PV = "3.4.4"
PR = "2.el10_2"
PACKAGES = " \
 mariadb-connector-c \
 mariadb-connector-c-config \
 mariadb-connector-c-devel \
 mariadb-connector-c-doc \
 mariadb-connector-c-test \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mariadb-connector-c-3.4.4-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49c2003dbc061ea43bcc475c261be2fd814475f7d2d54fe9dea4c0f5447ca55f"

URI_x86_64_v2_mariadb-connector-c = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mariadb-connector-c-3.4.4-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_mariadb-connector-c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-connector-c}"
SRC_URI[x86_64_v2_mariadb-connector-c.sha256sum] = "f6ea1e05daf2862eeb1b90a9fd28427e763cbf7c5dbd69473f0276dcf7a5cc58"

URI_x86_64_v2_mariadb-connector-c-config = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mariadb-connector-c-config-3.4.4-2.el10_2.noarch.rpm;name=x86_64_v2_mariadb-connector-c-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-connector-c-config}"
SRC_URI[x86_64_v2_mariadb-connector-c-config.sha256sum] = "b6fcb23fd7175f5ec595f2713711197fe45d0f48fc6fc2e2149de956221a13ce"

URI_x86_64_v2_mariadb-connector-c-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-connector-c-devel-3.4.4-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_mariadb-connector-c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-connector-c-devel}"
SRC_URI[x86_64_v2_mariadb-connector-c-devel.sha256sum] = "347e54309379011544c8d5706e0da1d8abe4d5de5606e9d4e2207ccc73271034"

URI_x86_64_v2_mariadb-connector-c-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mariadb-connector-c-doc-3.4.4-2.el10_2.noarch.rpm;name=x86_64_v2_mariadb-connector-c-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-connector-c-doc}"
SRC_URI[x86_64_v2_mariadb-connector-c-doc.sha256sum] = "8cf1ce56d4d79c064cdad31b2bb230e2d0a09ef70c34615e9310cb74aabd0d18"

URI_x86_64_v2_mariadb-connector-c-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mariadb-connector-c-test-3.4.4-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_mariadb-connector-c-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-connector-c-test}"
SRC_URI[x86_64_v2_mariadb-connector-c-test.sha256sum] = "617353bad3d43e4e2bd11e9c82a51ffe942ece57a2096b337263c4f75c7d4938"

URI_aarch64_mariadb-connector-c = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mariadb-connector-c-3.4.4-2.el10_2.aarch64.rpm;name=aarch64_mariadb-connector-c;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-connector-c}"
SRC_URI[aarch64_mariadb-connector-c.sha256sum] = "0c2cbde9abc1eb286866e511752997cbcf94faca50de1bbeec63ae63ecb0e641"

URI_aarch64_mariadb-connector-c-config = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mariadb-connector-c-config-3.4.4-2.el10_2.noarch.rpm;name=aarch64_mariadb-connector-c-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-connector-c-config}"
SRC_URI[aarch64_mariadb-connector-c-config.sha256sum] = "b6fcb23fd7175f5ec595f2713711197fe45d0f48fc6fc2e2149de956221a13ce"

URI_aarch64_mariadb-connector-c-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-connector-c-devel-3.4.4-2.el10_2.aarch64.rpm;name=aarch64_mariadb-connector-c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-connector-c-devel}"
SRC_URI[aarch64_mariadb-connector-c-devel.sha256sum] = "ad815ec4da9e53959867b00032ff0988d9e82a62939a1626a4954b7e64c5f3ee"

URI_aarch64_mariadb-connector-c-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mariadb-connector-c-doc-3.4.4-2.el10_2.noarch.rpm;name=aarch64_mariadb-connector-c-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-connector-c-doc}"
SRC_URI[aarch64_mariadb-connector-c-doc.sha256sum] = "8cf1ce56d4d79c064cdad31b2bb230e2d0a09ef70c34615e9310cb74aabd0d18"

URI_aarch64_mariadb-connector-c-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mariadb-connector-c-test-3.4.4-2.el10_2.aarch64.rpm;name=aarch64_mariadb-connector-c-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-connector-c-test}"
SRC_URI[aarch64_mariadb-connector-c-test.sha256sum] = "d4667f394d47325f5ac89a40184cea6c9fa2eecef2c8d1d1e6e5875f5b319556"

RDEPENDS:mariadb-connector-c = " \
 glibc \
 krb5-libs \
 libzstd \
 mariadb-connector-c-config \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-connector-c-config = " \
 "
RDEPENDS:mariadb-connector-c-devel = " \
 glibc \
 mariadb-connector-c \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:mariadb-connector-c-doc = " \
 mariadb-connector-c \
 "
RDEPENDS:mariadb-connector-c-test = " \
 cmake \
 glibc \
 mariadb-connector-c \
 openssl-libs \
 zlib-ng-compat \
 "
