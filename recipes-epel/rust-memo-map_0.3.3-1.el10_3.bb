# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memo-map"
PV = "0.3.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-memo-map+default-devel \
 rust-memo-map-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memo-map-0.3.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e24a585407f7bff56736d257fc01f40bcdd36f74e338341fc3382e3e6a957bf7"

URI_x86_64_v2_rust-memo-map+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memo-map+default-devel-0.3.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memo-map+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memo-map+default-devel}"
SRC_URI[x86_64_v2_rust-memo-map+default-devel.sha256sum] = "6ad81e33327b54524505d68946aa5d1a779e0a7ef4665dca34d9307ae00b8f92"

URI_x86_64_v2_rust-memo-map-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memo-map-devel-0.3.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memo-map-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memo-map-devel}"
SRC_URI[x86_64_v2_rust-memo-map-devel.sha256sum] = "45d169e5f72922bd4a756a57cc3768e4fb1ebb38e4336eb178ee6d2570babe72"

URI_aarch64_rust-memo-map+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memo-map+default-devel-0.3.3-1.el10_3.noarch.rpm;name=aarch64_rust-memo-map+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memo-map+default-devel}"
SRC_URI[aarch64_rust-memo-map+default-devel.sha256sum] = "5b2462092963795b02efcbc987b097c03c201551c85143e81e44c06ce1596888"

URI_aarch64_rust-memo-map-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memo-map-devel-0.3.3-1.el10_3.noarch.rpm;name=aarch64_rust-memo-map-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memo-map-devel}"
SRC_URI[aarch64_rust-memo-map-devel.sha256sum] = "9d6a2a0934c364b8f21ee05283fdfbff5b9b7c79db8c4a65654d786ec02025aa"

RDEPENDS:rust-memo-map+default-devel = " \
 cargo \
 rust-memo-map-devel \
 "
RDEPENDS:rust-memo-map-devel = " \
 cargo \
 rust \
 "
