# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-generic-array"
PV = "0.14.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-generic-array+default-devel \
 rust-generic-array+more_lengths-devel \
 rust-generic-array+serde-devel \
 rust-generic-array+zeroize-devel \
 rust-generic-array-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-generic-array-0.14.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16b7d22e464b972bfa1cf073b2fde1a56776427e8558fbeb36d6ca561558429d"

URI_x86_64_v2_rust-generic-array+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array+default-devel-0.14.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-generic-array+default-devel}"
SRC_URI[x86_64_v2_rust-generic-array+default-devel.sha256sum] = "d1601982e71aabd3b0965a4768e31c539774be0cd07e7e1b6d0b407dd5b3a92b"

URI_x86_64_v2_rust-generic-array+more_lengths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array+more_lengths-devel-0.14.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array+more_lengths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-generic-array+more_lengths-devel}"
SRC_URI[x86_64_v2_rust-generic-array+more_lengths-devel.sha256sum] = "f5768ed51fc50b6035fe870f1a82d1e56fd9a6b625b2c977840f50987755b99f"

URI_x86_64_v2_rust-generic-array+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array+serde-devel-0.14.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-generic-array+serde-devel}"
SRC_URI[x86_64_v2_rust-generic-array+serde-devel.sha256sum] = "41b7e7718f3eb7dd9c503894a017e656655a50fb0a6be74d4f04a6969cc621d4"

URI_x86_64_v2_rust-generic-array+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array+zeroize-devel-0.14.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-generic-array+zeroize-devel}"
SRC_URI[x86_64_v2_rust-generic-array+zeroize-devel.sha256sum] = "a8bd44ba6a8c15ff21287598c3a8887400da8bc9d2da4d7bbec5aa1b55c9baa7"

URI_x86_64_v2_rust-generic-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array-devel-0.14.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-generic-array-devel}"
SRC_URI[x86_64_v2_rust-generic-array-devel.sha256sum] = "eb239976e93364ec57d290917f3bd87c420e38ef6aae7c78ae86a38e8e9d5115"

URI_aarch64_rust-generic-array+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array+default-devel-0.14.9-1.el10_2.noarch.rpm;name=aarch64_rust-generic-array+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-generic-array+default-devel}"
SRC_URI[aarch64_rust-generic-array+default-devel.sha256sum] = "adaf585e8ab23261775b2516893642232f34c64ec6a5dcfa350cf75c8b005ced"

URI_aarch64_rust-generic-array+more_lengths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array+more_lengths-devel-0.14.9-1.el10_2.noarch.rpm;name=aarch64_rust-generic-array+more_lengths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-generic-array+more_lengths-devel}"
SRC_URI[aarch64_rust-generic-array+more_lengths-devel.sha256sum] = "9dae5675cf474cba76727f618f0a0043affaf9b35861aec5eb35ff6c65fbaa8e"

URI_aarch64_rust-generic-array+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array+serde-devel-0.14.9-1.el10_2.noarch.rpm;name=aarch64_rust-generic-array+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-generic-array+serde-devel}"
SRC_URI[aarch64_rust-generic-array+serde-devel.sha256sum] = "6b7267f21658a3bdf669f57593e39e1ec4bb4842e1e4caa4a7d882a44783eda4"

URI_aarch64_rust-generic-array+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array+zeroize-devel-0.14.9-1.el10_2.noarch.rpm;name=aarch64_rust-generic-array+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-generic-array+zeroize-devel}"
SRC_URI[aarch64_rust-generic-array+zeroize-devel.sha256sum] = "e168be4a6234489ad4229ccc7248ca0638efbba4596815dab20d14c1aebd321a"

URI_aarch64_rust-generic-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array-devel-0.14.9-1.el10_2.noarch.rpm;name=aarch64_rust-generic-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-generic-array-devel}"
SRC_URI[aarch64_rust-generic-array-devel.sha256sum] = "9db4adaedfe001d4f60e188a1d086cd204485ce9eb564092be1a34d1d1e1f872"

RDEPENDS:rust-generic-array+default-devel = " \
 cargo \
 rust-generic-array-devel \
 "
RDEPENDS:rust-generic-array+more_lengths-devel = " \
 cargo \
 rust-generic-array-devel \
 "
RDEPENDS:rust-generic-array+serde-devel = " \
 cargo \
 rust-generic-array-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-generic-array+zeroize-devel = " \
 cargo \
 rust-generic-array-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-generic-array-devel = " \
 cargo \
 rust-typenum+default-devel \
 rust-version_check+default-devel \
 "
