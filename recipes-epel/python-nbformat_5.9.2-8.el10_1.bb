# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nbformat"
PV = "5.9.2"
PR = "8.el10_1"
PACKAGES = " \
 python3-nbformat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-nbformat-5.9.2-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9c0522a4b6b6a998a4cf236149ca3571d80a38ac168188d81fc641affccf581"

URI_x86_64_v2_python3-nbformat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nbformat-5.9.2-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-nbformat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nbformat}"
SRC_URI[x86_64_v2_python3-nbformat.sha256sum] = "16fc8ae679c2e6fa9f0bc7c0d9db2e62b7b3d5b5c9b0fee65d0d8239487edb2e"

URI_aarch64_python3-nbformat = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nbformat-5.9.2-8.el10_1.noarch.rpm;name=aarch64_python3-nbformat;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nbformat}"
SRC_URI[aarch64_python3-nbformat.sha256sum] = "bf31720c804e48bd0a01df3b8d05e566ce1f318eeddf8cb25788bf60ffd43762"

RDEPENDS:python3-nbformat = " \
 python3 \
 python3-fastjsonschema \
 python3-jsonschema \
 python3-jupyter-core \
 python3-traitlets \
 "
