# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexical-write-integer"
PV = "1.0.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-lexical-write-integer+compact-devel \
 rust-lexical-write-integer+default-devel \
 rust-lexical-write-integer+format-devel \
 rust-lexical-write-integer+lint-devel \
 rust-lexical-write-integer+power-of-two-devel \
 rust-lexical-write-integer+radix-devel \
 rust-lexical-write-integer+std-devel \
 rust-lexical-write-integer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexical-write-integer-1.0.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55605fe877973e11f42ff27022e505ecb38a1c4e6ca30086c0270dace082c14a"

URI_x86_64_v2_rust-lexical-write-integer+compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-integer+compact-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-integer+compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-integer+compact-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-integer+compact-devel.sha256sum] = "e0c0ca853144f783930972debfe4bc59821e6e22d9cfd81cbcb27257434b111e"

URI_x86_64_v2_rust-lexical-write-integer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-integer+default-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-integer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-integer+default-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-integer+default-devel.sha256sum] = "59d978103a82fb88c24728b7fbe666280d23791173dc3e70fbcbfa22796ddf14"

URI_x86_64_v2_rust-lexical-write-integer+format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-integer+format-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-integer+format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-integer+format-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-integer+format-devel.sha256sum] = "3c397c0473dd9d9aeb9ba41215b0ded937e65a4d1381b66880880be135d55f9e"

URI_x86_64_v2_rust-lexical-write-integer+lint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-integer+lint-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-integer+lint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-integer+lint-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-integer+lint-devel.sha256sum] = "2c314f43cd08ebe1663012ef287c2bad3bf421c60a4d5436f20f6775d7e914d2"

URI_x86_64_v2_rust-lexical-write-integer+power-of-two-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-integer+power-of-two-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-integer+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-integer+power-of-two-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-integer+power-of-two-devel.sha256sum] = "3890246db1bf4fcf57f49bade070dde84ce10fdccd01b119f887ebe3136a85d7"

URI_x86_64_v2_rust-lexical-write-integer+radix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-integer+radix-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-integer+radix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-integer+radix-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-integer+radix-devel.sha256sum] = "fbb847550989db032dbe1c4654d4e46e1ea78f9756acf5f75194889234df87b0"

URI_x86_64_v2_rust-lexical-write-integer+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-integer+std-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-integer+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-integer+std-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-integer+std-devel.sha256sum] = "ad3699a9b1ca10e0de76af5396f70d817e38edc8f255fc332f8562f5428211b7"

URI_x86_64_v2_rust-lexical-write-integer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-integer-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-integer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-integer-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-integer-devel.sha256sum] = "d50a633e90299d77635191784b2cc65a144cd3ab94be3a49af7ae61b1d78ff19"

URI_aarch64_rust-lexical-write-integer+compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-integer+compact-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-integer+compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-integer+compact-devel}"
SRC_URI[aarch64_rust-lexical-write-integer+compact-devel.sha256sum] = "4768a7dac8e92ca063282a83a13cadd103f7f509e5c6dfd540441bfc83f0edf8"

URI_aarch64_rust-lexical-write-integer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-integer+default-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-integer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-integer+default-devel}"
SRC_URI[aarch64_rust-lexical-write-integer+default-devel.sha256sum] = "962c197aea4ca4472085db3b280b4cb6965c4e62d8d8923924a7ecc6666f5bcc"

URI_aarch64_rust-lexical-write-integer+format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-integer+format-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-integer+format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-integer+format-devel}"
SRC_URI[aarch64_rust-lexical-write-integer+format-devel.sha256sum] = "e8d83f27dd910015fe7cf1759a7b475c0ee7cf7b151946e944142f3e21a307cd"

URI_aarch64_rust-lexical-write-integer+lint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-integer+lint-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-integer+lint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-integer+lint-devel}"
SRC_URI[aarch64_rust-lexical-write-integer+lint-devel.sha256sum] = "7569e5bdcf397404da1108031ab65e7b88a3a53f3881dfbc28550d933307f254"

URI_aarch64_rust-lexical-write-integer+power-of-two-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-integer+power-of-two-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-integer+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-integer+power-of-two-devel}"
SRC_URI[aarch64_rust-lexical-write-integer+power-of-two-devel.sha256sum] = "dbbf7842775367afcfb35516c2404444d9ea76389d518d6b64ea6fb48cf43f96"

URI_aarch64_rust-lexical-write-integer+radix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-integer+radix-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-integer+radix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-integer+radix-devel}"
SRC_URI[aarch64_rust-lexical-write-integer+radix-devel.sha256sum] = "b4698d69edb08bf69f61515de7db033263239916ab8542a7c64043629e980bee"

URI_aarch64_rust-lexical-write-integer+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-integer+std-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-integer+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-integer+std-devel}"
SRC_URI[aarch64_rust-lexical-write-integer+std-devel.sha256sum] = "de5660e7d72ac699b58002766d09e2aff87e47c2ec2c11268fa49ee47faaa1c4"

URI_aarch64_rust-lexical-write-integer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-integer-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-integer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-integer-devel}"
SRC_URI[aarch64_rust-lexical-write-integer-devel.sha256sum] = "6525df05f41835c1072db89f25c893af77e5a909a28fbceaa8ee7ff9c7fef041"

RDEPENDS:rust-lexical-write-integer+compact-devel = " \
 cargo \
 rust-lexical-util+compact-devel \
 rust-lexical-write-integer-devel \
 "
RDEPENDS:rust-lexical-write-integer+default-devel = " \
 cargo \
 rust-lexical-write-integer+std-devel \
 rust-lexical-write-integer-devel \
 "
RDEPENDS:rust-lexical-write-integer+format-devel = " \
 cargo \
 rust-lexical-util+format-devel \
 rust-lexical-write-integer-devel \
 "
RDEPENDS:rust-lexical-write-integer+lint-devel = " \
 cargo \
 rust-lexical-util+lint-devel \
 rust-lexical-write-integer-devel \
 "
RDEPENDS:rust-lexical-write-integer+power-of-two-devel = " \
 cargo \
 rust-lexical-util+power-of-two-devel \
 rust-lexical-write-integer-devel \
 "
RDEPENDS:rust-lexical-write-integer+radix-devel = " \
 cargo \
 rust-lexical-util+radix-devel \
 rust-lexical-write-integer+power-of-two-devel \
 rust-lexical-write-integer-devel \
 "
RDEPENDS:rust-lexical-write-integer+std-devel = " \
 cargo \
 rust-lexical-util+std-devel \
 rust-lexical-write-integer-devel \
 "
RDEPENDS:rust-lexical-write-integer-devel = " \
 cargo \
 rust \
 rust-lexical-util+write-integers-devel \
 rust-lexical-util-devel \
 "
