# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-msal"
PV = "1.37.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-msal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-msal-1.37.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ddc5f4aec4cb8aebbfc510ec61215ce5848908206dbf9e90f5ef443bd20c166"

URI_x86_64_v2_python3-msal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-msal-1.37.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-msal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-msal}"
SRC_URI[x86_64_v2_python3-msal.sha256sum] = "54991286aa57d221dad04aeb80ab465a6f22723e72b1b4945bacf87ecafa184a"

URI_aarch64_python3-msal = "${EPEL_MIRROR}/aarch64/Packages/p/python3-msal-1.37.0-1.el10_3.noarch.rpm;name=aarch64_python3-msal;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-msal}"
SRC_URI[aarch64_python3-msal.sha256sum] = "b64f1230269f8dbbf8bde809348841c0963fc2c13dc4a0378f274753e44d0ec9"

RDEPENDS:python3-msal = " \
 python3 \
 python3-cryptography \
 python3-jwt \
 python3-jwt+crypto \
 python3-requests \
 "
