# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-repeat"
PV = "0.9.3"
PR = "1.el10_0"
PACKAGES = " \
 python3-pytest-repeat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-repeat-0.9.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00c353f41f1be1dee8ba14e1e1d85cdfda96b946fdaca0e68ce1f9f06793d1a0"

URI_x86_64_v2_python3-pytest-repeat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-repeat-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-repeat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-repeat}"
SRC_URI[x86_64_v2_python3-pytest-repeat.sha256sum] = "19e8d5d3f52bd9c967c21ec2c2456323919a65092a438cf8d77bc484e3835a65"

URI_aarch64_python3-pytest-repeat = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-repeat-0.9.3-1.el10_0.noarch.rpm;name=aarch64_python3-pytest-repeat;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-repeat}"
SRC_URI[aarch64_python3-pytest-repeat.sha256sum] = "37d5f1886bd62af3077385256fbca2168eab23c1557b5d1d0061a3b2a58ae09c"

RDEPENDS:python3-pytest-repeat = " \
 python3 \
 python3-pytest \
 "
