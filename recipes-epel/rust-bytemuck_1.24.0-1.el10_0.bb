# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytemuck"
PV = "1.24.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-bytemuck+aarch64_simd-devel \
 rust-bytemuck+align_offset-devel \
 rust-bytemuck+alloc_uninit-devel \
 rust-bytemuck+avx512_simd-devel \
 rust-bytemuck+bytemuck_derive-devel \
 rust-bytemuck+const_zeroed-devel \
 rust-bytemuck+default-devel \
 rust-bytemuck+derive-devel \
 rust-bytemuck+extern_crate_alloc-devel \
 rust-bytemuck+extern_crate_std-devel \
 rust-bytemuck+impl_core_error-devel \
 rust-bytemuck+min_const_generics-devel \
 rust-bytemuck+must_cast-devel \
 rust-bytemuck+must_cast_extra-devel \
 rust-bytemuck+nightly_stdsimd-devel \
 rust-bytemuck+track_caller-devel \
 rust-bytemuck+transparentwrapper_extra-devel \
 rust-bytemuck+unsound_ptr_pod_impl-devel \
 rust-bytemuck+zeroable_atomics-devel \
 rust-bytemuck+zeroable_maybe_uninit-devel \
 rust-bytemuck+zeroable_unwind_fn-devel \
 rust-bytemuck-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytemuck-1.24.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dab496c5ef6ac09813ccfbff3bd9666809f348eeec2ffe4555317e32857429cd"

URI_x86_64_v2_rust-bytemuck+aarch64_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+aarch64_simd-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+aarch64_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+aarch64_simd-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+aarch64_simd-devel.sha256sum] = "1dd0c73d94a35e155ae9bf8f9a3d002994c0c73406fbfe783d8c776d853aa0c4"

URI_x86_64_v2_rust-bytemuck+align_offset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+align_offset-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+align_offset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+align_offset-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+align_offset-devel.sha256sum] = "d2618e747a94a2ba2ec834904d6925eaf3d281b2cfcdbddb295a60c5ce50f4bd"

URI_x86_64_v2_rust-bytemuck+alloc_uninit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+alloc_uninit-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+alloc_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+alloc_uninit-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+alloc_uninit-devel.sha256sum] = "c8d9b33ecc101b2f4aaeb7901939bafa476db7e7706f94da4a82311db9d08d38"

URI_x86_64_v2_rust-bytemuck+avx512_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+avx512_simd-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+avx512_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+avx512_simd-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+avx512_simd-devel.sha256sum] = "1f1c013b7f0aec0c84563241c66cfc674a97f9b5b519bc6d25f74fc6f5c7b803"

URI_x86_64_v2_rust-bytemuck+bytemuck_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+bytemuck_derive-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+bytemuck_derive-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+bytemuck_derive-devel.sha256sum] = "95ba5f1243f6b836c1597e7e306fe82d41cde5c1ebe09b97a357bae39e1eb7eb"

URI_x86_64_v2_rust-bytemuck+const_zeroed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+const_zeroed-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+const_zeroed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+const_zeroed-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+const_zeroed-devel.sha256sum] = "b8647af012f245853ac3571c954e7c71a56e5076b5e93cabdf643256dc8e93c5"

URI_x86_64_v2_rust-bytemuck+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+default-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+default-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+default-devel.sha256sum] = "f0c8f667d6e0bbda2125b1258ba1d6fcfdec3cfbd7fe5d55c62e29ac73d36def"

URI_x86_64_v2_rust-bytemuck+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+derive-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+derive-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+derive-devel.sha256sum] = "80cfb07bdb846a64a2b5a621af67aeb6ed83f9446d2e4a1009101c774226a0f2"

URI_x86_64_v2_rust-bytemuck+extern_crate_alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+extern_crate_alloc-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+extern_crate_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+extern_crate_alloc-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+extern_crate_alloc-devel.sha256sum] = "fde7c7a7a4702c657ef56b5688482a68bc99d2968c802ea3f231fb44e46c3002"

URI_x86_64_v2_rust-bytemuck+extern_crate_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+extern_crate_std-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+extern_crate_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+extern_crate_std-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+extern_crate_std-devel.sha256sum] = "b71b75ca93f56463f6a1766810daae2141a9e85be4af2cab3650ad09232018b2"

URI_x86_64_v2_rust-bytemuck+impl_core_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+impl_core_error-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+impl_core_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+impl_core_error-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+impl_core_error-devel.sha256sum] = "368bdab86355ca228bcd4f0263f7516f89910cf9d02b8a8de5e1e4ffed01d8a3"

URI_x86_64_v2_rust-bytemuck+min_const_generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+min_const_generics-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+min_const_generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+min_const_generics-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+min_const_generics-devel.sha256sum] = "c70dabec89c37eea098a9789bed1a26eeebde6ff7f3671ff3edbf4bc3815dca3"

URI_x86_64_v2_rust-bytemuck+must_cast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+must_cast-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+must_cast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+must_cast-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+must_cast-devel.sha256sum] = "f07e2d95f2d3c17d6a501702be1c8751420b41d6181d40b1ce416d7090918dcb"

URI_x86_64_v2_rust-bytemuck+must_cast_extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+must_cast_extra-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+must_cast_extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+must_cast_extra-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+must_cast_extra-devel.sha256sum] = "28dc6121d9b233e113fece6d17b93486f4702c6c2ee1f5c874132a4c48ed73c1"

URI_x86_64_v2_rust-bytemuck+nightly_stdsimd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+nightly_stdsimd-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+nightly_stdsimd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+nightly_stdsimd-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+nightly_stdsimd-devel.sha256sum] = "783f467daade560137ac7900e00b02463fd45fc491468e3e976e6727ca6a7b70"

URI_x86_64_v2_rust-bytemuck+track_caller-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+track_caller-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+track_caller-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+track_caller-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+track_caller-devel.sha256sum] = "12fed898d06a9d4fa3978ccabbf589c7c09b0c9be485ff9cb4196cac6e289b3d"

URI_x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+transparentwrapper_extra-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel.sha256sum] = "69f0e990ccb0b3d827ca8128354769eb8646b4ae4c03dc29caca3304457bb7bb"

URI_x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+unsound_ptr_pod_impl-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel.sha256sum] = "c711451c7723081798007b765a200fa529c7be34f0fdfe9ab0496b08fed00479"

URI_x86_64_v2_rust-bytemuck+zeroable_atomics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+zeroable_atomics-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+zeroable_atomics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+zeroable_atomics-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+zeroable_atomics-devel.sha256sum] = "472952eed4429cb0f7d4109fe5ea1a74e216b7d0a3658c7e2804b244e975e2fb"

URI_x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+zeroable_maybe_uninit-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel.sha256sum] = "b1ceaa518d63be0a2c21f5489ee17d7c878aeeb0d7679b21611dd5248ced5756"

URI_x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+zeroable_unwind_fn-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel.sha256sum] = "9cdc716ca0fa1f3f8c6988ebf1d08f8f9a970a319b568f47afd2f9939dcdda6c"

URI_x86_64_v2_rust-bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck-devel-1.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck-devel}"
SRC_URI[x86_64_v2_rust-bytemuck-devel.sha256sum] = "8e8646f2edb52af5215659c402551aaf026924e4db782e40f8219c4e7e6fc642"

URI_aarch64_rust-bytemuck+aarch64_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+aarch64_simd-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+aarch64_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+aarch64_simd-devel}"
SRC_URI[aarch64_rust-bytemuck+aarch64_simd-devel.sha256sum] = "deb151a1524b0944a5fcdaef8248d9927aac590b50743803dffd1b514669f77e"

URI_aarch64_rust-bytemuck+align_offset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+align_offset-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+align_offset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+align_offset-devel}"
SRC_URI[aarch64_rust-bytemuck+align_offset-devel.sha256sum] = "9de6b3d9abd4f3812bd05fc8ab82e4516f5bcda31869654d3752f2546cd1e42f"

URI_aarch64_rust-bytemuck+alloc_uninit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+alloc_uninit-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+alloc_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+alloc_uninit-devel}"
SRC_URI[aarch64_rust-bytemuck+alloc_uninit-devel.sha256sum] = "0eedb3cb19a40be05df7b5586825a9a1721c25fa5a3b49b9758eb55dc8d36b73"

URI_aarch64_rust-bytemuck+avx512_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+avx512_simd-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+avx512_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+avx512_simd-devel}"
SRC_URI[aarch64_rust-bytemuck+avx512_simd-devel.sha256sum] = "47e37697fca66680c9208f337def011d20b4487bb385db680ee5aeefb81b2d4a"

URI_aarch64_rust-bytemuck+bytemuck_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+bytemuck_derive-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+bytemuck_derive-devel}"
SRC_URI[aarch64_rust-bytemuck+bytemuck_derive-devel.sha256sum] = "9746f0eb933a0327f43ab558434e43fa1a2d052f383092e5f7a6f45779bb97ac"

URI_aarch64_rust-bytemuck+const_zeroed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+const_zeroed-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+const_zeroed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+const_zeroed-devel}"
SRC_URI[aarch64_rust-bytemuck+const_zeroed-devel.sha256sum] = "cbb071f462cd01ee8789861169e6d454d7238b4d2ffaad116ae9f83606b6573b"

URI_aarch64_rust-bytemuck+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+default-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+default-devel}"
SRC_URI[aarch64_rust-bytemuck+default-devel.sha256sum] = "59ee90c4d15e15a3f3605379941f7881dbe824b52b9ba92f7bd5c0d0772a4f48"

URI_aarch64_rust-bytemuck+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+derive-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+derive-devel}"
SRC_URI[aarch64_rust-bytemuck+derive-devel.sha256sum] = "a4a65968d88fc28f278bce0abb9ca33d79a154054aee3abe6c22ded874cdc0cf"

URI_aarch64_rust-bytemuck+extern_crate_alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+extern_crate_alloc-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+extern_crate_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+extern_crate_alloc-devel}"
SRC_URI[aarch64_rust-bytemuck+extern_crate_alloc-devel.sha256sum] = "98dad9aadb7f4ebbe1672daa87895ba168c6dc982ff9a31e1eb385d9c3156d71"

URI_aarch64_rust-bytemuck+extern_crate_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+extern_crate_std-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+extern_crate_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+extern_crate_std-devel}"
SRC_URI[aarch64_rust-bytemuck+extern_crate_std-devel.sha256sum] = "be4b07dd724a1c3efecaa6a2479de2caf2ca6a343ff169d5b61577198b8b83fb"

URI_aarch64_rust-bytemuck+impl_core_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+impl_core_error-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+impl_core_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+impl_core_error-devel}"
SRC_URI[aarch64_rust-bytemuck+impl_core_error-devel.sha256sum] = "f03c899de877deea51cd0476efcfb010f404dd968804f8399d30a42bfae24d51"

URI_aarch64_rust-bytemuck+min_const_generics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+min_const_generics-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+min_const_generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+min_const_generics-devel}"
SRC_URI[aarch64_rust-bytemuck+min_const_generics-devel.sha256sum] = "61ccf95f9070d34b8261b392a069f70e892afd5b88ad08f4cf0d40310a3bf7ac"

URI_aarch64_rust-bytemuck+must_cast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+must_cast-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+must_cast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+must_cast-devel}"
SRC_URI[aarch64_rust-bytemuck+must_cast-devel.sha256sum] = "54f32194630cb03fa2cf5e10e624824a79b370ca8399c5b44c7d2f9e542306dc"

URI_aarch64_rust-bytemuck+must_cast_extra-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+must_cast_extra-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+must_cast_extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+must_cast_extra-devel}"
SRC_URI[aarch64_rust-bytemuck+must_cast_extra-devel.sha256sum] = "0e929884a5e67c1ccdcfc6743d492b961f9924060b35d585a2070d9923b44d22"

URI_aarch64_rust-bytemuck+nightly_stdsimd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+nightly_stdsimd-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+nightly_stdsimd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+nightly_stdsimd-devel}"
SRC_URI[aarch64_rust-bytemuck+nightly_stdsimd-devel.sha256sum] = "2f6a6ba8e97aca0f06e49994652e2b75b4305d1fdc3c752f4c602f78f4216f73"

URI_aarch64_rust-bytemuck+track_caller-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+track_caller-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+track_caller-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+track_caller-devel}"
SRC_URI[aarch64_rust-bytemuck+track_caller-devel.sha256sum] = "59ea842a29e493557540be47bd45ea8cb11b1a51aa0d81ddf811d8d89957e56f"

URI_aarch64_rust-bytemuck+transparentwrapper_extra-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+transparentwrapper_extra-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+transparentwrapper_extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+transparentwrapper_extra-devel}"
SRC_URI[aarch64_rust-bytemuck+transparentwrapper_extra-devel.sha256sum] = "d286c8a3f89bb30cab550a86e14907217d64f18b54d64a658ef2af18de9cfbdd"

URI_aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+unsound_ptr_pod_impl-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel}"
SRC_URI[aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel.sha256sum] = "9bc39baba552cd2f6c9b7f8bf0651f3af2926a1661ef641503b57dde76c39504"

URI_aarch64_rust-bytemuck+zeroable_atomics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+zeroable_atomics-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+zeroable_atomics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+zeroable_atomics-devel}"
SRC_URI[aarch64_rust-bytemuck+zeroable_atomics-devel.sha256sum] = "bb8e64df526877ea911f0059fefc15f96e1ba77e02f2b54d0dece90a4a73be02"

URI_aarch64_rust-bytemuck+zeroable_maybe_uninit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+zeroable_maybe_uninit-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+zeroable_maybe_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+zeroable_maybe_uninit-devel}"
SRC_URI[aarch64_rust-bytemuck+zeroable_maybe_uninit-devel.sha256sum] = "e12324013d36c756b479ef65f5ec5dcf03b0af0ad00df1af6175c35bae6678b0"

URI_aarch64_rust-bytemuck+zeroable_unwind_fn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+zeroable_unwind_fn-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck+zeroable_unwind_fn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+zeroable_unwind_fn-devel}"
SRC_URI[aarch64_rust-bytemuck+zeroable_unwind_fn-devel.sha256sum] = "af80d7f50959c8b27bc1f05113557332ae288db5516f718d099ed8ca00e44402"

URI_aarch64_rust-bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck-devel-1.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck-devel}"
SRC_URI[aarch64_rust-bytemuck-devel.sha256sum] = "a1c5d367ddcc8f40a225cbba99cdd57ea92c9a04fd5c0587b06907bbccec236e"

RDEPENDS:rust-bytemuck+aarch64_simd-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+align_offset-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+alloc_uninit-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+avx512_simd-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+bytemuck_derive-devel = " \
 cargo \
 rust-bytemuck-devel \
 rust-bytemuck_derive+default-devel \
 "
RDEPENDS:rust-bytemuck+const_zeroed-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+default-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+derive-devel = " \
 cargo \
 rust-bytemuck+bytemuck_derive-devel \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+extern_crate_alloc-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+extern_crate_std-devel = " \
 cargo \
 rust-bytemuck+extern_crate_alloc-devel \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+impl_core_error-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+min_const_generics-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+must_cast-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+must_cast_extra-devel = " \
 cargo \
 rust-bytemuck+must_cast-devel \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+nightly_stdsimd-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+track_caller-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+transparentwrapper_extra-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+unsound_ptr_pod_impl-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+zeroable_atomics-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+zeroable_maybe_uninit-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+zeroable_unwind_fn-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck-devel = " \
 cargo \
 "
