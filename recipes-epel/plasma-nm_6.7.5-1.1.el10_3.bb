# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-nm"
PV = "6.7.5"
PR = "1.1.el10_3"
PACKAGES = " \
 plasma-nm \
 plasma-nm-l2tp \
 plasma-nm-openconnect \
 plasma-nm-openswan \
 plasma-nm-openvpn \
 plasma-nm-pptp \
 plasma-nm-strongswan \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-nm-6.7.5-1.1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3f74400d58d76d278c3f024acfc7e24ba8316948ed10471477ccc0df366609e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-6.7.5-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm;unpack=0"
SRC_URI[x86_64_v2_plasma-nm.sha256sum] = "2be22059f213a3dfd131a10be076c4e184a87d4a89d6f0e7f0724a68ba7fa22b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-l2tp-6.7.5-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-l2tp;unpack=0"
SRC_URI[x86_64_v2_plasma-nm-l2tp.sha256sum] = "3ebef3ec6b781ce3edcd843f309d696e2343705f3fb1f4b5776b8a5a0dbb8b77"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openconnect-6.7.5-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openconnect;unpack=0"
SRC_URI[x86_64_v2_plasma-nm-openconnect.sha256sum] = "af923b69624e01a8b61ec665c49eb5aefbb9c495885f5f2f8cd318e6cc205fa0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openswan-6.7.5-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openswan;unpack=0"
SRC_URI[x86_64_v2_plasma-nm-openswan.sha256sum] = "b9d87802b33caefee94bd2c35f5eb2ae86e1073bdaa4912237a42f19728e9ad4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openvpn-6.7.5-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openvpn;unpack=0"
SRC_URI[x86_64_v2_plasma-nm-openvpn.sha256sum] = "91e27f8a2d842c95b696b1830e28d850f232b8d2594ebc8170cff7b6d2028ba5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-pptp-6.7.5-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-pptp;unpack=0"
SRC_URI[x86_64_v2_plasma-nm-pptp.sha256sum] = "73d1668fd0fa32bd422b37170d01a8d0285be537c4a900816850a4e6ee4d7b9b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-strongswan-6.7.5-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-strongswan;unpack=0"
SRC_URI[x86_64_v2_plasma-nm-strongswan.sha256sum] = "35e01061ef5504972dc5f62ef938077c5cda8c8a6d4d8310618ee2b303fa59ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-6.7.5-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-nm;unpack=0"
SRC_URI[aarch64_plasma-nm.sha256sum] = "332f276ee5de719bd79963502a9324415f53eeca4844acb925a7de38942b3797"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-l2tp-6.7.5-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-nm-l2tp;unpack=0"
SRC_URI[aarch64_plasma-nm-l2tp.sha256sum] = "4dfa7f9d03a45e5f7c11086bdd90b492318945531cce596f49070f9170ee326f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openconnect-6.7.5-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-nm-openconnect;unpack=0"
SRC_URI[aarch64_plasma-nm-openconnect.sha256sum] = "03c2d42852d00513f8e29b31d2a679af86afb60c63eaa05e2021e49dc5ff7b5a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openswan-6.7.5-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-nm-openswan;unpack=0"
SRC_URI[aarch64_plasma-nm-openswan.sha256sum] = "cf99ba82ee1d06dcf051682eef7144560231c991007ebdc83c93fa917250b325"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openvpn-6.7.5-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-nm-openvpn;unpack=0"
SRC_URI[aarch64_plasma-nm-openvpn.sha256sum] = "a9e04915766aaa066226549cddcdb26571a78940e7899ea263a829a32f0d9be0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-pptp-6.7.5-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-nm-pptp;unpack=0"
SRC_URI[aarch64_plasma-nm-pptp.sha256sum] = "2c4c0cd655515ec55e0c5002f57a254a6770c1f616fae9368234e3afc722962f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-strongswan-6.7.5-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-nm-strongswan;unpack=0"
SRC_URI[aarch64_plasma-nm-strongswan.sha256sum] = "2dc85e5d24c85f3621715c10315290bff98df3f81f821ba08663beaffb22e57e"

RDEPENDS:plasma-nm = " \
 NetworkManager \
 NetworkManager-libnm \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-modemmanager-qt \
 kf6-networkmanager-qt \
 kf6-prison \
 kf6-solid \
 libplasma \
 libstdc++ \
 openssl-libs \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qtkeychain-qt6 \
 "
RDEPENDS:plasma-nm-l2tp = " \
 NetworkManager-l2tp \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-openconnect = " \
 NetworkManager-openconnect \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 openconnect \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:plasma-nm-openswan = " \
 NetworkManager-libreswan \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-openvpn = " \
 NetworkManager-libnm \
 NetworkManager-openvpn \
 glib2 \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-pptp = " \
 NetworkManager-pptp \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-strongswan = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 strongswan \
 "
