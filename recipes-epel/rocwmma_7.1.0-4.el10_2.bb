# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocwmma"
PV = "7.1.0"
PR = "4.el10_2"
PACKAGES:x86_64_v2 = " \
 rocwmma-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocwmma-7.1.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b031b77d0829e3ce47a81bab3d5c9897fd23ba86f501b3609bbd36d4b653d38"

URI_x86_64_v2_rocwmma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocwmma-devel-7.1.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocwmma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocwmma-devel}"
SRC_URI[x86_64_v2_rocwmma-devel.sha256sum] = "59634fa31908e0486579c343881932ed69a472f3c5804d140d2a8ac30289521a"

RDEPENDS:rocwmma-devel = " \
 "
