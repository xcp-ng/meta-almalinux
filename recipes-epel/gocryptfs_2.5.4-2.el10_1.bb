# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gocryptfs"
PV = "2.5.4"
PR = "2.el10_1"
PACKAGES = " \
 gocryptfs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gocryptfs-2.5.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c13f9358c8c2eb67d18cb6874dd5704124465774c304bc9f3b242cfbafc0a832"

URI_x86_64_v2_gocryptfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gocryptfs-2.5.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gocryptfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gocryptfs}"
SRC_URI[x86_64_v2_gocryptfs.sha256sum] = "148d08feeace547c22cfad4ca0d1f6d5a90c8706182325c9c7cdb64eb65141e0"

URI_aarch64_gocryptfs = "${EPEL_MIRROR}/aarch64/Packages/g/gocryptfs-2.5.4-2.el10_1.aarch64.rpm;name=aarch64_gocryptfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gocryptfs}"
SRC_URI[aarch64_gocryptfs.sha256sum] = "ab873f64b15a32e711277d982e5b0d7a911d7e5fdf850c8e50b9fd804712cd14"

RDEPENDS:gocryptfs = " \
 fuse3 \
 glibc \
 openssl-libs \
 "
