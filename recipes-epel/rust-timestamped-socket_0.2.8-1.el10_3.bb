# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-timestamped-socket"
PV = "0.2.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-timestamped-socket+default-devel \
 rust-timestamped-socket+serde-devel \
 rust-timestamped-socket-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-timestamped-socket-0.2.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88a226715d27dccccbc5461e5f7aa58116f16edd19b06cb066ec6d272735e845"

URI_x86_64_v2_rust-timestamped-socket+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-timestamped-socket+default-devel-0.2.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-timestamped-socket+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-timestamped-socket+default-devel}"
SRC_URI[x86_64_v2_rust-timestamped-socket+default-devel.sha256sum] = "11e2d99f077dd4ef3f32684d96c1416d1574694c0d75a0d3989b3f06b614b899"

URI_x86_64_v2_rust-timestamped-socket+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-timestamped-socket+serde-devel-0.2.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-timestamped-socket+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-timestamped-socket+serde-devel}"
SRC_URI[x86_64_v2_rust-timestamped-socket+serde-devel.sha256sum] = "c886f9178302fe06e16a416d97ba1a1482d9c545c0ad9d42eb025624b41829ba"

URI_x86_64_v2_rust-timestamped-socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-timestamped-socket-devel-0.2.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-timestamped-socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-timestamped-socket-devel}"
SRC_URI[x86_64_v2_rust-timestamped-socket-devel.sha256sum] = "2472e9f926940f179937950e9420a1735889016030dbfd14d20ce370e3bb4ef9"

URI_aarch64_rust-timestamped-socket+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-timestamped-socket+default-devel-0.2.8-1.el10_3.noarch.rpm;name=aarch64_rust-timestamped-socket+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-timestamped-socket+default-devel}"
SRC_URI[aarch64_rust-timestamped-socket+default-devel.sha256sum] = "ad650f7e921bf33c1683d173741092302a165a1331e39be638df40d78312e56c"

URI_aarch64_rust-timestamped-socket+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-timestamped-socket+serde-devel-0.2.8-1.el10_3.noarch.rpm;name=aarch64_rust-timestamped-socket+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-timestamped-socket+serde-devel}"
SRC_URI[aarch64_rust-timestamped-socket+serde-devel.sha256sum] = "58a70f561d7aa7b7dba7925ef477e7a3e117a50c1e81516bd1d7bc22dc7ea4b2"

URI_aarch64_rust-timestamped-socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-timestamped-socket-devel-0.2.8-1.el10_3.noarch.rpm;name=aarch64_rust-timestamped-socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-timestamped-socket-devel}"
SRC_URI[aarch64_rust-timestamped-socket-devel.sha256sum] = "691ce42fc9df2479e2d8f428693d8e1c23d8659c3af147f02579aa581253f693"

RDEPENDS:rust-timestamped-socket+default-devel = " \
 cargo \
 rust-timestamped-socket+serde-devel \
 rust-timestamped-socket-devel \
 "
RDEPENDS:rust-timestamped-socket+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-timestamped-socket-devel \
 "
RDEPENDS:rust-timestamped-socket-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 rust-tokio+default-devel \
 rust-tokio+net-devel \
 rust-tokio+time-devel \
 rust-tracing+log-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
