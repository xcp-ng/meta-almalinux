# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yamllint"
PV = "1.37.1"
PR = "1.el10_2"
PACKAGES = " \
 yamllint \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yamllint-1.37.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b47c83fbd98755bb7b8e3e4dda3b84ddc65048936839fbade7f53f1896a3a02b"

URI_x86_64_v2_yamllint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yamllint-1.37.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_yamllint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yamllint}"
SRC_URI[x86_64_v2_yamllint.sha256sum] = "3461420ca1464e6161ca93b3faab5d2ac96c39402ad45f82081a600258406203"

URI_aarch64_yamllint = "${EPEL_MIRROR}/aarch64/Packages/y/yamllint-1.37.1-1.el10_2.noarch.rpm;name=aarch64_yamllint;unpack=0"
SRC_URI:append = " ${URI_aarch64_yamllint}"
SRC_URI[aarch64_yamllint.sha256sum] = "9ee200810b1df936581b10b0ad469f03dc38e16a347e12faa16c09f7bd293c81"

RDEPENDS:yamllint = " \
 python3 \
 python3-pathspec \
 python3-pyyaml \
 "
