# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sec1"
PV = "0.7.3"
PR = "7.el10_2"
PACKAGES = " \
 rust-sec1+alloc-devel \
 rust-sec1+default-devel \
 rust-sec1+der-devel \
 rust-sec1+pem-devel \
 rust-sec1+pkcs8-devel \
 rust-sec1+point-devel \
 rust-sec1+serde-devel \
 rust-sec1+std-devel \
 rust-sec1+subtle-devel \
 rust-sec1+zeroize-devel \
 rust-sec1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sec1-0.7.3-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42018fc013b367ed65220943ac0a86b73340f604334417518e69f82b351f2c7a"

URI_x86_64_v2_rust-sec1+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+alloc-devel-0.7.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+alloc-devel}"
SRC_URI[x86_64_v2_rust-sec1+alloc-devel.sha256sum] = "fcbab4ce06fdd06e94f065c2037339a3cc72c48fb7f63e1b029da9f4da324f75"

URI_x86_64_v2_rust-sec1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+default-devel-0.7.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+default-devel}"
SRC_URI[x86_64_v2_rust-sec1+default-devel.sha256sum] = "025b2bae99102db5eae08bffd88877ae9900c16da47811d7d2dffdce83f2c3ab"

URI_x86_64_v2_rust-sec1+der-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+der-devel-0.7.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+der-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+der-devel}"
SRC_URI[x86_64_v2_rust-sec1+der-devel.sha256sum] = "dc597d9bfc5cc44fd6753759f9c82a7cc10e716976ff226cc8109c5905ea550f"

URI_x86_64_v2_rust-sec1+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+pem-devel-0.7.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+pem-devel}"
SRC_URI[x86_64_v2_rust-sec1+pem-devel.sha256sum] = "16ec79261d6f979b0cfc3ff1681063750e45d55b3e8caf0a597163bf667be8a2"

URI_x86_64_v2_rust-sec1+pkcs8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+pkcs8-devel-0.7.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+pkcs8-devel}"
SRC_URI[x86_64_v2_rust-sec1+pkcs8-devel.sha256sum] = "cb862905f3258668e6d6ae622e50ff60e20de9d01c18cd46ee3a54d006ffd4fa"

URI_x86_64_v2_rust-sec1+point-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+point-devel-0.7.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+point-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+point-devel}"
SRC_URI[x86_64_v2_rust-sec1+point-devel.sha256sum] = "1f41958ec17da71473e8bd26ec8c1eb66db63f9195ee563e808c59d7f96dbc73"

URI_x86_64_v2_rust-sec1+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+serde-devel-0.7.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+serde-devel}"
SRC_URI[x86_64_v2_rust-sec1+serde-devel.sha256sum] = "b76bde51e88bae8f1769dfd7353397a52180f7a6feb4362c16f2bd825f98bff1"

URI_x86_64_v2_rust-sec1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+std-devel-0.7.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+std-devel}"
SRC_URI[x86_64_v2_rust-sec1+std-devel.sha256sum] = "5319cb0bc100816364a68846b618e56c27ab1098d0a405e8cf729a5c57e2d7c5"

URI_x86_64_v2_rust-sec1+subtle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+subtle-devel-0.7.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+subtle-devel}"
SRC_URI[x86_64_v2_rust-sec1+subtle-devel.sha256sum] = "e1ae0c8f0ffce02e364d7fad1d03ec4803d25d3f6994159b4ffabcfe1f872cfa"

URI_x86_64_v2_rust-sec1+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+zeroize-devel-0.7.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+zeroize-devel}"
SRC_URI[x86_64_v2_rust-sec1+zeroize-devel.sha256sum] = "11c7b590621c160758f96a79dff3ac8ca60ee768382feb6a615c94b7555e76c7"

URI_x86_64_v2_rust-sec1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1-devel-0.7.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1-devel}"
SRC_URI[x86_64_v2_rust-sec1-devel.sha256sum] = "ce8b2ce76f2151ccdf541589db9e2921125fcef789bd640ef9ed4befbb0c04ce"

URI_aarch64_rust-sec1+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+alloc-devel-0.7.3-7.el10_2.noarch.rpm;name=aarch64_rust-sec1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+alloc-devel}"
SRC_URI[aarch64_rust-sec1+alloc-devel.sha256sum] = "fce468112dec7de9020544f2d7c888effae1bbdbb4644e6f0a2f9d53c3103cc2"

URI_aarch64_rust-sec1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+default-devel-0.7.3-7.el10_2.noarch.rpm;name=aarch64_rust-sec1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+default-devel}"
SRC_URI[aarch64_rust-sec1+default-devel.sha256sum] = "ff91fd64db147bc66a2c59c6f99164de59dde516687ba116dffddabe509a03d6"

URI_aarch64_rust-sec1+der-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+der-devel-0.7.3-7.el10_2.noarch.rpm;name=aarch64_rust-sec1+der-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+der-devel}"
SRC_URI[aarch64_rust-sec1+der-devel.sha256sum] = "1b559203bb4f4a0b31c1cf4637427e322478e36e4784ad17a928ace37dab41ac"

URI_aarch64_rust-sec1+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+pem-devel-0.7.3-7.el10_2.noarch.rpm;name=aarch64_rust-sec1+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+pem-devel}"
SRC_URI[aarch64_rust-sec1+pem-devel.sha256sum] = "be489e4506a021ef765af3f672e4efa4e1b4cff560863be19ddccd868bc109b3"

URI_aarch64_rust-sec1+pkcs8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+pkcs8-devel-0.7.3-7.el10_2.noarch.rpm;name=aarch64_rust-sec1+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+pkcs8-devel}"
SRC_URI[aarch64_rust-sec1+pkcs8-devel.sha256sum] = "63bf87544c75767309d3070ebce1550f31c08bdf9e5b2c95dcca82e5358ed7f0"

URI_aarch64_rust-sec1+point-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+point-devel-0.7.3-7.el10_2.noarch.rpm;name=aarch64_rust-sec1+point-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+point-devel}"
SRC_URI[aarch64_rust-sec1+point-devel.sha256sum] = "e6c6e8116b701a74f0387196108c82a12c40d4ae59e083ffa9fb4a96d12594c8"

URI_aarch64_rust-sec1+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+serde-devel-0.7.3-7.el10_2.noarch.rpm;name=aarch64_rust-sec1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+serde-devel}"
SRC_URI[aarch64_rust-sec1+serde-devel.sha256sum] = "ca560d21c05cd9b1dd64cc3748241123342823e5d3e4bdad5b3a87c3cd9b94ec"

URI_aarch64_rust-sec1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+std-devel-0.7.3-7.el10_2.noarch.rpm;name=aarch64_rust-sec1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+std-devel}"
SRC_URI[aarch64_rust-sec1+std-devel.sha256sum] = "085c772d7c73ea972e8a0911495344643bb71cbfdc70f6c637be1ec25faf9de4"

URI_aarch64_rust-sec1+subtle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+subtle-devel-0.7.3-7.el10_2.noarch.rpm;name=aarch64_rust-sec1+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+subtle-devel}"
SRC_URI[aarch64_rust-sec1+subtle-devel.sha256sum] = "37118c6335ba200b00faa61e8fce28593f14d29815a21fe31fef0193084f0513"

URI_aarch64_rust-sec1+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+zeroize-devel-0.7.3-7.el10_2.noarch.rpm;name=aarch64_rust-sec1+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+zeroize-devel}"
SRC_URI[aarch64_rust-sec1+zeroize-devel.sha256sum] = "c4b4bb7b7f4f52ea56e2a1a82cd5c5a78fdd72889cd58df21fea19f316759d1d"

URI_aarch64_rust-sec1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1-devel-0.7.3-7.el10_2.noarch.rpm;name=aarch64_rust-sec1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1-devel}"
SRC_URI[aarch64_rust-sec1-devel.sha256sum] = "d11feed3734fcf7c87f692a22c54f0b7e1a9d5dc72c3ef5c37d0f93a9c423ed9"

RDEPENDS:rust-sec1+alloc-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-der+default-devel \
 rust-der+oid-devel \
 rust-pkcs8+alloc-devel \
 rust-pkcs8-devel \
 rust-sec1-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-sec1+default-devel = " \
 cargo \
 rust-sec1+der-devel \
 rust-sec1+point-devel \
 rust-sec1-devel \
 "
RDEPENDS:rust-sec1+der-devel = " \
 cargo \
 rust-der+default-devel \
 rust-der+oid-devel \
 rust-sec1+zeroize-devel \
 rust-sec1-devel \
 "
RDEPENDS:rust-sec1+pem-devel = " \
 cargo \
 rust-der+default-devel \
 rust-der+oid-devel \
 rust-der+pem-devel \
 rust-pkcs8+pem-devel \
 rust-pkcs8-devel \
 rust-sec1+alloc-devel \
 rust-sec1-devel \
 "
RDEPENDS:rust-sec1+pkcs8-devel = " \
 cargo \
 rust-pkcs8-devel \
 rust-sec1-devel \
 "
RDEPENDS:rust-sec1+point-devel = " \
 cargo \
 rust-base16ct-devel \
 rust-generic-array-devel \
 rust-sec1-devel \
 "
RDEPENDS:rust-sec1+serde-devel = " \
 cargo \
 rust-sec1-devel \
 rust-serdect+alloc-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-sec1+std-devel = " \
 cargo \
 rust-der+default-devel \
 rust-der+oid-devel \
 rust-der+std-devel \
 rust-sec1+alloc-devel \
 rust-sec1-devel \
 "
RDEPENDS:rust-sec1+subtle-devel = " \
 cargo \
 rust-sec1-devel \
 rust-subtle-devel \
 "
RDEPENDS:rust-sec1+zeroize-devel = " \
 cargo \
 rust-der+default-devel \
 rust-der+oid-devel \
 rust-der+zeroize-devel \
 rust-sec1-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-sec1-devel = " \
 cargo \
 rust \
 "
