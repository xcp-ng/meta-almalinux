# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytecheck_derive"
PV = "0.8.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-bytecheck_derive+default-devel \
 rust-bytecheck_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytecheck_derive-0.8.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc2622e1a2e2416c651e9146acc38b03b8845f8bee9d2f784416454d36f7e771"

URI_x86_64_v2_rust-bytecheck_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck_derive+default-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck_derive+default-devel}"
SRC_URI[x86_64_v2_rust-bytecheck_derive+default-devel.sha256sum] = "1457592a9171363867de2da31bd660bc9efa8514c2d51901b4dc5938f8ab63b4"

URI_x86_64_v2_rust-bytecheck_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck_derive-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck_derive-devel}"
SRC_URI[x86_64_v2_rust-bytecheck_derive-devel.sha256sum] = "b53404168c5eb8c06a5d9588ef82462dd1c219d28f041ad664da425d26baa1c5"

URI_aarch64_rust-bytecheck_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck_derive+default-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-bytecheck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck_derive+default-devel}"
SRC_URI[aarch64_rust-bytecheck_derive+default-devel.sha256sum] = "7b5bad01af6aae0b0444bff419ae50fd19e49bd456e4be088a3c7c36d3adf657"

URI_aarch64_rust-bytecheck_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck_derive-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-bytecheck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck_derive-devel}"
SRC_URI[aarch64_rust-bytecheck_derive-devel.sha256sum] = "a405e67218996f1221810a6b2926a8085691f604e0a42616afecc9aec7ff4c62"

RDEPENDS:rust-bytecheck_derive+default-devel = " \
 cargo \
 rust-bytecheck_derive-devel \
 "
RDEPENDS:rust-bytecheck_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
