# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsemanage"
PV = "3.10"
PR = "1.el10"
PACKAGES = " \
 libsemanage \
 libsemanage-devel \
 python3-libsemanage \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libsemanage-3.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9fb43a43fcbc3b72596f71de02a682bd06f4c251c98e193ccca6046084062916"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsemanage-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsemanage;unpack=0"
SRC_URI[x86_64_v2_libsemanage.sha256sum] = "2c88328e2e637bb83b11ab4c357f5087bd1b1b24897db66beb998dd120746819"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsemanage-devel-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsemanage-devel;unpack=0"
SRC_URI[x86_64_v2_libsemanage-devel.sha256sum] = "52dfa0b318494408c548ed67ca98a56dc1e49d0761e31e74a475d72f5692d84e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libsemanage-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libsemanage;unpack=0"
SRC_URI[x86_64_v2_python3-libsemanage.sha256sum] = "50030bd752b0af84c9429e45256d376025f426a3378f96773e4dfcc8b731ea38"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsemanage-3.10-1.el10.aarch64.rpm;name=aarch64_libsemanage;unpack=0"
SRC_URI[aarch64_libsemanage.sha256sum] = "c4a3093844c10526f41b549193f6ab7d84e6ed6a6e69834f1b87443dd1db8529"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsemanage-devel-3.10-1.el10.aarch64.rpm;name=aarch64_libsemanage-devel;unpack=0"
SRC_URI[aarch64_libsemanage-devel.sha256sum] = "8fe1f24fb2689c362050bf92b643c127c751e0fbcf6059a0bccb00c6624e7791"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libsemanage-3.10-1.el10.aarch64.rpm;name=aarch64_python3-libsemanage;unpack=0"
SRC_URI[aarch64_python3-libsemanage.sha256sum] = "8f88dcb16fce935c0e34a8ce64c2e35c885ca77648d3b9a1264b469ba51a13eb"

RDEPENDS:libsemanage = " \
 audit-libs \
 bzip2-libs \
 glibc \
 libselinux \
 libsepol \
 "
RDEPENDS:libsemanage-devel = " \
 libselinux-devel \
 libsemanage \
 libsepol-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libsemanage = " \
 glibc \
 libsemanage \
 python3 \
 python3-libselinux \
 "
