# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uuid"
PV = "1.26.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-uuid+arbitrary-devel \
 rust-uuid+atomic-devel \
 rust-uuid+bytemuck-devel \
 rust-uuid+default-devel \
 rust-uuid+fast-rng-devel \
 rust-uuid+md5-devel \
 rust-uuid+rng-devel \
 rust-uuid+rng-getrandom-devel \
 rust-uuid+rng-rand-devel \
 rust-uuid+serde-devel \
 rust-uuid+sha1-devel \
 rust-uuid+slog-devel \
 rust-uuid+std-devel \
 rust-uuid+v1-devel \
 rust-uuid+v3-devel \
 rust-uuid+v4-devel \
 rust-uuid+v5-devel \
 rust-uuid+v6-devel \
 rust-uuid+v7-devel \
 rust-uuid+v8-devel \
 rust-uuid-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-uuid-1.26.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6966d6418c0921ebdc4083bf382966161dabf67f3ea66ee836e46a7c3584a065"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+arbitrary-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+arbitrary-devel.sha256sum] = "c45f197085a30043282341ecdc1f3abaed0c3a030996fd92ae2baa480ed8e4fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+atomic-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+atomic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+atomic-devel.sha256sum] = "32597a7dc3e8d530f09e316de76441500774500fe9520dcf1c49917075c81c17"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+bytemuck-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+bytemuck-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+bytemuck-devel.sha256sum] = "e5890ac53107f99be8e607bf49ae99ef5cdd33848d0016d40f4433c14b7eedb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+default-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+default-devel.sha256sum] = "66dc13f25b360719f857dc73b6955df15c69bc0a06de30942f5a256f511cf021"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+fast-rng-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+fast-rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+fast-rng-devel.sha256sum] = "2548b9b6874e75732c128da653aea48c4b898674402c1180856968ab1ade6dbe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+md5-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+md5-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+md5-devel.sha256sum] = "218cbf3fcf8878e0757e7c5a9889553b410296bdee0112454531e52f3314c2e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+rng-devel.sha256sum] = "2528596d6385de7631809aa27fac14f7d8df692ad67872072a5cb544d1ef91b0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-getrandom-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-getrandom-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+rng-getrandom-devel.sha256sum] = "eaff0248f2d3fc8b09300ba03346b4da334fed1e5d6e8ab5ea06e1475bd1a178"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-rand-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-rand-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+rng-rand-devel.sha256sum] = "f45d22c042e394cbc3d1b865f030757b6685279bd5bb04a1c88a920958609c3c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+serde-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+serde-devel.sha256sum] = "19715084e23e0cc3bc7cffed981f7f9427a4a4e4d203e6ffc08b08ba74ba4304"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+sha1-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+sha1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+sha1-devel.sha256sum] = "7457f0815e13e03042c00b3356250823f2b264608baae39fe324f273d4176d4f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+slog-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+slog-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+slog-devel.sha256sum] = "87077a9170b804536dc52f181b8803b07fbea5395b4c9bdca9bc1842b37106b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+std-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+std-devel.sha256sum] = "8f4aefc07b6ca631403481cb6cb0becfd44ae4c8741dce4feb658feaf5c50a84"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v1-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+v1-devel.sha256sum] = "60e31a8a6d30a887f2d573ceb0d8dbee2c777c6350934a561a0d2fa1ee149ff0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v3-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v3-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+v3-devel.sha256sum] = "1321667fd93b9422801a3d068074b1b51860bd2a3e397e833fe3f371f489bcbe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v4-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v4-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+v4-devel.sha256sum] = "1f294d18660edf9188604e6e18b533e1d5e1e601327b05ae4c6f85a9040921b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v5-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v5-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+v5-devel.sha256sum] = "1a1acbce3adc85214d36772bf8ca60d74edde3de2f833b9c20c64e1a982bec91"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v6-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v6-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+v6-devel.sha256sum] = "a8d4e093e26346b853374ef3dbf398e6ca3eaa91959c25bbeb8d1490eae6a9ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v7-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v7-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+v7-devel.sha256sum] = "688b640f23df8ce947f8b63d4dae234ff076ffa3d085c89412fd6e0b0f1a81db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v8-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v8-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+v8-devel.sha256sum] = "c5174c27249e22ae8901dc032ec3a8feba8bd857b9becd12dd943c0bb7affba8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid-devel-1.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid-devel.sha256sum] = "11e042016e32ecc8b4d4fedb97163b6b7e48fdbb5711176e0023598f8fa17c7b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+arbitrary-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+arbitrary-devel.sha256sum] = "a3c272b466a444cbaf4767c66b370e51a56ccfdc00ae7d83372b03d96b3781a5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+atomic-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+atomic-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+atomic-devel.sha256sum] = "a1e0933c37952e0814872d797e4909f78b9341936f1c8553090f0c6dd4468a44"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+bytemuck-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+bytemuck-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+bytemuck-devel.sha256sum] = "45081e03182a7aca1579719d80b4bdcbb86b19a4eed40827576f7a87e77f59e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+default-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+default-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+default-devel.sha256sum] = "272e8de3cc51aa6785427c896583f935bc6f788526ed3681c84f952405ce3178"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+fast-rng-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+fast-rng-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+fast-rng-devel.sha256sum] = "40289e5e7b41e42f35095db1ea27c4c4ad813463517eadd815f71d2a46d49a48"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+md5-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+md5-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+md5-devel.sha256sum] = "a4930a70a445682bdb9a2de0f50e6bd93dff5ceae8a696aa13bd61949f3ce2b2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+rng-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+rng-devel.sha256sum] = "da342f462cf0028a79325ce61f5e1e9e1bf83819266fabb30bb4b9ad8c8bbd40"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-getrandom-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+rng-getrandom-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+rng-getrandom-devel.sha256sum] = "41005b7880c4b250ad340f48cebad76cba211f5dd5dee22f4fdf24676a8e7209"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-rand-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+rng-rand-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+rng-rand-devel.sha256sum] = "ba39de15943ce4e9b63d231404e883b426de3448e908746d38baa14f85d12b74"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+serde-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+serde-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+serde-devel.sha256sum] = "0cabf252ef513c520a110113e98f3c96c4663a49863ca451fd78bd9de2013e83"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+sha1-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+sha1-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+sha1-devel.sha256sum] = "7bc5c0dc70528904e4a45c59ddf412bf13e89cedda29b3d922f88ca71eeb99cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+slog-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+slog-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+slog-devel.sha256sum] = "8914958d9103ed8d556bc13c2d059891bd9887b687cc0145c3c5bb3daeefc2e1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+std-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+std-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+std-devel.sha256sum] = "08707636dfa366bf829ccc4f80ab6e434e4f95a9f812d15c9db298e800503365"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v1-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+v1-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+v1-devel.sha256sum] = "33bee23102d30b0b8d28b248c44c7b04029bb9fbdd784f1afa9f7e19aefaccd5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v3-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+v3-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+v3-devel.sha256sum] = "4042fb723f528be6191ad6da684f1a53d1ec302cd5683dfd6ddeb97780100832"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v4-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+v4-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+v4-devel.sha256sum] = "3a47132e811d9e579bc0059c63171d52f7178d2a52bb805c0283df16e2c68ec5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v5-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+v5-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+v5-devel.sha256sum] = "29c30750f7d8a1d5fd1ef79d6eeb7572d822d516ad14bbf7995f9e20635da7d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v6-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+v6-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+v6-devel.sha256sum] = "ae91a60e89ffaebdba3e068a8c58e91c71cf85fac23c5e1100577113dc05eb5b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v7-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+v7-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+v7-devel.sha256sum] = "6ec772c0c457e3ed3f8de6b4c78601ce604c1c5a7a374c0e12c458f42122e537"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v8-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+v8-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+v8-devel.sha256sum] = "ca633186185f5805511748c52e0ea93d87d62278431fd624f184fca54b790b9c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid-devel-1.26.1-1.el10_2.noarch.rpm;name=aarch64_rust-uuid-devel;unpack=0"
SRC_URI[aarch64_rust-uuid-devel.sha256sum] = "d940d9799d9c573526361ec82752afde0b2367fbb125d6ae0fd33fd3dff8e09c"

RDEPENDS:rust-uuid+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+atomic-devel = " \
 cargo \
 rust-atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-bytemuck+derive-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+default-devel = " \
 cargo \
 rust-uuid+std-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+fast-rng-devel = " \
 cargo \
 rust-rand+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+md5-devel = " \
 cargo \
 rust-md-5-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-rand-devel = " \
 cargo \
 rust-rand+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+sha1-devel = " \
 cargo \
 rust-sha1_smol-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+slog-devel = " \
 cargo \
 rust-slog+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+std-devel = " \
 cargo \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v1-devel = " \
 cargo \
 rust-uuid+atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v3-devel = " \
 cargo \
 rust-uuid+md5-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v4-devel = " \
 cargo \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v5-devel = " \
 cargo \
 rust-uuid+sha1-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v6-devel = " \
 cargo \
 rust-uuid+atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v7-devel = " \
 cargo \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v8-devel = " \
 cargo \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid-devel = " \
 cargo \
 rust \
 "
