# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crosstermion"
PV = "0.16.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-crosstermion+async-channel-devel \
 rust-crosstermion+color-devel \
 rust-crosstermion+crossterm-devel \
 rust-crosstermion+default-devel \
 rust-crosstermion+futures-channel-devel \
 rust-crosstermion+futures-core-devel \
 rust-crosstermion+futures-lite-devel \
 rust-crosstermion+input-async-crossterm-devel \
 rust-crosstermion+input-async-devel \
 rust-crosstermion+nu-ansi-term-devel \
 rust-crosstermion+tui-crossterm-backend-devel \
 rust-crosstermion+tui-crossterm-devel \
 rust-crosstermion+tui-devel \
 rust-crosstermion+tui-react-crossterm-devel \
 rust-crosstermion+tui-react-devel \
 rust-crosstermion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crosstermion-0.16.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7f67bbab9f2e07b170e6cd44e727bf5de038e8e4d0005919ebf883fb542dece"

URI_x86_64_v2_rust-crosstermion+async-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+async-channel-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+async-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+async-channel-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+async-channel-devel.sha256sum] = "754c297f136c7dad85e11179ce22cf1d5fa5de67598b5418e5590ccfa44cb536"

URI_x86_64_v2_rust-crosstermion+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+color-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+color-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+color-devel.sha256sum] = "06fcc16ad12eed7b92b97c907ae1a197653a3432526cbdf752f903450b3c2554"

URI_x86_64_v2_rust-crosstermion+crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+crossterm-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+crossterm-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+crossterm-devel.sha256sum] = "4d0020f4de14ba6a4bbc0bd6a17e6574f25614660450654c14b89fc16a7b544f"

URI_x86_64_v2_rust-crosstermion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+default-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+default-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+default-devel.sha256sum] = "d60ee068873e19cf89776e580a8ca8d89c1bd05122b4dfa7dac8765896722766"

URI_x86_64_v2_rust-crosstermion+futures-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+futures-channel-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+futures-channel-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+futures-channel-devel.sha256sum] = "66cb88910072eed5633d27fd8469eadf243f3c29ea53de32700f52173726f6d4"

URI_x86_64_v2_rust-crosstermion+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+futures-core-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+futures-core-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+futures-core-devel.sha256sum] = "1d0f3d78945e723e4bc64ce444595edb2ce92e7d22265cbeb41b046a23a570b9"

URI_x86_64_v2_rust-crosstermion+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+futures-lite-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+futures-lite-devel.sha256sum] = "360ee74bcdbda037e380d25ce22faa34046caa8aaade9b0bf70fca2615a4e190"

URI_x86_64_v2_rust-crosstermion+input-async-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+input-async-crossterm-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+input-async-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+input-async-crossterm-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+input-async-crossterm-devel.sha256sum] = "c808290055dee24c5e86b6e284603d322bc2a0510d0634e0ebc62d1d22c9e060"

URI_x86_64_v2_rust-crosstermion+input-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+input-async-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+input-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+input-async-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+input-async-devel.sha256sum] = "20565d5a70002c6bbe5fb0ba70d438120c2da8ee8a59ebd34d50e04082feb1a0"

URI_x86_64_v2_rust-crosstermion+nu-ansi-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+nu-ansi-term-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+nu-ansi-term-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+nu-ansi-term-devel.sha256sum] = "a052e089e1e2db560b7cb35951276f61574447468fa9abd4e7685af5a983bb58"

URI_x86_64_v2_rust-crosstermion+tui-crossterm-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+tui-crossterm-backend-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+tui-crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+tui-crossterm-backend-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+tui-crossterm-backend-devel.sha256sum] = "86c458e2c9ef5e6cbbe5bec1e97a40c81100aca20a80ad2e0c156b5955edc1ae"

URI_x86_64_v2_rust-crosstermion+tui-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+tui-crossterm-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+tui-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+tui-crossterm-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+tui-crossterm-devel.sha256sum] = "8f75159f61b182b086c81868da5778042466d9fffe0a06b03afa4f27287c5118"

URI_x86_64_v2_rust-crosstermion+tui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+tui-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+tui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+tui-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+tui-devel.sha256sum] = "389bc775b174b3d92b0e8ac05370898ddcb8e582338b05f0b104b7b217c88f31"

URI_x86_64_v2_rust-crosstermion+tui-react-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+tui-react-crossterm-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+tui-react-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+tui-react-crossterm-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+tui-react-crossterm-devel.sha256sum] = "ad466dabb8fa9f03fbd0d62249269e79d47a350d2e49dea6d3736e80944271d2"

URI_x86_64_v2_rust-crosstermion+tui-react-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+tui-react-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+tui-react-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+tui-react-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+tui-react-devel.sha256sum] = "e8d4bf06b77a191380a9da4cf764881e22dd8faafac402100c670d962717c178"

URI_x86_64_v2_rust-crosstermion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion-devel}"
SRC_URI[x86_64_v2_rust-crosstermion-devel.sha256sum] = "214899a056617cc23f2b1f441effe509a47b9196213c7e5ef56db2cfab72f55a"

URI_aarch64_rust-crosstermion+async-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+async-channel-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+async-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+async-channel-devel}"
SRC_URI[aarch64_rust-crosstermion+async-channel-devel.sha256sum] = "a7dcdda785fddaa97146632ac41dd44605cea7df47df51ce400af1e2ec440d94"

URI_aarch64_rust-crosstermion+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+color-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+color-devel}"
SRC_URI[aarch64_rust-crosstermion+color-devel.sha256sum] = "a0d49528f98309d6865e0af4d0466b14ccb3d31b91475a07c1dc080ad9e48164"

URI_aarch64_rust-crosstermion+crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+crossterm-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+crossterm-devel}"
SRC_URI[aarch64_rust-crosstermion+crossterm-devel.sha256sum] = "a5aed097bd9351f93ef8ed46f4eca03b99c9921d9cedd37d7aff7feefc1adf60"

URI_aarch64_rust-crosstermion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+default-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+default-devel}"
SRC_URI[aarch64_rust-crosstermion+default-devel.sha256sum] = "58dd806af8fcc96cb8cc7e56da80a0bdb97d33ff5c260d7b8fe76c1c2ed4d018"

URI_aarch64_rust-crosstermion+futures-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+futures-channel-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+futures-channel-devel}"
SRC_URI[aarch64_rust-crosstermion+futures-channel-devel.sha256sum] = "ba366eb8460c0bf9b90c3b5ac9f718c8c61048e5efc520c221488f30d5960ed9"

URI_aarch64_rust-crosstermion+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+futures-core-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+futures-core-devel}"
SRC_URI[aarch64_rust-crosstermion+futures-core-devel.sha256sum] = "43b561ad63dcb195199310eab01c8a3a7fdbd8a6cce47266d32a90dc14f0f790"

URI_aarch64_rust-crosstermion+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+futures-lite-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+futures-lite-devel}"
SRC_URI[aarch64_rust-crosstermion+futures-lite-devel.sha256sum] = "f790535cf63e811558443b927b26d787d1a3c0e98701c99abfded60578845144"

URI_aarch64_rust-crosstermion+input-async-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+input-async-crossterm-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+input-async-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+input-async-crossterm-devel}"
SRC_URI[aarch64_rust-crosstermion+input-async-crossterm-devel.sha256sum] = "2887319102ae178542288ed3bedc22de00b8a70c489a7efe069d45b8e9b5db0e"

URI_aarch64_rust-crosstermion+input-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+input-async-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+input-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+input-async-devel}"
SRC_URI[aarch64_rust-crosstermion+input-async-devel.sha256sum] = "18b552aca7835af00d1bd5b5bd9b311af314c736f4306de61301362bd18f3558"

URI_aarch64_rust-crosstermion+nu-ansi-term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+nu-ansi-term-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+nu-ansi-term-devel}"
SRC_URI[aarch64_rust-crosstermion+nu-ansi-term-devel.sha256sum] = "7c13a89aff4d62547a2c1c69d50a7d9d7a52f6217a4385adeae89b5d364499a3"

URI_aarch64_rust-crosstermion+tui-crossterm-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+tui-crossterm-backend-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+tui-crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+tui-crossterm-backend-devel}"
SRC_URI[aarch64_rust-crosstermion+tui-crossterm-backend-devel.sha256sum] = "983ee746cf166807323963c88169db63b19587515eb3c6e41764a7415246bfc5"

URI_aarch64_rust-crosstermion+tui-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+tui-crossterm-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+tui-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+tui-crossterm-devel}"
SRC_URI[aarch64_rust-crosstermion+tui-crossterm-devel.sha256sum] = "49c0ee84156541a2630edbc36c2c6496d3d2bb57af721cbd6be980f22a0c77e3"

URI_aarch64_rust-crosstermion+tui-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+tui-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+tui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+tui-devel}"
SRC_URI[aarch64_rust-crosstermion+tui-devel.sha256sum] = "0151c499e8fbbf289fa3eb97fa89db5d641dc1ece8ae9bcec0251dc9342b5ac4"

URI_aarch64_rust-crosstermion+tui-react-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+tui-react-crossterm-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+tui-react-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+tui-react-crossterm-devel}"
SRC_URI[aarch64_rust-crosstermion+tui-react-crossterm-devel.sha256sum] = "40ad9bb70b0de256fbea0115c3a1fb9832ba838bfab4c5ec6fdf85d8a85cf2f9"

URI_aarch64_rust-crosstermion+tui-react-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+tui-react-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion+tui-react-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+tui-react-devel}"
SRC_URI[aarch64_rust-crosstermion+tui-react-devel.sha256sum] = "73ca850b0c8e39e50db0e92433a6bcd3014e26baea7b3c283523a4b9b535247b"

URI_aarch64_rust-crosstermion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-crosstermion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion-devel}"
SRC_URI[aarch64_rust-crosstermion-devel.sha256sum] = "01f902c29b227d7d0cef09195672e62915ce47782156d91777776a0ba6537d22"

RDEPENDS:rust-crosstermion+async-channel-devel = " \
 cargo \
 rust-async-channel+default-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+color-devel = " \
 cargo \
 rust-crosstermion+nu-ansi-term-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+crossterm-devel = " \
 cargo \
 rust-crossterm+events-devel \
 rust-crossterm-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+default-devel = " \
 cargo \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+futures-channel-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-futures-channel+sink-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-crosstermion+futures-core-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-crosstermion+futures-lite-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-futures-lite+default-devel \
 "
RDEPENDS:rust-crosstermion+input-async-crossterm-devel = " \
 cargo \
 rust-crossterm+event-stream-devel \
 rust-crossterm+events-devel \
 rust-crossterm-devel \
 rust-crosstermion+input-async-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+input-async-devel = " \
 cargo \
 rust-crosstermion+async-channel-devel \
 rust-crosstermion+futures-channel-devel \
 rust-crosstermion+futures-core-devel \
 rust-crosstermion+futures-lite-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+nu-ansi-term-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-nu-ansi-term-devel \
 "
RDEPENDS:rust-crosstermion+tui-crossterm-backend-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-ratatui+crossterm-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-crosstermion+tui-crossterm-devel = " \
 cargo \
 rust-crosstermion+crossterm-devel \
 rust-crosstermion+tui-crossterm-backend-devel \
 rust-crosstermion+tui-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+tui-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-crosstermion+tui-react-crossterm-devel = " \
 cargo \
 rust-crosstermion+crossterm-devel \
 rust-crosstermion+tui-crossterm-backend-devel \
 rust-crosstermion+tui-devel \
 rust-crosstermion+tui-react-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+tui-react-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-tui-react-devel \
 "
RDEPENDS:rust-crosstermion-devel = " \
 cargo \
 "
