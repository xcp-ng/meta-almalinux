# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-shell-words"
PV = "1.1.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-shell-words+default-devel \
 rust-shell-words+std-devel \
 rust-shell-words-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-shell-words-1.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2527171a4a1baa940daba12eefd24b224427c9cbd0383effdee86cbbe00e2c7"

URI_x86_64_v2_rust-shell-words+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shell-words+default-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shell-words+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shell-words+default-devel}"
SRC_URI[x86_64_v2_rust-shell-words+default-devel.sha256sum] = "bc41e608e464890b2b8a7fc2471927389dcc3c12ecdbe4c5cf6e4f8236f6ab5f"

URI_x86_64_v2_rust-shell-words+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shell-words+std-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shell-words+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shell-words+std-devel}"
SRC_URI[x86_64_v2_rust-shell-words+std-devel.sha256sum] = "f3b440b9a54f280db0332d1704e21b4c497851bb4da7c7e453f0f02274d5ccf9"

URI_x86_64_v2_rust-shell-words-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shell-words-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shell-words-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shell-words-devel}"
SRC_URI[x86_64_v2_rust-shell-words-devel.sha256sum] = "169a0a216eb1a8c02dd9b8cf791c2178fc73d0a65f4910b47d4e8d4bb3e75cd9"

URI_aarch64_rust-shell-words+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shell-words+default-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-shell-words+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shell-words+default-devel}"
SRC_URI[aarch64_rust-shell-words+default-devel.sha256sum] = "68a27e38d4279bdbb53266695f1555789be7750df46bd5ad54dd0e47e207371b"

URI_aarch64_rust-shell-words+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shell-words+std-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-shell-words+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shell-words+std-devel}"
SRC_URI[aarch64_rust-shell-words+std-devel.sha256sum] = "cc72cfadd55945d95378387a979633e888e297a42f866c54e95bfee2692f6822"

URI_aarch64_rust-shell-words-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shell-words-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-shell-words-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shell-words-devel}"
SRC_URI[aarch64_rust-shell-words-devel.sha256sum] = "0dd773a934f6401e62876cb70d9f60af11f18bcfcde203bba4a056b2269ac731"

RDEPENDS:rust-shell-words+default-devel = " \
 cargo \
 rust-shell-words+std-devel \
 rust-shell-words-devel \
 "
RDEPENDS:rust-shell-words+std-devel = " \
 cargo \
 rust-shell-words-devel \
 "
RDEPENDS:rust-shell-words-devel = " \
 cargo \
 "
