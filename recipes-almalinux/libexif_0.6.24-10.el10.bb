# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libexif"
PV = "0.6.24"
PR = "10.el10"
PACKAGES = " \
 libexif \
 libexif-devel \
 libexif-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libexif-0.6.24-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b7f318e1c3d9e09f5481aee1d3997a97c0972211c293f50116161e36133a81d"

URI_x86_64_v2_libexif = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libexif-0.6.24-10.el10.x86_64_v2.rpm;name=x86_64_v2_libexif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libexif}"
SRC_URI[x86_64_v2_libexif.sha256sum] = "c98901933ab4f43b77d5f818585fb06635e5a17667d129346db0f4c0da2a6cf5"

URI_x86_64_v2_libexif-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libexif-devel-0.6.24-10.el10.x86_64_v2.rpm;name=x86_64_v2_libexif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libexif-devel}"
SRC_URI[x86_64_v2_libexif-devel.sha256sum] = "f58bb8c47cf5f7251efe0d37d15011f65d5bc1077cba5994ec7b6f180b5f4831"

URI_x86_64_v2_libexif-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libexif-doc-0.6.24-10.el10.x86_64_v2.rpm;name=x86_64_v2_libexif-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libexif-doc}"
SRC_URI[x86_64_v2_libexif-doc.sha256sum] = "0772b57adc27d0b8f90ea36aba6b6d0605ac50b3edef5255cbb90b3e1989a313"

URI_aarch64_libexif = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libexif-0.6.24-10.el10.aarch64.rpm;name=aarch64_libexif;unpack=0"
SRC_URI:append = " ${URI_aarch64_libexif}"
SRC_URI[aarch64_libexif.sha256sum] = "8d495780cc0e1ac0959e42dc756c7cdbb360cc3e842d7c87302ec6f7c8a321cc"

URI_aarch64_libexif-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libexif-devel-0.6.24-10.el10.aarch64.rpm;name=aarch64_libexif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libexif-devel}"
SRC_URI[aarch64_libexif-devel.sha256sum] = "3a3eaef53e325507719908dd19746015264eaf9d2389e95ffe7e460cf1f814e5"

URI_aarch64_libexif-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libexif-doc-0.6.24-10.el10.aarch64.rpm;name=aarch64_libexif-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libexif-doc}"
SRC_URI[aarch64_libexif-doc.sha256sum] = "5ec8c788429695b916e7213b66c29b9ce586cd4876c7dd60e3011016571de412"

RDEPENDS:libexif = " \
 glibc \
 "
RDEPENDS:libexif-devel = " \
 libexif \
 pkgconf-pkg-config \
 "
RDEPENDS:libexif-doc = " \
 libexif \
 "
