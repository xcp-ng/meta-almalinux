# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-threadweaver"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-threadweaver \
 kf6-threadweaver-devel \
 kf6-threadweaver-doc \
 kf6-threadweaver-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-threadweaver-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "daa75c1d51c13800272d0793388f2bacc987188f644ab46a0d09c12ebf780ff7"

URI_x86_64_v2_kf6-threadweaver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-threadweaver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver}"
SRC_URI[x86_64_v2_kf6-threadweaver.sha256sum] = "9e308364e023ee7be2c17e15da2de717dc4fef88355d61b4573fc103a7bfb976"

URI_x86_64_v2_kf6-threadweaver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-threadweaver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver-devel}"
SRC_URI[x86_64_v2_kf6-threadweaver-devel.sha256sum] = "df181bae9753cb7e5513648acef7c0f640d376d832e5e34a6c9b2bd8059fed04"

URI_x86_64_v2_kf6-threadweaver-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-threadweaver-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver-doc}"
SRC_URI[x86_64_v2_kf6-threadweaver-doc.sha256sum] = "a59908a38f1e7f8deac4908dbdbd445bd1833943e3dac7b7201f2671fef89494"

URI_x86_64_v2_kf6-threadweaver-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-threadweaver-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver-html}"
SRC_URI[x86_64_v2_kf6-threadweaver-html.sha256sum] = "101ddaa95a923d98d5dedb28ef7a7f5f42f9b288e270ff884a78a92945651d7e"

URI_aarch64_kf6-threadweaver = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-threadweaver;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver}"
SRC_URI[aarch64_kf6-threadweaver.sha256sum] = "853901899663c7046abccd2424a7fc526b39b893a5daf33182cef0ea8ea0cf06"

URI_aarch64_kf6-threadweaver-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-threadweaver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver-devel}"
SRC_URI[aarch64_kf6-threadweaver-devel.sha256sum] = "bef041f4461bec4ba7b19c659184cb69e99cc73bccecf80b47f1d42e2b42f331"

URI_aarch64_kf6-threadweaver-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-threadweaver-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver-doc}"
SRC_URI[aarch64_kf6-threadweaver-doc.sha256sum] = "6f4c63d4fffbe6170f63485723032f0afd1f64fa1dfe2fce9bc7bf791946eb11"

URI_aarch64_kf6-threadweaver-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-threadweaver-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver-html}"
SRC_URI[aarch64_kf6-threadweaver-html.sha256sum] = "8e982e498c52aa32a4a7b625186e019c99a8e1c3ab1035ef7c5d2207fbdcff49"

RDEPENDS:kf6-threadweaver = " \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-threadweaver-devel = " \
 cmake-filesystem \
 kf6-threadweaver \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-threadweaver-doc = " \
 "
RDEPENDS:kf6-threadweaver-html = " \
 "
