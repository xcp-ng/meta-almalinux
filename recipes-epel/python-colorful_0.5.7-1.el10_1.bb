# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colorful"
PV = "0.5.7"
PR = "1.el10_1"
PACKAGES = " \
 python3-colorful \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colorful-0.5.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46d9a901072bfa7210af068069670935644b972b7033d9433b47499dfcf6ee88"

URI_x86_64_v2_python3-colorful = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colorful-0.5.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colorful;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colorful}"
SRC_URI[x86_64_v2_python3-colorful.sha256sum] = "a30e9f388d2d5a613ede5d8c8182bbe9484f8d4b321d049f3b0da30b76d69ba4"

URI_aarch64_python3-colorful = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colorful-0.5.7-1.el10_1.noarch.rpm;name=aarch64_python3-colorful;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colorful}"
SRC_URI[aarch64_python3-colorful.sha256sum] = "18a9ccc9c698cdf0af77d52ce4ae90fb9c0667f81a576ae9a49e5c76b272258e"

RDEPENDS:python3-colorful = " \
 python3 \
 "
