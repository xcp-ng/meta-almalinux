# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-raphf"
PV = "2.0.2"
PR = "1.el10_0"
PACKAGES = " \
 php-pecl-raphf \
 php-pecl-raphf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-raphf-2.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73f348d0365ada0a11d821c8a14ffd8c97a8f81c2ee906f6ab913941bcc7b762"

URI_x86_64_v2_php-pecl-raphf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-raphf-2.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-raphf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-raphf}"
SRC_URI[x86_64_v2_php-pecl-raphf.sha256sum] = "ab14a6a74217c27a8b8d056658759352f1c907cc17b5e89c11c396a7150a6960"

URI_x86_64_v2_php-pecl-raphf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-raphf-devel-2.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-raphf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-raphf-devel}"
SRC_URI[x86_64_v2_php-pecl-raphf-devel.sha256sum] = "a2a4f49ec9640989cbce74e24ef4df464d3ba625137ab5f92039f0ff9eb76b5d"

URI_aarch64_php-pecl-raphf = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-raphf-2.0.2-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-raphf;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-raphf}"
SRC_URI[aarch64_php-pecl-raphf.sha256sum] = "8886eda3634f478d8ddca0c5cfed71a4bef97a2dcf2f87dd3bb3306578595753"

URI_aarch64_php-pecl-raphf-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-raphf-devel-2.0.2-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-raphf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-raphf-devel}"
SRC_URI[aarch64_php-pecl-raphf-devel.sha256sum] = "b181f551b918f96298bbda7bea87e3761ed5987e12617ec91f7935675910b5d5"

RDEPENDS:php-pecl-raphf = " \
 glibc \
 php-common \
 "
RDEPENDS:php-pecl-raphf-devel = " \
 php-devel \
 php-pecl-raphf \
 "
