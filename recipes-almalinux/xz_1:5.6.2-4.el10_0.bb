# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xz"
PE = "1"
PV = "5.6.2"
PR = "4.el10_0"
PACKAGES = " \
 xz \
 xz-devel \
 xz-libs \
 xz-lzma-compat \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/xz-5.6.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8393ae2108a7bae26bdb88cf10b1c0e17e0b4338cdf1cc072e33bc960db7bda"

URI_x86_64_v2_xz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/xz-5.6.2-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_xz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xz}"
SRC_URI[x86_64_v2_xz.sha256sum] = "c00d63d8b9cb2370b0ad30d9541c07c53eb4e102cb0ab5a5d2fc7512ae484b4b"

URI_x86_64_v2_xz-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xz-devel-5.6.2-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xz-devel}"
SRC_URI[x86_64_v2_xz-devel.sha256sum] = "91547781b065a70683d73be32ae95f838e46b94bfbb75fbed4dc348cf33b4d23"

URI_x86_64_v2_xz-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/xz-libs-5.6.2-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_xz-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xz-libs}"
SRC_URI[x86_64_v2_xz-libs.sha256sum] = "b7c86e6258fbaa517d906a7c941b1ecdf46876afc8e5a678f3510831af850b7b"

URI_x86_64_v2_xz-lzma-compat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xz-lzma-compat-5.6.2-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_xz-lzma-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xz-lzma-compat}"
SRC_URI[x86_64_v2_xz-lzma-compat.sha256sum] = "467078e7ab2d60b09bd70548139f39474422592df480762c40888c333200372b"

URI_aarch64_xz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/xz-5.6.2-4.el10_0.aarch64.rpm;name=aarch64_xz;unpack=0"
SRC_URI:append = " ${URI_aarch64_xz}"
SRC_URI[aarch64_xz.sha256sum] = "023389fab7fef4e28002a18562da52e029daab2ef5e356180b0fe6142a3ec024"

URI_aarch64_xz-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xz-devel-5.6.2-4.el10_0.aarch64.rpm;name=aarch64_xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xz-devel}"
SRC_URI[aarch64_xz-devel.sha256sum] = "f6b9843c41fc22d0993e1136bab576b0deca0a823bc1f2c4672c2be9c785ba6d"

URI_aarch64_xz-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/xz-libs-5.6.2-4.el10_0.aarch64.rpm;name=aarch64_xz-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xz-libs}"
SRC_URI[aarch64_xz-libs.sha256sum] = "2b69ce283d825b3b99a888ee4e417dce967102eb80bdbf757c7506aa2e441651"

URI_aarch64_xz-lzma-compat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xz-lzma-compat-5.6.2-4.el10_0.aarch64.rpm;name=aarch64_xz-lzma-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_xz-lzma-compat}"
SRC_URI[aarch64_xz-lzma-compat.sha256sum] = "0d4948b7147255434a079c3508fe9725b158e483acd336b05e95d99a7a6268c6"

RDEPENDS:xz = " \
 bash \
 glibc \
 grep \
 xz-libs \
 "
RDEPENDS:xz-devel = " \
 pkgconf-pkg-config \
 xz-libs \
 "
RDEPENDS:xz-libs = " \
 glibc \
 "
RDEPENDS:xz-lzma-compat = " \
 glibc \
 xz \
 xz-libs \
 "
