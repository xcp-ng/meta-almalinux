# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lunasvg"
PV = "3.1.0"
PR = "1.el10_0"
PACKAGES = " \
 lunasvg \
 lunasvg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lunasvg-3.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e321f2cad26d0f945cfe1211a1990ada57bdad5873662b24fc5b85042d6f4d04"

URI_x86_64_v2_lunasvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lunasvg-3.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lunasvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lunasvg}"
SRC_URI[x86_64_v2_lunasvg.sha256sum] = "0647d7f71c22e234de035c7cc8b4ad02dacdf1bd3782f8260fb7599182e6c259"

URI_x86_64_v2_lunasvg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lunasvg-devel-3.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lunasvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lunasvg-devel}"
SRC_URI[x86_64_v2_lunasvg-devel.sha256sum] = "b3aa19392ab5e3dcf66c37feef3d0205c4f15f246f17ee95404e4d691bc842c5"

URI_aarch64_lunasvg = "${EPEL_MIRROR}/aarch64/Packages/l/lunasvg-3.1.0-1.el10_0.aarch64.rpm;name=aarch64_lunasvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_lunasvg}"
SRC_URI[aarch64_lunasvg.sha256sum] = "904a829fdb784c61771200def1de5be97195755012d3834ab725cfc2e37ad78a"

URI_aarch64_lunasvg-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lunasvg-devel-3.1.0-1.el10_0.aarch64.rpm;name=aarch64_lunasvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lunasvg-devel}"
SRC_URI[aarch64_lunasvg-devel.sha256sum] = "74216d3a95123acd0e020dcedf7743f864d17a9c6a1b10d44497c6f3417006eb"

RDEPENDS:lunasvg = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:lunasvg-devel = " \
 cmake-filesystem \
 lunasvg \
 "
