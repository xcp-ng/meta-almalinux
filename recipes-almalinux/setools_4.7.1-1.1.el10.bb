# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setools"
PV = "4.7.1"
PR = "1.1.el10"
PACKAGES = " \
 python3-setools \
 setools \
 setools-console \
 setools-console-analyses \
 setools-gui \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/setools-4.7.1-1.1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "25ddea0ffa4a314fec6c6b98465d8f9b8016090c2bbd32383bf44a818a1b2b16"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-setools-4.7.1-1.1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-setools;unpack=0"
SRC_URI[x86_64_v2_python3-setools.sha256sum] = "2ca32f4da714ec61958f4faee19136cae028ace5001b80737851bafa33a0665a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-4.7.1-1.1.el10.x86_64_v2.rpm;name=x86_64_v2_setools;unpack=0"
SRC_URI[x86_64_v2_setools.sha256sum] = "ffa145253c47f20608a973d1511b938cbe1f686d643ecea6a3c299be4d2d1a10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/setools-console-4.7.1-1.1.el10.x86_64_v2.rpm;name=x86_64_v2_setools-console;unpack=0"
SRC_URI[x86_64_v2_setools-console.sha256sum] = "9e6291394332f8705a70ad7da87d2d254648bdbcc4c03e619e81e4df4dddbab3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-console-analyses-4.7.1-1.1.el10.x86_64_v2.rpm;name=x86_64_v2_setools-console-analyses;unpack=0"
SRC_URI[x86_64_v2_setools-console-analyses.sha256sum] = "55ca24e4b67f6bc5256262f105b83313c16caaeffaa09db077a15189f7501e28"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-gui-4.7.1-1.1.el10.x86_64_v2.rpm;name=x86_64_v2_setools-gui;unpack=0"
SRC_URI[x86_64_v2_setools-gui.sha256sum] = "24e1465a8e67f3c71c6e56fe7aa31ed10883b52a6bb36f10bc4bc799ac714744"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-setools-4.7.1-1.1.el10.aarch64.rpm;name=aarch64_python3-setools;unpack=0"
SRC_URI[aarch64_python3-setools.sha256sum] = "d877c3f7bd2057fe3b538b390c41bbccc6cb304b4c6bd523056949b5eab20a4f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-4.7.1-1.1.el10.aarch64.rpm;name=aarch64_setools;unpack=0"
SRC_URI[aarch64_setools.sha256sum] = "f8d7a8f93d8f9f7eff35b952cc2b6e102cd209271fad489d3d21536da8f74efd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/setools-console-4.7.1-1.1.el10.aarch64.rpm;name=aarch64_setools-console;unpack=0"
SRC_URI[aarch64_setools-console.sha256sum] = "336a0dad8a3fe72d26e8fe8d0482707157f7e88ab26eec5658f5c2ab241d97a9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-console-analyses-4.7.1-1.1.el10.aarch64.rpm;name=aarch64_setools-console-analyses;unpack=0"
SRC_URI[aarch64_setools-console-analyses.sha256sum] = "ff3dd44488071949dc29dea52fe489d6ce7a55f9e8c888aec2c977e6d909de5d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-gui-4.7.1-1.1.el10.aarch64.rpm;name=aarch64_setools-gui;unpack=0"
SRC_URI[aarch64_setools-gui.sha256sum] = "a5f08c469e14f5631463f1e296b9a1e8b18438b6b071741c970d2464c7b5d547"

RDEPENDS:python3-setools = " \
 glibc \
 libselinux \
 libsepol \
 python3 \
 "
RDEPENDS:setools = " \
 setools-console \
 setools-console-analyses \
 setools-gui \
 "
RDEPENDS:setools-console = " \
 libselinux \
 python3 \
 python3-setools \
 "
RDEPENDS:setools-console-analyses = " \
 libselinux \
 python3 \
 python3-networkx \
 python3-setools \
 "
RDEPENDS:setools-gui = " \
 python3 \
 python3-networkx \
 python3-pyqt6 \
 python3-pyqt6-sip \
 python3-setools \
 "
