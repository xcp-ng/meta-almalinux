# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-proxy-utils"
PV = "7.3"
PR = "4.el10_0"
PACKAGES = " \
 globus-proxy-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-proxy-utils-7.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30f57db8a7fef31a065b5bd451f4f47b90449e520b8c7b4e78cd1433b5710f7d"

URI_x86_64_v2_globus-proxy-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-proxy-utils-7.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-proxy-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-proxy-utils}"
SRC_URI[x86_64_v2_globus-proxy-utils.sha256sum] = "4dbfad434fdf1f900585e9162f02e570fcf90b2b6c5633e9774765ab91e79c62"

URI_aarch64_globus-proxy-utils = "${EPEL_MIRROR}/aarch64/Packages/g/globus-proxy-utils-7.3-4.el10_0.aarch64.rpm;name=aarch64_globus-proxy-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-proxy-utils}"
SRC_URI[aarch64_globus-proxy-utils.sha256sum] = "f3141410c977c7ce81499da0dee973de53a7a4a3424ecca89e90b3a85600f457"

RDEPENDS:globus-proxy-utils = " \
 glibc \
 globus-common \
 globus-gsi-callback \
 globus-gsi-credential \
 globus-gsi-openssl-error \
 globus-gsi-proxy-core \
 globus-gsi-sysconfig \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-openssl-module \
 openssl-libs \
 "
