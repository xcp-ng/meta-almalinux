# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-kiosk"
PV = "47.0"
PR = "9.el10_0"
PACKAGES = " \
 gnome-kiosk \
 gnome-kiosk-script-session \
 gnome-kiosk-search-appliance \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-kiosk-47.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2da48428741b2c40c5ad30c37da5a976d218586f96c56493d1343ad73c71885c"

URI_x86_64_v2_gnome-kiosk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-kiosk-47.0-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_gnome-kiosk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-kiosk}"
SRC_URI[x86_64_v2_gnome-kiosk.sha256sum] = "e5f8bb185ff353a32ad57dd86da3b9335b2eb759cf78d62312616661b2574c58"
RPROVIDES:gnome-kiosk:x86_64_v2 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_x86_64_v2_gnome-kiosk-script-session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-kiosk-script-session-47.0-9.el10_0.noarch.rpm;name=x86_64_v2_gnome-kiosk-script-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-kiosk-script-session}"
SRC_URI[x86_64_v2_gnome-kiosk-script-session.sha256sum] = "cb32e94cd908cf0323354fc0687fda881ddc5e2793e6e64c9040c6bfdbb4fb3f"

URI_x86_64_v2_gnome-kiosk-search-appliance = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-kiosk-search-appliance-47.0-9.el10_0.noarch.rpm;name=x86_64_v2_gnome-kiosk-search-appliance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-kiosk-search-appliance}"
SRC_URI[x86_64_v2_gnome-kiosk-search-appliance.sha256sum] = "11dcec200b647eb58c5a7699434f78ca71296e2b888020eddac8c755b5f778e0"

URI_aarch64_gnome-kiosk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-kiosk-47.0-9.el10_0.aarch64.rpm;name=aarch64_gnome-kiosk;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-kiosk}"
SRC_URI[aarch64_gnome-kiosk.sha256sum] = "4c0e36dd7fc51561654a034868517f95efa80f203f8ff1615dbfdc2d87db4f09"
RPROVIDES:gnome-kiosk:aarch64 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_aarch64_gnome-kiosk-script-session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-kiosk-script-session-47.0-9.el10_0.noarch.rpm;name=aarch64_gnome-kiosk-script-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-kiosk-script-session}"
SRC_URI[aarch64_gnome-kiosk-script-session.sha256sum] = "cb32e94cd908cf0323354fc0687fda881ddc5e2793e6e64c9040c6bfdbb4fb3f"

URI_aarch64_gnome-kiosk-search-appliance = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-kiosk-search-appliance-47.0-9.el10_0.noarch.rpm;name=aarch64_gnome-kiosk-search-appliance;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-kiosk-search-appliance}"
SRC_URI[aarch64_gnome-kiosk-search-appliance.sha256sum] = "11dcec200b647eb58c5a7699434f78ca71296e2b888020eddac8c755b5f778e0"

RDEPENDS:gnome-kiosk = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-desktop4 \
 gnome-settings-daemon \
 gsettings-desktop-schemas \
 ibus-libs \
 libX11 \
 libgcc \
 libglvnd-gles \
 mutter \
 systemd-libs \
 "
RDEPENDS:gnome-kiosk-script-session = " \
 bash \
 gnome-kiosk \
 gnome-session \
 "
RDEPENDS:gnome-kiosk-search-appliance = " \
 flatpak \
 gnome-kiosk \
 gnome-session \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

PROVIDES:append:aarch64 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"
