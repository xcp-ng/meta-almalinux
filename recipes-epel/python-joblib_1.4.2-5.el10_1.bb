# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-joblib"
PV = "1.4.2"
PR = "5.el10_1"
PACKAGES = " \
 python3-joblib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-joblib-1.4.2-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7ea34809e19a850105cf34d8ca944c1a16dd4dbee8b103b4f4cfe6f7de70bcc"

URI_x86_64_v2_python3-joblib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-joblib-1.4.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-joblib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-joblib}"
SRC_URI[x86_64_v2_python3-joblib.sha256sum] = "112a8d9d913e93455569652121c79670888e2d8961c16b1dc7f5226e42ff47e1"

URI_aarch64_python3-joblib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-joblib-1.4.2-5.el10_1.noarch.rpm;name=aarch64_python3-joblib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-joblib}"
SRC_URI[aarch64_python3-joblib.sha256sum] = "e45cbdb8ab28b0469ae5d19c9ddff1b034d654dfa2bf5416c6cb80cb3249a08c"

RDEPENDS:python3-joblib = " \
 python3 \
 python3-cloudpickle \
 "
