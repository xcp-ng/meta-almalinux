# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-cucumber-tag-expressions"
PV = "4.0.2"
PR = "10.el10_1"
PACKAGES = " \
 rubygem-cucumber-tag-expressions \
 rubygem-cucumber-tag-expressions-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-cucumber-tag-expressions-4.0.2-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "288a84850bfc06b13e2727e09fb5e624339379fd927543134b707884848d61d5"

URI_x86_64_v2_rubygem-cucumber-tag-expressions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-tag-expressions-4.0.2-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-tag-expressions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-tag-expressions}"
SRC_URI[x86_64_v2_rubygem-cucumber-tag-expressions.sha256sum] = "c78951e06c928caa7936fecdad951e31160754dfd8e0944cb74996a33162dfef"

URI_x86_64_v2_rubygem-cucumber-tag-expressions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-tag-expressions-doc-4.0.2-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-tag-expressions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-tag-expressions-doc}"
SRC_URI[x86_64_v2_rubygem-cucumber-tag-expressions-doc.sha256sum] = "40bcb5fa861a9a245da8c1110f107ccc0b03ec87ddf9a283e35e3fd18110ee4a"

URI_aarch64_rubygem-cucumber-tag-expressions = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-tag-expressions-4.0.2-10.el10_1.noarch.rpm;name=aarch64_rubygem-cucumber-tag-expressions;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-tag-expressions}"
SRC_URI[aarch64_rubygem-cucumber-tag-expressions.sha256sum] = "15df3d80c0ec57bc2c70d532bdcc10581840c6121fd7ec5ef5be3bef9912c223"

URI_aarch64_rubygem-cucumber-tag-expressions-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-tag-expressions-doc-4.0.2-10.el10_1.noarch.rpm;name=aarch64_rubygem-cucumber-tag-expressions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-tag-expressions-doc}"
SRC_URI[aarch64_rubygem-cucumber-tag-expressions-doc.sha256sum] = "ca929254d015e0c75593db6f32083a5fea76366264df0c6e9f603c75b46f1291"

RDEPENDS:rubygem-cucumber-tag-expressions = " \
 rubygems \
 "
RDEPENDS:rubygem-cucumber-tag-expressions-doc = " \
 rubygem-cucumber-tag-expressions \
 "
