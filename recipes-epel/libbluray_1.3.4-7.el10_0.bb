# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libbluray"
PV = "1.3.4"
PR = "7.el10_0"
PACKAGES = " \
 libbluray \
 libbluray-bdj \
 libbluray-devel \
 libbluray-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libbluray-1.3.4-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f74457973c9c8c3328977b5cbe867932a0faf0dd10a7049e9ca9c68cec125ada"

URI_x86_64_v2_libbluray = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbluray-1.3.4-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbluray;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbluray}"
SRC_URI[x86_64_v2_libbluray.sha256sum] = "dc28c32ff665a6912e1ac933b4d0d0126e9051441cd151ec7040facb267176bd"

URI_x86_64_v2_libbluray-bdj = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbluray-bdj-1.3.4-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbluray-bdj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbluray-bdj}"
SRC_URI[x86_64_v2_libbluray-bdj.sha256sum] = "32f6797404076f6d7227c5ab0225a38090de065d89a75431dcab748abad491fd"

URI_x86_64_v2_libbluray-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbluray-devel-1.3.4-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbluray-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbluray-devel}"
SRC_URI[x86_64_v2_libbluray-devel.sha256sum] = "f63086d7cc6b7026cbf9d494c3d4b377240e263f5554c5c7b4f9619eab3402c8"

URI_x86_64_v2_libbluray-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbluray-utils-1.3.4-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbluray-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbluray-utils}"
SRC_URI[x86_64_v2_libbluray-utils.sha256sum] = "831691fb4d34f7f4af2d73e063f13e76cac192fb7199084d3bb93a102129cda9"

URI_aarch64_libbluray = "${EPEL_MIRROR}/aarch64/Packages/l/libbluray-1.3.4-7.el10_0.aarch64.rpm;name=aarch64_libbluray;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbluray}"
SRC_URI[aarch64_libbluray.sha256sum] = "c6eeef5137c2619e75d962fe521f356198bfc00344be72baa681e78d66e52437"

URI_aarch64_libbluray-bdj = "${EPEL_MIRROR}/aarch64/Packages/l/libbluray-bdj-1.3.4-7.el10_0.aarch64.rpm;name=aarch64_libbluray-bdj;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbluray-bdj}"
SRC_URI[aarch64_libbluray-bdj.sha256sum] = "15e09230a803084a0fada50195ab3668390d78b4176de859a62913b8ada7114e"

URI_aarch64_libbluray-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libbluray-devel-1.3.4-7.el10_0.aarch64.rpm;name=aarch64_libbluray-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbluray-devel}"
SRC_URI[aarch64_libbluray-devel.sha256sum] = "ff46b961a915d63741a133fd67a43f08e183271bb037d6b0975286fe3e716a5d"

URI_aarch64_libbluray-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libbluray-utils-1.3.4-7.el10_0.aarch64.rpm;name=aarch64_libbluray-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbluray-utils}"
SRC_URI[aarch64_libbluray-utils.sha256sum] = "8fd9a07ce1fc4d9333efc764af33fb7c775e0eeca75ebce8bbb872b95400df46"

RDEPENDS:libbluray = " \
 fontconfig \
 freetype \
 glibc \
 libudfread \
 libxml2 \
 "
RDEPENDS:libbluray-bdj = " \
 java-21-openjdk-headless \
 javapackages-tools \
 libbluray \
 "
RDEPENDS:libbluray-devel = " \
 fontconfig-devel \
 freetype-devel \
 libbluray \
 libudfread-devel \
 libxml2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libbluray-utils = " \
 glibc \
 libbluray \
 "
