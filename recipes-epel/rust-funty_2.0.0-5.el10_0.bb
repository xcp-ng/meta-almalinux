# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-funty"
PV = "2.0.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-funty+default-devel \
 rust-funty+std-devel \
 rust-funty-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-funty-2.0.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02eefebedf18b6e2503e9a9809daa41a62dabc47255c598d11c884908abe6d8a"

URI_x86_64_v2_rust-funty+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-funty+default-devel-2.0.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-funty+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-funty+default-devel}"
SRC_URI[x86_64_v2_rust-funty+default-devel.sha256sum] = "0216c60ed064adba564168060666eab5e9f35ce2943329e08a966450e949aa31"

URI_x86_64_v2_rust-funty+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-funty+std-devel-2.0.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-funty+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-funty+std-devel}"
SRC_URI[x86_64_v2_rust-funty+std-devel.sha256sum] = "1ec8180a78eaaed56ca06031eccf79c6b478a6f9f44ced706c6ee0a842e50583"

URI_x86_64_v2_rust-funty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-funty-devel-2.0.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-funty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-funty-devel}"
SRC_URI[x86_64_v2_rust-funty-devel.sha256sum] = "ac9a490b19b2c21e2c12c7228424fad48545d6e659890d7adc1af6c20fe4d90f"

URI_aarch64_rust-funty+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-funty+default-devel-2.0.0-5.el10_0.noarch.rpm;name=aarch64_rust-funty+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-funty+default-devel}"
SRC_URI[aarch64_rust-funty+default-devel.sha256sum] = "55a3c0850ab474e4d448420f5b599d0490f732c6034da47dd9625c83712d608c"

URI_aarch64_rust-funty+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-funty+std-devel-2.0.0-5.el10_0.noarch.rpm;name=aarch64_rust-funty+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-funty+std-devel}"
SRC_URI[aarch64_rust-funty+std-devel.sha256sum] = "dd41468bf96d5b27f6c1b9648a0fe7419351513474d0c7c866fcc372493193ce"

URI_aarch64_rust-funty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-funty-devel-2.0.0-5.el10_0.noarch.rpm;name=aarch64_rust-funty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-funty-devel}"
SRC_URI[aarch64_rust-funty-devel.sha256sum] = "7cfe95aa1e1a0b3af5f62996bf3321a040d799adf3a134a28497acb032d5bc24"

RDEPENDS:rust-funty+default-devel = " \
 cargo \
 rust-funty+std-devel \
 rust-funty-devel \
 "
RDEPENDS:rust-funty+std-devel = " \
 cargo \
 rust-funty-devel \
 "
RDEPENDS:rust-funty-devel = " \
 cargo \
 "
