# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs-nodemon"
PV = "3.1.14"
PR = "3.el10_2"
PACKAGES = " \
 nodejs-nodemon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs-nodemon-3.1.14-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebcf973b6d03580ff9b118721395b250c5680cb7342134a0e1638d61e79cd882"

URI_x86_64_v2_nodejs-nodemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-nodemon-3.1.14-3.el10_2.noarch.rpm;name=x86_64_v2_nodejs-nodemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-nodemon}"
SRC_URI[x86_64_v2_nodejs-nodemon.sha256sum] = "754dbb75c7096126fe89e0025ab2e31e63eda960fb77226c5e627a74feb18d21"

URI_aarch64_nodejs-nodemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-nodemon-3.1.14-3.el10_2.noarch.rpm;name=aarch64_nodejs-nodemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-nodemon}"
SRC_URI[aarch64_nodejs-nodemon.sha256sum] = "754dbb75c7096126fe89e0025ab2e31e63eda960fb77226c5e627a74feb18d21"

RDEPENDS:nodejs-nodemon = " \
 virtual/nodejs_engine_ \
 "
