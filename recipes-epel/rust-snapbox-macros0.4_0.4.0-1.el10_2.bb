# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snapbox-macros0.4"
PV = "0.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-snapbox-macros0.4+color-devel \
 rust-snapbox-macros0.4+debug-devel \
 rust-snapbox-macros0.4+default-devel \
 rust-snapbox-macros0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snapbox-macros0.4-0.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63bc6fc634de10da901079dd472dfc8536232b0f9e69e694006f67378935a99c"

URI_x86_64_v2_rust-snapbox-macros0.4+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros0.4+color-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros0.4+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros0.4+color-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros0.4+color-devel.sha256sum] = "6f4399e8f9e9faab6835572c255e75607bcb2754be14d75ec4ed458a6893b7c3"

URI_x86_64_v2_rust-snapbox-macros0.4+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros0.4+debug-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros0.4+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros0.4+debug-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros0.4+debug-devel.sha256sum] = "fe1c1dcaa6d909394a0cb6182dcc3311441f9aa3a5283d98a125afb36bc86d90"

URI_x86_64_v2_rust-snapbox-macros0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros0.4+default-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros0.4+default-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros0.4+default-devel.sha256sum] = "b19b3a5b480ecf8e35203e7a34148386b9997d1cad160a73a9e0fcae795b1e6b"

URI_x86_64_v2_rust-snapbox-macros0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros0.4-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros0.4-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros0.4-devel.sha256sum] = "21d3ad38485edd2015714401180588838fd0dda4a72cf5628998aa2a99cd9cf2"

URI_aarch64_rust-snapbox-macros0.4+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros0.4+color-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox-macros0.4+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros0.4+color-devel}"
SRC_URI[aarch64_rust-snapbox-macros0.4+color-devel.sha256sum] = "6f4274993fcd24b1f6db61390de50e5464a977d3bd00ecb61e189ee9b7d8dd70"

URI_aarch64_rust-snapbox-macros0.4+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros0.4+debug-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox-macros0.4+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros0.4+debug-devel}"
SRC_URI[aarch64_rust-snapbox-macros0.4+debug-devel.sha256sum] = "bcaac698a051aa52e0e4cadde0e0942842dc8d4bb063f845d9adf687f644aaa9"

URI_aarch64_rust-snapbox-macros0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros0.4+default-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox-macros0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros0.4+default-devel}"
SRC_URI[aarch64_rust-snapbox-macros0.4+default-devel.sha256sum] = "212c9346b216b99205e15e358f18190d37848e2e2cef9b7a933edf86227f7816"

URI_aarch64_rust-snapbox-macros0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros0.4-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox-macros0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros0.4-devel}"
SRC_URI[aarch64_rust-snapbox-macros0.4-devel.sha256sum] = "c76d4d124ea73e9dcdc5acaa32b0b29c52345c249e6af0b1c2ca10c076234b36"

RDEPENDS:rust-snapbox-macros0.4+color-devel = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-snapbox-macros0.4-devel \
 "
RDEPENDS:rust-snapbox-macros0.4+debug-devel = " \
 cargo \
 rust-snapbox-macros0.4-devel \
 "
RDEPENDS:rust-snapbox-macros0.4+default-devel = " \
 cargo \
 rust-snapbox-macros0.4-devel \
 "
RDEPENDS:rust-snapbox-macros0.4-devel = " \
 cargo \
 rust \
 "
