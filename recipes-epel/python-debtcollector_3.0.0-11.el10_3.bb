# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-debtcollector"
PV = "3.0.0"
PR = "11.el10_3"
PACKAGES = " \
 python-debtcollector-doc \
 python3-debtcollector \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-debtcollector-3.0.0-11.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74d6c2c701f3cedfd6b1c669efb038b0188319bea0739df640ee892014e05034"

URI_x86_64_v2_python-debtcollector-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-debtcollector-doc-3.0.0-11.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-debtcollector-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-debtcollector-doc}"
SRC_URI[x86_64_v2_python-debtcollector-doc.sha256sum] = "e89004c838be38bf0f433f62cfe680df7cb66a673fb922fff63d8aa458c65c8a"

URI_x86_64_v2_python3-debtcollector = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-debtcollector-3.0.0-11.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-debtcollector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-debtcollector}"
SRC_URI[x86_64_v2_python3-debtcollector.sha256sum] = "b9ddd73b6664428b31093ce2307222362914e6405a28583cbdf851cd4f874de9"

URI_aarch64_python-debtcollector-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-debtcollector-doc-3.0.0-11.el10_3.noarch.rpm;name=aarch64_python-debtcollector-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-debtcollector-doc}"
SRC_URI[aarch64_python-debtcollector-doc.sha256sum] = "fd02d1255249d128520de969a461e8d83c298af6b52408aa2bbb18370f900e43"

URI_aarch64_python3-debtcollector = "${EPEL_MIRROR}/aarch64/Packages/p/python3-debtcollector-3.0.0-11.el10_3.noarch.rpm;name=aarch64_python3-debtcollector;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-debtcollector}"
SRC_URI[aarch64_python3-debtcollector.sha256sum] = "c0d61c84e7f553d9fd96e32aff440cc6fd25ab0bed0f0ad627890003b64c77e4"

RDEPENDS:python-debtcollector-doc = " \
 "
RDEPENDS:python3-debtcollector = " \
 python3 \
 python3-wrapt \
 "
