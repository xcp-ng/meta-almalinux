# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-darling0.20"
PV = "0.20.11"
PR = "1.el10_2"
PACKAGES = " \
 rust-darling0.20+default-devel \
 rust-darling0.20+diagnostics-devel \
 rust-darling0.20+suggestions-devel \
 rust-darling0.20-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-darling0.20-0.20.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e263090201fb3cdad55c3cab4a3262634c6499926936ee53519c93c7ab35075"

URI_x86_64_v2_rust-darling0.20+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling0.20+default-devel-0.20.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling0.20+default-devel}"
SRC_URI[x86_64_v2_rust-darling0.20+default-devel.sha256sum] = "4c34ec3633241e81dae2049461c1ac92d9158376a8d2abeb6b49a14c75c15b81"

URI_x86_64_v2_rust-darling0.20+diagnostics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling0.20+diagnostics-devel-0.20.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling0.20+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling0.20+diagnostics-devel}"
SRC_URI[x86_64_v2_rust-darling0.20+diagnostics-devel.sha256sum] = "ea6ccf2f5270a06d42347296d01a4a7eeed1f04721ba498a13a8da09266ec715"

URI_x86_64_v2_rust-darling0.20+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling0.20+suggestions-devel-0.20.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling0.20+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling0.20+suggestions-devel}"
SRC_URI[x86_64_v2_rust-darling0.20+suggestions-devel.sha256sum] = "37175809de75bcc44d315819160215395fa2e2d72c53ceedf77e68e48c2ac708"

URI_x86_64_v2_rust-darling0.20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling0.20-devel-0.20.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling0.20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling0.20-devel}"
SRC_URI[x86_64_v2_rust-darling0.20-devel.sha256sum] = "7313a6541978aae491a7233f6ba1fd0836a1304fc1b1b909a174455dbeec9c97"

URI_aarch64_rust-darling0.20+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling0.20+default-devel-0.20.11-1.el10_2.noarch.rpm;name=aarch64_rust-darling0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling0.20+default-devel}"
SRC_URI[aarch64_rust-darling0.20+default-devel.sha256sum] = "d9d12ea68342e9647f00b0e4aa6912de440e403659e89ddc8ec0be8fe70db2a2"

URI_aarch64_rust-darling0.20+diagnostics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling0.20+diagnostics-devel-0.20.11-1.el10_2.noarch.rpm;name=aarch64_rust-darling0.20+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling0.20+diagnostics-devel}"
SRC_URI[aarch64_rust-darling0.20+diagnostics-devel.sha256sum] = "2b9272150cfb95668c285c7d32b2f1121a417ae4a524ac4103f1ae9c1ed6ad81"

URI_aarch64_rust-darling0.20+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling0.20+suggestions-devel-0.20.11-1.el10_2.noarch.rpm;name=aarch64_rust-darling0.20+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling0.20+suggestions-devel}"
SRC_URI[aarch64_rust-darling0.20+suggestions-devel.sha256sum] = "70d41efbfa606a215f217943dcaa51be947329f05539223cd7bd30ec6579d74c"

URI_aarch64_rust-darling0.20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling0.20-devel-0.20.11-1.el10_2.noarch.rpm;name=aarch64_rust-darling0.20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling0.20-devel}"
SRC_URI[aarch64_rust-darling0.20-devel.sha256sum] = "7372374450142863a8e5443c3aa2ebcf0b8fd769806021c34cd2a10a2813ddba"

RDEPENDS:rust-darling0.20+default-devel = " \
 cargo \
 rust-darling0.20+suggestions-devel \
 rust-darling0.20-devel \
 "
RDEPENDS:rust-darling0.20+diagnostics-devel = " \
 cargo \
 rust-darling0.20-devel \
 rust-darling_core0.20+diagnostics-devel \
 "
RDEPENDS:rust-darling0.20+suggestions-devel = " \
 cargo \
 rust-darling0.20-devel \
 rust-darling_core0.20+suggestions-devel \
 "
RDEPENDS:rust-darling0.20-devel = " \
 cargo \
 rust \
 rust-darling_core0.20+default-devel \
 rust-darling_macro0.20+default-devel \
 "
