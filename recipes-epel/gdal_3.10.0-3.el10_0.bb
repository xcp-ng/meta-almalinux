# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdal"
PV = "3.10.0"
PR = "3.el10_0"
PACKAGES = " \
 gdal \
 gdal-devel \
 gdal-java \
 gdal-javadoc \
 gdal-libs \
 gdal-python-tools \
 python3-gdal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gdal-3.10.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9a30a1876cf0d2ab9823756b349ec65d18a784b1e7c7e65ff8d0091a9f97f39"

URI_x86_64_v2_gdal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal-3.10.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal}"
SRC_URI[x86_64_v2_gdal.sha256sum] = "37c10ffd07dd4cc84c323db6825f84318beaed2b6b73bec6d6659ca197818e15"

URI_x86_64_v2_gdal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal-devel-3.10.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal-devel}"
SRC_URI[x86_64_v2_gdal-devel.sha256sum] = "c81c4509d4e475a317800baf1bf5ad535da647a3243e1f221bae4988d77ac601"

URI_x86_64_v2_gdal-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal-java-3.10.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdal-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal-java}"
SRC_URI[x86_64_v2_gdal-java.sha256sum] = "c670253ae71b151dcc597ed0c3bcd4f34dccd2ea8c94f6d6359c97a75265db1f"

URI_x86_64_v2_gdal-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal-javadoc-3.10.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gdal-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal-javadoc}"
SRC_URI[x86_64_v2_gdal-javadoc.sha256sum] = "e74cf3adbb28e1a8ac7288d88494103219088f0113fd747143e6299e2dc8367f"

URI_x86_64_v2_gdal-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal-libs-3.10.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdal-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal-libs}"
SRC_URI[x86_64_v2_gdal-libs.sha256sum] = "a3a970c9ce50bd6bbe6eb8b891462be1e14b8eecc5080f424f7a2fd5b05146ab"

URI_x86_64_v2_gdal-python-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal-python-tools-3.10.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdal-python-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal-python-tools}"
SRC_URI[x86_64_v2_gdal-python-tools.sha256sum] = "b890705489770dc6bae44bcf2547126594baea33c15619cd8d2831a2891ee7e4"

URI_x86_64_v2_python3-gdal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gdal-3.10.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-gdal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gdal}"
SRC_URI[x86_64_v2_python3-gdal.sha256sum] = "1cf0108020ac8ecd541b46eeb1cd77d123121b471e37e01583d699c0f18a08a6"

URI_aarch64_gdal = "${EPEL_MIRROR}/aarch64/Packages/g/gdal-3.10.0-3.el10_0.aarch64.rpm;name=aarch64_gdal;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal}"
SRC_URI[aarch64_gdal.sha256sum] = "4049c622a87bdeef58a4d32a87be280ff250f6d72c3ff9d1a256bdb01413a907"

URI_aarch64_gdal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gdal-devel-3.10.0-3.el10_0.aarch64.rpm;name=aarch64_gdal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal-devel}"
SRC_URI[aarch64_gdal-devel.sha256sum] = "f67a2207eda709914735b212f5e28d1fc6a3ba082b7318d7dac2584e441f22f9"

URI_aarch64_gdal-java = "${EPEL_MIRROR}/aarch64/Packages/g/gdal-java-3.10.0-3.el10_0.aarch64.rpm;name=aarch64_gdal-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal-java}"
SRC_URI[aarch64_gdal-java.sha256sum] = "fc73583664671fab93c497d4726c6b3cf7cc342a0b43844ca78669e726638b1f"

URI_aarch64_gdal-javadoc = "${EPEL_MIRROR}/aarch64/Packages/g/gdal-javadoc-3.10.0-3.el10_0.noarch.rpm;name=aarch64_gdal-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal-javadoc}"
SRC_URI[aarch64_gdal-javadoc.sha256sum] = "231c09329d2c3c0753db506c1cbfe06e88951b9b4e22a109f02036b614b6f185"

URI_aarch64_gdal-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gdal-libs-3.10.0-3.el10_0.aarch64.rpm;name=aarch64_gdal-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal-libs}"
SRC_URI[aarch64_gdal-libs.sha256sum] = "5a360e168081d3d522c49e54b1b0c192059800715ae0795a712cc8827133dde9"

URI_aarch64_gdal-python-tools = "${EPEL_MIRROR}/aarch64/Packages/g/gdal-python-tools-3.10.0-3.el10_0.aarch64.rpm;name=aarch64_gdal-python-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal-python-tools}"
SRC_URI[aarch64_gdal-python-tools.sha256sum] = "997c11256ee00852eb1f0e04cb28d45f2622188b0011b812aa7e2938c2399412"

URI_aarch64_python3-gdal = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gdal-3.10.0-3.el10_0.aarch64.rpm;name=aarch64_python3-gdal;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gdal}"
SRC_URI[aarch64_python3-gdal.sha256sum] = "5fea017a32d4c3bb151509eaca64526dff19808b99a3177c93f03b11972170b6"

RDEPENDS:gdal = " \
 gdal-libs \
 glibc \
 gpsbabel \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:gdal-devel = " \
 bash \
 cmake-filesystem \
 gdal-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:gdal-java = " \
 gdal-libs \
 glibc \
 javapackages-tools \
 libstdc++ \
 "
RDEPENDS:gdal-javadoc = " \
 javapackages-tools \
 "
RDEPENDS:gdal-libs = " \
 armadillo \
 cfitsio \
 expat \
 freexl \
 geos \
 giflib \
 glibc \
 hdf5 \
 imath \
 json-c \
 libaec \
 libarchive \
 libarrow \
 libarrow-dataset-libs \
 libdeflate \
 libgcc \
 libgeotiff \
 libgta \
 libjpeg-turbo \
 libkml \
 liblerc \
 libpng \
 libpq \
 libqhull_r \
 libspatialite \
 libstdc++ \
 libtiff \
 libwebp \
 libxml2 \
 libzstd \
 lz4-libs \
 mariadb-connector-c \
 netcdf \
 ogdi \
 openexr-libs \
 openjpeg2 \
 openssl-libs \
 parquet-libs \
 pcre2 \
 poppler \
 proj \
 sqlite-libs \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 virtual/libdf.so.0___64bit_ \
 virtual/libmfhdf.so.0___64bit_ \
 xerces-c \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:gdal-python-tools = " \
 python3 \
 python3-gdal \
 "
RDEPENDS:python3-gdal = " \
 gdal-libs \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-numpy \
 "
