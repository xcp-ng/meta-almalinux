# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-cucumber"
PV = "7.1.0"
PR = "14.el10_2"
PACKAGES = " \
 rubygem-cucumber \
 rubygem-cucumber-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-cucumber-7.1.0-14.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ee6dadec2b8047b8ab7afc03d557c3cf9504d4adaef8bb3363a90716a6de453"

URI_x86_64_v2_rubygem-cucumber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-7.1.0-14.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber}"
SRC_URI[x86_64_v2_rubygem-cucumber.sha256sum] = "7fd815b72b72d861367e32079d933c6d4000e3210881e965c20526dc14a6ba89"

URI_x86_64_v2_rubygem-cucumber-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-doc-7.1.0-14.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-doc}"
SRC_URI[x86_64_v2_rubygem-cucumber-doc.sha256sum] = "0ec2a774341495c93054bf272962ef2c406dce207630acacb27db7160bd005b4"

URI_aarch64_rubygem-cucumber = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-7.1.0-14.el10_2.noarch.rpm;name=aarch64_rubygem-cucumber;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber}"
SRC_URI[aarch64_rubygem-cucumber.sha256sum] = "6fe7d081bf1fe1e0c03a496d9752733b36cc9fbd50e061677affd18697df8280"

URI_aarch64_rubygem-cucumber-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-doc-7.1.0-14.el10_2.noarch.rpm;name=aarch64_rubygem-cucumber-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-doc}"
SRC_URI[aarch64_rubygem-cucumber-doc.sha256sum] = "8a09a8c2fc93b5301b6f6b5d66927d7843ebc6a5187c0676c1aff3500b4e295e"

RDEPENDS:rubygem-cucumber = " \
 ruby \
 ruby-default-gems \
 rubygem-builder \
 rubygem-cucumber-core \
 rubygem-cucumber-create-meta \
 rubygem-cucumber-cucumber-expressions \
 rubygem-cucumber-gherkin \
 rubygem-cucumber-messages \
 rubygem-cucumber-wire \
 rubygem-diff-lcs \
 rubygem-mime-types \
 rubygem-multi_test \
 rubygem-sys-uname \
 rubygems \
 "
RDEPENDS:rubygem-cucumber-doc = " \
 rubygem-cucumber \
 "
