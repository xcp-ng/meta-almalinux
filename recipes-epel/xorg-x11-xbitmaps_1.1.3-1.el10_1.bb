# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xorg-x11-xbitmaps"
PV = "1.1.3"
PR = "1.el10_1"
PACKAGES = " \
 xorg-x11-xbitmaps \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xorg-x11-xbitmaps-1.1.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee179ceff0b488f6a639b3f971948de79dfb976e62d3de434ff1af4ce06db8d6"

URI_x86_64_v2_xorg-x11-xbitmaps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xorg-x11-xbitmaps-1.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_xorg-x11-xbitmaps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-xbitmaps}"
SRC_URI[x86_64_v2_xorg-x11-xbitmaps.sha256sum] = "e7882776d5a7a6b6ec90cb30b4c975ccce6091f8bc92add99bc6e19ebb339dec"

URI_aarch64_xorg-x11-xbitmaps = "${EPEL_MIRROR}/aarch64/Packages/x/xorg-x11-xbitmaps-1.1.3-1.el10_1.noarch.rpm;name=aarch64_xorg-x11-xbitmaps;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-xbitmaps}"
SRC_URI[aarch64_xorg-x11-xbitmaps.sha256sum] = "e4d894901b3d7ea7078160081f005fc5b803dbbea7eb221c95271dfff5f2448e"

RDEPENDS:xorg-x11-xbitmaps = " \
 pkgconf-pkg-config \
 "
