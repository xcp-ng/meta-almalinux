# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sort-Naturally"
PV = "1.03"
PR = "36.el10_0"
PACKAGES = " \
 perl-Sort-Naturally \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Sort-Naturally-1.03-36.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5579632c4426084bddbf685590dcaf439f2e1400ef3b204a71bcdc4f3558338f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sort-Naturally-1.03-36.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sort-Naturally;unpack=0"
SRC_URI[x86_64_v2_perl-Sort-Naturally.sha256sum] = "00b039e9ce4f498132080db1902621f06a9e792c7f37df8088cb66131699186d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Sort-Naturally-1.03-36.el10_0.noarch.rpm;name=aarch64_perl-Sort-Naturally;unpack=0"
SRC_URI[aarch64_perl-Sort-Naturally.sha256sum] = "618a7aabdb2e53948b0b436f6bf8b05ead24ab487dee08c0be7a583a4943e9cc"

RDEPENDS:perl-Sort-Naturally = " \
 perl-Exporter \
 perl-libs \
 perl-locale \
 "
