# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aribb24"
PV = "1.0.3^20160216git5e9be27"
PR = "1.el10_0"
PACKAGES = " \
 aribb24 \
 aribb24-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aribb24-1.0.3^20160216git5e9be27-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f3871f87e93bc49bb2e5b511c4d450f618e0803968b186b45264a84cc33a655"

URI_x86_64_v2_aribb24 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aribb24-1.0.3^20160216git5e9be27-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aribb24;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aribb24}"
SRC_URI[x86_64_v2_aribb24.sha256sum] = "064afd2551accdb355f727df30a84e2435cabe4fa131d5fe035efd9d8bcfaf5a"

URI_x86_64_v2_aribb24-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aribb24-devel-1.0.3^20160216git5e9be27-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aribb24-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aribb24-devel}"
SRC_URI[x86_64_v2_aribb24-devel.sha256sum] = "b691a329f3a336365541226256d8eba6be6900a180462e73e46a6ec05f31ff0d"

URI_aarch64_aribb24 = "${EPEL_MIRROR}/aarch64/Packages/a/aribb24-1.0.3^20160216git5e9be27-1.el10_0.aarch64.rpm;name=aarch64_aribb24;unpack=0"
SRC_URI:append = " ${URI_aarch64_aribb24}"
SRC_URI[aarch64_aribb24.sha256sum] = "36e91d97b9e070cacad6bf47c1254dcd0d6f498f5409bbf7967ce057da1c1518"

URI_aarch64_aribb24-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aribb24-devel-1.0.3^20160216git5e9be27-1.el10_0.aarch64.rpm;name=aarch64_aribb24-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aribb24-devel}"
SRC_URI[aarch64_aribb24-devel.sha256sum] = "65c4c91e2657f76ae491efc7fd3b3ed0982ad7297d89f88b3d6fbbe02063e407"

RDEPENDS:aribb24 = " \
 glibc \
 libpng \
 "
RDEPENDS:aribb24-devel = " \
 aribb24 \
 pkgconf-pkg-config \
 "
