# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llvm12"
PV = "12.0.1"
PR = "13.el10_0"
PACKAGES = " \
 llvm12 \
 llvm12-devel \
 llvm12-doc \
 llvm12-libs \
 llvm12-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/llvm12-12.0.1-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2c75b899e3959fcb57a49e7faa1bd4eb74eb5f96c89e3637499c2e1353c3c7b"

URI_x86_64_v2_llvm12 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm12-12.0.1-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm12;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm12}"
SRC_URI[x86_64_v2_llvm12.sha256sum] = "bc4280e08b67102cd16564f4744decf1a3d1ef95ae2be2aff5f7cf8f565fb9f9"

URI_x86_64_v2_llvm12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm12-devel-12.0.1-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm12-devel}"
SRC_URI[x86_64_v2_llvm12-devel.sha256sum] = "dbba3ae49eb7e24990117d090787f375ae42019649b1713f1d945894ce0b06b0"

URI_x86_64_v2_llvm12-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm12-doc-12.0.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_llvm12-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm12-doc}"
SRC_URI[x86_64_v2_llvm12-doc.sha256sum] = "d07518e7acac646f671ddc6a090dd03ff4e979bb3df942e9d2caada26b07ec15"

URI_x86_64_v2_llvm12-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm12-libs-12.0.1-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm12-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm12-libs}"
SRC_URI[x86_64_v2_llvm12-libs.sha256sum] = "5d3ac5451962f3cd085bfbd7dd7fa812853d41c8c88c67c44af952c35e0fbaad"

URI_x86_64_v2_llvm12-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm12-static-12.0.1-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm12-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm12-static}"
SRC_URI[x86_64_v2_llvm12-static.sha256sum] = "8a8204e87db03a1e6d3c688aa10afa1c80cb76b9aed268eaecaf61d11aeb77db"

URI_aarch64_llvm12 = "${EPEL_MIRROR}/aarch64/Packages/l/llvm12-12.0.1-13.el10_0.aarch64.rpm;name=aarch64_llvm12;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm12}"
SRC_URI[aarch64_llvm12.sha256sum] = "cb96614e5c91e7f3f1d519ea2684d8a495ab2c0abc204c080652a9e94fc7ae9f"

URI_aarch64_llvm12-devel = "${EPEL_MIRROR}/aarch64/Packages/l/llvm12-devel-12.0.1-13.el10_0.aarch64.rpm;name=aarch64_llvm12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm12-devel}"
SRC_URI[aarch64_llvm12-devel.sha256sum] = "f2baf30dace2aaa6613b09575f2783ac07a30fd4edffce44f18d712f3fb4cba7"

URI_aarch64_llvm12-doc = "${EPEL_MIRROR}/aarch64/Packages/l/llvm12-doc-12.0.1-13.el10_0.noarch.rpm;name=aarch64_llvm12-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm12-doc}"
SRC_URI[aarch64_llvm12-doc.sha256sum] = "332c76ef4b7fa53bbc4a950361ba6981db5b5b49e28f375c66c210d9d9d6a144"

URI_aarch64_llvm12-libs = "${EPEL_MIRROR}/aarch64/Packages/l/llvm12-libs-12.0.1-13.el10_0.aarch64.rpm;name=aarch64_llvm12-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm12-libs}"
SRC_URI[aarch64_llvm12-libs.sha256sum] = "1f3a824224724cb857d197d6f788b13b033deb7118519a5de624dfcd6b1c674a"

URI_aarch64_llvm12-static = "${EPEL_MIRROR}/aarch64/Packages/l/llvm12-static-12.0.1-13.el10_0.aarch64.rpm;name=aarch64_llvm12-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm12-static}"
SRC_URI[aarch64_llvm12-static.sha256sum] = "90742a6db9319020d3023b269f3482d15c4e1a8d505f038e00c64ca5047d4d33"

RDEPENDS:llvm12 = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm12-libs \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:llvm12-devel = " \
 alternatives \
 bash \
 libedit-devel \
 llvm12 \
 llvm12-libs \
 llvm12-static \
 "
RDEPENDS:llvm12-doc = " \
 llvm12 \
 "
RDEPENDS:llvm12-libs = " \
 glibc \
 libedit \
 libffi \
 libgcc \
 libstdc++ \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:llvm12-static = " \
 "
