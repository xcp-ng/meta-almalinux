# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-automod"
PV = "1.0.17"
PR = "1.el10_2"
PACKAGES = " \
 rust-automod+default-devel \
 rust-automod-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-automod-1.0.17-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5e9de5ccea0f5f5c7e5a0ed0b2d5bc2ff820717507a56bb76d79bb518113b79"

URI_x86_64_v2_rust-automod+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-automod+default-devel-1.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-automod+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-automod+default-devel}"
SRC_URI[x86_64_v2_rust-automod+default-devel.sha256sum] = "c530a59c994a3da33d3a18a189e6e738c4b8f65a0bde865d0c1cd69c4dab9d57"

URI_x86_64_v2_rust-automod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-automod-devel-1.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-automod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-automod-devel}"
SRC_URI[x86_64_v2_rust-automod-devel.sha256sum] = "f512d651061de950fdbbc92bb64ed5fab157341a1a05868509cc574b7d77a411"

URI_aarch64_rust-automod+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-automod+default-devel-1.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-automod+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-automod+default-devel}"
SRC_URI[aarch64_rust-automod+default-devel.sha256sum] = "a3575164f1cd8634801e48c091f1f78136d01c9079f1a1d745bfb298d983e69b"

URI_aarch64_rust-automod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-automod-devel-1.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-automod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-automod-devel}"
SRC_URI[aarch64_rust-automod-devel.sha256sum] = "9bae49287a67d39d6d304d7b3d69c2501ffa4f21b0e8d44b37c89b1ff26716c8"

RDEPENDS:rust-automod+default-devel = " \
 cargo \
 rust-automod-devel \
 "
RDEPENDS:rust-automod-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
