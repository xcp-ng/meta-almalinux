# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "signify"
PV = "33"
PR = "1.el10_2"
PACKAGES = " \
 signify \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/signify-33-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "441516eaf87c226ccac77666379871644b8959d280653cbc712acde259e3d29c"

URI_x86_64_v2_signify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signify-33-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signify}"
SRC_URI[x86_64_v2_signify.sha256sum] = "501359eecde84235bd21e8a3d631fffebb4d3f8a1cc0ed8250654a6b47235c8d"

URI_aarch64_signify = "${EPEL_MIRROR}/aarch64/Packages/s/signify-33-1.el10_2.aarch64.rpm;name=aarch64_signify;unpack=0"
SRC_URI:append = " ${URI_aarch64_signify}"
SRC_URI[aarch64_signify.sha256sum] = "620b844f07fc596aed6be68616659572b16c51c7abb231a9d5a814c41fec8f00"

RDEPENDS:signify = " \
 glibc \
 libbsd \
 "
