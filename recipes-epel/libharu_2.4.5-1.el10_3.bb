# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libharu"
PV = "2.4.5"
PR = "1.el10_3"
PACKAGES = " \
 libharu \
 libharu-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libharu-2.4.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7f47821ba5f5392eb1748684c789d6f6448b77e65c86f6bbd88555d1f580b98"

URI_x86_64_v2_libharu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libharu-2.4.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libharu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libharu}"
SRC_URI[x86_64_v2_libharu.sha256sum] = "fdef12ba7d9a67fd1f38ec2a84f1f16bf1bfba9912929e47c47f7619cc971eda"

URI_x86_64_v2_libharu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libharu-devel-2.4.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libharu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libharu-devel}"
SRC_URI[x86_64_v2_libharu-devel.sha256sum] = "ade46f1bdc8628b3a4e73b64f9b5496d7bfee2a777d721b784cc20175e0e1760"

URI_aarch64_libharu = "${EPEL_MIRROR}/aarch64/Packages/l/libharu-2.4.5-1.el10_3.aarch64.rpm;name=aarch64_libharu;unpack=0"
SRC_URI:append = " ${URI_aarch64_libharu}"
SRC_URI[aarch64_libharu.sha256sum] = "c0d1e158a7cb4ac68ea284dd4303075e735c169d9ef204dab24e043104b5e3c1"

URI_aarch64_libharu-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libharu-devel-2.4.5-1.el10_3.aarch64.rpm;name=aarch64_libharu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libharu-devel}"
SRC_URI[aarch64_libharu-devel.sha256sum] = "681ea73789eaf3dec57030f132f83a2e0e883154a3abf11e0972ff25d2163bfb"

RDEPENDS:libharu = " \
 glibc \
 libpng \
 zlib-ng-compat \
 "
RDEPENDS:libharu-devel = " \
 libharu \
 "
