# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-stestr"
PV = "4.2.1"
PR = "4.el10_2"
PACKAGES = " \
 python-stestr-doc \
 python3-stestr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-stestr-4.2.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8509705b2d57a3c79fc4a9d34dd9844af35e6a68660ca8666d00df009a5a7612"

URI_x86_64_v2_python-stestr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-stestr-doc-4.2.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-stestr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-stestr-doc}"
SRC_URI[x86_64_v2_python-stestr-doc.sha256sum] = "ca66072df1537fe311e48fc8adc5b2d9b8400a1705dba861c478eb32599d4524"

URI_x86_64_v2_python3-stestr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-stestr-4.2.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-stestr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-stestr}"
SRC_URI[x86_64_v2_python3-stestr.sha256sum] = "b44af49efc41a303a3d1edd8e5f427c0faa2cdc8fad8e331b442b1546baaa284"

URI_aarch64_python-stestr-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-stestr-doc-4.2.1-4.el10_2.noarch.rpm;name=aarch64_python-stestr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-stestr-doc}"
SRC_URI[aarch64_python-stestr-doc.sha256sum] = "268e637ef7304b8e5fb9947cae9c1a34d58f1ceb99cf42fda3ab96b9a61f991b"

URI_aarch64_python3-stestr = "${EPEL_MIRROR}/aarch64/Packages/p/python3-stestr-4.2.1-4.el10_2.noarch.rpm;name=aarch64_python3-stestr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-stestr}"
SRC_URI[aarch64_python3-stestr.sha256sum] = "6cd169d388fa6fbfd4a396f8fdacce3a7ab1ed17c23c581640f62113e6d1e732"

RDEPENDS:python-stestr-doc = " \
 "
RDEPENDS:python3-stestr = " \
 python3 \
 python3-cliff \
 python3-fixtures \
 python3-pyyaml \
 python3-subunit \
 python3-testtools \
 python3-tomlkit \
 python3-voluptuous \
 "
