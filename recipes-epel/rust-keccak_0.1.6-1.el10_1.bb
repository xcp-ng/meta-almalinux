# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-keccak"
PV = "0.1.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-keccak+asm-devel \
 rust-keccak+default-devel \
 rust-keccak+no_unroll-devel \
 rust-keccak+simd-devel \
 rust-keccak-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-keccak-0.1.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2120f70c7542e678b8296bea4832f114decf97ff5934b6b025bf6bf6726a980"

URI_x86_64_v2_rust-keccak+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak+asm-devel-0.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak+asm-devel}"
SRC_URI[x86_64_v2_rust-keccak+asm-devel.sha256sum] = "461e0ac754b43d52619c2bdbb8205a56cffda986a3e132b302d1332d37c03aea"

URI_x86_64_v2_rust-keccak+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak+default-devel-0.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak+default-devel}"
SRC_URI[x86_64_v2_rust-keccak+default-devel.sha256sum] = "84116f6ee8bb69d040c4cb78ffd3e888b6b3272b29268edc5e5a039eeb06ca52"

URI_x86_64_v2_rust-keccak+no_unroll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak+no_unroll-devel-0.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak+no_unroll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak+no_unroll-devel}"
SRC_URI[x86_64_v2_rust-keccak+no_unroll-devel.sha256sum] = "60497100a854d4265b5676b02927985db4645f81304ce79e6bdd232b7ae6fee6"

URI_x86_64_v2_rust-keccak+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak+simd-devel-0.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak+simd-devel}"
SRC_URI[x86_64_v2_rust-keccak+simd-devel.sha256sum] = "05a9a66f2e3eaa7f40f4b80cf924b1fd7f2e7047fdf6020ea65e473fe8d225d4"

URI_x86_64_v2_rust-keccak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak-devel-0.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak-devel}"
SRC_URI[x86_64_v2_rust-keccak-devel.sha256sum] = "42540b63d7cc9a435ae2d070d538bdc5e9bbc6b558f85b1099627eff6641ba30"

URI_aarch64_rust-keccak+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak+asm-devel-0.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-keccak+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak+asm-devel}"
SRC_URI[aarch64_rust-keccak+asm-devel.sha256sum] = "a7edb48eca94805a4045c8f17188ae0a050c6762c2024c4fbfaa736966bdb8bf"

URI_aarch64_rust-keccak+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak+default-devel-0.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-keccak+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak+default-devel}"
SRC_URI[aarch64_rust-keccak+default-devel.sha256sum] = "d88114b85222465195224d08611bf70c9185fb936de7951ac9e4743fc9ac3ae1"

URI_aarch64_rust-keccak+no_unroll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak+no_unroll-devel-0.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-keccak+no_unroll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak+no_unroll-devel}"
SRC_URI[aarch64_rust-keccak+no_unroll-devel.sha256sum] = "393246cb67d88cb75fcb9589bf0cb173c5a6b35aef629da2c6e14e90e642a499"

URI_aarch64_rust-keccak+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak+simd-devel-0.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-keccak+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak+simd-devel}"
SRC_URI[aarch64_rust-keccak+simd-devel.sha256sum] = "a70d7982cda80a8b159c68ef1d7bf349c0106ac5384eec3638e21e1d91bc87d9"

URI_aarch64_rust-keccak-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak-devel-0.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-keccak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak-devel}"
SRC_URI[aarch64_rust-keccak-devel.sha256sum] = "131480999bd184b4a701c324890216620deacc0e16465198b930d88a1f0b3a1b"

RDEPENDS:rust-keccak+asm-devel = " \
 cargo \
 rust-keccak-devel \
 "
RDEPENDS:rust-keccak+default-devel = " \
 cargo \
 rust-keccak-devel \
 "
RDEPENDS:rust-keccak+no_unroll-devel = " \
 cargo \
 rust-keccak-devel \
 "
RDEPENDS:rust-keccak+simd-devel = " \
 cargo \
 rust-keccak-devel \
 "
RDEPENDS:rust-keccak-devel = " \
 cargo \
 rust-cpufeatures+default-devel \
 "
