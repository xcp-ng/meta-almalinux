# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_mktemp"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_mktemp+default-devel \
 rust-uu_mktemp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_mktemp-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6408fe5c83ce5233717bd1632931062cdcb7d759302e7b103380e0c1d6696699"

URI_x86_64_v2_rust-uu_mktemp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_mktemp+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_mktemp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_mktemp+default-devel}"
SRC_URI[x86_64_v2_rust-uu_mktemp+default-devel.sha256sum] = "9cd02a645a4c2805cff5484276a8712cc2b037f57611ff3017d3135b5795efae"

URI_x86_64_v2_rust-uu_mktemp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_mktemp-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_mktemp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_mktemp-devel}"
SRC_URI[x86_64_v2_rust-uu_mktemp-devel.sha256sum] = "b16daba5dd38791cb8c695832472c19b25d524b87287af6b9238a240dd4e0d40"

URI_aarch64_rust-uu_mktemp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_mktemp+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_mktemp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_mktemp+default-devel}"
SRC_URI[aarch64_rust-uu_mktemp+default-devel.sha256sum] = "1ca5b0d1ef4fc8ff9b857f0df83fa54fb7e4d9932ec99d097dfaaadf61ccdbec"

URI_aarch64_rust-uu_mktemp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_mktemp-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_mktemp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_mktemp-devel}"
SRC_URI[aarch64_rust-uu_mktemp-devel.sha256sum] = "d55739763f2e1f59453dc525412bf3f3906e65aeeee582841a1a7672de9d42e6"

RDEPENDS:rust-uu_mktemp+default-devel = " \
 cargo \
 rust-uu_mktemp-devel \
 "
RDEPENDS:rust-uu_mktemp-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-rand0.9+default-devel \
 rust-rand0.9+small_rng-devel \
 rust-tempfile+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 "
