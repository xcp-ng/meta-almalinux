# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-matchers"
PV = "0.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-matchers+default-devel \
 rust-matchers+unicode-devel \
 rust-matchers-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-matchers-0.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c41c96cb2d3a79459ad6d79c7d81b49f206fe3d8e873fe8ce4ba25ef50dc24f5"

URI_x86_64_v2_rust-matchers+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchers+default-devel-0.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchers+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchers+default-devel}"
SRC_URI[x86_64_v2_rust-matchers+default-devel.sha256sum] = "b61bf7f1cfc6135a3909420cd09ac44423164bb483af6f5d981ec54bfa3baafb"

URI_x86_64_v2_rust-matchers+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchers+unicode-devel-0.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchers+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchers+unicode-devel}"
SRC_URI[x86_64_v2_rust-matchers+unicode-devel.sha256sum] = "37985de09c273016d4ebeae04961bae800aff30cd41835ddf68389454f1a8800"

URI_x86_64_v2_rust-matchers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchers-devel-0.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchers-devel}"
SRC_URI[x86_64_v2_rust-matchers-devel.sha256sum] = "439446d675343b63ca7ba5afc29e30df213d161045850d81e70072ec04a7adbf"

URI_aarch64_rust-matchers+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchers+default-devel-0.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-matchers+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchers+default-devel}"
SRC_URI[aarch64_rust-matchers+default-devel.sha256sum] = "883a4f1587c233a3946e708cfe540181ba753196a70937a8ff05c6521cef1bbf"

URI_aarch64_rust-matchers+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchers+unicode-devel-0.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-matchers+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchers+unicode-devel}"
SRC_URI[aarch64_rust-matchers+unicode-devel.sha256sum] = "4f867b5d3494af76e8266c892084a9df4c38f5d609b32ab427fcb9d523cf274f"

URI_aarch64_rust-matchers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchers-devel-0.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-matchers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchers-devel}"
SRC_URI[aarch64_rust-matchers-devel.sha256sum] = "7d68316e0c6a5584408b6818c53b5aab38724ec2fe1b46125c92380f131ef7fc"

RDEPENDS:rust-matchers+default-devel = " \
 cargo \
 rust-matchers-devel \
 "
RDEPENDS:rust-matchers+unicode-devel = " \
 cargo \
 rust-matchers-devel \
 rust-regex-automata+unicode-devel \
 "
RDEPENDS:rust-matchers-devel = " \
 cargo \
 rust-regex-automata+dfa-build-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 "
