# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "checkpointctl"
PE = "1"
PV = "1.4.1"
PR = "1.el10_1"
PACKAGES = " \
 checkpointctl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/checkpointctl-1.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e97a7cb57b55adfc6cb40aacb89aaa712458c8b695a61a879c088b6150bd0acc"

URI_x86_64_v2_checkpointctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/checkpointctl-1.4.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_checkpointctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_checkpointctl}"
SRC_URI[x86_64_v2_checkpointctl.sha256sum] = "172fa918aa011418c550310df8f408b352f5dc361a1d7c85a68b229ad79e57aa"

URI_aarch64_checkpointctl = "${EPEL_MIRROR}/aarch64/Packages/c/checkpointctl-1.4.1-1.el10_1.aarch64.rpm;name=aarch64_checkpointctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_checkpointctl}"
SRC_URI[aarch64_checkpointctl.sha256sum] = "d39336b4bf8e5c0593c1eb77664878a3d86d25ccb51cb6cb8844e2bf76e8c884"

RDEPENDS:checkpointctl = " \
 glibc \
 "
