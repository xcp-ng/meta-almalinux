# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-asn1"
PV = "0.24.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-asn1+default-devel \
 rust-asn1+std-devel \
 rust-asn1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-asn1-0.24.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5038f000d32f81aeb948d4948c04a056610293e6162e167eec9dea094b6a0833"

URI_x86_64_v2_rust-asn1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1+default-devel-0.24.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1+default-devel}"
SRC_URI[x86_64_v2_rust-asn1+default-devel.sha256sum] = "07a96e57d74c2a368147d878ce6367e8354b0375f9ba8b73bd813eff7d395531"

URI_x86_64_v2_rust-asn1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1+std-devel-0.24.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1+std-devel}"
SRC_URI[x86_64_v2_rust-asn1+std-devel.sha256sum] = "78334df05581be24b7559e5df7bd05b6536e5e99c13fd570750533fb44213314"

URI_x86_64_v2_rust-asn1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-devel-0.24.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-devel}"
SRC_URI[x86_64_v2_rust-asn1-devel.sha256sum] = "69fe010718d86609abe869bed34e5da9b7b8bcc0ddc2a42273821ed609ab9e9b"

URI_aarch64_rust-asn1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1+default-devel-0.24.1-2.el10_2.noarch.rpm;name=aarch64_rust-asn1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1+default-devel}"
SRC_URI[aarch64_rust-asn1+default-devel.sha256sum] = "ec32f47f6e62f1684a0db498e8826509bd451946d886112b9feb53775cfc9caf"

URI_aarch64_rust-asn1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1+std-devel-0.24.1-2.el10_2.noarch.rpm;name=aarch64_rust-asn1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1+std-devel}"
SRC_URI[aarch64_rust-asn1+std-devel.sha256sum] = "31cea31258b716acf4758ee4b2a52c0bd33c4c4e0a13111ee6bbc95b25341df1"

URI_aarch64_rust-asn1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-devel-0.24.1-2.el10_2.noarch.rpm;name=aarch64_rust-asn1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-devel}"
SRC_URI[aarch64_rust-asn1-devel.sha256sum] = "b3ef30d87593c6d7b18c7febe0c20959a8d940beb517d4a984fa57bddacc3c4b"

RDEPENDS:rust-asn1+default-devel = " \
 cargo \
 rust-asn1+std-devel \
 rust-asn1-devel \
 "
RDEPENDS:rust-asn1+std-devel = " \
 cargo \
 rust-asn1-devel \
 "
RDEPENDS:rust-asn1-devel = " \
 cargo \
 rust \
 rust-asn1_derive+default-devel \
 rust-itoa+default-devel \
 "
