# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-magnumclient"
PV = "4.10.0"
PR = "1.el10_3"
PACKAGES = " \
 python-magnumclient-doc \
 python3-magnumclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-magnumclient-4.10.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7e6f9c8705acfe2698a1fe1bc4ad5fb5d9d89639d62f97a4862ba66887a64bf"

URI_x86_64_v2_python-magnumclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-magnumclient-doc-4.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-magnumclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-magnumclient-doc}"
SRC_URI[x86_64_v2_python-magnumclient-doc.sha256sum] = "875e9ad89daa249abc92379818fef09ed4a81d9c0b759493fac8303a139552d3"

URI_x86_64_v2_python3-magnumclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-magnumclient-4.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-magnumclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-magnumclient}"
SRC_URI[x86_64_v2_python3-magnumclient.sha256sum] = "d3bf699a351676f5c982377fc8f4c7193ddf2462a720367380df32aa281a82d8"

URI_aarch64_python-magnumclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-magnumclient-doc-4.10.0-1.el10_3.noarch.rpm;name=aarch64_python-magnumclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-magnumclient-doc}"
SRC_URI[aarch64_python-magnumclient-doc.sha256sum] = "5d87bc87c294e6cf81791ad8e54ebacb0943cf574db9d7e030ddee63a335e131"

URI_aarch64_python3-magnumclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-magnumclient-4.10.0-1.el10_3.noarch.rpm;name=aarch64_python3-magnumclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-magnumclient}"
SRC_URI[aarch64_python3-magnumclient.sha256sum] = "e32df3a486decd0bb8cac94bcc5ee743ed112e59de5f7856e9b91d4c3d82a08f"

RDEPENDS:python-magnumclient-doc = " \
 "
RDEPENDS:python3-magnumclient = " \
 python3 \
 python3-cryptography \
 python3-decorator \
 python3-keystoneauth1 \
 python3-openstacksdk \
 python3-osc-lib \
 python3-oslo-i18n \
 python3-oslo-log \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-prettytable \
 python3-requests \
 python3-stevedore \
 "
