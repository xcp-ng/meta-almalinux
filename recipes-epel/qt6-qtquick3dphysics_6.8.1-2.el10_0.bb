# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtquick3dphysics"
PV = "6.8.1"
PR = "2.el10_0"
PACKAGES = " \
 qt6-qtquick3dphysics \
 qt6-qtquick3dphysics-devel \
 qt6-qtquick3dphysics-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtquick3dphysics-6.8.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab8fae99ebbd21420b5f2a5d93b5bd082acdd313d8c3864a1baa77288f1ec604"

URI_x86_64_v2_qt6-qtquick3dphysics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtquick3dphysics-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtquick3dphysics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtquick3dphysics}"
SRC_URI[x86_64_v2_qt6-qtquick3dphysics.sha256sum] = "d3b18f303d2e8e849e84067b573016799d7b63384a5ab3d87d4f030ab4b69c97"

URI_x86_64_v2_qt6-qtquick3dphysics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtquick3dphysics-devel-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtquick3dphysics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtquick3dphysics-devel}"
SRC_URI[x86_64_v2_qt6-qtquick3dphysics-devel.sha256sum] = "b8143fcbe1d2a2fd00e0d8302546ceffe4911a35db2fabf2271d4b62617a8da4"

URI_x86_64_v2_qt6-qtquick3dphysics-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtquick3dphysics-examples-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtquick3dphysics-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtquick3dphysics-examples}"
SRC_URI[x86_64_v2_qt6-qtquick3dphysics-examples.sha256sum] = "8e06250f8d9a48af025deb4a82e22f54bd4d7a13f87599a8df0086750a7a51b3"

URI_aarch64_qt6-qtquick3dphysics = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtquick3dphysics-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtquick3dphysics;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtquick3dphysics}"
SRC_URI[aarch64_qt6-qtquick3dphysics.sha256sum] = "2a93f339f9f7c9611129bdb4f879a8f178ee64a04ab7a4e94c940235430c052a"

URI_aarch64_qt6-qtquick3dphysics-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtquick3dphysics-devel-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtquick3dphysics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtquick3dphysics-devel}"
SRC_URI[aarch64_qt6-qtquick3dphysics-devel.sha256sum] = "8eb5dd47e8355e5a340874cc7eeb5dbf7c9cce30af216106441159f7709efad6"

URI_aarch64_qt6-qtquick3dphysics-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtquick3dphysics-examples-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtquick3dphysics-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtquick3dphysics-examples}"
SRC_URI[aarch64_qt6-qtquick3dphysics-examples.sha256sum] = "e6fe3743e11e5851d96c8bac31d32e6ea703adef36d93e49b6926292397c24e0"

RDEPENDS:qt6-qtquick3dphysics = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 "
RDEPENDS:qt6-qtquick3dphysics-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qtdeclarative-devel \
 qt6-qtquick3d \
 qt6-qtquick3d-devel \
 qt6-qtquick3dphysics \
 "
RDEPENDS:qt6-qtquick3dphysics-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3dphysics \
 "
