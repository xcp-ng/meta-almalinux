# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-w3lib"
PV = "2.3.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-w3lib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-w3lib-2.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8aa5f3e780a07059427966ff67d1d12d788e4628231b8af3f8e1e87c6522c70"

URI_x86_64_v2_python3-w3lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-w3lib-2.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-w3lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-w3lib}"
SRC_URI[x86_64_v2_python3-w3lib.sha256sum] = "eb3bedf97f457e944ec43aeee6ac3514d92ad0f73ac92e050ecbbf352c5f5c37"

URI_aarch64_python3-w3lib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-w3lib-2.3.1-1.el10_0.noarch.rpm;name=aarch64_python3-w3lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-w3lib}"
SRC_URI[aarch64_python3-w3lib.sha256sum] = "5ee9b4833f50b6e578bdbd59c7e537b19f022c1b6d22fac16792c83a0a213584"

RDEPENDS:python3-w3lib = " \
 python3 \
 "
