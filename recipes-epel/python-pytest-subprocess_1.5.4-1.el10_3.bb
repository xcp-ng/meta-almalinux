# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-subprocess"
PV = "1.5.4"
PR = "1.el10_3"
PACKAGES = " \
 python3-pytest-subprocess \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-subprocess-1.5.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa9e23e9cb9338355db018d4d8f50da14d7d18fad360a82d401f33ba7a7461e5"

URI_x86_64_v2_python3-pytest-subprocess = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-subprocess-1.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-subprocess;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-subprocess}"
SRC_URI[x86_64_v2_python3-pytest-subprocess.sha256sum] = "92d33bb0846adec63271a715e5c5bc8bdee063f4edbe1f16063103e594823624"

URI_aarch64_python3-pytest-subprocess = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-subprocess-1.5.4-1.el10_3.noarch.rpm;name=aarch64_python3-pytest-subprocess;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-subprocess}"
SRC_URI[aarch64_python3-pytest-subprocess.sha256sum] = "bfc855f9b8cf52c5d82450f6b5b90da03a99dbf7b1ba1e2450cc5b6b781853fb"

RDEPENDS:python3-pytest-subprocess = " \
 python3 \
 python3-pytest \
 "
