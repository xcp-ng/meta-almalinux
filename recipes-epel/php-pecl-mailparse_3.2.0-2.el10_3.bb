# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-mailparse"
PV = "3.2.0"
PR = "2.el10_3"
PACKAGES = " \
 php-pecl-mailparse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-mailparse-3.2.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31260d02661982e928dd36165236d5dfd76a07a9746651315aa045e2955589b0"

URI_x86_64_v2_php-pecl-mailparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-mailparse-3.2.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-mailparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-mailparse}"
SRC_URI[x86_64_v2_php-pecl-mailparse.sha256sum] = "242b6e20436ad091fd23ced218b97285c8c7abd560e870821644d7f5de123331"

URI_aarch64_php-pecl-mailparse = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-mailparse-3.2.0-2.el10_3.aarch64.rpm;name=aarch64_php-pecl-mailparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-mailparse}"
SRC_URI[aarch64_php-pecl-mailparse.sha256sum] = "0188695b7ab7d6daba29da18c27efe8f67a55eebfe8175b39f399a2cf56182d3"

RDEPENDS:php-pecl-mailparse = " \
 glibc \
 php-common \
 "
