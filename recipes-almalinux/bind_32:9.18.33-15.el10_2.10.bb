# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bind"
PE = "32"
PV = "9.18.33"
PR = "15.el10_2.10"
PACKAGES = " \
 bind \
 bind-chroot \
 bind-devel \
 bind-dnssec-utils \
 bind-doc \
 bind-libs \
 bind-license \
 bind-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bind-9.18.33-15.el10_2.10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d92c9d147a0cd7dbff5d4bbdbb407d1fa281bb8083825a7a6bf90346d2df2e9"

URI_x86_64_v2_bind = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-9.18.33-15.el10_2.10.x86_64_v2.rpm;name=x86_64_v2_bind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind}"
SRC_URI[x86_64_v2_bind.sha256sum] = "4a1d79869711ae51b9ae95c2e3d17b222f76915ed16121af31d47dd1de20e8f6"

URI_x86_64_v2_bind-chroot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-chroot-9.18.33-15.el10_2.10.x86_64_v2.rpm;name=x86_64_v2_bind-chroot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-chroot}"
SRC_URI[x86_64_v2_bind-chroot.sha256sum] = "96865d990dd12f80d93bf63663a5612bab8a14a0cf1fdb976144c600322512c6"

URI_x86_64_v2_bind-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bind-devel-9.18.33-15.el10_2.10.x86_64_v2.rpm;name=x86_64_v2_bind-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-devel}"
SRC_URI[x86_64_v2_bind-devel.sha256sum] = "d9d4825a7e3792aa8cc34c8cbd5fc6541eb4a9e6a7c9e9ab19407bb70045c2ca"

URI_x86_64_v2_bind-dnssec-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-dnssec-utils-9.18.33-15.el10_2.10.x86_64_v2.rpm;name=x86_64_v2_bind-dnssec-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-dnssec-utils}"
SRC_URI[x86_64_v2_bind-dnssec-utils.sha256sum] = "685abd266ec002e7fff8febe21204b66e7861beef11eaa14440cd17a239778e2"

URI_x86_64_v2_bind-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bind-doc-9.18.33-15.el10_2.10.noarch.rpm;name=x86_64_v2_bind-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-doc}"
SRC_URI[x86_64_v2_bind-doc.sha256sum] = "bef2f81f4c02f8446fe4280195a27721cd50f030c9396aa4d7f34ad45d7fc63c"

URI_x86_64_v2_bind-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-libs-9.18.33-15.el10_2.10.x86_64_v2.rpm;name=x86_64_v2_bind-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-libs}"
SRC_URI[x86_64_v2_bind-libs.sha256sum] = "e000fd62c4e1ec48610291e2b6c4ee431111dffd82143565a50c84859c6a9c64"

URI_x86_64_v2_bind-license = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-license-9.18.33-15.el10_2.10.noarch.rpm;name=x86_64_v2_bind-license;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-license}"
SRC_URI[x86_64_v2_bind-license.sha256sum] = "e7269f3a04d0f19af0b01cb87ae997a2d63f8b901c3fbbbd06b2be1ac756d519"

URI_x86_64_v2_bind-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-utils-9.18.33-15.el10_2.10.x86_64_v2.rpm;name=x86_64_v2_bind-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-utils}"
SRC_URI[x86_64_v2_bind-utils.sha256sum] = "9ecc585a8ac59230087d7fcc71647e0bb48be3cfe777bcd6c005471d84258973"

URI_aarch64_bind = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-9.18.33-15.el10_2.10.aarch64.rpm;name=aarch64_bind;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind}"
SRC_URI[aarch64_bind.sha256sum] = "f11cba18f5b3021f6d369270dcd3f677403c9d74381fa9664cfc2b29c0891986"

URI_aarch64_bind-chroot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-chroot-9.18.33-15.el10_2.10.aarch64.rpm;name=aarch64_bind-chroot;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-chroot}"
SRC_URI[aarch64_bind-chroot.sha256sum] = "6fdac0fc0c986797863283705dcc31a7d91382a529db5f95e52f5ff9565c324c"

URI_aarch64_bind-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bind-devel-9.18.33-15.el10_2.10.aarch64.rpm;name=aarch64_bind-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-devel}"
SRC_URI[aarch64_bind-devel.sha256sum] = "1811de90ac1095651a0cb1b5999a2172d89214075e120af4889325251b4de475"

URI_aarch64_bind-dnssec-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-dnssec-utils-9.18.33-15.el10_2.10.aarch64.rpm;name=aarch64_bind-dnssec-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-dnssec-utils}"
SRC_URI[aarch64_bind-dnssec-utils.sha256sum] = "66b4318adbf0fc787471d55409532cff0485e09adcf0b1892790f6fa114851c8"

URI_aarch64_bind-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bind-doc-9.18.33-15.el10_2.10.noarch.rpm;name=aarch64_bind-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-doc}"
SRC_URI[aarch64_bind-doc.sha256sum] = "bef2f81f4c02f8446fe4280195a27721cd50f030c9396aa4d7f34ad45d7fc63c"

URI_aarch64_bind-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-libs-9.18.33-15.el10_2.10.aarch64.rpm;name=aarch64_bind-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-libs}"
SRC_URI[aarch64_bind-libs.sha256sum] = "f00ae9f038455fb68f1a0fe62a6d066fcc55a64c4f6ee7478bf171022f7ddbdf"

URI_aarch64_bind-license = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-license-9.18.33-15.el10_2.10.noarch.rpm;name=aarch64_bind-license;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-license}"
SRC_URI[aarch64_bind-license.sha256sum] = "e7269f3a04d0f19af0b01cb87ae997a2d63f8b901c3fbbbd06b2be1ac756d519"

URI_aarch64_bind-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-utils-9.18.33-15.el10_2.10.aarch64.rpm;name=aarch64_bind-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-utils}"
SRC_URI[aarch64_bind-utils.sha256sum] = "cfc574740ee82a8fa55aef853cf6f3308448e93a6b911031e398e1e973b1c6f9"

RDEPENDS:bind = " \
 bash \
 bind-libs \
 fstrm \
 glibc \
 glibc-common \
 grep \
 json-c \
 libcap \
 libmaxminddb \
 libnghttp2 \
 libuv \
 libxml2 \
 lmdb-libs \
 openssl-libs \
 protobuf-c \
 shadow-utils \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:bind-chroot = " \
 bash \
 bind \
 grep \
 "
RDEPENDS:bind-devel = " \
 bind-libs \
 fstrm-devel \
 json-c-devel \
 krb5-devel \
 libcap-devel \
 libmaxminddb-devel \
 libxml2-devel \
 lmdb-devel \
 openssl-devel \
 protobuf-c-devel \
 "
RDEPENDS:bind-dnssec-utils = " \
 bind-libs \
 glibc \
 "
RDEPENDS:bind-doc = " \
 bind-license \
 python3-sphinx_rtd_theme \
 "
RDEPENDS:bind-libs = " \
 bind-license \
 fstrm \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libmaxminddb \
 libnghttp2 \
 libuv \
 libxml2 \
 lmdb-libs \
 openssl-libs \
 protobuf-c \
 zlib-ng-compat \
 "
RDEPENDS:bind-license = " \
 "
RDEPENDS:bind-utils = " \
 bind-libs \
 glibc \
 krb5-libs \
 libidn2 \
 lmdb-libs \
 protobuf-c \
 "
