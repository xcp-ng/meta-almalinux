# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmbox"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kmbox \
 kmbox-devel \
 kmbox-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmbox-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2b719495964d5301496432a34abd820b88f014bd838356118b23c53e5b5c248"

URI_x86_64_v2_kmbox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmbox}"
SRC_URI[x86_64_v2_kmbox.sha256sum] = "9363197f40a673c87124a569994f4e813061ccacf0f45239c09a18ec080b8108"

URI_x86_64_v2_kmbox-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmbox-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmbox-devel}"
SRC_URI[x86_64_v2_kmbox-devel.sha256sum] = "5311d20955b17851def771c245e7d20202633803559c2e0bdaa3321c6a6ea5db"

URI_x86_64_v2_kmbox-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kmbox-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmbox-doc}"
SRC_URI[x86_64_v2_kmbox-doc.sha256sum] = "1a1403ecfebb4a0c6bd7ae938871252aaac93f2bb888cfceada14d3a6703da4a"

URI_aarch64_kmbox = "${EPEL_MIRROR}/aarch64/Packages/k/kmbox-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kmbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmbox}"
SRC_URI[aarch64_kmbox.sha256sum] = "35fc702e2306769040776b4afcdf9297d2878b17a04dd301a25047f2ceb209fc"

URI_aarch64_kmbox-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kmbox-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kmbox-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmbox-devel}"
SRC_URI[aarch64_kmbox-devel.sha256sum] = "2cbc2c2227ebf68f406e296f066128eeaa554b88d2575d07bcc20c2555e0031a"

URI_aarch64_kmbox-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kmbox-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kmbox-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmbox-doc}"
SRC_URI[aarch64_kmbox-doc.sha256sum] = "1f1f13bd2677601ee0b12249cf361477cb675ea3f1a4f20bf9be5a498734e52b"

RDEPENDS:kmbox = " \
 glibc \
 kmime \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kmbox-devel = " \
 cmake-filesystem \
 kmbox \
 kmime-devel \
 "
RDEPENDS:kmbox-doc = " \
 "
