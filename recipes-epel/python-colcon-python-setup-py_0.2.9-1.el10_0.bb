# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-python-setup-py"
PV = "0.2.9"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-python-setup-py \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-python-setup-py-0.2.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42c9d9559b822dff442259a0d623349064befbd8b7645c0a3ca41c72e7084c41"

URI_x86_64_v2_python3-colcon-python-setup-py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-python-setup-py-0.2.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-python-setup-py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-python-setup-py}"
SRC_URI[x86_64_v2_python3-colcon-python-setup-py.sha256sum] = "97bcd7e24493beb68477dfa7cac49e1e258c741ce2ae9755aed9b02a0348e792"

URI_aarch64_python3-colcon-python-setup-py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-python-setup-py-0.2.9-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-python-setup-py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-python-setup-py}"
SRC_URI[aarch64_python3-colcon-python-setup-py.sha256sum] = "120dbf037397a4386ddaf73663de76dd6e961cfbf983e352427c54df875e557e"

RDEPENDS:python3-colcon-python-setup-py = " \
 python3 \
 python3-colcon-core \
 python3-setuptools \
 "
