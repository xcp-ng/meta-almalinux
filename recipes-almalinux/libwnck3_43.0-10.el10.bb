# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libwnck3"
PV = "43.0"
PR = "10.el10"
PACKAGES = " \
 libwnck3 \
 libwnck3-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libwnck3-43.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee23a1fda484aa5956b39c11c7d035b93ed743deee969720230b26fea5847b76"

URI_x86_64_v2_libwnck3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwnck3-43.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_libwnck3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwnck3}"
SRC_URI[x86_64_v2_libwnck3.sha256sum] = "b5c0de36ed6ab9c2f14dfded2edcfad6fd9f74e4a98f1f77efc84972e810c0db"

URI_x86_64_v2_libwnck3-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwnck3-devel-43.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_libwnck3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwnck3-devel}"
SRC_URI[x86_64_v2_libwnck3-devel.sha256sum] = "90112c4ecb33fcf117b77af57e2433b44391797285504756e0883a6ae431698f"

URI_aarch64_libwnck3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwnck3-43.0-10.el10.aarch64.rpm;name=aarch64_libwnck3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwnck3}"
SRC_URI[aarch64_libwnck3.sha256sum] = "18e5f69148d5a7125bdbe05b07c76f7779edbc66be5aca59427320fc739b1090"

URI_aarch64_libwnck3-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwnck3-devel-43.0-10.el10.aarch64.rpm;name=aarch64_libwnck3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwnck3-devel}"
SRC_URI[aarch64_libwnck3-devel.sha256sum] = "0ce4e8cb5c86109c7dfbad30c9d643bc71e4dd57bf3387d0744d3e8a95b9657d"

RDEPENDS:libwnck3 = " \
 atk \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libX11 \
 libXrender \
 libXres \
 pango \
 startup-notification \
 "
RDEPENDS:libwnck3-devel = " \
 cairo-devel \
 glib2 \
 glib2-devel \
 glibc \
 gtk3 \
 gtk3-devel \
 libX11 \
 libX11-devel \
 libXres-devel \
 libwnck3 \
 pango-devel \
 pkgconf-pkg-config \
 startup-notification-devel \
 "
