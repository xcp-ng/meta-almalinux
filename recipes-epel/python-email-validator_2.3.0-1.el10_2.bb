# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-email-validator"
PV = "2.3.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-email-validator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-email-validator-2.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4d821a42da0520658277dec4b5a2c83e6a597cce96b60dec8b96e07b1991e10"

URI_x86_64_v2_python3-email-validator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-email-validator-2.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-email-validator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-email-validator}"
SRC_URI[x86_64_v2_python3-email-validator.sha256sum] = "7c8829293728a87773afa3331bde6cacc1ef6a1cc16b6922b9c1f9ef0e5317ed"

URI_aarch64_python3-email-validator = "${EPEL_MIRROR}/aarch64/Packages/p/python3-email-validator-2.3.0-1.el10_2.noarch.rpm;name=aarch64_python3-email-validator;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-email-validator}"
SRC_URI[aarch64_python3-email-validator.sha256sum] = "797d05b4d6144ca2ee832a2360a3e50d2e063e8df611340fe580b25e5949bff1"

RDEPENDS:python3-email-validator = " \
 python3 \
 python3-dns \
 python3-idna \
 "
