# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-admin"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kio-admin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kio-admin-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5890424700e05c01664bb28a4d71a90c193fce94d7676119e90dbecf399dae8"

URI_x86_64_v2_kio-admin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-admin-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-admin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-admin}"
SRC_URI[x86_64_v2_kio-admin.sha256sum] = "3104f3be2c61ea0872af7c6879e92e06a645b9aceb362317d337d699d054ba95"

URI_aarch64_kio-admin = "${EPEL_MIRROR}/aarch64/Packages/k/kio-admin-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kio-admin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-admin}"
SRC_URI[aarch64_kio-admin.sha256sum] = "5b69705bd48903d9ccf0c72235f28cd51f068f8a305c804c3c6629f413179f09"

RDEPENDS:kio-admin = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 libatomic \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
