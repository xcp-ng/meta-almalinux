# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nagios-plugins"
PV = "2.4.12"
PR = "1.el10_1"
PACKAGES = " \
 nagios-plugins \
 nagios-plugins-all \
 nagios-plugins-apt \
 nagios-plugins-breeze \
 nagios-plugins-by_ssh \
 nagios-plugins-cluster \
 nagios-plugins-dhcp \
 nagios-plugins-dig \
 nagios-plugins-disk \
 nagios-plugins-disk_smb \
 nagios-plugins-dns \
 nagios-plugins-dummy \
 nagios-plugins-file_age \
 nagios-plugins-flexlm \
 nagios-plugins-fping \
 nagios-plugins-game \
 nagios-plugins-hpjd \
 nagios-plugins-http \
 nagios-plugins-icmp \
 nagios-plugins-ide_smart \
 nagios-plugins-ifoperstatus \
 nagios-plugins-ifstatus \
 nagios-plugins-ircd \
 nagios-plugins-ldap \
 nagios-plugins-load \
 nagios-plugins-log \
 nagios-plugins-mailq \
 nagios-plugins-mrtg \
 nagios-plugins-mrtgtraf \
 nagios-plugins-mysql \
 nagios-plugins-nagios \
 nagios-plugins-nt \
 nagios-plugins-ntp \
 nagios-plugins-nwstat \
 nagios-plugins-oracle \
 nagios-plugins-overcr \
 nagios-plugins-perl \
 nagios-plugins-pgsql \
 nagios-plugins-ping \
 nagios-plugins-procs \
 nagios-plugins-real \
 nagios-plugins-remove_perfdata \
 nagios-plugins-rpc \
 nagios-plugins-sensors \
 nagios-plugins-smtp \
 nagios-plugins-snmp \
 nagios-plugins-ssh \
 nagios-plugins-ssl_validity \
 nagios-plugins-swap \
 nagios-plugins-tcp \
 nagios-plugins-time \
 nagios-plugins-ups \
 nagios-plugins-uptime \
 nagios-plugins-users \
 nagios-plugins-wave \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nagios-plugins-2.4.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e15857bc46d9d5554a9ea798d93f9fc0c939111645d0c6473e44a42bf6bc9e3e"

URI_x86_64_v2_nagios-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins}"
SRC_URI[x86_64_v2_nagios-plugins.sha256sum] = "a25de314c84b04a4026786bfea024455fe72bb4a69f0e05aac4869a8d16874f3"

URI_x86_64_v2_nagios-plugins-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-all-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-all}"
SRC_URI[x86_64_v2_nagios-plugins-all.sha256sum] = "bbf33e0b7abafa908e34b63d890841d8edea7ec7d034420444c6f2888ce7fbc9"

URI_x86_64_v2_nagios-plugins-apt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-apt-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-apt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-apt}"
SRC_URI[x86_64_v2_nagios-plugins-apt.sha256sum] = "63c96b92d42baeed631c56e1300f991b9df5f855343a3fc37050b240419044f0"

URI_x86_64_v2_nagios-plugins-breeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-breeze-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-breeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-breeze}"
SRC_URI[x86_64_v2_nagios-plugins-breeze.sha256sum] = "552c9b660663d3944236800ccaf157d596e68fb1aba5594db68008b576395513"

URI_x86_64_v2_nagios-plugins-by_ssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-by_ssh-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-by_ssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-by_ssh}"
SRC_URI[x86_64_v2_nagios-plugins-by_ssh.sha256sum] = "759423116488322d665daab22ad0b5def13b989e9a41660b314faf8f3546be67"

URI_x86_64_v2_nagios-plugins-cluster = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-cluster-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-cluster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-cluster}"
SRC_URI[x86_64_v2_nagios-plugins-cluster.sha256sum] = "e4dd332f805cce9334dacadcdd6dcfac8266971f1f3732222a85e97ebd03343d"

URI_x86_64_v2_nagios-plugins-dhcp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-dhcp-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-dhcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-dhcp}"
SRC_URI[x86_64_v2_nagios-plugins-dhcp.sha256sum] = "0505f6a33b66a70061b8ce09b48cdbab634ae5cf867ac118442b10f1bd14898c"

URI_x86_64_v2_nagios-plugins-dig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-dig-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-dig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-dig}"
SRC_URI[x86_64_v2_nagios-plugins-dig.sha256sum] = "7956ebc2bcb67c2084885389aa24a02586c5ba1ab8c8b0ce289d2ef835a5029a"

URI_x86_64_v2_nagios-plugins-disk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-disk-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-disk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-disk}"
SRC_URI[x86_64_v2_nagios-plugins-disk.sha256sum] = "68deaa2690bbc448263514b583d2d809e43a39128edc55cc39c00b01e0190b20"

URI_x86_64_v2_nagios-plugins-disk_smb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-disk_smb-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-disk_smb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-disk_smb}"
SRC_URI[x86_64_v2_nagios-plugins-disk_smb.sha256sum] = "c66a47c8e1ccd871c676412460ae7eeba88badfaabfdd2dd1a7fc0654792985a"

URI_x86_64_v2_nagios-plugins-dns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-dns-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-dns}"
SRC_URI[x86_64_v2_nagios-plugins-dns.sha256sum] = "a1fa4210d611f1d1c16c3873c3daab949fe4e870a5c664f7ef30a753089fc50e"

URI_x86_64_v2_nagios-plugins-dummy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-dummy-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-dummy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-dummy}"
SRC_URI[x86_64_v2_nagios-plugins-dummy.sha256sum] = "024f83f935f566bac0714394a43eb67070f96074ab37c0c76ac42c72b4d59448"

URI_x86_64_v2_nagios-plugins-file_age = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-file_age-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-file_age;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-file_age}"
SRC_URI[x86_64_v2_nagios-plugins-file_age.sha256sum] = "7c593f021da9fa225e2854c8ee183561b7d9c1ebdea184cffd35f0a6c2b963a2"

URI_x86_64_v2_nagios-plugins-flexlm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-flexlm-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-flexlm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-flexlm}"
SRC_URI[x86_64_v2_nagios-plugins-flexlm.sha256sum] = "afbb710f17d2671397221c174618f148a0ceaea28054ea81fc81faf7ce389725"

URI_x86_64_v2_nagios-plugins-fping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-fping-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-fping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-fping}"
SRC_URI[x86_64_v2_nagios-plugins-fping.sha256sum] = "e3176add6ccf46ee29297ed7c5d60e1b615f09c31616aec16f18b14811a32531"

URI_x86_64_v2_nagios-plugins-game = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-game-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-game;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-game}"
SRC_URI[x86_64_v2_nagios-plugins-game.sha256sum] = "62498dffcf88ae49f8c384fb770aafb697e63f4082dfdf04c7b94dbc63504c22"

URI_x86_64_v2_nagios-plugins-hpjd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-hpjd-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-hpjd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-hpjd}"
SRC_URI[x86_64_v2_nagios-plugins-hpjd.sha256sum] = "966b6874bd5e951650df8ed4a151362afc640b437d571fc7706e97b4cf0303b3"

URI_x86_64_v2_nagios-plugins-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-http-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-http}"
SRC_URI[x86_64_v2_nagios-plugins-http.sha256sum] = "42541b1d647c5c16c7ae3806f4706217368cee8ffd95b65a880a4ea93f3bddf3"

URI_x86_64_v2_nagios-plugins-icmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-icmp-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-icmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-icmp}"
SRC_URI[x86_64_v2_nagios-plugins-icmp.sha256sum] = "f54b5db35998d00293f857748fa8bf03cead14c0568ccf3a86b562bae0913b95"

URI_x86_64_v2_nagios-plugins-ide_smart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ide_smart-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ide_smart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ide_smart}"
SRC_URI[x86_64_v2_nagios-plugins-ide_smart.sha256sum] = "7c632f238cf8b33d94767129734c2dde43278cfe7191b8fc81891b96aedaf35d"

URI_x86_64_v2_nagios-plugins-ifoperstatus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ifoperstatus-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ifoperstatus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ifoperstatus}"
SRC_URI[x86_64_v2_nagios-plugins-ifoperstatus.sha256sum] = "356edf028a52271100863e5260e3f312c69d43cd6e4ef3f8419e8ed22ee38cce"

URI_x86_64_v2_nagios-plugins-ifstatus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ifstatus-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ifstatus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ifstatus}"
SRC_URI[x86_64_v2_nagios-plugins-ifstatus.sha256sum] = "c97242734c27c7909957e29c8a5b0ae8de4cc25fe18bf04e50dc99b711a8eece"

URI_x86_64_v2_nagios-plugins-ircd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ircd-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ircd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ircd}"
SRC_URI[x86_64_v2_nagios-plugins-ircd.sha256sum] = "086c27cd9ac320c449083bb2138311dab004801a43ff032b5536ff3907bc7d00"

URI_x86_64_v2_nagios-plugins-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ldap-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ldap}"
SRC_URI[x86_64_v2_nagios-plugins-ldap.sha256sum] = "de0774c8981fde444d8b8019b8df9879ddbd969bc50231f0d93cecacfc8c5973"

URI_x86_64_v2_nagios-plugins-load = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-load-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-load;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-load}"
SRC_URI[x86_64_v2_nagios-plugins-load.sha256sum] = "a18224b2fac49b113e4820ff3b1210d080577af32460cceb0e783ef930da0abb"

URI_x86_64_v2_nagios-plugins-log = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-log-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-log}"
SRC_URI[x86_64_v2_nagios-plugins-log.sha256sum] = "d825bfad171a9c5612914445691ce3baeeffafe60cdfaf010bea9325544c056a"

URI_x86_64_v2_nagios-plugins-mailq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-mailq-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-mailq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-mailq}"
SRC_URI[x86_64_v2_nagios-plugins-mailq.sha256sum] = "6f3ade553545e497b9080475299168248123f2671651a15cd881e629394c0059"

URI_x86_64_v2_nagios-plugins-mrtg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-mrtg-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-mrtg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-mrtg}"
SRC_URI[x86_64_v2_nagios-plugins-mrtg.sha256sum] = "a6640fea90bd581bedbf3d2382dc8d8900c7f0b8025f52fa20f692e7d1c13f94"

URI_x86_64_v2_nagios-plugins-mrtgtraf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-mrtgtraf-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-mrtgtraf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-mrtgtraf}"
SRC_URI[x86_64_v2_nagios-plugins-mrtgtraf.sha256sum] = "2d882b180d9a6bb797c89e834d791aa2da25aad553bf86d47425942f7bf56d05"

URI_x86_64_v2_nagios-plugins-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-mysql-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-mysql}"
SRC_URI[x86_64_v2_nagios-plugins-mysql.sha256sum] = "14f379a07733c1e0c55da5c030033fd844954e2cd7d9758089635cdde0017ee5"

URI_x86_64_v2_nagios-plugins-nagios = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-nagios-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-nagios;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-nagios}"
SRC_URI[x86_64_v2_nagios-plugins-nagios.sha256sum] = "0e03be24ae0a45b63fdc128561e404bbc9f4a230225f904c6a5e6d41a53c90bc"

URI_x86_64_v2_nagios-plugins-nt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-nt-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-nt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-nt}"
SRC_URI[x86_64_v2_nagios-plugins-nt.sha256sum] = "428092985fd19d539d443f0e9fba541aa4a15c5e75f0f40ddc6b245a9276388c"

URI_x86_64_v2_nagios-plugins-ntp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ntp-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ntp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ntp}"
SRC_URI[x86_64_v2_nagios-plugins-ntp.sha256sum] = "b842b0beaf840a321830d6bc1e55bad786c1d6096f454e624d326430adf022b3"

URI_x86_64_v2_nagios-plugins-nwstat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-nwstat-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-nwstat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-nwstat}"
SRC_URI[x86_64_v2_nagios-plugins-nwstat.sha256sum] = "9043f039c8fecf856c4ba31ef2119be1a1dcc0abbc25f25cc3d145a01207c3d8"

URI_x86_64_v2_nagios-plugins-oracle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-oracle-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-oracle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-oracle}"
SRC_URI[x86_64_v2_nagios-plugins-oracle.sha256sum] = "490274d5ca3fe6025f48ded464375c05a802114998feed632c610f9f578de441"

URI_x86_64_v2_nagios-plugins-overcr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-overcr-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-overcr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-overcr}"
SRC_URI[x86_64_v2_nagios-plugins-overcr.sha256sum] = "02295647e2487780f2da9372d7c9eb515df7c3e537e8510be57c44f37774792b"

URI_x86_64_v2_nagios-plugins-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-perl-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-perl}"
SRC_URI[x86_64_v2_nagios-plugins-perl.sha256sum] = "d3fe225ff9efc1565a7981a319479e96dfdc1ec05877906ef13f1b63c811209c"

URI_x86_64_v2_nagios-plugins-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-pgsql-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-pgsql}"
SRC_URI[x86_64_v2_nagios-plugins-pgsql.sha256sum] = "c1f4a14044163e7dd97cfb2c1b7e0a7b3b4497b3a4f1d6d9f07d92314ccaeb96"

URI_x86_64_v2_nagios-plugins-ping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ping-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ping}"
SRC_URI[x86_64_v2_nagios-plugins-ping.sha256sum] = "594df166390b848937e8926e6de4dc95d2245ca2d85d7355ed05452089cf2afb"

URI_x86_64_v2_nagios-plugins-procs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-procs-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-procs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-procs}"
SRC_URI[x86_64_v2_nagios-plugins-procs.sha256sum] = "925fff3af9ade395c79977532b795dea88d72ad3b3e8e1e62b95fecd539abfd0"

URI_x86_64_v2_nagios-plugins-real = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-real-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-real;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-real}"
SRC_URI[x86_64_v2_nagios-plugins-real.sha256sum] = "e1baeb196dc9859b6173d9dbc05c9ee2d3505fb6ce3c848a526ce4a625ef18e3"

URI_x86_64_v2_nagios-plugins-remove_perfdata = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-remove_perfdata-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-remove_perfdata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-remove_perfdata}"
SRC_URI[x86_64_v2_nagios-plugins-remove_perfdata.sha256sum] = "448f6611e66b5c7973691dde90a6981dca8a962802b828601a1f071c61508227"

URI_x86_64_v2_nagios-plugins-rpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-rpc-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-rpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-rpc}"
SRC_URI[x86_64_v2_nagios-plugins-rpc.sha256sum] = "0b65d4a34dd55b3a6c7a61a072c385680e4a1fad1c2d3b79417ed7f785c4220f"

URI_x86_64_v2_nagios-plugins-sensors = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-sensors-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-sensors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-sensors}"
SRC_URI[x86_64_v2_nagios-plugins-sensors.sha256sum] = "c0080ad14030240ebb21622078d03a931ff079089a3858504d716c8dead4850a"

URI_x86_64_v2_nagios-plugins-smtp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-smtp-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-smtp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-smtp}"
SRC_URI[x86_64_v2_nagios-plugins-smtp.sha256sum] = "4f33b83229a2bde4568ef6e6a7a97778f5631f72a3378bd65569d0ab3b833b07"

URI_x86_64_v2_nagios-plugins-snmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-snmp-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-snmp}"
SRC_URI[x86_64_v2_nagios-plugins-snmp.sha256sum] = "911eb80d8b24e059fb4c7497ca89b96898f955b98cc2615309f2f31c9ba602af"

URI_x86_64_v2_nagios-plugins-ssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ssh-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ssh}"
SRC_URI[x86_64_v2_nagios-plugins-ssh.sha256sum] = "91defceb6d093289c37a0ebda8db9b7b9751e01c217481f678b433bea2ebec08"

URI_x86_64_v2_nagios-plugins-ssl_validity = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ssl_validity-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ssl_validity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ssl_validity}"
SRC_URI[x86_64_v2_nagios-plugins-ssl_validity.sha256sum] = "9854addb11c29d1323fef73a079aa1acae6442fe193afd31c16d5af853e88c4e"

URI_x86_64_v2_nagios-plugins-swap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-swap-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-swap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-swap}"
SRC_URI[x86_64_v2_nagios-plugins-swap.sha256sum] = "cc74dc7ed631dcb7ab8bfd8841f5c97ca56552482c369170268a4423da11dcb6"

URI_x86_64_v2_nagios-plugins-tcp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-tcp-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-tcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-tcp}"
SRC_URI[x86_64_v2_nagios-plugins-tcp.sha256sum] = "9dd96c5c474cca5d5a01e60f96408024478e7e4313dfe830d3f69bc2da6d1e23"

URI_x86_64_v2_nagios-plugins-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-time-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-time}"
SRC_URI[x86_64_v2_nagios-plugins-time.sha256sum] = "53c68babffd0a95a65c5d48abaadc5e45ebdb6eeeccf809494de893376d22408"

URI_x86_64_v2_nagios-plugins-ups = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ups-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ups;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ups}"
SRC_URI[x86_64_v2_nagios-plugins-ups.sha256sum] = "7e206b08388298cc21282e4828a677edefd061a3f9d688bf05925884825144fc"

URI_x86_64_v2_nagios-plugins-uptime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-uptime-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-uptime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-uptime}"
SRC_URI[x86_64_v2_nagios-plugins-uptime.sha256sum] = "fb3eb4a36cbb87b35e4d6aa817dbe098398cc0fcfed6ead463fc49da9ea08427"

URI_x86_64_v2_nagios-plugins-users = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-users-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-users;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-users}"
SRC_URI[x86_64_v2_nagios-plugins-users.sha256sum] = "e115d9bae85ad9e5bdcfe04065818e41aec5f2ebcbc23e51c9da2a5c50681fa2"

URI_x86_64_v2_nagios-plugins-wave = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-wave-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-wave;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-wave}"
SRC_URI[x86_64_v2_nagios-plugins-wave.sha256sum] = "4224f25bb699cac9b4d6612882e417f057e3b6e097ca332fab5030672591c0af"

URI_aarch64_nagios-plugins = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins}"
SRC_URI[aarch64_nagios-plugins.sha256sum] = "d72220a527e33f3c27909246292818c37ec9267652c61f3e64286e6db4c35967"

URI_aarch64_nagios-plugins-all = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-all-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-all}"
SRC_URI[aarch64_nagios-plugins-all.sha256sum] = "9c832a64ae1664e8a6b75d8ea5aea03af2c172aed127c66d4abe3abf30ab5f81"

URI_aarch64_nagios-plugins-apt = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-apt-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-apt;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-apt}"
SRC_URI[aarch64_nagios-plugins-apt.sha256sum] = "2a3e545601ed7acd214c741a8693aac8f34d934585139a6f0d2032b235df178f"

URI_aarch64_nagios-plugins-breeze = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-breeze-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-breeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-breeze}"
SRC_URI[aarch64_nagios-plugins-breeze.sha256sum] = "21781596a6358bc9f3bc3c8d6979d8c9d55ad40b5ff79776ff503bde41822615"

URI_aarch64_nagios-plugins-by_ssh = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-by_ssh-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-by_ssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-by_ssh}"
SRC_URI[aarch64_nagios-plugins-by_ssh.sha256sum] = "108a90fbcbbf58abbcdc4a8689cdfe6a027f3504f59aeb7dfeaf930bccbd955a"

URI_aarch64_nagios-plugins-cluster = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-cluster-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-cluster;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-cluster}"
SRC_URI[aarch64_nagios-plugins-cluster.sha256sum] = "9d2e34c836deb4e3528ad195666cf5e86fef06e3dd68436e35cea40e35e211b4"

URI_aarch64_nagios-plugins-dhcp = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-dhcp-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-dhcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-dhcp}"
SRC_URI[aarch64_nagios-plugins-dhcp.sha256sum] = "a1ee3cd92b3daf1c60131e2be9f2563886842e5cea05768f497018070ee40d86"

URI_aarch64_nagios-plugins-dig = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-dig-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-dig;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-dig}"
SRC_URI[aarch64_nagios-plugins-dig.sha256sum] = "6ff308de7e4990e7be94ec807f777bf006c3af17c1747b5bc3106d6d237c69b2"

URI_aarch64_nagios-plugins-disk = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-disk-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-disk;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-disk}"
SRC_URI[aarch64_nagios-plugins-disk.sha256sum] = "6ff20b3993a5f71bb1a80d7f738c4cbe6bde26cc2a2bf03c4e8eac54185c5834"

URI_aarch64_nagios-plugins-disk_smb = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-disk_smb-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-disk_smb;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-disk_smb}"
SRC_URI[aarch64_nagios-plugins-disk_smb.sha256sum] = "ef4ecff5751f6b2a1adc882b53240348aa16df892ef2f908a8eaa8afc41e30ae"

URI_aarch64_nagios-plugins-dns = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-dns-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-dns}"
SRC_URI[aarch64_nagios-plugins-dns.sha256sum] = "59a7d36af362a05cd81f7f85c603fb14c06934139b6e2d0325b195ae50258804"

URI_aarch64_nagios-plugins-dummy = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-dummy-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-dummy;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-dummy}"
SRC_URI[aarch64_nagios-plugins-dummy.sha256sum] = "5bbb48bc88175f976f759a55cf31e6d8f9e8b8adc4d2907815bbb58ba46c7ee3"

URI_aarch64_nagios-plugins-file_age = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-file_age-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-file_age;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-file_age}"
SRC_URI[aarch64_nagios-plugins-file_age.sha256sum] = "3ef96198a849a0ee51baebdc4adc3d787388698093bd47c347528f08ef6761c4"

URI_aarch64_nagios-plugins-flexlm = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-flexlm-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-flexlm;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-flexlm}"
SRC_URI[aarch64_nagios-plugins-flexlm.sha256sum] = "7686efca9f194d913501e1d40331d43e2808e0a09199731c79947a1ddbe11684"

URI_aarch64_nagios-plugins-fping = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-fping-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-fping;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-fping}"
SRC_URI[aarch64_nagios-plugins-fping.sha256sum] = "3eaa44eb8e2cd4b13a32612ae3461ce71190bc3b33a5aa3383c6dd4d74f4cc9c"

URI_aarch64_nagios-plugins-game = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-game-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-game;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-game}"
SRC_URI[aarch64_nagios-plugins-game.sha256sum] = "6d2932286a68f5a4f483e9d51197e7c7e8fc0a61abee94cf500cc511aceb1e67"

URI_aarch64_nagios-plugins-hpjd = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-hpjd-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-hpjd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-hpjd}"
SRC_URI[aarch64_nagios-plugins-hpjd.sha256sum] = "c740bc6214a8888805f1039af49eacd6c74e39300526cd25c2cf8fe8edd59f6b"

URI_aarch64_nagios-plugins-http = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-http-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-http}"
SRC_URI[aarch64_nagios-plugins-http.sha256sum] = "dadff455d75b50d7a05bc9433bfdc422edfd8d1f1d5d0232113fd4dcd50cc6a3"

URI_aarch64_nagios-plugins-icmp = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-icmp-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-icmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-icmp}"
SRC_URI[aarch64_nagios-plugins-icmp.sha256sum] = "12dcefc4c4b8c1f9f33713396d56adfb1702757ec54ff69da0a0f3652f981c7e"

URI_aarch64_nagios-plugins-ide_smart = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ide_smart-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-ide_smart;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ide_smart}"
SRC_URI[aarch64_nagios-plugins-ide_smart.sha256sum] = "ba27773ee1cb1a6acadcca72006c3e7279e6195f3271cc55ef0bb8beb61fe7e8"

URI_aarch64_nagios-plugins-ifoperstatus = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ifoperstatus-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-ifoperstatus;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ifoperstatus}"
SRC_URI[aarch64_nagios-plugins-ifoperstatus.sha256sum] = "4014716d35b7a3ac294a5cb6f2620a21bd1c4ed90c880eaa915adbd728a8c04a"

URI_aarch64_nagios-plugins-ifstatus = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ifstatus-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-ifstatus;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ifstatus}"
SRC_URI[aarch64_nagios-plugins-ifstatus.sha256sum] = "d9c748a71fdd0fc5b227d88ecfc290a1b770e23168539dc461d905253a7dd833"

URI_aarch64_nagios-plugins-ircd = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ircd-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-ircd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ircd}"
SRC_URI[aarch64_nagios-plugins-ircd.sha256sum] = "5dbdc05680c12fdc75ffff1f9c02d569fe4004ce0b4f8c774869ff413b081318"

URI_aarch64_nagios-plugins-ldap = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ldap-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ldap}"
SRC_URI[aarch64_nagios-plugins-ldap.sha256sum] = "70f1faabfc9e3556b40bdbd539da1a915d7725bb1337ad0323ea6bc251974d65"

URI_aarch64_nagios-plugins-load = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-load-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-load;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-load}"
SRC_URI[aarch64_nagios-plugins-load.sha256sum] = "9bae5f77bf94978a2b0ced5b58bd55e5a4d2975f7036772aa37254f076987897"

URI_aarch64_nagios-plugins-log = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-log-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-log;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-log}"
SRC_URI[aarch64_nagios-plugins-log.sha256sum] = "dad4e068e6bba6e65765285967cfe688dc1012163fb8ecf52b37f2dc4c4398e0"

URI_aarch64_nagios-plugins-mailq = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-mailq-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-mailq;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-mailq}"
SRC_URI[aarch64_nagios-plugins-mailq.sha256sum] = "ec208067a12f2f3faa3adad2534eb68ab1e8858372cfb9e0caf438bf36d6da93"

URI_aarch64_nagios-plugins-mrtg = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-mrtg-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-mrtg;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-mrtg}"
SRC_URI[aarch64_nagios-plugins-mrtg.sha256sum] = "d1bb4afef6d05e4ccf9e43c1e301fa48465e301c75ad95898df119a9ece42498"

URI_aarch64_nagios-plugins-mrtgtraf = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-mrtgtraf-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-mrtgtraf;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-mrtgtraf}"
SRC_URI[aarch64_nagios-plugins-mrtgtraf.sha256sum] = "c773615d311331cbc567c202bdef0b200d86dc2f01088fd12f89ce4b90433b6a"

URI_aarch64_nagios-plugins-mysql = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-mysql-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-mysql}"
SRC_URI[aarch64_nagios-plugins-mysql.sha256sum] = "b716683323d81bdf0d4b1862a98fe3b58fa0ca2b9164e9ae90be5c6d448f0e9f"

URI_aarch64_nagios-plugins-nagios = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-nagios-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-nagios;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-nagios}"
SRC_URI[aarch64_nagios-plugins-nagios.sha256sum] = "32db23fff4eef2a379a04572bf70d3b9c2c73890acfdd84b78726b4d06d27bff"

URI_aarch64_nagios-plugins-nt = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-nt-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-nt;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-nt}"
SRC_URI[aarch64_nagios-plugins-nt.sha256sum] = "4748bfbbee4f9ec299cf108ee08255a980a42470fe4354b4a337d2c0db6bf015"

URI_aarch64_nagios-plugins-ntp = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ntp-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-ntp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ntp}"
SRC_URI[aarch64_nagios-plugins-ntp.sha256sum] = "4ebeb62e5f6f08f2f42f7a4efac25309b04e8c04e1836bcc07ce2a44f510c3f0"

URI_aarch64_nagios-plugins-nwstat = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-nwstat-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-nwstat;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-nwstat}"
SRC_URI[aarch64_nagios-plugins-nwstat.sha256sum] = "fa5c8c620387d87459fff98eaa8d82242f25d6a3721c00ee62ec2953b7f32f4a"

URI_aarch64_nagios-plugins-oracle = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-oracle-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-oracle;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-oracle}"
SRC_URI[aarch64_nagios-plugins-oracle.sha256sum] = "fbff5820eb2a4b987d45e64c774b6e7a2b58a591c5538de1d107739b30394298"

URI_aarch64_nagios-plugins-overcr = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-overcr-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-overcr;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-overcr}"
SRC_URI[aarch64_nagios-plugins-overcr.sha256sum] = "8db7a9139009d48b2a941cb2ddffe7c33313bfd167de34e104e4b15119e7fd99"

URI_aarch64_nagios-plugins-perl = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-perl-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-perl}"
SRC_URI[aarch64_nagios-plugins-perl.sha256sum] = "0ee01fd4518fda15a6b5ed72ab012fbb25353b5640c6cecafb6767b43fda99c8"

URI_aarch64_nagios-plugins-pgsql = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-pgsql-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-pgsql}"
SRC_URI[aarch64_nagios-plugins-pgsql.sha256sum] = "cf11c9fa199e6ade2508387bbac2b0507bf97763b68d13f350fa9eba381503ba"

URI_aarch64_nagios-plugins-ping = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ping-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-ping;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ping}"
SRC_URI[aarch64_nagios-plugins-ping.sha256sum] = "c50a071ece6ba43dfb624bfae31aadb6d665cfe3e8c538c80ce3653f149aa8b2"

URI_aarch64_nagios-plugins-procs = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-procs-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-procs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-procs}"
SRC_URI[aarch64_nagios-plugins-procs.sha256sum] = "8fd6a65ba93ac832b8ef9bb92b798276ce754531d7e7c9746da7ada20ec1670e"

URI_aarch64_nagios-plugins-real = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-real-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-real;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-real}"
SRC_URI[aarch64_nagios-plugins-real.sha256sum] = "7f553fc9a5b7ea269b9aee0268a0fa82a0bfbf7d2ccb5f8d4b486e3a2ac3fac6"

URI_aarch64_nagios-plugins-remove_perfdata = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-remove_perfdata-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-remove_perfdata;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-remove_perfdata}"
SRC_URI[aarch64_nagios-plugins-remove_perfdata.sha256sum] = "11defd8db37e8ed237514225f6d2da76b38ef9f31f4d8d7595bce4afe8a2cc6c"

URI_aarch64_nagios-plugins-rpc = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-rpc-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-rpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-rpc}"
SRC_URI[aarch64_nagios-plugins-rpc.sha256sum] = "c33efa2f52b3dcf8e095bff183a94eb6e367e9f30f8078eb2e2d6af8a97d2e3f"

URI_aarch64_nagios-plugins-sensors = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-sensors-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-sensors;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-sensors}"
SRC_URI[aarch64_nagios-plugins-sensors.sha256sum] = "27f2e77483200dc7dd842672812475ec7f465b587276b89e394cdc93becefe38"

URI_aarch64_nagios-plugins-smtp = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-smtp-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-smtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-smtp}"
SRC_URI[aarch64_nagios-plugins-smtp.sha256sum] = "072b0c00be63b697910e8ef20c15191f715d10914dadf23358f9cdf2709a5198"

URI_aarch64_nagios-plugins-snmp = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-snmp-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-snmp}"
SRC_URI[aarch64_nagios-plugins-snmp.sha256sum] = "06f1c1ae73b507d49074a3cb16938c68b8f304a42f35a89d3cf4bc4009cd39a8"

URI_aarch64_nagios-plugins-ssh = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ssh-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-ssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ssh}"
SRC_URI[aarch64_nagios-plugins-ssh.sha256sum] = "9794bf2f0f906da71eeb276c700e70a4b2536d9e2f7fb4c767ca6075101ad6a7"

URI_aarch64_nagios-plugins-ssl_validity = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ssl_validity-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-ssl_validity;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ssl_validity}"
SRC_URI[aarch64_nagios-plugins-ssl_validity.sha256sum] = "e646d28af795078170ec5058545331d38ad3918f1e8bae3c6fe1308cda41b5f4"

URI_aarch64_nagios-plugins-swap = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-swap-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-swap;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-swap}"
SRC_URI[aarch64_nagios-plugins-swap.sha256sum] = "390d3dd0f385c11226ae1c22d677900bb8ea2ec54ebad7cb6eb4381ef70af075"

URI_aarch64_nagios-plugins-tcp = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-tcp-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-tcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-tcp}"
SRC_URI[aarch64_nagios-plugins-tcp.sha256sum] = "878cd0b40c6e3f0bb1a2bbfcfe12e1b8022134f12fd93bc23afc0ac680e1314a"

URI_aarch64_nagios-plugins-time = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-time-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-time}"
SRC_URI[aarch64_nagios-plugins-time.sha256sum] = "2de738b607bf6ac9acc49ccda6f69a3caec522401cac2298ce8ca8f70d4f3b2e"

URI_aarch64_nagios-plugins-ups = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ups-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-ups;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ups}"
SRC_URI[aarch64_nagios-plugins-ups.sha256sum] = "bd0932bd3fe1f538e2468d5ec5dd261ed78bed282e32290af7832d96b8dd9c14"

URI_aarch64_nagios-plugins-uptime = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-uptime-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-uptime;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-uptime}"
SRC_URI[aarch64_nagios-plugins-uptime.sha256sum] = "4542fe792a5c3a4b9e5326034d0cb02419808b4931891e0c7fb2e7e4f3724554"

URI_aarch64_nagios-plugins-users = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-users-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-users;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-users}"
SRC_URI[aarch64_nagios-plugins-users.sha256sum] = "852207e7836ae5338dc757ee9aab59ce0d5043b8ffc73a4b5450b65f553168a6"

URI_aarch64_nagios-plugins-wave = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-wave-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-wave;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-wave}"
SRC_URI[aarch64_nagios-plugins-wave.sha256sum] = "e59f2900427a6c2f40b3954892afa5a6ae07813e94d6c37c73d93c584f9ef5ac"

RDEPENDS:nagios-plugins = " \
 bash \
 glibc \
 nagios-common \
 "
RDEPENDS:nagios-plugins-all = " \
 nagios-plugins-breeze \
 nagios-plugins-by_ssh \
 nagios-plugins-cluster \
 nagios-plugins-dhcp \
 nagios-plugins-dig \
 nagios-plugins-disk \
 nagios-plugins-disk_smb \
 nagios-plugins-dns \
 nagios-plugins-dummy \
 nagios-plugins-file_age \
 nagios-plugins-flexlm \
 nagios-plugins-fping \
 nagios-plugins-game \
 nagios-plugins-hpjd \
 nagios-plugins-http \
 nagios-plugins-icmp \
 nagios-plugins-ide_smart \
 nagios-plugins-ircd \
 nagios-plugins-ldap \
 nagios-plugins-load \
 nagios-plugins-log \
 nagios-plugins-mailq \
 nagios-plugins-mrtg \
 nagios-plugins-mrtgtraf \
 nagios-plugins-mysql \
 nagios-plugins-nagios \
 nagios-plugins-nt \
 nagios-plugins-ntp \
 nagios-plugins-nwstat \
 nagios-plugins-oracle \
 nagios-plugins-overcr \
 nagios-plugins-pgsql \
 nagios-plugins-ping \
 nagios-plugins-procs \
 nagios-plugins-real \
 nagios-plugins-rpc \
 nagios-plugins-sensors \
 nagios-plugins-smtp \
 nagios-plugins-snmp \
 nagios-plugins-ssh \
 nagios-plugins-ssl_validity \
 nagios-plugins-swap \
 nagios-plugins-tcp \
 nagios-plugins-time \
 nagios-plugins-ups \
 nagios-plugins-users \
 nagios-plugins-wave \
 "
RDEPENDS:nagios-plugins-apt = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-breeze = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 "
RDEPENDS:nagios-plugins-by_ssh = " \
 glibc \
 nagios-plugins \
 openssh-clients \
 "
RDEPENDS:nagios-plugins-cluster = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-dhcp = " \
 glibc \
 nagios-common \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-dig = " \
 bind-utils \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-disk = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-disk_smb = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-utf8-all \
 perl-vars \
 samba-client \
 "
RDEPENDS:nagios-plugins-dns = " \
 bind-utils \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-dummy = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-file_age = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-English \
 perl-File-Basename \
 perl-File-stat \
 perl-FindBin \
 perl-Getopt-Long \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 "
RDEPENDS:nagios-plugins-flexlm = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 "
RDEPENDS:nagios-plugins-fping = " \
 fping \
 glibc \
 nagios-common \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-game = " \
 glibc \
 nagios-plugins \
 qstat \
 "
RDEPENDS:nagios-plugins-hpjd = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-http = " \
 glibc \
 nagios-plugins \
 openssl \
 openssl-libs \
 "
RDEPENDS:nagios-plugins-icmp = " \
 glibc \
 nagios-common \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-ide_smart = " \
 glibc \
 nagios-common \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-ifoperstatus = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Net-SNMP \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
RDEPENDS:nagios-plugins-ifstatus = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Net-SNMP \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
RDEPENDS:nagios-plugins-ircd = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Socket \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 "
RDEPENDS:nagios-plugins-ldap = " \
 glibc \
 nagios-plugins \
 openldap \
 openssl \
 openssl-libs \
 "
RDEPENDS:nagios-plugins-load = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-log = " \
 bash \
 grep \
 nagios-plugins \
 virtual/coreutils \
 "
RDEPENDS:nagios-plugins-mailq = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 virtual//usr/bin/mailq \
 "
RDEPENDS:nagios-plugins-mrtg = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-mrtgtraf = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-mysql = " \
 glibc \
 mariadb-connector-c \
 nagios-plugins \
 openssl \
 "
RDEPENDS:nagios-plugins-nagios = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-nt = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-ntp = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-nwstat = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-oracle = " \
 bash \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-overcr = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-perl = " \
 nagios-plugins \
 perl-Exporter \
 "
RDEPENDS:nagios-plugins-pgsql = " \
 glibc \
 libpq \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-ping = " \
 glibc \
 iputils \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-procs = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-real = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-remove_perfdata = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-rpc = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 rpcbind \
 "
RDEPENDS:nagios-plugins-sensors = " \
 bash \
 grep \
 lm_sensors \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-smtp = " \
 glibc \
 nagios-plugins \
 openssl \
 openssl-libs \
 "
RDEPENDS:nagios-plugins-snmp = " \
 glibc \
 nagios-plugins \
 net-snmp-utils \
 openssl-libs \
 "
RDEPENDS:nagios-plugins-ssh = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-ssl_validity = " \
 nagios-plugins \
 openssl \
 perl-Crypt-X509 \
 perl-Digest-MD5 \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-POSIX \
 perl-Text-Glob \
 perl-TimeDate \
 perl-interpreter \
 perl-libwww-perl \
 "
RDEPENDS:nagios-plugins-swap = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-tcp = " \
 glibc \
 nagios-plugins \
 openssl \
 openssl-libs \
 "
RDEPENDS:nagios-plugins-time = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-ups = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-uptime = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-users = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-wave = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 "
