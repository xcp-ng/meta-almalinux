# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Hash-Flatten"
PV = "1.19"
PR = "41.el10_0"
PACKAGES = " \
 perl-Hash-Flatten \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Hash-Flatten-1.19-41.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2cbfee3912e001b9dbe3d462b85d85c07a8a1f3afe3fbff53b3fc6bc076eaa5"

URI_x86_64_v2_perl-Hash-Flatten = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Hash-Flatten-1.19-41.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Hash-Flatten;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Hash-Flatten}"
SRC_URI[x86_64_v2_perl-Hash-Flatten.sha256sum] = "93567635ab8a5e403edb3a892b2b0dcc6ceb96e180ea24970b756936c94195a9"

URI_aarch64_perl-Hash-Flatten = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Hash-Flatten-1.19-41.el10_0.noarch.rpm;name=aarch64_perl-Hash-Flatten;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Hash-Flatten}"
SRC_URI[aarch64_perl-Hash-Flatten.sha256sum] = "687e87da2a1f7cfc2e96028545bec5ba1eafcf4bff3b3b7320db37f71c8888b6"

RDEPENDS:perl-Hash-Flatten = " \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 perl-vars \
 "
