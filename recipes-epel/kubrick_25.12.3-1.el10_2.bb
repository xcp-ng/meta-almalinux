# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kubrick"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kubrick \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kubrick-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a07deedb9983fa4ba374735c9b6335a055c91141e3413ea5e97a17cec33c0a2"

URI_x86_64_v2_kubrick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kubrick-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kubrick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kubrick}"
SRC_URI[x86_64_v2_kubrick.sha256sum] = "c200709fedbf1402b7a996cd813668791e669c6b78baac5aaefcc88c1f1837d4"

URI_aarch64_kubrick = "${EPEL_MIRROR}/aarch64/Packages/k/kubrick-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kubrick;unpack=0"
SRC_URI:append = " ${URI_aarch64_kubrick}"
SRC_URI[aarch64_kubrick.sha256sum] = "1df33eae0d003ae0a63f0c245f1e5d3cc77699dbb578e61f4939e41d43db7be5"

RDEPENDS:kubrick = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libglvnd-opengl \
 libkdegames \
 libstdc++ \
 mesa-libGLU \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
