# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tiff"
PV = "0.10.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-tiff+default-devel \
 rust-tiff+deflate-devel \
 rust-tiff+fax-devel \
 rust-tiff+jpeg-devel \
 rust-tiff+lzw-devel \
 rust-tiff+zstd-devel \
 rust-tiff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tiff-0.10.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0602c818d62fcebae46cbcca8f38ecc9a56b60392dc4eff1f8c43194c3fa84d6"

URI_x86_64_v2_rust-tiff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff+default-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff+default-devel}"
SRC_URI[x86_64_v2_rust-tiff+default-devel.sha256sum] = "270199cb0f49fe85cfd65004a6a94a708c89d8aa8fa07ddb004c36142c973ffd"

URI_x86_64_v2_rust-tiff+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff+deflate-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff+deflate-devel}"
SRC_URI[x86_64_v2_rust-tiff+deflate-devel.sha256sum] = "e49bdd9b513126351554ec2dd4606677ab4233c717caedd9f6be02ac1c83cee1"

URI_x86_64_v2_rust-tiff+fax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff+fax-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff+fax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff+fax-devel}"
SRC_URI[x86_64_v2_rust-tiff+fax-devel.sha256sum] = "234b67d4b107fcab7284b92d8d00d34fbfc6ba430bc8dabebb532a5785343475"

URI_x86_64_v2_rust-tiff+jpeg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff+jpeg-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff+jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff+jpeg-devel}"
SRC_URI[x86_64_v2_rust-tiff+jpeg-devel.sha256sum] = "e248e64ebfc9e85e1527876be44e2e6f5e01003f526c15971b712f0a141dbb1a"

URI_x86_64_v2_rust-tiff+lzw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff+lzw-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff+lzw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff+lzw-devel}"
SRC_URI[x86_64_v2_rust-tiff+lzw-devel.sha256sum] = "be6bd41eaa8158d47fa4d2ff69ffabad9494597fa9990087e5f3d679dafa94b7"

URI_x86_64_v2_rust-tiff+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff+zstd-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff+zstd-devel}"
SRC_URI[x86_64_v2_rust-tiff+zstd-devel.sha256sum] = "b57d14500e78e3ec6883c22a704417f3e0445cacfb11bde09617186cbc2fb0c6"

URI_x86_64_v2_rust-tiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff-devel}"
SRC_URI[x86_64_v2_rust-tiff-devel.sha256sum] = "da9770ff829efe0d16ec92d603ee95172331519a298fcdc070ed2aa8680a1e5c"

URI_aarch64_rust-tiff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff+default-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-tiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff+default-devel}"
SRC_URI[aarch64_rust-tiff+default-devel.sha256sum] = "11705b22ac6171a9be316be5fb164ecc2bb0825f2bf99d16e5787d9faf17d040"

URI_aarch64_rust-tiff+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff+deflate-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-tiff+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff+deflate-devel}"
SRC_URI[aarch64_rust-tiff+deflate-devel.sha256sum] = "5e76031fa0e92ab72acca577ade6325fe9cb35cfcaaf79c36384f632e1528b6e"

URI_aarch64_rust-tiff+fax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff+fax-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-tiff+fax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff+fax-devel}"
SRC_URI[aarch64_rust-tiff+fax-devel.sha256sum] = "4246f4807fb363d1767deca42255ccb6334bb3aa5ed3dec4b4f9d3256ccf1857"

URI_aarch64_rust-tiff+jpeg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff+jpeg-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-tiff+jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff+jpeg-devel}"
SRC_URI[aarch64_rust-tiff+jpeg-devel.sha256sum] = "0f80f8dfd2aa5031b2996cc51538c185265a28862a9af9b38b7de9a28e5f820a"

URI_aarch64_rust-tiff+lzw-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff+lzw-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-tiff+lzw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff+lzw-devel}"
SRC_URI[aarch64_rust-tiff+lzw-devel.sha256sum] = "0a6e2e9bb497058d2d5c4e13b9a13040ee1e7fc2492f02514b1100213fea6532"

URI_aarch64_rust-tiff+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff+zstd-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-tiff+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff+zstd-devel}"
SRC_URI[aarch64_rust-tiff+zstd-devel.sha256sum] = "935e7d83ceeb75c75af44223558c68d4cf77d55e559784b9ebf56ed78180e875"

URI_aarch64_rust-tiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-tiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff-devel}"
SRC_URI[aarch64_rust-tiff-devel.sha256sum] = "3dec290f009a9a36fdada5135a2220ec3805ac4707c1eeab11071b65baa68280"

RDEPENDS:rust-tiff+default-devel = " \
 cargo \
 rust-tiff+deflate-devel \
 rust-tiff+fax-devel \
 rust-tiff+jpeg-devel \
 rust-tiff+lzw-devel \
 rust-tiff-devel \
 "
RDEPENDS:rust-tiff+deflate-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-tiff-devel \
 "
RDEPENDS:rust-tiff+fax-devel = " \
 cargo \
 rust-fax+default-devel \
 rust-tiff-devel \
 "
RDEPENDS:rust-tiff+jpeg-devel = " \
 cargo \
 rust-tiff-devel \
 rust-zune-jpeg0.4+default-devel \
 "
RDEPENDS:rust-tiff+lzw-devel = " \
 cargo \
 rust-tiff-devel \
 rust-weezl+default-devel \
 "
RDEPENDS:rust-tiff+zstd-devel = " \
 cargo \
 rust-tiff-devel \
 rust-zstd+default-devel \
 "
RDEPENDS:rust-tiff-devel = " \
 cargo \
 rust \
 rust-half+default-devel \
 rust-quick-error+default-devel \
 "
