# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stow"
PV = "2.4.1"
PR = "1.el10_3"
PACKAGES = " \
 stow \
 stow-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stow-2.4.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb91168ffbe0fba6f987cc5202de9bd26a843314af054893d9b4288bedfe01c5"

URI_x86_64_v2_stow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stow-2.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_stow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stow}"
SRC_URI[x86_64_v2_stow.sha256sum] = "126c4beb11e10a44967bb2fd72a5f5327a28a69c266c54375df8ee327a3b8b76"

URI_x86_64_v2_stow-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stow-doc-2.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_stow-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stow-doc}"
SRC_URI[x86_64_v2_stow-doc.sha256sum] = "e520f803dffe82c79e0acf24b19247d8ab67cd47bc4c80507b831ced8d1a69c7"

URI_aarch64_stow = "${EPEL_MIRROR}/aarch64/Packages/s/stow-2.4.1-1.el10_3.noarch.rpm;name=aarch64_stow;unpack=0"
SRC_URI:append = " ${URI_aarch64_stow}"
SRC_URI[aarch64_stow.sha256sum] = "8653ba80bfc0538b72676efc05057ac9e2301d4541b8b830935c330114efa1f1"

URI_aarch64_stow-doc = "${EPEL_MIRROR}/aarch64/Packages/s/stow-doc-2.4.1-1.el10_3.noarch.rpm;name=aarch64_stow-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_stow-doc}"
SRC_URI[aarch64_stow-doc.sha256sum] = "263ee2942a6a60b06529a93af83728334804703d34f2e55f9682d4c8cc795efd"

RDEPENDS:stow = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Copy \
 perl-File-Find \
 perl-Getopt-Long \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Text-ParseWords \
 perl-base \
 perl-interpreter \
 perl-libs \
 stow \
 "
RDEPENDS:stow-doc = " \
 stow \
 "
