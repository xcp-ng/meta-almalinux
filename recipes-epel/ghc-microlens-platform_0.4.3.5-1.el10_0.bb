# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-microlens-platform"
PV = "0.4.3.5"
PR = "1.el10_0"
PACKAGES = " \
 ghc-microlens-platform \
 ghc-microlens-platform-devel \
 ghc-microlens-platform-doc \
 ghc-microlens-platform-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-microlens-platform-0.4.3.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cce90c96ae5afc1a1dbaac217aefcab165f84752695cf3d2cd1f40a5178c84b"

URI_x86_64_v2_ghc-microlens-platform = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-platform-0.4.3.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens-platform;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-platform}"
SRC_URI[x86_64_v2_ghc-microlens-platform.sha256sum] = "6bb5eb79bf5b1a0e49cb58c4f82e421049257d1ed61e7a714243fc5bf2c64618"

URI_x86_64_v2_ghc-microlens-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-platform-devel-0.4.3.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-platform-devel}"
SRC_URI[x86_64_v2_ghc-microlens-platform-devel.sha256sum] = "89bcbd8f97adc07dae9b0b70d2e4ae4bdc3a78d9b52421db6cb0d7ffc480dd99"

URI_x86_64_v2_ghc-microlens-platform-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-platform-doc-0.4.3.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-microlens-platform-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-platform-doc}"
SRC_URI[x86_64_v2_ghc-microlens-platform-doc.sha256sum] = "b58abf96fb20f478c23183591a0db6681a797a62203bddcce4a74796923a1499"

URI_x86_64_v2_ghc-microlens-platform-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-platform-prof-0.4.3.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens-platform-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-platform-prof}"
SRC_URI[x86_64_v2_ghc-microlens-platform-prof.sha256sum] = "12e35d7ad96dcaaec9fb336a412fec6defaa0a5fec51814909e59aa0066d7c02"

URI_aarch64_ghc-microlens-platform = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-platform-0.4.3.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-microlens-platform;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-platform}"
SRC_URI[aarch64_ghc-microlens-platform.sha256sum] = "8ecf702827fff5bd3ed46f9599a467f760c570cc86e5e73e4dacb10f9f1f7c1b"

URI_aarch64_ghc-microlens-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-platform-devel-0.4.3.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-microlens-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-platform-devel}"
SRC_URI[aarch64_ghc-microlens-platform-devel.sha256sum] = "0886069d98cb39bf19347074815838b1855c43696c77464bc3ef696f752a7c17"

URI_aarch64_ghc-microlens-platform-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-platform-doc-0.4.3.5-1.el10_0.noarch.rpm;name=aarch64_ghc-microlens-platform-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-platform-doc}"
SRC_URI[aarch64_ghc-microlens-platform-doc.sha256sum] = "c2ff97e89e2709b7d846b3e919f34a3a0c262ae898757e420e5cd483c94cddde"

URI_aarch64_ghc-microlens-platform-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-platform-prof-0.4.3.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-microlens-platform-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-platform-prof}"
SRC_URI[aarch64_ghc-microlens-platform-prof.sha256sum] = "3a7e08e0b01074bc4bcc570f0f1dcc2a358544cc37e84d72c2e781fc8d312ffc"

RDEPENDS:ghc-microlens-platform = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-microlens \
 ghc-microlens-ghc \
 ghc-microlens-mtl \
 ghc-microlens-th \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-th-abstraction \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-microlens-platform-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-hashable-devel \
 ghc-microlens-devel \
 ghc-microlens-ghc-devel \
 ghc-microlens-mtl-devel \
 ghc-microlens-platform \
 ghc-microlens-th-devel \
 ghc-text-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-microlens-platform-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-microlens-platform-prof = " \
 ghc-base-prof \
 ghc-hashable-prof \
 ghc-microlens-ghc-prof \
 ghc-microlens-mtl-prof \
 ghc-microlens-platform-devel \
 ghc-microlens-prof \
 ghc-microlens-th-prof \
 ghc-text-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
