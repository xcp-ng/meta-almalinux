# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "docbook5-schemas"
PV = "5.1"
PR = "16.el10_0"
PACKAGES = " \
 docbook5-schemas \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/docbook5-schemas-5.1-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06ce0914c5c79e43acd5fa75f06f73c4e15f94be658c2479afaa4aaa95155ed9"

URI_x86_64_v2_docbook5-schemas = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/docbook5-schemas-5.1-16.el10_0.noarch.rpm;name=x86_64_v2_docbook5-schemas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_docbook5-schemas}"
SRC_URI[x86_64_v2_docbook5-schemas.sha256sum] = "95d4e4aa54615c9f62f5b1f4edf671ac5b6e2f60bcd96009170acd35b86bc4bc"

URI_aarch64_docbook5-schemas = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/docbook5-schemas-5.1-16.el10_0.noarch.rpm;name=aarch64_docbook5-schemas;unpack=0"
SRC_URI:append = " ${URI_aarch64_docbook5-schemas}"
SRC_URI[aarch64_docbook5-schemas.sha256sum] = "95d4e4aa54615c9f62f5b1f4edf671ac5b6e2f60bcd96009170acd35b86bc4bc"

RDEPENDS:docbook5-schemas = " \
 bash \
 libxml2 \
 xml-common \
 "
