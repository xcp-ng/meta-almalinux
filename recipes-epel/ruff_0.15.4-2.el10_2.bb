# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruff"
PV = "0.15.4"
PR = "2.el10_2"
PACKAGES = " \
 python3-ruff \
 ruff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/ruff-0.15.4-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca37a6d5960deb6d1e6f90dd7e4c50ff621e2c5b32acc87a7550658c03b7abfa"

URI_x86_64_v2_python3-ruff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ruff-0.15.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ruff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ruff}"
SRC_URI[x86_64_v2_python3-ruff.sha256sum] = "31c92d2bede266d944dbfe7a7f65ef74806db5c902d8196d87ec935061bd05da"

URI_x86_64_v2_ruff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruff-0.15.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ruff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruff}"
SRC_URI[x86_64_v2_ruff.sha256sum] = "7ad6d6b344647b9082089d52eba3070b45ed23014d4b45a34eafb4fdb3bcb9d3"

URI_aarch64_python3-ruff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ruff-0.15.4-2.el10_2.noarch.rpm;name=aarch64_python3-ruff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ruff}"
SRC_URI[aarch64_python3-ruff.sha256sum] = "21ebd1a489b47eea09ea1ecd3c422c83e9de4786a0a4d51a3ca0bc956d22150e"

URI_aarch64_ruff = "${EPEL_MIRROR}/aarch64/Packages/r/ruff-0.15.4-2.el10_2.aarch64.rpm;name=aarch64_ruff;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruff}"
SRC_URI[aarch64_ruff.sha256sum] = "1b266ac04641a7ba3aa5179bf94cbed1bc7f9b9dda770f61ce467d4fca74fd89"

RDEPENDS:python3-ruff = " \
 python3 \
 ruff \
 "
RDEPENDS:ruff = " \
 glibc \
 jemalloc \
 libgcc \
 "
