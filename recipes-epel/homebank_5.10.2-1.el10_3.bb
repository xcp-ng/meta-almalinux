# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "homebank"
PV = "5.10.2"
PR = "1.el10_3"
PACKAGES = " \
 homebank \
 homebank-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/homebank-5.10.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "351c08726c6a9043aa158aa7144c34c50fe0b26d7b7794980e02d4ca23114608"

URI_x86_64_v2_homebank = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/homebank-5.10.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_homebank;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_homebank}"
SRC_URI[x86_64_v2_homebank.sha256sum] = "6c91c7e97bf4cefe88e01435b4623c32769de598cf3041765bc0066ceee02e85"

URI_x86_64_v2_homebank-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/homebank-doc-5.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_homebank-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_homebank-doc}"
SRC_URI[x86_64_v2_homebank-doc.sha256sum] = "4bfe888c19b126752890e9badc87c2eaf4cac1a776c327727d9e6d68144fa0e4"

URI_aarch64_homebank = "${EPEL_MIRROR}/aarch64/Packages/h/homebank-5.10.2-1.el10_3.aarch64.rpm;name=aarch64_homebank;unpack=0"
SRC_URI:append = " ${URI_aarch64_homebank}"
SRC_URI[aarch64_homebank.sha256sum] = "c6d1caace0485edb576c40d2287ac80dd63ef853cdf7f4d885324be2de4fff37"

URI_aarch64_homebank-doc = "${EPEL_MIRROR}/aarch64/Packages/h/homebank-doc-5.10.2-1.el10_3.noarch.rpm;name=aarch64_homebank-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_homebank-doc}"
SRC_URI[aarch64_homebank-doc.sha256sum] = "33650186f34f181fcb101ea0e40b34eaf2a5abf5c2ec513ea1f236e684b00317"

RDEPENDS:homebank = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libgcc \
 libofx \
 libsoup3 \
 pango \
 "
RDEPENDS:homebank-doc = " \
 homebank \
 "
