# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "augeas"
PV = "1.14.2"
PR = "0.2.20240909git2de06e0.el10"
PACKAGES = " \
 augeas \
 augeas-devel \
 augeas-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/augeas-1.14.2-0.2.20240909git2de06e0.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f208219a9299bd707f030433441cad73a7afdd74d501b98d58653a1482bf54b6"

URI_x86_64_v2_augeas = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/augeas-1.14.2-0.2.20240909git2de06e0.el10.x86_64_v2.rpm;name=x86_64_v2_augeas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_augeas}"
SRC_URI[x86_64_v2_augeas.sha256sum] = "ec66d116ab931109d5b21851bd87cb687296f6ae26503808dfe2c69594810a66"

URI_x86_64_v2_augeas-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/augeas-devel-1.14.2-0.2.20240909git2de06e0.el10.x86_64_v2.rpm;name=x86_64_v2_augeas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_augeas-devel}"
SRC_URI[x86_64_v2_augeas-devel.sha256sum] = "ed86d0529e54df3265d9cff61ecceb9bc94f07e206dbc2a371a9fc312d28a004"

URI_x86_64_v2_augeas-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/augeas-libs-1.14.2-0.2.20240909git2de06e0.el10.x86_64_v2.rpm;name=x86_64_v2_augeas-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_augeas-libs}"
SRC_URI[x86_64_v2_augeas-libs.sha256sum] = "0cbe769e503218d7f9b03a36e51ac9e67c1206d5b62de98c68ed09d66bededda"

URI_aarch64_augeas = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/augeas-1.14.2-0.2.20240909git2de06e0.el10.aarch64.rpm;name=aarch64_augeas;unpack=0"
SRC_URI:append = " ${URI_aarch64_augeas}"
SRC_URI[aarch64_augeas.sha256sum] = "239c23bd7a643406ff9cc0ca4d0af57df387aca41ccab201c4120876b3d7e1b1"

URI_aarch64_augeas-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/augeas-devel-1.14.2-0.2.20240909git2de06e0.el10.aarch64.rpm;name=aarch64_augeas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_augeas-devel}"
SRC_URI[aarch64_augeas-devel.sha256sum] = "b00a95cf9895cda1aedebbc8f14f51932f2c29535910b33a232003adfff1d133"

URI_aarch64_augeas-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/augeas-libs-1.14.2-0.2.20240909git2de06e0.el10.aarch64.rpm;name=aarch64_augeas-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_augeas-libs}"
SRC_URI[aarch64_augeas-libs.sha256sum] = "e3ea640644a121d4804e8f07ad8f481716df804d9ca85e13f98ebb0bb90364f5"

RDEPENDS:augeas = " \
 augeas-libs \
 glibc \
 libgcc \
 readline \
 "
RDEPENDS:augeas-devel = " \
 augeas-libs \
 libselinux-devel \
 libxml2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:augeas-libs = " \
 glibc \
 libselinux \
 libxml2 \
 "
