# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-bitop"
PV = "1.0.2"
PR = "17.el10_1"
PACKAGES = " \
 lua5.1-bitop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-bitop-1.0.2-17.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b21f3e82f9a2b1fe78b81c68ecaded66782d09f7c2fbf191dfd524758fa82c63"

URI_x86_64_v2_lua5.1-bitop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-bitop-1.0.2-17.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua5.1-bitop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-bitop}"
SRC_URI[x86_64_v2_lua5.1-bitop.sha256sum] = "c8bb731fa856103c7088a79f8391cffc6b8870ee86c48142b39d43d4d6b26bd9"

URI_aarch64_lua5.1-bitop = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-bitop-1.0.2-17.el10_1.aarch64.rpm;name=aarch64_lua5.1-bitop;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-bitop}"
SRC_URI[aarch64_lua5.1-bitop.sha256sum] = "527ed457189ac8365713c089e80b62497fb517cbf789da778e2143e3f3f8ce8e"

RDEPENDS:lua5.1-bitop = " \
 compat-lua-libs \
 glibc \
 "
