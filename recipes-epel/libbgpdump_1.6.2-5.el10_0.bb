# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libbgpdump"
PV = "1.6.2"
PR = "5.el10_0"
PACKAGES = " \
 bgpdump \
 libbgpdump \
 libbgpdump-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libbgpdump-1.6.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4d5b8318d8f224e5ce8122bf535639d7ab266df9de5dadedef3adda2cbb9b21"

URI_x86_64_v2_bgpdump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bgpdump-1.6.2-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bgpdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bgpdump}"
SRC_URI[x86_64_v2_bgpdump.sha256sum] = "bb54c95a3b71de596e6006ce288e96387327d5290b59706643bfc59f961cd266"

URI_x86_64_v2_libbgpdump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbgpdump-1.6.2-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbgpdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbgpdump}"
SRC_URI[x86_64_v2_libbgpdump.sha256sum] = "837807e3760745da5400a1d75d42d8461fe66184981c5439a773eae6a7b7144a"

URI_x86_64_v2_libbgpdump-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbgpdump-devel-1.6.2-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbgpdump-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbgpdump-devel}"
SRC_URI[x86_64_v2_libbgpdump-devel.sha256sum] = "52313b9e09c7e7ca384acd2306a152bae41d0486bf06c395b2b2c5e6b1bee1db"

URI_aarch64_bgpdump = "${EPEL_MIRROR}/aarch64/Packages/b/bgpdump-1.6.2-5.el10_0.aarch64.rpm;name=aarch64_bgpdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_bgpdump}"
SRC_URI[aarch64_bgpdump.sha256sum] = "6f205a81e3053680da97c90cbdbbcbff278bf83a93bd6e879b21806fea1e71b6"

URI_aarch64_libbgpdump = "${EPEL_MIRROR}/aarch64/Packages/l/libbgpdump-1.6.2-5.el10_0.aarch64.rpm;name=aarch64_libbgpdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbgpdump}"
SRC_URI[aarch64_libbgpdump.sha256sum] = "3532bfc09f8eaad79eb1653db23a7a9d103d29b61cc9140c2924ef43c6beedf5"

URI_aarch64_libbgpdump-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libbgpdump-devel-1.6.2-5.el10_0.aarch64.rpm;name=aarch64_libbgpdump-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbgpdump-devel}"
SRC_URI[aarch64_libbgpdump-devel.sha256sum] = "361608394db15de7e63cd37c645604bf94d6a000f3e6f12fcef5d82b774ccb27"

RDEPENDS:bgpdump = " \
 glibc \
 libbgpdump \
 "
RDEPENDS:libbgpdump = " \
 bzip2-libs \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:libbgpdump-devel = " \
 libbgpdump \
 "
