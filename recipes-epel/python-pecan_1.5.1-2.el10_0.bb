# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pecan"
PV = "1.5.1"
PR = "2.el10_0"
PACKAGES = " \
 python3-pecan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pecan-1.5.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fb05a81863092592c9636978bcaee84b459ab390a4cc0ed9d9602d9951dc42b"

URI_x86_64_v2_python3-pecan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pecan-1.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pecan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pecan}"
SRC_URI[x86_64_v2_python3-pecan.sha256sum] = "7e8c522b8997541bc9b0d7a45439e75116209da1e989c6e86dfcc403554d1ada"

URI_aarch64_python3-pecan = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pecan-1.5.1-2.el10_0.noarch.rpm;name=aarch64_python3-pecan;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pecan}"
SRC_URI[aarch64_python3-pecan.sha256sum] = "82682ec5e8287ca5cad4c1f2998557c2f91e4f98a19d8e3605ffb1aaf75223cc"

RDEPENDS:python3-pecan = " \
 python3 \
 python3-logutils \
 python3-mako \
 python3-setuptools \
 python3-webob \
 "
