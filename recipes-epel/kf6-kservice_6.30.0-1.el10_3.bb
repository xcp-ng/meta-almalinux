# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kservice"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kservice \
 kf6-kservice-devel \
 kf6-kservice-doc \
 kf6-kservice-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kservice-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4f5faedfc652906dd4e6354cb9f994687db99cd04b7f3384fc87159f59380751"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kservice;unpack=0"
SRC_URI[x86_64_v2_kf6-kservice.sha256sum] = "3c05d873f0aa193bc2fbfa605cfdf2d0bf9ba23d6892adab1fba9fa536302f69"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kservice-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kservice-devel.sha256sum] = "4430c11677ff9773c0158c1e5120baaec3c9fd6a117f300b4dad250fb74dccc4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kservice-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kservice-doc.sha256sum] = "62282cbbbfc2e115b29ad2b6bdbed35900633af2656985e461751825dfa8a025"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kservice-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kservice-html.sha256sum] = "435a71953f6cc3a527c40a4eab75f25f0416b55b433a6fc4f8f61e682a144dba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kservice;unpack=0"
SRC_URI[aarch64_kf6-kservice.sha256sum] = "22246d73e3ae26bb746f14720eb49d7310986794c7f42a24ebc6cccca6c9dc99"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kservice-devel;unpack=0"
SRC_URI[aarch64_kf6-kservice-devel.sha256sum] = "309b7cc325aebcff7b5d3dc779fb4c92b26758aa4674c97d52a8ed40fa040be4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kservice-doc;unpack=0"
SRC_URI[aarch64_kf6-kservice-doc.sha256sum] = "57563aeb4e8f8e8bd3b308783d8142c0b7571b2d7e0c2f94e02fcdc2a2ed6fb0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kservice-html;unpack=0"
SRC_URI[aarch64_kf6-kservice-html.sha256sum] = "0bc00f0a3dc36692230274bc5d4c6cba066654727ffb6e1234bf56144ef1a3d5"

RDEPENDS:kf6-kservice = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kservice-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kcoreaddons-devel \
 kf6-kservice \
 "
RDEPENDS:kf6-kservice-doc = " \
 "
RDEPENDS:kf6-kservice-html = " \
 "
