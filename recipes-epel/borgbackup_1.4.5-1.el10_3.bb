# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "borgbackup"
PV = "1.4.5"
PR = "1.el10_3"
PACKAGES = " \
 borgbackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/borgbackup-1.4.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67b048328a664726a18b309ea3b5f3fb8631325310e81dbcbbfdc39174731684"

URI_x86_64_v2_borgbackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/borgbackup-1.4.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_borgbackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_borgbackup}"
SRC_URI[x86_64_v2_borgbackup.sha256sum] = "8cb9610487926602d4bd879760294a2fd7cec17992ebd89da518e20f8ce4ae4b"

URI_aarch64_borgbackup = "${EPEL_MIRROR}/aarch64/Packages/b/borgbackup-1.4.5-1.el10_3.aarch64.rpm;name=aarch64_borgbackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_borgbackup}"
SRC_URI[aarch64_borgbackup.sha256sum] = "f813003e64df5797584e595c90e5ad1f3c11a72b32f6679aa44328d5d23df516"

RDEPENDS:borgbackup = " \
 fuse \
 glibc \
 libacl \
 libzstd \
 lz4-libs \
 openssl-libs \
 python3 \
 python3-llfuse \
 python3-msgpack \
 python3-packaging \
 xxhash-libs \
 "
