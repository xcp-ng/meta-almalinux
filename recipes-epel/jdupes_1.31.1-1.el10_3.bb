# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jdupes"
PV = "1.31.1"
PR = "1.el10_3"
PACKAGES = " \
 jdupes \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/jdupes-1.31.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4b1437ee95f214e650c8d6b17ed729834ea7b7dc83dab26d342af9a1901e18ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jdupes-1.31.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jdupes;unpack=0"
SRC_URI[x86_64_v2_jdupes.sha256sum] = "3b54b5cbef57be986bfb3ee88aaf2d8253939912a8a862d88508a7303325c514"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/jdupes-1.31.1-1.el10_3.aarch64.rpm;name=aarch64_jdupes;unpack=0"
SRC_URI[aarch64_jdupes.sha256sum] = "b41626000b4bb1fe5d7519d01b7e102ab5332714f454a6d9cd888ab67f1d1c9b"

RDEPENDS:jdupes = " \
 glibc \
 libjodycode \
 "
