# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rdiff-backup"
PV = "2.2.6"
PR = "7.el10_0"
PACKAGES = " \
 rdiff-backup \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rdiff-backup-2.2.6-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6d67c537f66a96317b2a647ec8e2c34ea9132c94b0988488269d90f8a5662a4f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rdiff-backup-2.2.6-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rdiff-backup;unpack=0"
SRC_URI[x86_64_v2_rdiff-backup.sha256sum] = "7e00185d9bfb86612c686ec35ff10c8ce2dbdb45a20b519d178643ba3d03814f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rdiff-backup-2.2.6-7.el10_0.aarch64.rpm;name=aarch64_rdiff-backup;unpack=0"
SRC_URI[aarch64_rdiff-backup.sha256sum] = "62e10dcdcd48927378534796666b1e14700bed0ffbb53047cd0a98890a31d977"

RDEPENDS:rdiff-backup = " \
 glibc \
 librsync \
 python3 \
 python3-pyyaml \
 "
