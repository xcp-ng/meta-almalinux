# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1"
PV = "1.24.11"
PR = "1.el10"
PACKAGES = " \
 gstreamer1 \
 gstreamer1-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-1.24.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90d9b14969aa3855f9389b9772a42627f9e7a281bcc414eb25ff600647738160"

URI_x86_64_v2_gstreamer1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-1.24.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1}"
SRC_URI[x86_64_v2_gstreamer1.sha256sum] = "9ed1b20f33de1e0b426c83362dabc70f609ae6f086d804fafcff7b3b99d25c3e"

URI_x86_64_v2_gstreamer1-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-devel-1.24.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-devel}"
SRC_URI[x86_64_v2_gstreamer1-devel.sha256sum] = "86b74009cb77030c43c3b4deff537e94c9d57651226b057196c847b5e8677b71"

URI_aarch64_gstreamer1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-1.24.11-1.el10.aarch64.rpm;name=aarch64_gstreamer1;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1}"
SRC_URI[aarch64_gstreamer1.sha256sum] = "efa4c77fc7cb9b23a868c7e5a736e3952fbadf8f870855b33c16e89dcdad2354"

URI_aarch64_gstreamer1-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-devel-1.24.11-1.el10.aarch64.rpm;name=aarch64_gstreamer1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-devel}"
SRC_URI[aarch64_gstreamer1-devel.sha256sum] = "5f72decc0cdba9d09bff5f9023b4d13a460e220a1ad214c4d149363d7c24add0"

RDEPENDS:gstreamer1 = " \
 bash \
 glib2 \
 glibc \
 libcap \
 libgcc \
 python3 \
 "
RDEPENDS:gstreamer1-devel = " \
 check-devel \
 glib2-devel \
 gstreamer1 \
 gstreamer1-devel \
 libxml2-devel \
 pkgconf-pkg-config \
 "
