# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gram_grep"
PV = "0.10.2"
PR = "2.el10_1"
PACKAGES = " \
 gram_grep \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gram_grep-0.10.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ab919397ac387170f925150402f017d34cd7b9acf1bac3bcaeaf969681cc932"

URI_x86_64_v2_gram_grep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gram_grep-0.10.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gram_grep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gram_grep}"
SRC_URI[x86_64_v2_gram_grep.sha256sum] = "f2fcd46f0b8cfe836e22bc176c978037e76a4e7762add2588411d5113c8e2082"

URI_aarch64_gram_grep = "${EPEL_MIRROR}/aarch64/Packages/g/gram_grep-0.10.2-2.el10_1.aarch64.rpm;name=aarch64_gram_grep;unpack=0"
SRC_URI:append = " ${URI_aarch64_gram_grep}"
SRC_URI[aarch64_gram_grep.sha256sum] = "c4b6d4c82e0538dfa1412912759e79cc56517ff833346c8f75dadbb0abca34b6"

RDEPENDS:gram_grep = " \
 glibc \
 libgcc \
 libstdc++ \
 "
