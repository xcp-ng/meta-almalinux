# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "falkon"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 falkon \
 falkon-kde \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/falkon-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dd654b4a986c3bd4595b8e9671c150c2b9b80552a47773f36c1382792e2b49b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/falkon-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_falkon;unpack=0"
SRC_URI[x86_64_v2_falkon.sha256sum] = "c5f012ca9507de6c0172fc050d681b1525613c1a9a6d8355f81609e32be01fee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/falkon-kde-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_falkon-kde;unpack=0"
SRC_URI[x86_64_v2_falkon-kde.sha256sum] = "3c15c0139433ba21e2ad90277c6eb58acd18a3627572d71117f6040be260d60e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/falkon-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_falkon;unpack=0"
SRC_URI[aarch64_falkon.sha256sum] = "87e1af0cdf0e026ab3cccd37a6a7d5d60c43c2c957d129ef20c82f5df7024b7f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/falkon-kde-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_falkon-kde;unpack=0"
SRC_URI[aarch64_falkon-kde.sha256sum] = "d7038f7df9ea82fd8032570498ac9c4100c05fce9dbbd7bb6ebafaedb044b32d"

RDEPENDS:falkon = " \
 glibc \
 hicolor-icon-theme \
 kf6-karchive \
 libgcc \
 libstdc++ \
 libxcb \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
RDEPENDS:falkon-kde = " \
 falkon \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kio-core-libs \
 kf6-kjobwidgets \
 kf6-kwallet-libs \
 kf6-purpose \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
