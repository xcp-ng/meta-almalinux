# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ossl"
PV = "1.5.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-ossl+default-devel \
 rust-ossl+openssl-sys-devel \
 rust-ossl+ossl320-devel \
 rust-ossl+ossl350-devel \
 rust-ossl+ossl400-devel \
 rust-ossl+rfc9580-devel \
 rust-ossl-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ossl-1.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "70357b55d1e6c08290eb7fa8b36f097ceda81600b9e34d2c884fa14c498a7bd2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+default-devel-1.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ossl+default-devel.sha256sum] = "ed7b5b2cdb6746341b128c526608444f2bc05442242c14d5d5bc501744999680"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+openssl-sys-devel-1.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+openssl-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ossl+openssl-sys-devel.sha256sum] = "599de5425a2c0d6228b30a8832626bf80a5b14f2100af9006e619243c1e66883"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+ossl320-devel-1.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+ossl320-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ossl+ossl320-devel.sha256sum] = "dfe613ed2c91c03e6865e8223740d049249dbfcc0b96d6815cb728e8ae7812e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+ossl350-devel-1.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+ossl350-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ossl+ossl350-devel.sha256sum] = "f315aab6ea8e97ce65f39c15ea6aa4ddb28b33dd58e3ef5fc35c5d499c2748fe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+ossl400-devel-1.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+ossl400-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ossl+ossl400-devel.sha256sum] = "62d765a70950e810f8e0809a9cd61b34faef2aab4fe87e6cc833bdfc7ada8bb4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+rfc9580-devel-1.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+rfc9580-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ossl+rfc9580-devel.sha256sum] = "6d6941cb67bc2893ce5b7eb42944acfb2b73bbbd3b70796726a9c16c1b6371e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl-devel-1.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ossl-devel.sha256sum] = "7d89575eb7e000c56aefc965b1ec0f27cde85d67a1175d0825f8206db8f836a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+default-devel-1.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-ossl+default-devel;unpack=0"
SRC_URI[aarch64_rust-ossl+default-devel.sha256sum] = "cb2cd15b61e415634ec642130c4f73125f3b99baf1c36f6dec629e81ae84ee6f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+openssl-sys-devel-1.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-ossl+openssl-sys-devel;unpack=0"
SRC_URI[aarch64_rust-ossl+openssl-sys-devel.sha256sum] = "cc04ed738e131a706942b076f1365418a9febb1e8504391000784ed93a7f4c6e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+ossl320-devel-1.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-ossl+ossl320-devel;unpack=0"
SRC_URI[aarch64_rust-ossl+ossl320-devel.sha256sum] = "c0f005fce37e135cd237bee3fcf0092d0dfc495584c72a9ce420909ee068060c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+ossl350-devel-1.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-ossl+ossl350-devel;unpack=0"
SRC_URI[aarch64_rust-ossl+ossl350-devel.sha256sum] = "ad6441d88bbd99a2f81c7f4dabc69953357a92196e9be3978928475c0a0c1cf6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+ossl400-devel-1.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-ossl+ossl400-devel;unpack=0"
SRC_URI[aarch64_rust-ossl+ossl400-devel.sha256sum] = "b91a99e20291e9797d092a765cb1898a9224e03151381f438cfb8c476363c983"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+rfc9580-devel-1.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-ossl+rfc9580-devel;unpack=0"
SRC_URI[aarch64_rust-ossl+rfc9580-devel.sha256sum] = "dc71f3298e8ae71063e70289c496a2360e4b93f94bcd72a1d1e7ed1f3e1eade0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl-devel-1.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-ossl-devel;unpack=0"
SRC_URI[aarch64_rust-ossl-devel.sha256sum] = "caa5b7013c84f869078d9230acdb4ea5e8134280e9c7adeaf43a8563b1398387"

RDEPENDS:rust-ossl+default-devel = " \
 cargo \
 rust-ossl+openssl-sys-devel \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+openssl-sys-devel = " \
 cargo \
 rust-openssl-sys+bindgen-devel \
 rust-openssl-sys+default-devel \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+ossl320-devel = " \
 cargo \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+ossl350-devel = " \
 cargo \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+ossl400-devel = " \
 cargo \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+rfc9580-devel = " \
 cargo \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl-devel = " \
 cargo \
 rust-bindgen+default-devel \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
