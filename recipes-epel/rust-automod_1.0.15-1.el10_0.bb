# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-automod"
PV = "1.0.15"
PR = "1.el10_0"
PACKAGES = " \
 rust-automod+default-devel \
 rust-automod-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-automod-1.0.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4da8fe2fc16ccca304bc02000a9663e2273ab4f0d9eacaede2f11e365227b92c"

URI_x86_64_v2_rust-automod+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-automod+default-devel-1.0.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-automod+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-automod+default-devel}"
SRC_URI[x86_64_v2_rust-automod+default-devel.sha256sum] = "7521005041ffced9d5ed12d7563a8e1a4b766ddc39755544611c0884d4eb2fca"

URI_x86_64_v2_rust-automod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-automod-devel-1.0.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-automod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-automod-devel}"
SRC_URI[x86_64_v2_rust-automod-devel.sha256sum] = "bbabc502fa2d00ef97d0040f3f46c563e862ca1b1940a642c3f8610d33eb7b87"

URI_aarch64_rust-automod+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-automod+default-devel-1.0.15-1.el10_0.noarch.rpm;name=aarch64_rust-automod+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-automod+default-devel}"
SRC_URI[aarch64_rust-automod+default-devel.sha256sum] = "5b39ff4cf20ee8cdec0b621a2c025810942d9df1b8b098da63758b0fa1084a5f"

URI_aarch64_rust-automod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-automod-devel-1.0.15-1.el10_0.noarch.rpm;name=aarch64_rust-automod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-automod-devel}"
SRC_URI[aarch64_rust-automod-devel.sha256sum] = "343cd8931bf5acc0fb17522352202ed274c0bc20637e4eb3e56d0a44b67b16a4"

RDEPENDS:rust-automod+default-devel = " \
 cargo \
 rust-automod-devel \
 "
RDEPENDS:rust-automod-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
