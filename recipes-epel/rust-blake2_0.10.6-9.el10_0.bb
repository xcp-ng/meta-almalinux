# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blake2"
PV = "0.10.6"
PR = "9.el10_0"
PACKAGES = " \
 rust-blake2+default-devel \
 rust-blake2+reset-devel \
 rust-blake2+simd-devel \
 rust-blake2+simd_asm-devel \
 rust-blake2+simd_opt-devel \
 rust-blake2+size_opt-devel \
 rust-blake2+std-devel \
 rust-blake2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blake2-0.10.6-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e199e767ec635b698108a554d6c4202c78862b21b9c3a70560d103611baa5f08"

URI_x86_64_v2_rust-blake2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2+default-devel-0.10.6-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2+default-devel}"
SRC_URI[x86_64_v2_rust-blake2+default-devel.sha256sum] = "ca674e60c8805f52cf132db2faee221655f2bf2210b736897475cc8ec878dc88"

URI_x86_64_v2_rust-blake2+reset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2+reset-devel-0.10.6-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2+reset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2+reset-devel}"
SRC_URI[x86_64_v2_rust-blake2+reset-devel.sha256sum] = "b0257c03be918b926810661d1c28e9302d7f828db8887f3ed0d0bf02877a9649"

URI_x86_64_v2_rust-blake2+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2+simd-devel-0.10.6-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2+simd-devel}"
SRC_URI[x86_64_v2_rust-blake2+simd-devel.sha256sum] = "ef9103e38a21841ad311e370f3ce6ab43140b21e2024b57ff1f6966cba0020f2"

URI_x86_64_v2_rust-blake2+simd_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2+simd_asm-devel-0.10.6-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2+simd_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2+simd_asm-devel}"
SRC_URI[x86_64_v2_rust-blake2+simd_asm-devel.sha256sum] = "2bb90a703cf876b30a1458a7654aca9a0d079966641a6718aede59a569c9f659"

URI_x86_64_v2_rust-blake2+simd_opt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2+simd_opt-devel-0.10.6-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2+simd_opt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2+simd_opt-devel}"
SRC_URI[x86_64_v2_rust-blake2+simd_opt-devel.sha256sum] = "956c01da5b1c2fc14dd7a16b32e7ef579c10f6f2178bd200aa2a8d81ab81df4e"

URI_x86_64_v2_rust-blake2+size_opt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2+size_opt-devel-0.10.6-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2+size_opt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2+size_opt-devel}"
SRC_URI[x86_64_v2_rust-blake2+size_opt-devel.sha256sum] = "a69a4f591b1e3218b55d9ecff168b957b07dd2e8461a950d7ea113ef00813056"

URI_x86_64_v2_rust-blake2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2+std-devel-0.10.6-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2+std-devel}"
SRC_URI[x86_64_v2_rust-blake2+std-devel.sha256sum] = "4a5ac798170e6b4a8d874dc282e9a1170da0c35dfea82140094ee1032816418c"

URI_x86_64_v2_rust-blake2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2-devel-0.10.6-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2-devel}"
SRC_URI[x86_64_v2_rust-blake2-devel.sha256sum] = "e1e32c380375e6b4e1bc9a2b2e87495dddf0d9bc6569fc5a33c071c401aa171a"

URI_aarch64_rust-blake2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2+default-devel-0.10.6-9.el10_0.noarch.rpm;name=aarch64_rust-blake2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2+default-devel}"
SRC_URI[aarch64_rust-blake2+default-devel.sha256sum] = "61b5c489059973835c73441311ae6c2c104f6d334a8f73babd00086bacd01933"

URI_aarch64_rust-blake2+reset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2+reset-devel-0.10.6-9.el10_0.noarch.rpm;name=aarch64_rust-blake2+reset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2+reset-devel}"
SRC_URI[aarch64_rust-blake2+reset-devel.sha256sum] = "f250c06ec19727c1a6fabeea23539d759758ec601850854cc3bf80da5596d5e6"

URI_aarch64_rust-blake2+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2+simd-devel-0.10.6-9.el10_0.noarch.rpm;name=aarch64_rust-blake2+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2+simd-devel}"
SRC_URI[aarch64_rust-blake2+simd-devel.sha256sum] = "267bcc65c41a49d8e142c1f073003f3297fb5e8d0de6ee1fd7d141749b8495ce"

URI_aarch64_rust-blake2+simd_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2+simd_asm-devel-0.10.6-9.el10_0.noarch.rpm;name=aarch64_rust-blake2+simd_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2+simd_asm-devel}"
SRC_URI[aarch64_rust-blake2+simd_asm-devel.sha256sum] = "c3e7e661a3f088a048df56c5e88eac7a89026922a2fc2037025aa82aa01237db"

URI_aarch64_rust-blake2+simd_opt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2+simd_opt-devel-0.10.6-9.el10_0.noarch.rpm;name=aarch64_rust-blake2+simd_opt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2+simd_opt-devel}"
SRC_URI[aarch64_rust-blake2+simd_opt-devel.sha256sum] = "17e84320253a5995c633f054e0e50aeb8ec08bc702fb6aee78b418e62c300d41"

URI_aarch64_rust-blake2+size_opt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2+size_opt-devel-0.10.6-9.el10_0.noarch.rpm;name=aarch64_rust-blake2+size_opt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2+size_opt-devel}"
SRC_URI[aarch64_rust-blake2+size_opt-devel.sha256sum] = "85a19ff72b12e986caa1e77ccf6e5f0cd6597763a5ed28050e34ba4d5f1f5e3d"

URI_aarch64_rust-blake2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2+std-devel-0.10.6-9.el10_0.noarch.rpm;name=aarch64_rust-blake2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2+std-devel}"
SRC_URI[aarch64_rust-blake2+std-devel.sha256sum] = "97da48ab12c07af28f3856034f2365156cf355a01ac73157588de67cd11b6093"

URI_aarch64_rust-blake2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2-devel-0.10.6-9.el10_0.noarch.rpm;name=aarch64_rust-blake2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2-devel}"
SRC_URI[aarch64_rust-blake2-devel.sha256sum] = "ec067f1a0d5bdbd942a421b8165dbc711eeb215cbceb71059cfd42b3743eef4b"

RDEPENDS:rust-blake2+default-devel = " \
 cargo \
 rust-blake2+std-devel \
 rust-blake2-devel \
 "
RDEPENDS:rust-blake2+reset-devel = " \
 cargo \
 rust-blake2-devel \
 "
RDEPENDS:rust-blake2+simd-devel = " \
 cargo \
 rust-blake2-devel \
 "
RDEPENDS:rust-blake2+simd_asm-devel = " \
 cargo \
 rust-blake2+simd_opt-devel \
 rust-blake2-devel \
 "
RDEPENDS:rust-blake2+simd_opt-devel = " \
 cargo \
 rust-blake2+simd-devel \
 rust-blake2-devel \
 "
RDEPENDS:rust-blake2+size_opt-devel = " \
 cargo \
 rust-blake2-devel \
 "
RDEPENDS:rust-blake2+std-devel = " \
 cargo \
 rust-blake2-devel \
 rust-digest+std-devel \
 "
RDEPENDS:rust-blake2-devel = " \
 cargo \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 "
