# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fixedbitset"
PV = "0.5.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-fixedbitset+default-devel \
 rust-fixedbitset+serde-devel \
 rust-fixedbitset+std-devel \
 rust-fixedbitset-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fixedbitset-0.5.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08bb226028ab06ef653dc3fec18382e8187b5748e17f7cedf203e23f435c36d6"

URI_x86_64_v2_rust-fixedbitset+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixedbitset+default-devel-0.5.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixedbitset+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixedbitset+default-devel}"
SRC_URI[x86_64_v2_rust-fixedbitset+default-devel.sha256sum] = "97e700577e9eb3731a7d4e03661bea15d2c2c6880f146663bef9a7bbf764b4b4"

URI_x86_64_v2_rust-fixedbitset+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixedbitset+serde-devel-0.5.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixedbitset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixedbitset+serde-devel}"
SRC_URI[x86_64_v2_rust-fixedbitset+serde-devel.sha256sum] = "56435ac0bfbe62a10a36c24787c9828b097f0fe62f53cd166114f014dcb5d79f"

URI_x86_64_v2_rust-fixedbitset+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixedbitset+std-devel-0.5.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixedbitset+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixedbitset+std-devel}"
SRC_URI[x86_64_v2_rust-fixedbitset+std-devel.sha256sum] = "1f211b76b75a355f31c929cf7a0f458df20c93176eacc858f32dcffe15cab902"

URI_x86_64_v2_rust-fixedbitset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixedbitset-devel-0.5.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixedbitset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixedbitset-devel}"
SRC_URI[x86_64_v2_rust-fixedbitset-devel.sha256sum] = "652c5d8eb80c1a006c7d1c198e366c42c076b79082ece663b1e8072c2332b14c"

URI_aarch64_rust-fixedbitset+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixedbitset+default-devel-0.5.7-1.el10_0.noarch.rpm;name=aarch64_rust-fixedbitset+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixedbitset+default-devel}"
SRC_URI[aarch64_rust-fixedbitset+default-devel.sha256sum] = "c40f55acf0b98c5b25933d4566edf5c98ae160ef3e1cecd7819b86c8e5a60b0b"

URI_aarch64_rust-fixedbitset+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixedbitset+serde-devel-0.5.7-1.el10_0.noarch.rpm;name=aarch64_rust-fixedbitset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixedbitset+serde-devel}"
SRC_URI[aarch64_rust-fixedbitset+serde-devel.sha256sum] = "745649f0e100d723553f81a03687f1d98bd01a1daf302345c0d118b7f14cd528"

URI_aarch64_rust-fixedbitset+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixedbitset+std-devel-0.5.7-1.el10_0.noarch.rpm;name=aarch64_rust-fixedbitset+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixedbitset+std-devel}"
SRC_URI[aarch64_rust-fixedbitset+std-devel.sha256sum] = "e16256fae75ccd4f6dc04f305ca776cca600d0e2fe26c7abd27222562f17e221"

URI_aarch64_rust-fixedbitset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixedbitset-devel-0.5.7-1.el10_0.noarch.rpm;name=aarch64_rust-fixedbitset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixedbitset-devel}"
SRC_URI[aarch64_rust-fixedbitset-devel.sha256sum] = "2add6efcfa3d2d10d301266c65bab1479bb0bf0b5681481d31c5143d215a0ae4"

RDEPENDS:rust-fixedbitset+default-devel = " \
 cargo \
 rust-fixedbitset+std-devel \
 rust-fixedbitset-devel \
 "
RDEPENDS:rust-fixedbitset+serde-devel = " \
 cargo \
 rust-fixedbitset-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-fixedbitset+std-devel = " \
 cargo \
 rust-fixedbitset-devel \
 "
RDEPENDS:rust-fixedbitset-devel = " \
 cargo \
 rust \
 "
