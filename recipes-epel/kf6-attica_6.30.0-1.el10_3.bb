# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-attica"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-attica \
 kf6-attica-devel \
 kf6-attica-doc \
 kf6-attica-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-attica-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b250e3f49d81cab89d419fb6fb88595ef0c5826b9c028efa06e0d5eaf1cca9c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-attica;unpack=0"
SRC_URI[x86_64_v2_kf6-attica.sha256sum] = "c29b9e3cbb8a159a3efde38adca6d9ed93d467a0230133d71c9a83caebf02b69"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-attica-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-attica-devel.sha256sum] = "11a1c2b68a1277d9fd04bf9452d12de707cbedc334afbd69bf70d2af1063a189"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-attica-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-attica-doc.sha256sum] = "6a5544d8cdc981157ebc029f0de428fbc4944501b698f67932ba3dd7302189a5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-attica-html;unpack=0"
SRC_URI[x86_64_v2_kf6-attica-html.sha256sum] = "b52cc82d1caaf64ffb5753090596b447c12dc9b8abee5773c48e8beae45a699c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-attica;unpack=0"
SRC_URI[aarch64_kf6-attica.sha256sum] = "3bf3ed5e968a5986c373f0cf4ce6f93c37018086fde663fdea03eeccc76ab5c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-attica-devel;unpack=0"
SRC_URI[aarch64_kf6-attica-devel.sha256sum] = "28f866cb1b99109da80139a291ac58e37fab769d891f58daad4ec1d3eae3b1db"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-attica-doc;unpack=0"
SRC_URI[aarch64_kf6-attica-doc.sha256sum] = "ab0c9f5c97eb313a43b2971c26a528e6163daad8ec853170175b745022dbbaae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-attica-html;unpack=0"
SRC_URI[aarch64_kf6-attica-html.sha256sum] = "4e95b37d6780949bea0731a56ae5594b6c1d8003a49ad28ca735646ceae1daf1"

RDEPENDS:kf6-attica = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-attica-devel = " \
 cmake-filesystem \
 kf6-attica \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-attica-doc = " \
 "
RDEPENDS:kf6-attica-html = " \
 "
