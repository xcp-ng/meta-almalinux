# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-channel"
PV = "0.5.16"
PR = "1.el10_3"
PACKAGES = " \
 rust-crossbeam-channel+default-devel \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-channel-0.5.16-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcf7400bf534d5135aa64281b002fc7a926702669eaa01be66a9299111283551"

URI_x86_64_v2_rust-crossbeam-channel+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel+default-devel-0.5.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-channel+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-channel+default-devel.sha256sum] = "b5d9a1db9e2c17b094cab46730878a941ff5eb8f68b791ce7e9085f03dfa791a"

URI_x86_64_v2_rust-crossbeam-channel+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel+std-devel-0.5.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-channel+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-channel+std-devel.sha256sum] = "6ea351eeecfd492ef00c96044c4fff32270df1f919d47fd4904e5e52c7c325c3"

URI_x86_64_v2_rust-crossbeam-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel-devel-0.5.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-channel-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-channel-devel.sha256sum] = "b54b6eb864cb5ca7e6aba902b55edff2f1b6d000777e05dd448dbfa8d9bc2324"

URI_aarch64_rust-crossbeam-channel+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel+default-devel-0.5.16-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-channel+default-devel}"
SRC_URI[aarch64_rust-crossbeam-channel+default-devel.sha256sum] = "1a71c95873bdcac647c5b1e5a26d47f027fe15861d64b2f7f0709b82a989ddf0"

URI_aarch64_rust-crossbeam-channel+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel+std-devel-0.5.16-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-channel+std-devel}"
SRC_URI[aarch64_rust-crossbeam-channel+std-devel.sha256sum] = "1837edeadd261c34e5ffa23a0f18c27495e992745948dc87bc5c2d9ffa960e55"

URI_aarch64_rust-crossbeam-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel-devel-0.5.16-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-channel-devel}"
SRC_URI[aarch64_rust-crossbeam-channel-devel.sha256sum] = "c0dad0d731057fc254a7fd41d3af03ca4ac6e09be7552cd96a35c6169ba2c152"

RDEPENDS:rust-crossbeam-channel+default-devel = " \
 cargo \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 "
RDEPENDS:rust-crossbeam-channel+std-devel = " \
 cargo \
 rust-crossbeam-channel-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-channel-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
