# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glue-schema"
PV = "2.1.0"
PR = "1.el10_1"
PACKAGES = " \
 glue-schema \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/glue-schema-2.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73e7b541cbd3f70914ace86bf6f050ac4c8b704985c110c45b703697a142c5d8"

URI_x86_64_v2_glue-schema = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glue-schema-2.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_glue-schema;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glue-schema}"
SRC_URI[x86_64_v2_glue-schema.sha256sum] = "7ed0fb64aff2a4f46c2dac1617734c59a2e8df5faed98c026bf923033e8db83e"

URI_aarch64_glue-schema = "${EPEL_MIRROR}/aarch64/Packages/g/glue-schema-2.1.0-1.el10_1.noarch.rpm;name=aarch64_glue-schema;unpack=0"
SRC_URI:append = " ${URI_aarch64_glue-schema}"
SRC_URI[aarch64_glue-schema.sha256sum] = "df709bf47e73c7dc07673a489e6a89a79333cfe8a8fff818822902e31bf52a66"

RDEPENDS:glue-schema = " \
 "
