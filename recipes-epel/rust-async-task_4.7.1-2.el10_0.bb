# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-task"
PV = "4.7.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-async-task+default-devel \
 rust-async-task+portable-atomic-devel \
 rust-async-task+std-devel \
 rust-async-task-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-task-4.7.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b69ffd8ba0525ccece781f670317175e1b7a74fba66367d211947c556128664"

URI_x86_64_v2_rust-async-task+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-task+default-devel-4.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-task+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-task+default-devel}"
SRC_URI[x86_64_v2_rust-async-task+default-devel.sha256sum] = "95f701c7fe405ce2ce1a0a8eff5c2cc67c1a0850af8843cdd10b1801c237fe71"

URI_x86_64_v2_rust-async-task+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-task+portable-atomic-devel-4.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-task+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-task+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-async-task+portable-atomic-devel.sha256sum] = "912661d433ee2cdb6b387de8a752d6e23346ace80efba28f0044619d9bcbdcf7"

URI_x86_64_v2_rust-async-task+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-task+std-devel-4.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-task+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-task+std-devel}"
SRC_URI[x86_64_v2_rust-async-task+std-devel.sha256sum] = "58632e4059ee45583bf4554bcf8f28a5fd80742c78c15aa2913c5fc29649ce06"

URI_x86_64_v2_rust-async-task-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-task-devel-4.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-task-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-task-devel}"
SRC_URI[x86_64_v2_rust-async-task-devel.sha256sum] = "7dc5a13f014731d68d494d48c81745e53f56052630bfb8173218d68197f8c62c"

URI_aarch64_rust-async-task+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-task+default-devel-4.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-async-task+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-task+default-devel}"
SRC_URI[aarch64_rust-async-task+default-devel.sha256sum] = "9920ef35cafacc516b4ad80be2a066d36d588e1257f5af004bbc147f5d9876a4"

URI_aarch64_rust-async-task+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-task+portable-atomic-devel-4.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-async-task+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-task+portable-atomic-devel}"
SRC_URI[aarch64_rust-async-task+portable-atomic-devel.sha256sum] = "c6ffe6540fe89c3875103c0d0511427f759cf172b7fa321443974b345f65c2c3"

URI_aarch64_rust-async-task+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-task+std-devel-4.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-async-task+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-task+std-devel}"
SRC_URI[aarch64_rust-async-task+std-devel.sha256sum] = "79df1cf32d7097099a4f1c26ef816111eab3b6c43dafada7faefd45180908719"

URI_aarch64_rust-async-task-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-task-devel-4.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-async-task-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-task-devel}"
SRC_URI[aarch64_rust-async-task-devel.sha256sum] = "dabc2077c4a8b80f26ecb003b41a4b9486c918744560264b64b28f6b094ef3de"

RDEPENDS:rust-async-task+default-devel = " \
 cargo \
 rust-async-task+std-devel \
 rust-async-task-devel \
 "
RDEPENDS:rust-async-task+portable-atomic-devel = " \
 cargo \
 rust-async-task-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-async-task+std-devel = " \
 cargo \
 rust-async-task-devel \
 "
RDEPENDS:rust-async-task-devel = " \
 cargo \
 rust \
 "
