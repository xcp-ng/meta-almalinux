# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dehydrated"
PV = "0.7.1"
PR = "6.el10_0"
PACKAGES = " \
 dehydrated \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dehydrated-0.7.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "491ea2003c2e5217f44c30ae9051a95e301823770ba175834528da1a8e1528df"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dehydrated-0.7.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dehydrated;unpack=0"
SRC_URI[x86_64_v2_dehydrated.sha256sum] = "7f1ece9f0770e5278c27390d3867e55d9748be0b8ba90730035f2eaa8f231854"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dehydrated-0.7.1-6.el10_0.noarch.rpm;name=aarch64_dehydrated;unpack=0"
SRC_URI[aarch64_dehydrated.sha256sum] = "2f0a19f6cb15044ccce1188e74e5631965f941ad16ba8b20fac9ebdf71cc9641"

RDEPENDS:dehydrated = " \
 bash \
 curl \
 diffutils \
 gawk \
 grep \
 openssl \
 s-nail \
 sed \
 systemd \
 util-linux \
 virtual/coreutils \
 "
