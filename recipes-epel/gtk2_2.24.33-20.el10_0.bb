# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtk2"
PV = "2.24.33"
PR = "20.el10_0"
PACKAGES = " \
 gtk-immodules-imsettings \
 gtk2 \
 gtk2-devel \
 gtk2-devel-docs \
 gtk2-immodule-xim \
 gtk2-immodules \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gtk2-2.24.33-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a8c0b792dae5c6a73b86f0893655a50680b2e5c0b175831e38999ae98b8026ef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtk-immodules-imsettings-2.24.33-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gtk-immodules-imsettings;unpack=0"
SRC_URI[x86_64_v2_gtk-immodules-imsettings.sha256sum] = "968dac0f598443e9faf5236e72599470238f92f05bcbde52b8b1bb202d5632db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtk2-2.24.33-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtk2;unpack=0"
SRC_URI[x86_64_v2_gtk2.sha256sum] = "0a938aadafea016e007f5194f8c81f3b08f308a069d1344b880c402b5c252eeb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtk2-devel-2.24.33-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtk2-devel;unpack=0"
SRC_URI[x86_64_v2_gtk2-devel.sha256sum] = "014010a14982b1bc4ed64cf1b4d067df8cc074c6a705d6131e71e9fd7cecd937"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtk2-devel-docs-2.24.33-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtk2-devel-docs;unpack=0"
SRC_URI[x86_64_v2_gtk2-devel-docs.sha256sum] = "76195dba7b8dfa1f5da583033051eda8a987a2344e895a3fd071ee5b16b28cdc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtk2-immodule-xim-2.24.33-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtk2-immodule-xim;unpack=0"
SRC_URI[x86_64_v2_gtk2-immodule-xim.sha256sum] = "232d31c6a608dc42bec2b4ea1ded14860f027e41cd1e83ea425e4e69d9a11478"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtk2-immodules-2.24.33-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtk2-immodules;unpack=0"
SRC_URI[x86_64_v2_gtk2-immodules.sha256sum] = "44baa9f69b4ab65a38c34c59c505bbfb407757089a081ff55a709288508cb1f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gtk-immodules-imsettings-2.24.33-20.el10_0.noarch.rpm;name=aarch64_gtk-immodules-imsettings;unpack=0"
SRC_URI[aarch64_gtk-immodules-imsettings.sha256sum] = "130ec9e4036772585bd739e089e4a81139df77483052d62dd7fa4a4b58d95c35"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gtk2-2.24.33-20.el10_0.aarch64.rpm;name=aarch64_gtk2;unpack=0"
SRC_URI[aarch64_gtk2.sha256sum] = "d613b7491094165523742776c133a55a99673af64e113ea3086469c99f8204cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gtk2-devel-2.24.33-20.el10_0.aarch64.rpm;name=aarch64_gtk2-devel;unpack=0"
SRC_URI[aarch64_gtk2-devel.sha256sum] = "6abe50b7e6225fbbfa745e466fd9bd11c657e7eded0e9b7413b767a823c42aa9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gtk2-devel-docs-2.24.33-20.el10_0.aarch64.rpm;name=aarch64_gtk2-devel-docs;unpack=0"
SRC_URI[aarch64_gtk2-devel-docs.sha256sum] = "4c63b1c8edff78eba97b56ac5e5b4a22350cb952dec8ae3cdd0afa55ce81a5ee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gtk2-immodule-xim-2.24.33-20.el10_0.aarch64.rpm;name=aarch64_gtk2-immodule-xim;unpack=0"
SRC_URI[aarch64_gtk2-immodule-xim.sha256sum] = "916a4b2b98e8b1ca5ffbdac6bda924edb8672629fd4c5e878b5d108b6f28869c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gtk2-immodules-2.24.33-20.el10_0.aarch64.rpm;name=aarch64_gtk2-immodules;unpack=0"
SRC_URI[aarch64_gtk2-immodules.sha256sum] = "c21c00416a30b18c7666ee0672cf719f3e310eb5f345605403aa1217c128efa7"

RDEPENDS:gtk-immodules-imsettings = " \
 "
RDEPENDS:gtk2 = " \
 atk \
 bash \
 cairo \
 cups-libs \
 fontconfig \
 gdk-pixbuf2 \
 gdk-pixbuf2-modules \
 glib2 \
 glibc \
 gtk-update-icon-cache \
 hicolor-icon-theme \
 libX11 \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libXrender \
 libtiff \
 pango \
 "
RDEPENDS:gtk2-devel = " \
 atk-devel \
 cairo \
 cairo-devel \
 gdk-pixbuf2 \
 gdk-pixbuf2-devel \
 glib2 \
 glib2-devel \
 glibc \
 gtk2 \
 gtk2-devel \
 libX11-devel \
 libXcomposite-devel \
 libXcursor-devel \
 libXext-devel \
 libXfixes-devel \
 libXi-devel \
 libXinerama-devel \
 libXrandr-devel \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 python3 \
 "
RDEPENDS:gtk2-devel-docs = " \
 gtk2 \
 "
RDEPENDS:gtk2-immodule-xim = " \
 glib2 \
 glibc \
 gtk2 \
 libX11 \
 pango \
 "
RDEPENDS:gtk2-immodules = " \
 glib2 \
 glibc \
 gtk-immodules-imsettings \
 gtk2 \
 pango \
 "
