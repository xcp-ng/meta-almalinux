# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-protocol"
PV = "0.51.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-protocol+async-client-devel \
 rust-gix-protocol+blocking-client-devel \
 rust-gix-protocol+default-devel \
 rust-gix-protocol+document-features-devel \
 rust-gix-protocol+fetch-devel \
 rust-gix-protocol+futures-lite-devel \
 rust-gix-protocol+handshake-devel \
 rust-gix-protocol+serde-devel \
 rust-gix-protocol-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-protocol-0.51.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1deddf4fcad41ef68cbd17fdeea8e7a033888bf55149546eb0fe826f4896b2a"

URI_x86_64_v2_rust-gix-protocol+async-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+async-client-devel-0.51.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+async-client-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+async-client-devel.sha256sum] = "7a1d42b7a412cd7d40c32fb14fa26836eb54de6af4b6fa75fd4082456f499a00"

URI_x86_64_v2_rust-gix-protocol+blocking-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+blocking-client-devel-0.51.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+blocking-client-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+blocking-client-devel.sha256sum] = "8f88dae73fb876ded08ba442e329748a2df09c1066b80bdec8ba0060aae01b82"

URI_x86_64_v2_rust-gix-protocol+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+default-devel-0.51.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+default-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+default-devel.sha256sum] = "9b8519ad4e86b7c58f7638f7e380c0d5debc0d824d1b25e42c84d0220db5b6ff"

URI_x86_64_v2_rust-gix-protocol+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+document-features-devel-0.51.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+document-features-devel.sha256sum] = "9643b739ba0f12bac8b3b13be3f279bc51010cbdc26097360fe4e1220a342155"

URI_x86_64_v2_rust-gix-protocol+fetch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+fetch-devel-0.51.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+fetch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+fetch-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+fetch-devel.sha256sum] = "af289790da629809c5d51cb6859eb612793d09147f5e892b3924ef38a7785a3e"

URI_x86_64_v2_rust-gix-protocol+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+futures-lite-devel-0.51.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+futures-lite-devel.sha256sum] = "944c6ff0fe87c0d24742f6ef994230c84668c1ccfe2bb1f9c85fa5414252f466"

URI_x86_64_v2_rust-gix-protocol+handshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+handshake-devel-0.51.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+handshake-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+handshake-devel.sha256sum] = "5c687c79ad6ca1fd5ed4d13f2bd75abb2f2e12af6d95a1a288e47476cff2ead7"

URI_x86_64_v2_rust-gix-protocol+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+serde-devel-0.51.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+serde-devel.sha256sum] = "5ce0a33905f2bfcd06eb87fee15917a761372899bfc4d3cbfa3116d296833154"

URI_x86_64_v2_rust-gix-protocol-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol-devel-0.51.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol-devel.sha256sum] = "a04547d84fdcf36b16e13e0675257192d9d70e070ea49f0949b510f170ae595c"

URI_aarch64_rust-gix-protocol+async-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+async-client-devel-0.51.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-protocol+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+async-client-devel}"
SRC_URI[aarch64_rust-gix-protocol+async-client-devel.sha256sum] = "d58077af4ec9c5993252b0a1040a0388a6f58e9f056370b81c297e57a89030a5"

URI_aarch64_rust-gix-protocol+blocking-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+blocking-client-devel-0.51.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-protocol+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+blocking-client-devel}"
SRC_URI[aarch64_rust-gix-protocol+blocking-client-devel.sha256sum] = "400e4e3f56e3e6c9321841e7fcba9022c0f821034d68722dc92ae84acc1065be"

URI_aarch64_rust-gix-protocol+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+default-devel-0.51.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-protocol+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+default-devel}"
SRC_URI[aarch64_rust-gix-protocol+default-devel.sha256sum] = "fc396844450b61bf26be22903c881691695990ef3d516b4a1cf94c7bfca13011"

URI_aarch64_rust-gix-protocol+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+document-features-devel-0.51.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-protocol+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+document-features-devel}"
SRC_URI[aarch64_rust-gix-protocol+document-features-devel.sha256sum] = "d607cf98b090ab80ac2b56ce9e1743310826c8a04dcda27b813ac7884fbdbfdc"

URI_aarch64_rust-gix-protocol+fetch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+fetch-devel-0.51.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-protocol+fetch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+fetch-devel}"
SRC_URI[aarch64_rust-gix-protocol+fetch-devel.sha256sum] = "20ae022a1250a4a065ad0a8a13523fc64b8d56595150157fad4bce45f3543816"

URI_aarch64_rust-gix-protocol+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+futures-lite-devel-0.51.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-protocol+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+futures-lite-devel}"
SRC_URI[aarch64_rust-gix-protocol+futures-lite-devel.sha256sum] = "32a20848706d962ba62300dca84eaa1f2b8231f98dc002fd9338a4bca46f3729"

URI_aarch64_rust-gix-protocol+handshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+handshake-devel-0.51.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-protocol+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+handshake-devel}"
SRC_URI[aarch64_rust-gix-protocol+handshake-devel.sha256sum] = "32fcd6f59c99c94969c23e2e93507400292e50434d3d82291e8c12dd405c5861"

URI_aarch64_rust-gix-protocol+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+serde-devel-0.51.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-protocol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+serde-devel}"
SRC_URI[aarch64_rust-gix-protocol+serde-devel.sha256sum] = "3271a07234c354347a08e892bb2bcff9c2adbe86f4aee284586ff48db067b909"

URI_aarch64_rust-gix-protocol-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol-devel-0.51.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol-devel}"
SRC_URI[aarch64_rust-gix-protocol-devel.sha256sum] = "46f1c3ebcbcf8d0546dcef613a33e20caae0992982a8d08e7537ae0015f7ef9a"

RDEPENDS:rust-gix-protocol+async-client-devel = " \
 cargo \
 rust-async-trait+default-devel \
 rust-futures-io+default-devel \
 rust-gix-protocol+fetch-devel \
 rust-gix-protocol+futures-lite-devel \
 rust-gix-protocol+handshake-devel \
 rust-gix-protocol-devel \
 rust-gix-transport+async-client-devel \
 "
RDEPENDS:rust-gix-protocol+blocking-client-devel = " \
 cargo \
 rust-gix-protocol+fetch-devel \
 rust-gix-protocol+handshake-devel \
 rust-gix-protocol-devel \
 rust-gix-transport+blocking-client-devel \
 rust-maybe-async+is_sync-devel \
 "
RDEPENDS:rust-gix-protocol+default-devel = " \
 cargo \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+fetch-devel = " \
 cargo \
 rust-gix-lock+default-devel \
 rust-gix-negotiate+default-devel \
 rust-gix-object+default-devel \
 rust-gix-protocol-devel \
 rust-gix-refspec+default-devel \
 rust-gix-revwalk+default-devel \
 rust-gix-trace+default-devel \
 "
RDEPENDS:rust-gix-protocol+futures-lite-devel = " \
 cargo \
 rust-futures-lite+default-devel \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+handshake-devel = " \
 cargo \
 rust-gix-credentials+default-devel \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-protocol-devel \
 rust-gix-shallow+serde-devel \
 rust-gix-transport+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-protocol-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-date+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-hash+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-shallow+default-devel \
 rust-gix-transport+default-devel \
 rust-gix-utils+default-devel \
 rust-maybe-async+default-devel \
 rust-thiserror+default-devel \
 rust-winnow+default-devel \
 rust-winnow+simd-devel \
 "
