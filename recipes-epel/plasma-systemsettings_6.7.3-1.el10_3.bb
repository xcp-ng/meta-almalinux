# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-systemsettings"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-systemsettings \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-systemsettings-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "834a5ea2f5618f89e8c166e7e0c177778a5dfb14a761ee2ebb496c36f2511428"

URI_x86_64_v2_plasma-systemsettings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-systemsettings-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-systemsettings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-systemsettings}"
SRC_URI[x86_64_v2_plasma-systemsettings.sha256sum] = "4514241c81b2cd5331d8dd188139a9f90b659e7e73678eef706711ac6d7c4dae"

URI_aarch64_plasma-systemsettings = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-systemsettings-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-systemsettings;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-systemsettings}"
SRC_URI[aarch64_plasma-systemsettings.sha256sum] = "c6e155e5747dc07355fd37480e8bb9a17bbf5277918fb8916affc33749a185af"

RDEPENDS:plasma-systemsettings = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-krunner \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
