# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sushy"
PV = "5.10.1"
PR = "1.el10_2"
PACKAGES = " \
 python-sushy-doc \
 python3-sushy \
 python3-sushy-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sushy-5.10.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "485d53c5ae8327ae2cfb1ac94ef2f283d8e1ffbdd4b60fe17fc80f99f4a21642"

URI_x86_64_v2_python-sushy-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-sushy-doc-5.10.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-sushy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-sushy-doc}"
SRC_URI[x86_64_v2_python-sushy-doc.sha256sum] = "cc326c1aab57d74a8a7a7e8bc186506bc2a2f5637c7572d82e1e24bdc978c413"

URI_x86_64_v2_python3-sushy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sushy-5.10.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sushy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sushy}"
SRC_URI[x86_64_v2_python3-sushy.sha256sum] = "95073c1b91912acc2a550b23b6dedb261cb692964f2fb1c354ff1e54d9f97c7c"

URI_x86_64_v2_python3-sushy-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sushy-tests-5.10.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sushy-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sushy-tests}"
SRC_URI[x86_64_v2_python3-sushy-tests.sha256sum] = "c55bd810794a822b3a5e45106e5fcba1fe9622c9232327e85c13676cd27514d9"

URI_aarch64_python-sushy-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-sushy-doc-5.10.1-1.el10_2.noarch.rpm;name=aarch64_python-sushy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-sushy-doc}"
SRC_URI[aarch64_python-sushy-doc.sha256sum] = "d71c76f0605f2f1ee37dbb8b222acd5b4cfdd00303a558a467e16271fcdc24e1"

URI_aarch64_python3-sushy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sushy-5.10.1-1.el10_2.noarch.rpm;name=aarch64_python3-sushy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sushy}"
SRC_URI[aarch64_python3-sushy.sha256sum] = "0f506761b7b99227acf9f01372b65fb3d1f455ff2bc4a295425f195ce7cf6559"

URI_aarch64_python3-sushy-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sushy-tests-5.10.1-1.el10_2.noarch.rpm;name=aarch64_python3-sushy-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sushy-tests}"
SRC_URI[aarch64_python3-sushy-tests.sha256sum] = "ecbf3bd844dfffc9f7e0202a50e0002765fe1890b7f60db853400e3913c39f55"

RDEPENDS:python-sushy-doc = " \
 "
RDEPENDS:python3-sushy = " \
 python3 \
 python3-dateutil \
 python3-pbr \
 python3-requests \
 python3-stevedore \
 "
RDEPENDS:python3-sushy-tests = " \
 python3 \
 python3-sushy \
 "
