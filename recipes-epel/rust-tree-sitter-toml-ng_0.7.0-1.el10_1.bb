# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-toml-ng"
PV = "0.7.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-toml-ng+default-devel \
 rust-tree-sitter-toml-ng-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-toml-ng-0.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28d415eecd6e3cde9d83b0c9fe0fa1087c9424cbf9f00304385a04e91c93f23c"

URI_x86_64_v2_rust-tree-sitter-toml-ng+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-toml-ng+default-devel-0.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-toml-ng+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-toml-ng+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-toml-ng+default-devel.sha256sum] = "4668e8be8114d016adc4d254922180b6e665c481f7ef5d5e4725e621d86a2c6b"

URI_x86_64_v2_rust-tree-sitter-toml-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-toml-ng-devel-0.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-toml-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-toml-ng-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-toml-ng-devel.sha256sum] = "a69468c30f2085c863715c64faee5c8940d4b3aa41004329a8475bbc42e57212"

URI_aarch64_rust-tree-sitter-toml-ng+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-toml-ng+default-devel-0.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-toml-ng+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-toml-ng+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-toml-ng+default-devel.sha256sum] = "687cbd8d5987dc3d414c28fec74828b1b1bfb9f7274959f07c97698747b86c52"

URI_aarch64_rust-tree-sitter-toml-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-toml-ng-devel-0.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-toml-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-toml-ng-devel}"
SRC_URI[aarch64_rust-tree-sitter-toml-ng-devel.sha256sum] = "e4237b90069b5959276d489647ace3499c49a31440d41a345bad31c6afd55121"

RDEPENDS:rust-tree-sitter-toml-ng+default-devel = " \
 cargo \
 rust-tree-sitter-toml-ng-devel \
 "
RDEPENDS:rust-tree-sitter-toml-ng-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
