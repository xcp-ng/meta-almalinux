# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "foxi"
PV = "1.4.1^git20210526.c278588"
PR = "6.el10_1"
PACKAGES = " \
 foxi \
 foxi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/foxi-1.4.1^git20210526.c278588-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad361c88394186c044e04f56ad75002d9d4c62b5ee98b1824c3727abb9f9e7a0"

URI_x86_64_v2_foxi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/foxi-1.4.1^git20210526.c278588-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_foxi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foxi}"
SRC_URI[x86_64_v2_foxi.sha256sum] = "1ca4c4f7cd52672e49abb70537d73394f37b7eb625483f2827af2d1eb54f90d3"

URI_x86_64_v2_foxi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/foxi-devel-1.4.1^git20210526.c278588-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_foxi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foxi-devel}"
SRC_URI[x86_64_v2_foxi-devel.sha256sum] = "8e57a49d2bd4e8ada61b64d9674da9134c56275a86813c585f58ea60e6da69a8"

URI_aarch64_foxi = "${EPEL_MIRROR}/aarch64/Packages/f/foxi-1.4.1^git20210526.c278588-6.el10_1.aarch64.rpm;name=aarch64_foxi;unpack=0"
SRC_URI:append = " ${URI_aarch64_foxi}"
SRC_URI[aarch64_foxi.sha256sum] = "566c323595f38613bf39883165b40c66cb90e88db7d1471b7669c88dd8d84222"

URI_aarch64_foxi-devel = "${EPEL_MIRROR}/aarch64/Packages/f/foxi-devel-1.4.1^git20210526.c278588-6.el10_1.aarch64.rpm;name=aarch64_foxi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_foxi-devel}"
SRC_URI[aarch64_foxi-devel.sha256sum] = "c6d4b041c404388bdd716ded8186128b6ccae8fbd73108a1e2ca864518c19b9f"

RDEPENDS:foxi = " \
 glibc \
 "
RDEPENDS:foxi-devel = " \
 foxi \
 "
