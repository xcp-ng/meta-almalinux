# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "holland"
PV = "1.3.1"
PR = "2.el10_2"
PACKAGES = " \
 holland \
 holland-command \
 holland-common \
 holland-commvault \
 holland-lvm \
 holland-mariabackup \
 holland-mariadb-dump \
 holland-mongodump \
 holland-mysql \
 holland-mysqldump \
 holland-mysqllvm \
 holland-mysqlsh \
 holland-pg_basebackup \
 holland-pgdump \
 holland-xtrabackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/holland-1.3.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f1c6c60dd1d06b61f052f7b9a2a7e94f55fec1661c5afb6b2cc39b7be4dbae2"

URI_x86_64_v2_holland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland}"
SRC_URI[x86_64_v2_holland.sha256sum] = "1f603c86bd1704d835c478cfa5f347661eff2833b33930586545639b99c64246"

URI_x86_64_v2_holland-command = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-command-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland-command;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-command}"
SRC_URI[x86_64_v2_holland-command.sha256sum] = "71b6c2699463d1902320cf357f7d8f6429c5fbbb050cbde3f28984fb8f3c0eb1"

URI_x86_64_v2_holland-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-common-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-common}"
SRC_URI[x86_64_v2_holland-common.sha256sum] = "3031562e2bdc973bea50547af6a53d19405626204d4c28c3d388c46dd429fb41"

URI_x86_64_v2_holland-commvault = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-commvault-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland-commvault;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-commvault}"
SRC_URI[x86_64_v2_holland-commvault.sha256sum] = "5674a46c99d4ab975ef4ae938d17432173b1676f35a1a347f9eee3326560b110"

URI_x86_64_v2_holland-lvm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-lvm-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland-lvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-lvm}"
SRC_URI[x86_64_v2_holland-lvm.sha256sum] = "7177082102514c5afacc67f007f6325fbc4695a62b9eea76455759ecff28eaee"

URI_x86_64_v2_holland-mariabackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mariabackup-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mariabackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mariabackup}"
SRC_URI[x86_64_v2_holland-mariabackup.sha256sum] = "7e00c22350c00e4e8bd6aed4ca5cc0031fa10d2076edeaa9a2168c06bfc3a4ae"

URI_x86_64_v2_holland-mariadb-dump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mariadb-dump-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mariadb-dump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mariadb-dump}"
SRC_URI[x86_64_v2_holland-mariadb-dump.sha256sum] = "cbc2a8aea5f5ac9c0ddf7fb463facd494ed71252adb10d3dbff8be0977a11294"

URI_x86_64_v2_holland-mongodump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mongodump-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mongodump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mongodump}"
SRC_URI[x86_64_v2_holland-mongodump.sha256sum] = "aa575963801d58d10ae33478213b90584700ecd9eca1e226a9cbd1972af01201"

URI_x86_64_v2_holland-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mysql-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mysql}"
SRC_URI[x86_64_v2_holland-mysql.sha256sum] = "cfd9d0f2f349ddb8b37158c409268a4b0f5d61cf59501a718baebc176fb60872"

URI_x86_64_v2_holland-mysqldump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mysqldump-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mysqldump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mysqldump}"
SRC_URI[x86_64_v2_holland-mysqldump.sha256sum] = "9e6e6bbe43fd674dba233a1c4fe998396e0ad014fcb5a629f12ce51dd7da0e8b"

URI_x86_64_v2_holland-mysqllvm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mysqllvm-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mysqllvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mysqllvm}"
SRC_URI[x86_64_v2_holland-mysqllvm.sha256sum] = "01793477eeb0d9365933c3289b29847da6b273355ced6b70ce969d7a41c950d2"

URI_x86_64_v2_holland-mysqlsh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mysqlsh-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mysqlsh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mysqlsh}"
SRC_URI[x86_64_v2_holland-mysqlsh.sha256sum] = "5ecdd4b53ab9165110da063fe308478f5d4e2b3c7a9927ee29ee870cdfb26ca1"

URI_x86_64_v2_holland-pg_basebackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-pg_basebackup-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland-pg_basebackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-pg_basebackup}"
SRC_URI[x86_64_v2_holland-pg_basebackup.sha256sum] = "6aa414de1f26aae269aad5c56ac6a28e1889c566f9e7a6529ae6d1da99ff6439"

URI_x86_64_v2_holland-pgdump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-pgdump-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland-pgdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-pgdump}"
SRC_URI[x86_64_v2_holland-pgdump.sha256sum] = "5d3b5d65b6a809f993ba2c5b95577150d748508528f5e191ee66707f228d574d"

URI_x86_64_v2_holland-xtrabackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-xtrabackup-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_holland-xtrabackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-xtrabackup}"
SRC_URI[x86_64_v2_holland-xtrabackup.sha256sum] = "30ab141a5e09256939cf16e114b02c66427678e4e44762f4cebef77e638bbfc8"

URI_aarch64_holland = "${EPEL_MIRROR}/aarch64/Packages/h/holland-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland}"
SRC_URI[aarch64_holland.sha256sum] = "d4a4f9e6727a54966bc20d9c8c7930010e30cf1db60bc473a280aa442d8231b6"

URI_aarch64_holland-command = "${EPEL_MIRROR}/aarch64/Packages/h/holland-command-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland-command;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-command}"
SRC_URI[aarch64_holland-command.sha256sum] = "237c9eb487e26ef7eedb4b2fd378e605f316ee5ab99559a87615549c64f7cf4d"

URI_aarch64_holland-common = "${EPEL_MIRROR}/aarch64/Packages/h/holland-common-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-common}"
SRC_URI[aarch64_holland-common.sha256sum] = "d181d6ec72f83e85770fa367850200a378f1847ea402249e8e89bf8ccc04f407"

URI_aarch64_holland-commvault = "${EPEL_MIRROR}/aarch64/Packages/h/holland-commvault-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland-commvault;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-commvault}"
SRC_URI[aarch64_holland-commvault.sha256sum] = "991d9a7e1d7a42bb539cc593930258b89696a62c764f1d3cdd1f0330a915f6ab"

URI_aarch64_holland-lvm = "${EPEL_MIRROR}/aarch64/Packages/h/holland-lvm-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland-lvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-lvm}"
SRC_URI[aarch64_holland-lvm.sha256sum] = "d50634d728ec55b7b1548293b00c07bdf5d14e1f0a99759fa2629603148e8e5e"

URI_aarch64_holland-mariabackup = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mariabackup-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland-mariabackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mariabackup}"
SRC_URI[aarch64_holland-mariabackup.sha256sum] = "160e98e49fe4cc731159edda0d6d115b3b19ddfcae6c148a391279cecdd2f71e"

URI_aarch64_holland-mariadb-dump = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mariadb-dump-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland-mariadb-dump;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mariadb-dump}"
SRC_URI[aarch64_holland-mariadb-dump.sha256sum] = "19a9d133cd665e65baa0cf5a6eed9a153d0fa1151b8d8f18342bffd115d1928d"

URI_aarch64_holland-mongodump = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mongodump-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland-mongodump;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mongodump}"
SRC_URI[aarch64_holland-mongodump.sha256sum] = "b43aadf2f429c3d1bb951c88afee4e20320e0fbb68312a11a7cafd98ea938520"

URI_aarch64_holland-mysql = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mysql-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mysql}"
SRC_URI[aarch64_holland-mysql.sha256sum] = "75d1298449479b3f7883d880b69489bb8314e4b9c65319b681cb318f4652f976"

URI_aarch64_holland-mysqldump = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mysqldump-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland-mysqldump;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mysqldump}"
SRC_URI[aarch64_holland-mysqldump.sha256sum] = "ca17f5dc6ea545b3922a1f9e930239c629ffd8d410b6abcfcad07ad5a9451187"

URI_aarch64_holland-mysqllvm = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mysqllvm-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland-mysqllvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mysqllvm}"
SRC_URI[aarch64_holland-mysqllvm.sha256sum] = "d4502a1189752cf10188ed0b1a91cdd7ab73dc5020e03d880d3329de10aa2e60"

URI_aarch64_holland-mysqlsh = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mysqlsh-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland-mysqlsh;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mysqlsh}"
SRC_URI[aarch64_holland-mysqlsh.sha256sum] = "1f0c2a18f07c4a65dd57491532d94c01e0519e821f12b174f0bf8bdf12c02b66"

URI_aarch64_holland-pg_basebackup = "${EPEL_MIRROR}/aarch64/Packages/h/holland-pg_basebackup-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland-pg_basebackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-pg_basebackup}"
SRC_URI[aarch64_holland-pg_basebackup.sha256sum] = "e1061672d6cf1f799693e94bbde328a2182c382d5f70201885a33055116a27f4"

URI_aarch64_holland-pgdump = "${EPEL_MIRROR}/aarch64/Packages/h/holland-pgdump-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland-pgdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-pgdump}"
SRC_URI[aarch64_holland-pgdump.sha256sum] = "8410f02bf1fe5b32aed4953a308751755edca64dc338a0f847e8d5de1205958d"

URI_aarch64_holland-xtrabackup = "${EPEL_MIRROR}/aarch64/Packages/h/holland-xtrabackup-1.3.1-2.el10_2.noarch.rpm;name=aarch64_holland-xtrabackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-xtrabackup}"
SRC_URI[aarch64_holland-xtrabackup.sha256sum] = "ccf74265e81383cebc1bb693f360c99c901b4e9f71e144d96efe6d7cd2c6838c"

RDEPENDS:holland = " \
 logrotate \
 python3 \
 python3-configobj \
 python3-setuptools \
 python3-six \
 "
RDEPENDS:holland-command = " \
 holland-common \
 python3 \
 "
RDEPENDS:holland-common = " \
 holland \
 python3 \
 "
RDEPENDS:holland-commvault = " \
 holland \
 python3 \
 python3-pid \
 tar \
 "
RDEPENDS:holland-lvm = " \
 holland \
 python3 \
 "
RDEPENDS:holland-mariabackup = " \
 holland-common \
 holland-mysql \
 python3 \
 virtual//usr/bin/mariabackup \
 "
RDEPENDS:holland-mariadb-dump = " \
 holland-common \
 holland-mysql \
 python3 \
 virtual//usr/bin/mariadb-dump \
 "
RDEPENDS:holland-mongodump = " \
 holland-common \
 python3 \
 python3-pymongo \
 "
RDEPENDS:holland-mysql = " \
 holland-common \
 python3 \
 python3-PyMySQL \
 python3-mysqlclient \
 "
RDEPENDS:holland-mysqldump = " \
 holland-mysql \
 python3 \
 virtual//usr/bin/mysqldump \
 "
RDEPENDS:holland-mysqllvm = " \
 holland-lvm \
 holland-mysql \
 lvm2 \
 python3 \
 tar \
 "
RDEPENDS:holland-mysqlsh = " \
 holland-common \
 holland-mysql \
 python3 \
 "
RDEPENDS:holland-pg_basebackup = " \
 holland-common \
 python3 \
 python3-psycopg2 \
 "
RDEPENDS:holland-pgdump = " \
 holland-common \
 python3 \
 python3-psycopg2 \
 "
RDEPENDS:holland-xtrabackup = " \
 holland-common \
 holland-mysql \
 python3 \
 python3-mysqlclient \
 "
