# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Touch"
PV = "0.12"
PR = "10.el10_0"
PACKAGES = " \
 perl-File-Touch \
 perl-File-Touch-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-Touch-0.12-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8279cc6bcc31e84c18a5a7a1604fbdab54a173cbdaae0a861958626bbe542dda"

URI_x86_64_v2_perl-File-Touch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Touch-0.12-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Touch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Touch}"
SRC_URI[x86_64_v2_perl-File-Touch.sha256sum] = "ea992eec40343016d353d5c5727b0145ee96e97558ba4f4e1bb123daa73755bd"

URI_x86_64_v2_perl-File-Touch-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Touch-tests-0.12-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Touch-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Touch-tests}"
SRC_URI[x86_64_v2_perl-File-Touch-tests.sha256sum] = "7f121e61f8d7ccd3ba04112e0dea5728eadd8a4e5d7d926bbb6a72c4c3463ee0"

URI_aarch64_perl-File-Touch = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Touch-0.12-10.el10_0.noarch.rpm;name=aarch64_perl-File-Touch;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Touch}"
SRC_URI[aarch64_perl-File-Touch.sha256sum] = "4a2ff0d9eba11f2897a1dcf14d86cd0bebcac218318bdb6551e0de7ca464ff47"

URI_aarch64_perl-File-Touch-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Touch-tests-0.12-10.el10_0.noarch.rpm;name=aarch64_perl-File-Touch-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Touch-tests}"
SRC_URI[aarch64_perl-File-Touch-tests.sha256sum] = "8b1a3b9c85bd1536676f26e28e02958f32d2f4c205b148e0f4a3930f217871bf"

RDEPENDS:perl-File-Touch = " \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-File-stat \
 perl-IO \
 perl-Time-HiRes \
 perl-libs \
 "
RDEPENDS:perl-File-Touch-tests = " \
 bash \
 perl-File-Touch \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-libs \
 virtual/coreutils \
 "
