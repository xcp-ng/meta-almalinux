# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opentype-sanitizer"
PV = "9.2.0"
PR = "1.el10_0"
PACKAGES = " \
 opentype-sanitizer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opentype-sanitizer-9.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d05ec7f17bbc86f2542ce5f7f0ad1c25d59193e276c8e506605dd9e4dc42c38e"

URI_x86_64_v2_opentype-sanitizer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opentype-sanitizer-9.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opentype-sanitizer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opentype-sanitizer}"
SRC_URI[x86_64_v2_opentype-sanitizer.sha256sum] = "1790be2d4b712d273addbf9068341b7d80e6e5c0a85737bf2389d69ae32910e5"

URI_aarch64_opentype-sanitizer = "${EPEL_MIRROR}/aarch64/Packages/o/opentype-sanitizer-9.2.0-1.el10_0.aarch64.rpm;name=aarch64_opentype-sanitizer;unpack=0"
SRC_URI:append = " ${URI_aarch64_opentype-sanitizer}"
SRC_URI[aarch64_opentype-sanitizer.sha256sum] = "3123bcd04a5a715262f5002878c2af7dd7b021f49d979460aea87330bd6963f3"

RDEPENDS:opentype-sanitizer = " \
 freetype \
 glibc \
 libgcc \
 libstdc++ \
 lz4-libs \
 woff2 \
 zlib-ng-compat \
 "
