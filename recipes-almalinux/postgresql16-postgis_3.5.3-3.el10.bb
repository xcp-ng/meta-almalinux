# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql16-postgis"
PV = "3.5.3"
PR = "3.el10"
PACKAGES = " \
 postgis \
 postgis-client \
 postgis-docs \
 postgis-upgrade \
 postgis-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql16-postgis-3.5.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65eee3380b2e4267abbc66e90460d54a9af3fb0a02e8ca74e599782ad0f3a885"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - postgis-client: libgeos_c.so.1()(64bit)
# - postgis-upgrade: libgeos_c.so.1()(64bit)
# - postgis: libgeos_c.so.1()(64bit)

URI_x86_64_v2_postgis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgis-3.5.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgis}"
SRC_URI[x86_64_v2_postgis.sha256sum] = "cef2172a0ff59621a5b84d952950afcb386ca4aa6aaa2cf0396c486352faa701"

URI_x86_64_v2_postgis-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgis-client-3.5.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgis-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgis-client}"
SRC_URI[x86_64_v2_postgis-client.sha256sum] = "1033ec39ca6d68d12a8293259763a76b91a230bea0b0dd0d1d17a8295f685e2e"

URI_x86_64_v2_postgis-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgis-docs-3.5.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgis-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgis-docs}"
SRC_URI[x86_64_v2_postgis-docs.sha256sum] = "c43e38a553b936b2646821fe9fd60d2fc11b963577e0efe80bd3d28e53dc1c23"

URI_x86_64_v2_postgis-upgrade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgis-upgrade-3.5.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgis-upgrade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgis-upgrade}"
SRC_URI[x86_64_v2_postgis-upgrade.sha256sum] = "44d15851c4831b3914634518eb0e54922b847b1ebd1fb7d97a682a71ddc9844b"

URI_x86_64_v2_postgis-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgis-utils-3.5.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgis-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgis-utils}"
SRC_URI[x86_64_v2_postgis-utils.sha256sum] = "883306cb83696a990116b18111c3aef2d4106b424d5a5884ac35273969e43706"

URI_aarch64_postgis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgis-3.5.3-3.el10.aarch64.rpm;name=aarch64_postgis;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgis}"
SRC_URI[aarch64_postgis.sha256sum] = "f071dcba0745d8314d8558cda9582e22e94c30382844eb7cf286e49b24dfbdd4"

URI_aarch64_postgis-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgis-client-3.5.3-3.el10.aarch64.rpm;name=aarch64_postgis-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgis-client}"
SRC_URI[aarch64_postgis-client.sha256sum] = "b1458bf068870e3b0c9e663f1b6f76730226a76c0db692008a7e1b628e897096"

URI_aarch64_postgis-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgis-docs-3.5.3-3.el10.aarch64.rpm;name=aarch64_postgis-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgis-docs}"
SRC_URI[aarch64_postgis-docs.sha256sum] = "221d4e36834ee679edf4ab2bc7a3a96863c98394f6f226379251d29d426f347d"

URI_aarch64_postgis-upgrade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgis-upgrade-3.5.3-3.el10.aarch64.rpm;name=aarch64_postgis-upgrade;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgis-upgrade}"
SRC_URI[aarch64_postgis-upgrade.sha256sum] = "33de46b0574b320923e903c13a32fdd5b674c59d63b3fe1fd4f85610d8897fcc"

URI_aarch64_postgis-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgis-utils-3.5.3-3.el10.aarch64.rpm;name=aarch64_postgis-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgis-utils}"
SRC_URI[aarch64_postgis-utils.sha256sum] = "e697e0c349f7e5e32c56680131689040dc9f8471dfc70e22a968ceea52393d0c"

RDEPENDS:postgis:x86_64_v2 = " \
 gdal-libs \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 proj \
 protobuf-c \
"
RDEPENDS:postgis:aarch64 = " \
 gdal-libs \
 geos \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 proj \
 protobuf-c \
"
RDEPENDS:postgis-client:x86_64_v2 = " \
 bash \
 gdal-libs \
 glibc \
 perl-File-Basename \
 perl-interpreter \
 perl-libs \
 postgis \
 postgresql-private-libs \
 proj \
"
RDEPENDS:postgis-client:aarch64 = " \
 bash \
 gdal-libs \
 geos \
 glibc \
 perl-File-Basename \
 perl-interpreter \
 perl-libs \
 postgis \
 postgresql-private-libs \
 proj \
"
RDEPENDS:postgis-docs = " \
 "
RDEPENDS:postgis-upgrade:x86_64_v2 = " \
 gdal-libs \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 postgis \
 postgresql-upgrade \
 proj \
 protobuf-c \
"
RDEPENDS:postgis-upgrade:aarch64 = " \
 gdal-libs \
 geos \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 postgis \
 postgresql-upgrade \
 proj \
 protobuf-c \
"
RDEPENDS:postgis-utils = " \
 perl-DBD-Pg \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 postgis \
 "
