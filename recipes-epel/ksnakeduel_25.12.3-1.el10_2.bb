# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksnakeduel"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ksnakeduel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksnakeduel-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8b010d02d1335c04ccc091217e4b2a143739bff587ce2779253fcadcfd6a5a8"

URI_x86_64_v2_ksnakeduel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksnakeduel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksnakeduel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksnakeduel}"
SRC_URI[x86_64_v2_ksnakeduel.sha256sum] = "da937285f54664f644a6734042013f965c820b330b3a0ff3e621cfff326bc6f2"

URI_aarch64_ksnakeduel = "${EPEL_MIRROR}/aarch64/Packages/k/ksnakeduel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ksnakeduel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksnakeduel}"
SRC_URI[aarch64_ksnakeduel.sha256sum] = "f46e600ab7dfbbb128c4b9097f8136e35607526efc41fb514ae8ff6f2b892d00"

RDEPENDS:ksnakeduel = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
