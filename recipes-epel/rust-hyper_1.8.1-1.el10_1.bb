# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper"
PV = "1.8.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-hyper+capi-devel \
 rust-hyper+client-devel \
 rust-hyper+default-devel \
 rust-hyper+ffi-devel \
 rust-hyper+full-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper+server-devel \
 rust-hyper+tracing-devel \
 rust-hyper-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-1.8.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e36d2ae70c0262d92625ad0caf77ece61aee27b547d04d65816b70e132c11ba0"

URI_x86_64_v2_rust-hyper+capi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+capi-devel-1.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+capi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+capi-devel}"
SRC_URI[x86_64_v2_rust-hyper+capi-devel.sha256sum] = "4d15bcfd2d8f25328fc9a1fb9543fc777f091f3f5b61d8ab0d35a0457739a91d"

URI_x86_64_v2_rust-hyper+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+client-devel-1.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+client-devel}"
SRC_URI[x86_64_v2_rust-hyper+client-devel.sha256sum] = "a5a9b09d23dac446005e909008c8b88495003491573671911eb77b1a0fb8a113"

URI_x86_64_v2_rust-hyper+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+default-devel-1.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+default-devel}"
SRC_URI[x86_64_v2_rust-hyper+default-devel.sha256sum] = "31dc48a6acf05a36e3d78832f1ca9b668a8182d99cf9c4d46e4badf9be0fb697"

URI_x86_64_v2_rust-hyper+ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+ffi-devel-1.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+ffi-devel}"
SRC_URI[x86_64_v2_rust-hyper+ffi-devel.sha256sum] = "07f13b755dbdd1b4456866d4811f5bb83e10dbd38012e3a83009e59cd2dcbbff"

URI_x86_64_v2_rust-hyper+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+full-devel-1.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+full-devel}"
SRC_URI[x86_64_v2_rust-hyper+full-devel.sha256sum] = "babb0fe78090ab31d480b5d01441994124daa0277b1bc4ad3817aab39681b3b0"

URI_x86_64_v2_rust-hyper+http1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+http1-devel-1.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+http1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+http1-devel}"
SRC_URI[x86_64_v2_rust-hyper+http1-devel.sha256sum] = "4f92f5ce1f180c76fe109bcd4809869824dce05a71c88480a2112b3614f16844"

URI_x86_64_v2_rust-hyper+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+http2-devel-1.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+http2-devel}"
SRC_URI[x86_64_v2_rust-hyper+http2-devel.sha256sum] = "0a74159c391f578a880f1ef7297554541b2c23362c477742fc7078e5617dcc39"

URI_x86_64_v2_rust-hyper+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+server-devel-1.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+server-devel}"
SRC_URI[x86_64_v2_rust-hyper+server-devel.sha256sum] = "547a0e81060f8f7139cf737d78908d50d17fc87383724bd54cf4756e6d9ae412"

URI_x86_64_v2_rust-hyper+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+tracing-devel-1.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+tracing-devel}"
SRC_URI[x86_64_v2_rust-hyper+tracing-devel.sha256sum] = "e2163802e54aae1d479cce68ce31949a03c3c7f192eb49c163f1a814caae001d"

URI_x86_64_v2_rust-hyper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-devel-1.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-devel}"
SRC_URI[x86_64_v2_rust-hyper-devel.sha256sum] = "33ca0ee16b9824746876bff304f2c1ef0ca9cd40cbf5a33e7678cc61020653ca"

URI_aarch64_rust-hyper+capi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+capi-devel-1.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-hyper+capi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+capi-devel}"
SRC_URI[aarch64_rust-hyper+capi-devel.sha256sum] = "e7a4e2f030e2f7f08080c444e2e2e497b56868db5e7bb0d1301fa63547e153e7"

URI_aarch64_rust-hyper+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+client-devel-1.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-hyper+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+client-devel}"
SRC_URI[aarch64_rust-hyper+client-devel.sha256sum] = "4a4a7ae3cf0b493c86568ce153c2044e59fe4734c76b3627415db8c104ce81e7"

URI_aarch64_rust-hyper+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+default-devel-1.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-hyper+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+default-devel}"
SRC_URI[aarch64_rust-hyper+default-devel.sha256sum] = "481f7c08ec43e2ddf0e7475591d32c3f3d9433d5562c79cd6e0481ffc991f104"

URI_aarch64_rust-hyper+ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+ffi-devel-1.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-hyper+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+ffi-devel}"
SRC_URI[aarch64_rust-hyper+ffi-devel.sha256sum] = "0296b269433ce433a064b930476db8d45c1e929b08269eca2f57528621ec0983"

URI_aarch64_rust-hyper+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+full-devel-1.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-hyper+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+full-devel}"
SRC_URI[aarch64_rust-hyper+full-devel.sha256sum] = "1564b46dbc1953dfc69a7f6e577dbed7cf0b4ac7399cca1ff5d11d484f5aadf4"

URI_aarch64_rust-hyper+http1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+http1-devel-1.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-hyper+http1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+http1-devel}"
SRC_URI[aarch64_rust-hyper+http1-devel.sha256sum] = "f4e6229bb38174571ae4028075feab8e65e8197ef2b6900e2833feb3f7bd292a"

URI_aarch64_rust-hyper+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+http2-devel-1.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-hyper+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+http2-devel}"
SRC_URI[aarch64_rust-hyper+http2-devel.sha256sum] = "74456119f2e543b5f348cf197cb3f95143db2032aa758aad999900f1496ebef8"

URI_aarch64_rust-hyper+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+server-devel-1.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-hyper+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+server-devel}"
SRC_URI[aarch64_rust-hyper+server-devel.sha256sum] = "90f920cc3075a829313c9d8233666cf38f46e58246b68b0c24ef6ff23dfa9cb4"

URI_aarch64_rust-hyper+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+tracing-devel-1.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-hyper+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+tracing-devel}"
SRC_URI[aarch64_rust-hyper+tracing-devel.sha256sum] = "c24938153a77dc1dcd63828dd57cce4f8e87e3d21f6e4a42b494e3d58f6777e5"

URI_aarch64_rust-hyper-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-devel-1.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-hyper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-devel}"
SRC_URI[aarch64_rust-hyper-devel.sha256sum] = "122191492530394585e36031d28a64453d97572f8e4868cf55ff81cdeb435b42"

RDEPENDS:rust-hyper+capi-devel = " \
 cargo \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+client-devel = " \
 cargo \
 rust-hyper-devel \
 rust-pin-project-lite+default-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-want+default-devel \
 "
RDEPENDS:rust-hyper+default-devel = " \
 cargo \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+ffi-devel = " \
 cargo \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http-body-util+default-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+full-devel = " \
 cargo \
 rust-hyper+client-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper+server-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+http1-devel = " \
 cargo \
 rust-atomic-waker+default-devel \
 rust-futures-channel+default-devel \
 rust-futures-core+default-devel \
 rust-httparse+default-devel \
 rust-hyper-devel \
 rust-itoa+default-devel \
 rust-pin-utils+default-devel \
 "
RDEPENDS:rust-hyper+http2-devel = " \
 cargo \
 rust-futures-channel+default-devel \
 rust-futures-core+default-devel \
 rust-h2+default-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+server-devel = " \
 cargo \
 rust-httpdate+default-devel \
 rust-hyper-devel \
 rust-pin-project-lite+default-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-hyper+tracing-devel = " \
 cargo \
 rust-hyper-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-hyper-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
