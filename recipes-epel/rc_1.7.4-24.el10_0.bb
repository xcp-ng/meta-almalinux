# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rc"
PV = "1.7.4"
PR = "24.el10_0"
PACKAGES = " \
 rc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rc-1.7.4-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e5926c6a0a5e67355b706a98d475944bc341c24b650c279b3bfdc64fc75a264"

URI_x86_64_v2_rc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rc-1.7.4-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rc}"
SRC_URI[x86_64_v2_rc.sha256sum] = "f184bdfb98af5db9b5b4f991b2b2c2991cc3cc012e3eac72e55b1da90a6912fb"

URI_aarch64_rc = "${EPEL_MIRROR}/aarch64/Packages/r/rc-1.7.4-24.el10_0.aarch64.rpm;name=aarch64_rc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rc}"
SRC_URI[aarch64_rc.sha256sum] = "d9568ec3ac7ce5da3e50f26ea22d354a6a24ac9e9947c585e352a0ab58cd36bf"

RDEPENDS:rc = " \
 bash \
 glibc \
 grep \
 readline \
 sed \
 "
