# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomlplusplus"
PV = "3.4.0"
PR = "5.el10_1"
PACKAGES = " \
 tomlplusplus \
 tomlplusplus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tomlplusplus-3.4.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed6b24f63f62c53c43da1023b9498e82b0e1fc923799a4d7f9c3abd7adc6262e"

URI_x86_64_v2_tomlplusplus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tomlplusplus-3.4.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tomlplusplus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomlplusplus}"
SRC_URI[x86_64_v2_tomlplusplus.sha256sum] = "82df7108407850cd9a0769d769b86c8f4b6af3f1a12dd7ef5a39158bea3d7a82"

URI_x86_64_v2_tomlplusplus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tomlplusplus-devel-3.4.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tomlplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomlplusplus-devel}"
SRC_URI[x86_64_v2_tomlplusplus-devel.sha256sum] = "15bb1959f9a6b6f7a3b363d1096ac65ec96efc7475000b3e1e9c22e0c14ff2d2"

URI_aarch64_tomlplusplus = "${EPEL_MIRROR}/aarch64/Packages/t/tomlplusplus-3.4.0-5.el10_1.aarch64.rpm;name=aarch64_tomlplusplus;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomlplusplus}"
SRC_URI[aarch64_tomlplusplus.sha256sum] = "7f485d46c26497738293d546ce46b55e74223221a2a9ad7bec7af541348e73d7"

URI_aarch64_tomlplusplus-devel = "${EPEL_MIRROR}/aarch64/Packages/t/tomlplusplus-devel-3.4.0-5.el10_1.aarch64.rpm;name=aarch64_tomlplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomlplusplus-devel}"
SRC_URI[aarch64_tomlplusplus-devel.sha256sum] = "9cacab6ab6beeb555cceacb190dde0b954d1ddd37fc539cdc18ebc3b56885596"

RDEPENDS:tomlplusplus = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:tomlplusplus-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 tomlplusplus \
 "
