# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-rsc-pdf"
PV = "0.1.1"
PR = "19.el10_0"
PACKAGES = " \
 golang-rsc-pdf \
 golang-rsc-pdf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-rsc-pdf-0.1.1-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5736a865d3e90aa5d99366f1465d08320dec3e99fe981994ba65f546e1e0333"

URI_x86_64_v2_golang-rsc-pdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-rsc-pdf-0.1.1-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-rsc-pdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-rsc-pdf}"
SRC_URI[x86_64_v2_golang-rsc-pdf.sha256sum] = "2373f1e581676b048f3ed8dabbd9544527d403e39e9bb9008ddaff9c9f66bbce"

URI_x86_64_v2_golang-rsc-pdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-rsc-pdf-devel-0.1.1-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-rsc-pdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-rsc-pdf-devel}"
SRC_URI[x86_64_v2_golang-rsc-pdf-devel.sha256sum] = "f0a2cac5ca357b5ea34ef94449a899e3547b3a0348e75f25154dfbc466c9fc2a"

URI_aarch64_golang-rsc-pdf = "${EPEL_MIRROR}/aarch64/Packages/g/golang-rsc-pdf-0.1.1-19.el10_0.aarch64.rpm;name=aarch64_golang-rsc-pdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-rsc-pdf}"
SRC_URI[aarch64_golang-rsc-pdf.sha256sum] = "78074169269019b5fd58ccc6b1e1078f2dd1f3ad0b940d4c951cc37e4ce22ace"

URI_aarch64_golang-rsc-pdf-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-rsc-pdf-devel-0.1.1-19.el10_0.noarch.rpm;name=aarch64_golang-rsc-pdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-rsc-pdf-devel}"
SRC_URI[aarch64_golang-rsc-pdf-devel.sha256sum] = "29b3425932251178d629003fe25b0368792281bef994b9d64b063dbfdad94de7"

RDEPENDS:golang-rsc-pdf = " \
 glibc \
 "
RDEPENDS:golang-rsc-pdf-devel = " \
 go-filesystem \
 "
