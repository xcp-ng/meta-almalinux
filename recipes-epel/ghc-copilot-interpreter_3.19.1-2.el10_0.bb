# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-copilot-interpreter"
PV = "3.19.1"
PR = "2.el10_0"
PACKAGES = " \
 ghc-copilot-interpreter \
 ghc-copilot-interpreter-devel \
 ghc-copilot-interpreter-doc \
 ghc-copilot-interpreter-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-copilot-interpreter-3.19.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "952fa869bca5d8dcf0209ced1ff3c35830aeaf1c1fa2c9cd662df2f1b9eaccb4"

URI_x86_64_v2_ghc-copilot-interpreter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-interpreter-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-interpreter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-interpreter}"
SRC_URI[x86_64_v2_ghc-copilot-interpreter.sha256sum] = "fd8b159fc27330cf0ca22e18991ce3b6d8259d9f830057151d7d51e144ad9968"

URI_x86_64_v2_ghc-copilot-interpreter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-interpreter-devel-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-interpreter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-interpreter-devel}"
SRC_URI[x86_64_v2_ghc-copilot-interpreter-devel.sha256sum] = "edd58871233070c9819cfce41e6d7ef2f67ada3795c391d371ba426c63f00fb7"

URI_x86_64_v2_ghc-copilot-interpreter-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-interpreter-doc-3.19.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-copilot-interpreter-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-interpreter-doc}"
SRC_URI[x86_64_v2_ghc-copilot-interpreter-doc.sha256sum] = "2cce8ecafb03ef48c29cfdb1cf6412f78ad326aa1e26288a1d70b09fad424809"

URI_x86_64_v2_ghc-copilot-interpreter-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-interpreter-prof-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-interpreter-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-interpreter-prof}"
SRC_URI[x86_64_v2_ghc-copilot-interpreter-prof.sha256sum] = "8a21a8e3899bb035e12b80faee2b42232641e5147ac6ab1471b1a88c5047690d"

URI_aarch64_ghc-copilot-interpreter = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-interpreter-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-interpreter;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-interpreter}"
SRC_URI[aarch64_ghc-copilot-interpreter.sha256sum] = "1be109e86e783b53252fac78fe106c54d76905b1dc2491f80ae9340d4964e24d"

URI_aarch64_ghc-copilot-interpreter-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-interpreter-devel-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-interpreter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-interpreter-devel}"
SRC_URI[aarch64_ghc-copilot-interpreter-devel.sha256sum] = "0ce29acac10d4e08956857f0f903fa8a716533a40da0e1eeb62faf9aa6a8ba29"

URI_aarch64_ghc-copilot-interpreter-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-interpreter-doc-3.19.1-2.el10_0.noarch.rpm;name=aarch64_ghc-copilot-interpreter-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-interpreter-doc}"
SRC_URI[aarch64_ghc-copilot-interpreter-doc.sha256sum] = "c763884d95b67a0696d2af3c1fd5dad71b89428ca48c3d95098f493b2de7b354"

URI_aarch64_ghc-copilot-interpreter-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-interpreter-prof-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-interpreter-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-interpreter-prof}"
SRC_URI[aarch64_ghc-copilot-interpreter-prof.sha256sum] = "5c96297dc0972924dfc1e01afa1e5166c343ec4f2e4ade7ad3142db0a4f61e28"

RDEPENDS:ghc-copilot-interpreter = " \
 ghc-array \
 ghc-base \
 ghc-copilot-core \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc-copilot-interpreter-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-copilot-core-devel \
 ghc-copilot-interpreter \
 ghc-pretty-devel \
 "
RDEPENDS:ghc-copilot-interpreter-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-copilot-interpreter-prof = " \
 ghc-base-prof \
 ghc-copilot-core-prof \
 ghc-copilot-interpreter-devel \
 ghc-pretty-prof \
 "
