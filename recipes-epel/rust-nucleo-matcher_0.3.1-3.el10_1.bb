# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nucleo-matcher"
PV = "0.3.1"
PR = "3.el10_1"
PACKAGES = " \
 rust-nucleo-matcher+default-devel \
 rust-nucleo-matcher+unicode-casefold-devel \
 rust-nucleo-matcher+unicode-normalization-devel \
 rust-nucleo-matcher+unicode-segmentation-devel \
 rust-nucleo-matcher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nucleo-matcher-0.3.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74d5c9e73f9dce1b2cf84e6ee5a7211fa3741bc3804e50ae95415c32ef3db9c1"

URI_x86_64_v2_rust-nucleo-matcher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nucleo-matcher+default-devel-0.3.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nucleo-matcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nucleo-matcher+default-devel}"
SRC_URI[x86_64_v2_rust-nucleo-matcher+default-devel.sha256sum] = "52b8cf154edfd03c7e13b70c489722c2eff30f0e695041bbb7d2c66f164cfadc"

URI_x86_64_v2_rust-nucleo-matcher+unicode-casefold-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nucleo-matcher+unicode-casefold-devel-0.3.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nucleo-matcher+unicode-casefold-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nucleo-matcher+unicode-casefold-devel}"
SRC_URI[x86_64_v2_rust-nucleo-matcher+unicode-casefold-devel.sha256sum] = "a0496625cf16b91c7549a16b55c508500b81334998c5849836ec442a68b95463"

URI_x86_64_v2_rust-nucleo-matcher+unicode-normalization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nucleo-matcher+unicode-normalization-devel-0.3.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nucleo-matcher+unicode-normalization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nucleo-matcher+unicode-normalization-devel}"
SRC_URI[x86_64_v2_rust-nucleo-matcher+unicode-normalization-devel.sha256sum] = "5fe4e957979b856a832fba523c2722ada619d4eb129a234b9467b32d165995e6"

URI_x86_64_v2_rust-nucleo-matcher+unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nucleo-matcher+unicode-segmentation-devel-0.3.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nucleo-matcher+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nucleo-matcher+unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-nucleo-matcher+unicode-segmentation-devel.sha256sum] = "4febc64757d84704fcc3b38befb619526eb068e18f9cd84940ca2516406d2588"

URI_x86_64_v2_rust-nucleo-matcher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nucleo-matcher-devel-0.3.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nucleo-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nucleo-matcher-devel}"
SRC_URI[x86_64_v2_rust-nucleo-matcher-devel.sha256sum] = "c1136db7883e0593a780b9357ef6076fb951218c9222a5ac5eac7a6f3bfd1c2c"

URI_aarch64_rust-nucleo-matcher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nucleo-matcher+default-devel-0.3.1-3.el10_1.noarch.rpm;name=aarch64_rust-nucleo-matcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nucleo-matcher+default-devel}"
SRC_URI[aarch64_rust-nucleo-matcher+default-devel.sha256sum] = "68c4447300cf8c972b980208391df226d7c59f02d994d60b0d72a181ed5715ce"

URI_aarch64_rust-nucleo-matcher+unicode-casefold-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nucleo-matcher+unicode-casefold-devel-0.3.1-3.el10_1.noarch.rpm;name=aarch64_rust-nucleo-matcher+unicode-casefold-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nucleo-matcher+unicode-casefold-devel}"
SRC_URI[aarch64_rust-nucleo-matcher+unicode-casefold-devel.sha256sum] = "99c4db497792210df0dccd561d2c5835417c5eb0a3d0d12939f568e483b6c379"

URI_aarch64_rust-nucleo-matcher+unicode-normalization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nucleo-matcher+unicode-normalization-devel-0.3.1-3.el10_1.noarch.rpm;name=aarch64_rust-nucleo-matcher+unicode-normalization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nucleo-matcher+unicode-normalization-devel}"
SRC_URI[aarch64_rust-nucleo-matcher+unicode-normalization-devel.sha256sum] = "39bcf06b60bfe0c77815339dff36f8d0dc729b88b992303747e92c856e9cd10e"

URI_aarch64_rust-nucleo-matcher+unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nucleo-matcher+unicode-segmentation-devel-0.3.1-3.el10_1.noarch.rpm;name=aarch64_rust-nucleo-matcher+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nucleo-matcher+unicode-segmentation-devel}"
SRC_URI[aarch64_rust-nucleo-matcher+unicode-segmentation-devel.sha256sum] = "3ef54d7a91e9705080c3bd05d194898a4d8feb803aa7001a40c9739803e63b00"

URI_aarch64_rust-nucleo-matcher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nucleo-matcher-devel-0.3.1-3.el10_1.noarch.rpm;name=aarch64_rust-nucleo-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nucleo-matcher-devel}"
SRC_URI[aarch64_rust-nucleo-matcher-devel.sha256sum] = "b7b1afcec3fa30e68daef52646e541aaf91c1f65ebb364a67a9d3338019822e0"

RDEPENDS:rust-nucleo-matcher+default-devel = " \
 cargo \
 rust-nucleo-matcher+unicode-casefold-devel \
 rust-nucleo-matcher+unicode-normalization-devel \
 rust-nucleo-matcher+unicode-segmentation-devel \
 rust-nucleo-matcher-devel \
 "
RDEPENDS:rust-nucleo-matcher+unicode-casefold-devel = " \
 cargo \
 rust-nucleo-matcher-devel \
 "
RDEPENDS:rust-nucleo-matcher+unicode-normalization-devel = " \
 cargo \
 rust-nucleo-matcher-devel \
 "
RDEPENDS:rust-nucleo-matcher+unicode-segmentation-devel = " \
 cargo \
 rust-nucleo-matcher-devel \
 rust-unicode-segmentation+default-devel \
 "
RDEPENDS:rust-nucleo-matcher-devel = " \
 bash \
 cargo \
 rust-memchr+default-devel \
 "
