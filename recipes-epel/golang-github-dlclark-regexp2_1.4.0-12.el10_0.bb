# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-dlclark-regexp2"
PV = "1.4.0"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-dlclark-regexp2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-dlclark-regexp2-1.4.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37d4c3b9ab0899f68f31673aa56d84f7447b6b49378a9aa960b96ad131eac686"

URI_x86_64_v2_golang-github-dlclark-regexp2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-dlclark-regexp2-devel-1.4.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-dlclark-regexp2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-dlclark-regexp2-devel}"
SRC_URI[x86_64_v2_golang-github-dlclark-regexp2-devel.sha256sum] = "4de7bc45dbf31572dfa8d5da812f70721e94b1333b2fd7b2759ebce71472bc5f"

URI_aarch64_golang-github-dlclark-regexp2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-dlclark-regexp2-devel-1.4.0-12.el10_0.noarch.rpm;name=aarch64_golang-github-dlclark-regexp2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-dlclark-regexp2-devel}"
SRC_URI[aarch64_golang-github-dlclark-regexp2-devel.sha256sum] = "2d6e3259e3ad4036ceea89bdb05a72c84539739a81fa08c62f0ebc5e8049b3c2"

RDEPENDS:golang-github-dlclark-regexp2-devel = " \
 go-filesystem \
 "
