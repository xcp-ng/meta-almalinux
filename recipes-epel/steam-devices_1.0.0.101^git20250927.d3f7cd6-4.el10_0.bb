# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "steam-devices"
PV = "1.0.0.101^git20250927.d3f7cd6"
PR = "4.el10_0"
PACKAGES = " \
 steam-devices \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/steam-devices-1.0.0.101^git20250927.d3f7cd6-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ed319a06737a57a19136a390a5a4f0303ac7832e1987a8926ccd5585b146ca6"

URI_x86_64_v2_steam-devices = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/steam-devices-1.0.0.101^git20250927.d3f7cd6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_steam-devices;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_steam-devices}"
SRC_URI[x86_64_v2_steam-devices.sha256sum] = "1874d00f6c8ae4bb0854cfc7c22d2e30fb788cf1b2c990bd533d82dab81a195d"

URI_aarch64_steam-devices = "${EPEL_MIRROR}/aarch64/Packages/s/steam-devices-1.0.0.101^git20250927.d3f7cd6-4.el10_0.noarch.rpm;name=aarch64_steam-devices;unpack=0"
SRC_URI:append = " ${URI_aarch64_steam-devices}"
SRC_URI[aarch64_steam-devices.sha256sum] = "d6a417f7ca1aa71f81b89baca5cc7b5a7a37e4e270bc0542c0c871b44f5cbbba"

RDEPENDS:steam-devices = " \
 "
