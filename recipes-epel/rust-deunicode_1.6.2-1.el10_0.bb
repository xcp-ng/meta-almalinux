# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deunicode"
PV = "1.6.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-deunicode+alloc-devel \
 rust-deunicode+default-devel \
 rust-deunicode-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deunicode-1.6.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c566c3f3ef89e766a42a5a934171dca994a4d3c78d658a3cd51e79958c7de3f4"

URI_x86_64_v2_rust-deunicode+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deunicode+alloc-devel-1.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deunicode+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deunicode+alloc-devel}"
SRC_URI[x86_64_v2_rust-deunicode+alloc-devel.sha256sum] = "1d0670acff901c65bd14d6ec26f5124400cfdf4173f4fae65ff1c1cde5980d6a"

URI_x86_64_v2_rust-deunicode+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deunicode+default-devel-1.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deunicode+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deunicode+default-devel}"
SRC_URI[x86_64_v2_rust-deunicode+default-devel.sha256sum] = "38cb7bb6ca477e113e576f77d96f1d9af6a606d3fb464697a661d9c1615ddb63"

URI_x86_64_v2_rust-deunicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deunicode-devel-1.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deunicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deunicode-devel}"
SRC_URI[x86_64_v2_rust-deunicode-devel.sha256sum] = "09cb77960e69e5760e3d260b325aace4ceb634196aaaa4c189411a4ea921184a"

URI_aarch64_rust-deunicode+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deunicode+alloc-devel-1.6.2-1.el10_0.noarch.rpm;name=aarch64_rust-deunicode+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deunicode+alloc-devel}"
SRC_URI[aarch64_rust-deunicode+alloc-devel.sha256sum] = "5aa7acd9fd0b5fc01ca4a1f5337bc8850cc39b586af1e60aeb42efed318ef4ec"

URI_aarch64_rust-deunicode+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deunicode+default-devel-1.6.2-1.el10_0.noarch.rpm;name=aarch64_rust-deunicode+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deunicode+default-devel}"
SRC_URI[aarch64_rust-deunicode+default-devel.sha256sum] = "8cb8b0408257c5f04e13787b919abc02a3145e52139ac891479e05c24564e3be"

URI_aarch64_rust-deunicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deunicode-devel-1.6.2-1.el10_0.noarch.rpm;name=aarch64_rust-deunicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deunicode-devel}"
SRC_URI[aarch64_rust-deunicode-devel.sha256sum] = "48710c60f5387606d166e442e32aa19448a0d0b0f92533b11a54af86a83b14e5"

RDEPENDS:rust-deunicode+alloc-devel = " \
 cargo \
 rust-deunicode-devel \
 "
RDEPENDS:rust-deunicode+default-devel = " \
 cargo \
 rust-deunicode+alloc-devel \
 rust-deunicode-devel \
 "
RDEPENDS:rust-deunicode-devel = " \
 cargo \
 rust \
 "
