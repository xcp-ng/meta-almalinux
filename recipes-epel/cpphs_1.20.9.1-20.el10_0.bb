# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cpphs"
PV = "1.20.9.1"
PR = "20.el10_0"
PACKAGES = " \
 cpphs \
 ghc-cpphs \
 ghc-cpphs-devel \
 ghc-cpphs-doc \
 ghc-cpphs-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cpphs-1.20.9.1-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be67be3c052588b64232d48c98d6674742bc6c4fe3e86edea0d25658fa652f43"

URI_x86_64_v2_cpphs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cpphs-1.20.9.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cpphs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpphs}"
SRC_URI[x86_64_v2_cpphs.sha256sum] = "c7475798267441be86a30f5bc7420d9d3a92c53c66c9cbaf911cf4d1569f0de1"

URI_x86_64_v2_ghc-cpphs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cpphs-1.20.9.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cpphs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cpphs}"
SRC_URI[x86_64_v2_ghc-cpphs.sha256sum] = "eeac5983a559a545cdd5262d8d534454d19905276d596bae4ec1f35089ca34f6"

URI_x86_64_v2_ghc-cpphs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cpphs-devel-1.20.9.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cpphs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cpphs-devel}"
SRC_URI[x86_64_v2_ghc-cpphs-devel.sha256sum] = "8c128735314dcad157108958fd1ba3363cc9bb77e192982e280249968cb3f064"

URI_x86_64_v2_ghc-cpphs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cpphs-doc-1.20.9.1-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-cpphs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cpphs-doc}"
SRC_URI[x86_64_v2_ghc-cpphs-doc.sha256sum] = "bde4b9a0d46d788569ab0b13b5d22be1ccbd1e44778d0b833591f8d34199bb04"

URI_x86_64_v2_ghc-cpphs-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cpphs-prof-1.20.9.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cpphs-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cpphs-prof}"
SRC_URI[x86_64_v2_ghc-cpphs-prof.sha256sum] = "e729215e7ed56f0ce3fd74b723dc429e2ca48bb8208111a54d5c009e332ad0dc"

URI_aarch64_cpphs = "${EPEL_MIRROR}/aarch64/Packages/c/cpphs-1.20.9.1-20.el10_0.aarch64.rpm;name=aarch64_cpphs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpphs}"
SRC_URI[aarch64_cpphs.sha256sum] = "02d260274a0cf5f05984868f77ca01a8bdde3067df2055ae42f4972c730317a0"

URI_aarch64_ghc-cpphs = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cpphs-1.20.9.1-20.el10_0.aarch64.rpm;name=aarch64_ghc-cpphs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cpphs}"
SRC_URI[aarch64_ghc-cpphs.sha256sum] = "3cd6d94d09c8e7028a88dc00311f230a52765bafcfe1bdb152c6b81b82ceb916"

URI_aarch64_ghc-cpphs-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cpphs-devel-1.20.9.1-20.el10_0.aarch64.rpm;name=aarch64_ghc-cpphs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cpphs-devel}"
SRC_URI[aarch64_ghc-cpphs-devel.sha256sum] = "35a8eb5409c9a0275039afb56947dfd4408839818a9656dca47c920bf20092f7"

URI_aarch64_ghc-cpphs-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cpphs-doc-1.20.9.1-20.el10_0.noarch.rpm;name=aarch64_ghc-cpphs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cpphs-doc}"
SRC_URI[aarch64_ghc-cpphs-doc.sha256sum] = "79fdde3fcce93c7460904e937a1f2842fea3c8cd59efe3d37fa07249a2ac008a"

URI_aarch64_ghc-cpphs-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cpphs-prof-1.20.9.1-20.el10_0.aarch64.rpm;name=aarch64_ghc-cpphs-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cpphs-prof}"
SRC_URI[aarch64_ghc-cpphs-prof.sha256sum] = "42ce2d88ef2ff4009697fd96099eba1bd40e0929c3dd28310eb6ac7298deaf91"

RDEPENDS:cpphs = " \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc-cpphs = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-polyparse \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-cpphs-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-cpphs \
 ghc-directory-devel \
 ghc-polyparse-devel \
 ghc-time-devel \
 "
RDEPENDS:ghc-cpphs-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cpphs-prof = " \
 ghc-base-prof \
 ghc-cpphs-devel \
 ghc-directory-prof \
 ghc-polyparse-prof \
 ghc-time-prof \
 "
