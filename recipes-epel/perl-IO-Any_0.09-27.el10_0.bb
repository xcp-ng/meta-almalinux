# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Any"
PV = "0.09"
PR = "27.el10_0"
PACKAGES = " \
 perl-IO-Any \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IO-Any-0.09-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e354e391c3ada966269482a70fa311cf25642417d84d9f2c473663bcba52da01"

URI_x86_64_v2_perl-IO-Any = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IO-Any-0.09-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IO-Any;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Any}"
SRC_URI[x86_64_v2_perl-IO-Any.sha256sum] = "3b1d41174a44d5f8f8fc43049cc0ce1f34052af0bc409f6574b9b6b7e051c233"

URI_aarch64_perl-IO-Any = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IO-Any-0.09-27.el10_0.noarch.rpm;name=aarch64_perl-IO-Any;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Any}"
SRC_URI[aarch64_perl-IO-Any.sha256sum] = "c56a82e57cd255d0ab2e34ddbd083a53ddb66771e3e858e4e8ccebca174592d8"

RDEPENDS:perl-IO-Any = " \
 perl-Carp \
 perl-Fcntl \
 perl-IO \
 perl-IO-String \
 perl-IO-stringy \
 perl-List-MoreUtils \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-libs \
 "
