# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-rust-orchard"
PV = "0.13.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-rust-orchard+default-devel \
 rust-tree-sitter-rust-orchard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-rust-orchard-0.13.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c45c8406af4ccad0d5f83cc56844a3dd92a383f14a698d50ef7cfeb50df26ff"

URI_x86_64_v2_rust-tree-sitter-rust-orchard+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-rust-orchard+default-devel-0.13.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-rust-orchard+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-rust-orchard+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-rust-orchard+default-devel.sha256sum] = "f578a1d24a207653136ca5003eb76f5f04dad9ea6597a79bd887b0e10bce2b93"

URI_x86_64_v2_rust-tree-sitter-rust-orchard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-rust-orchard-devel-0.13.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-rust-orchard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-rust-orchard-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-rust-orchard-devel.sha256sum] = "b43318a765dd2cd2df864f486a3b5be2cd4269ab9324655b48d3c9f7e2172b1f"

URI_aarch64_rust-tree-sitter-rust-orchard+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-rust-orchard+default-devel-0.13.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-rust-orchard+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-rust-orchard+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-rust-orchard+default-devel.sha256sum] = "89cda20940de5925b0be986ef2c840e0a940d774283d403ee0f740686ee2fdc6"

URI_aarch64_rust-tree-sitter-rust-orchard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-rust-orchard-devel-0.13.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-rust-orchard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-rust-orchard-devel}"
SRC_URI[aarch64_rust-tree-sitter-rust-orchard-devel.sha256sum] = "ea798668a54273660ad7423ba2f7133df0aefe5d61a692c973e9ec35f643f7ca"

RDEPENDS:rust-tree-sitter-rust-orchard+default-devel = " \
 cargo \
 rust-tree-sitter-rust-orchard-devel \
 "
RDEPENDS:rust-tree-sitter-rust-orchard-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
