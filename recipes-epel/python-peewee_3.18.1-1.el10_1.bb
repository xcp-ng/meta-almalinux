# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-peewee"
PV = "3.18.1"
PR = "1.el10_1"
PACKAGES = " \
 python-peewee-docs \
 python3-peewee \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-peewee-3.18.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3400d6dd8ec8cbeee15edc81f645d637ef4f2921dc61e71e94a7c44f3314da5b"

URI_x86_64_v2_python-peewee-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-peewee-docs-3.18.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python-peewee-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-peewee-docs}"
SRC_URI[x86_64_v2_python-peewee-docs.sha256sum] = "8069baea275e97e9f0a2f4fe5f44b63f7c01a28afc0a946f6c978a821d420159"

URI_x86_64_v2_python3-peewee = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-peewee-3.18.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-peewee;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-peewee}"
SRC_URI[x86_64_v2_python3-peewee.sha256sum] = "afbe57111ba2f19ed4adfb204e6ea27894f2448de50504fbad28b33e5ff14657"

URI_aarch64_python-peewee-docs = "${EPEL_MIRROR}/aarch64/Packages/p/python-peewee-docs-3.18.1-1.el10_1.aarch64.rpm;name=aarch64_python-peewee-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-peewee-docs}"
SRC_URI[aarch64_python-peewee-docs.sha256sum] = "e8a67472d87fd93c8b8e7e46a194af969b98f8afefda8ce5418caea79d28d0f7"

URI_aarch64_python3-peewee = "${EPEL_MIRROR}/aarch64/Packages/p/python3-peewee-3.18.1-1.el10_1.aarch64.rpm;name=aarch64_python3-peewee;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-peewee}"
SRC_URI[aarch64_python3-peewee.sha256sum] = "9d1cca6b1795f96b551ac37373c54dc7c9b35bb0bb39541b3f24b8612a7b0d7c"

RDEPENDS:python-peewee-docs = " \
 "
RDEPENDS:python3-peewee = " \
 glibc \
 python3 \
 sqlite-libs \
 "
