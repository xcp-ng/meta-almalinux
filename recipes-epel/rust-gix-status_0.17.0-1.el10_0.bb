# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-status"
PV = "0.17.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-status+default-devel \
 rust-gix-status+document-features-devel \
 rust-gix-status+worktree-rewrites-devel \
 rust-gix-status-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-status-0.17.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f74e51226de02e18327900089581fdbfa86b9522ff0adb3c51478ac7603b2532"

URI_x86_64_v2_rust-gix-status+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+default-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+default-devel}"
SRC_URI[x86_64_v2_rust-gix-status+default-devel.sha256sum] = "8e9d7c76c83ff932320c7336a05d08e37c54e38d56405cd32435b64fe8415af5"

URI_x86_64_v2_rust-gix-status+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+document-features-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-status+document-features-devel.sha256sum] = "a6211450aeaa3fe07b194428bef26353d7275588187dd35ca6a36fcc59772ab9"

URI_x86_64_v2_rust-gix-status+worktree-rewrites-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+worktree-rewrites-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+worktree-rewrites-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+worktree-rewrites-devel}"
SRC_URI[x86_64_v2_rust-gix-status+worktree-rewrites-devel.sha256sum] = "fa8eaf84ea645e708797782cf4eec498fd1ab7c76a1b45a1e5cddd78c9962b4c"

URI_x86_64_v2_rust-gix-status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status-devel}"
SRC_URI[x86_64_v2_rust-gix-status-devel.sha256sum] = "25ed6163de033debef551c88a0f36b0120e982565cf1393d0afa5bab5e09c0fb"

URI_aarch64_rust-gix-status+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+default-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-status+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+default-devel}"
SRC_URI[aarch64_rust-gix-status+default-devel.sha256sum] = "be05f438aa774f1bf28ec24818c47d58e143ecbd754a87f0b269d4c9418ad260"

URI_aarch64_rust-gix-status+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+document-features-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-status+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+document-features-devel}"
SRC_URI[aarch64_rust-gix-status+document-features-devel.sha256sum] = "c151655380162bc255ed8bcfd311e9e9f7b30b06304252af11241ce1b7cc4516"

URI_aarch64_rust-gix-status+worktree-rewrites-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+worktree-rewrites-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-status+worktree-rewrites-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+worktree-rewrites-devel}"
SRC_URI[aarch64_rust-gix-status+worktree-rewrites-devel.sha256sum] = "ceeebcd037c5bda2b68a35b9333d61f07378c62c20a9157b71aab8be20ac5c6a"

URI_aarch64_rust-gix-status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status-devel}"
SRC_URI[aarch64_rust-gix-status-devel.sha256sum] = "50c516c5dcc0277ba2b6b0f0cb6db5cbb46d93b0d7fc80371c1dc2feb2158a6e"

RDEPENDS:rust-gix-status+default-devel = " \
 cargo \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status+worktree-rewrites-devel = " \
 cargo \
 rust-gix-diff+blob-devel \
 rust-gix-diff-devel \
 rust-gix-dir+default-devel \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-filetime+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-thiserror+default-devel \
 "
