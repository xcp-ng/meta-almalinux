# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php"
PV = "8.3.33"
PR = "1.el10_2"
PACKAGES = " \
 php \
 php-bcmath \
 php-cli \
 php-common \
 php-dba \
 php-dbg \
 php-devel \
 php-embedded \
 php-enchant \
 php-ffi \
 php-fpm \
 php-gd \
 php-gmp \
 php-intl \
 php-ldap \
 php-mbstring \
 php-mysqlnd \
 php-odbc \
 php-opcache \
 php-pdo \
 php-pgsql \
 php-process \
 php-snmp \
 php-soap \
 php-xml \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/php-8.3.33-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "969a9b0da7bf84b509347a11e21cbc8dc0c20a36ad38236b5150e5204e174aed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php;unpack=0"
SRC_URI[x86_64_v2_php.sha256sum] = "4e4929816fe1f40ba24bfc4604044d8314e77179866536bc0f7cbff3a148148f"
RPROVIDES:php:append:x86_64_v2 = " virtual/php"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-bcmath-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-bcmath;unpack=0"
SRC_URI[x86_64_v2_php-bcmath.sha256sum] = "1a108fe794d1e9347e9c5ad925745e708d92475245a993eb0a846b85e0acd111"
RPROVIDES:php-bcmath:append:x86_64_v2 = " virtual/php-bcmath"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-cli-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-cli;unpack=0"
SRC_URI[x86_64_v2_php-cli.sha256sum] = "0e4747d7cf661738af4d86f645e126ff481f9c00f0e5c4f6c87a763b818c9089"
RPROVIDES:php-cli:append:x86_64_v2 = " virtual//usr/bin/php virtual/php-cli virtual/php-pcntl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-common-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-common;unpack=0"
SRC_URI[x86_64_v2_php-common.sha256sum] = "844edf952528c3b81c6e4f058e9605246dfb8d267da9180b53b7ba679edf157e"
RPROVIDES:php-common:append:x86_64_v2 = " virtual/php-bz2 virtual/php-ctype virtual/php-curl virtual/php-date virtual/php-exif virtual/php-fileinfo virtual/php-filter virtual/php-ftp virtual/php-gettext virtual/php-hash virtual/php-iconv virtual/php-iconv_x86-64_ virtual/php-json virtual/php-json_x86-64_ virtual/php-libxml virtual/php-mhash virtual/php-openssl virtual/php-pcre virtual/php-phar virtual/php-reflection virtual/php-session virtual/php-sockets virtual/php-sockets_x86-64_ virtual/php-spl virtual/php-spl_x86-64_ virtual/php-tokenizer virtual/php-tokenizer_x86-64_ virtual/php-zlib virtual/php_language__ge_5.3.0 virtual/php_language__ge_5.3.1 virtual/php_language__ge_5.3.3 virtual/php_language__ge_7.1 virtual/php_language__ge_7.2 virtual/php_language__ge_7.2.5 virtual/php_language__ge_7.3 virtual/php_language__ge_7.4 virtual/php_language__ge_8.1 virtual/php_language__gt_5.3 virtual/php_language__gt_5.4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-dba-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-dba;unpack=0"
SRC_URI[x86_64_v2_php-dba.sha256sum] = "096fbe6ef5c68e7234db923d181a5207990da1bc6db371081f1089c5f08b4188"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-dbg-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-dbg;unpack=0"
SRC_URI[x86_64_v2_php-dbg.sha256sum] = "87185cd5abbae83564808a945c58d9af6867f199c9d32a43954391d308df188e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-devel-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-devel;unpack=0"
SRC_URI[x86_64_v2_php-devel.sha256sum] = "0eaad2e848c9c2468252ffe330a0d49414d0a305bc9310fed98b86de22e05c30"
RPROVIDES:php-devel:append:x86_64_v2 = " virtual/php-devel_x86-64_ virtual/php-devel_x86-64__ge_5.3.0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-embedded-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-embedded;unpack=0"
SRC_URI[x86_64_v2_php-embedded.sha256sum] = "0f6db89328ee33d44258cebcc815e7b094703fc3fdea25a7935f92c9998bce2d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-enchant-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-enchant;unpack=0"
SRC_URI[x86_64_v2_php-enchant.sha256sum] = "2bc9aebf64fbb63ce625afa845b3c007ce92a91c673d19e0559aa11cff9bd133"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-ffi-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-ffi;unpack=0"
SRC_URI[x86_64_v2_php-ffi.sha256sum] = "d4e4de4e8d326c9389a0599131b4f17cb797d60dd6b8993bfe39f745fc48c97a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-fpm-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-fpm;unpack=0"
SRC_URI[x86_64_v2_php-fpm.sha256sum] = "f044c3b9b86b8d80d38c5208c6e27dfbd162cb111b51916a3be1dd7ae907354b"
RPROVIDES:php-fpm:append:x86_64_v2 = " virtual/php-fpm virtual/php-fpm_ge_8.0 virtual/php_httpd_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-gd-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-gd;unpack=0"
SRC_URI[x86_64_v2_php-gd.sha256sum] = "d1f1a4af4f966fcf6f8531e552619c5953bdfde1b42b3ff6e3cdbdbff186131b"
RPROVIDES:php-gd:append:x86_64_v2 = " virtual/php-gd virtual/php-gd_x86-64_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-gmp-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-gmp;unpack=0"
SRC_URI[x86_64_v2_php-gmp.sha256sum] = "5e57148d07aca22fff2cd3d35b49903835795f05e578de052608f81b5432636c"
RPROVIDES:php-gmp:append:x86_64_v2 = " virtual/php-gmp"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-intl-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-intl;unpack=0"
SRC_URI[x86_64_v2_php-intl.sha256sum] = "53f7434adacc136f21f64a9956da34bb1f9b1f6ed30aa103724897079669d763"
RPROVIDES:php-intl:append:x86_64_v2 = " virtual/php-intl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-ldap-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-ldap;unpack=0"
SRC_URI[x86_64_v2_php-ldap.sha256sum] = "9a7d90eafe411883070838be066e576ca9fa7910ebdd76616f37058c5b1723f7"
RPROVIDES:php-ldap:append:x86_64_v2 = " virtual/php-ldap"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-mbstring-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-mbstring;unpack=0"
SRC_URI[x86_64_v2_php-mbstring.sha256sum] = "54df09ac640da5bb0c80e41d0f360a3c4e8666e12760e0fa7709326fefd869e0"
RPROVIDES:php-mbstring:append:x86_64_v2 = " virtual/php-mbstring"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-mysqlnd-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-mysqlnd;unpack=0"
SRC_URI[x86_64_v2_php-mysqlnd.sha256sum] = "9be1f00306fa8e0cee21f4ad702e02ad796cd0e536fb7ac46853a6bd8ac88029"
RPROVIDES:php-mysqlnd:append:x86_64_v2 = " virtual/php-mysqli virtual/php-mysqlnd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-odbc-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-odbc;unpack=0"
SRC_URI[x86_64_v2_php-odbc.sha256sum] = "3b8358b1f541507bedeea50ec21502a9878574dc3b69f792196a87ec994dc606"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-opcache-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-opcache;unpack=0"
SRC_URI[x86_64_v2_php-opcache.sha256sum] = "c07e904ede2b47f26e6d88d79b9b62df7f7a4505cc0c1a35a94896d1d6996717"
RPROVIDES:php-opcache:append:x86_64_v2 = " virtual/php-opcache"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pdo-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-pdo;unpack=0"
SRC_URI[x86_64_v2_php-pdo.sha256sum] = "d0395845940963d68eb2cb17924e347fa8ab3fe66e73469979829601173ee261"
RPROVIDES:php-pdo:append:x86_64_v2 = " virtual/php-pdo virtual/php-sqlite3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pgsql-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-pgsql;unpack=0"
SRC_URI[x86_64_v2_php-pgsql.sha256sum] = "534f9fec7dee1ab76f3ec2646a37199cfc335bacda4f7b7d84626003880de02a"
RPROVIDES:php-pgsql:append:x86_64_v2 = " virtual/php-pgsql"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-process-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-process;unpack=0"
SRC_URI[x86_64_v2_php-process.sha256sum] = "db2b651685d9be0f2ac92024137fdaa16d63e2d9d9e7d13f4b64b497897daff1"
RPROVIDES:php-process:append:x86_64_v2 = " virtual/php-posix virtual/php-process"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-snmp-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-snmp;unpack=0"
SRC_URI[x86_64_v2_php-snmp.sha256sum] = "147a6dd4a86bcc7e0d4fa283c1ae9e08eda4d5518ece18bac4214ded0b99449d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-soap-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-soap;unpack=0"
SRC_URI[x86_64_v2_php-soap.sha256sum] = "219292020d4e07a33bd3ae9950fa337c9d60707845c34f2ca70e4f35dc000081"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-xml-8.3.33-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-xml;unpack=0"
SRC_URI[x86_64_v2_php-xml.sha256sum] = "8a7a27b51c4022e032d43ae91979660972fce6090b624f341d5125f312e37286"
RPROVIDES:php-xml:append:x86_64_v2 = " virtual/php-dom virtual/php-simplexml virtual/php-xml virtual/php-xmlreader virtual/php-xmlwriter virtual/php-xsl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php;unpack=0"
SRC_URI[aarch64_php.sha256sum] = "d0e83510699cd91bfeeb73c3eada5ff13ef8f2237b5cbc375ea4f83b5b7b34fc"
RPROVIDES:php:append:aarch64 = " virtual/php"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-bcmath-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-bcmath;unpack=0"
SRC_URI[aarch64_php-bcmath.sha256sum] = "ea5733ab38f974b6ea2554f2fdeb50938692354d0e28ed46850f679ccca46b18"
RPROVIDES:php-bcmath:append:aarch64 = " virtual/php-bcmath"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-cli-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-cli;unpack=0"
SRC_URI[aarch64_php-cli.sha256sum] = "c7fd45b1f6186edcf712b0f8144a1fd0323f7bb7de9607c8020d214da71ad83f"
RPROVIDES:php-cli:append:aarch64 = " virtual//usr/bin/php virtual/php-cli virtual/php-pcntl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-common-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-common;unpack=0"
SRC_URI[aarch64_php-common.sha256sum] = "0d3e124a17a26e01c28ec181e6ef3df0fd80fbf8ade68a1c93a68421a5cc2fd1"
RPROVIDES:php-common:append:aarch64 = " virtual/php-bz2 virtual/php-ctype virtual/php-curl virtual/php-date virtual/php-exif virtual/php-fileinfo virtual/php-filter virtual/php-ftp virtual/php-gettext virtual/php-hash virtual/php-iconv virtual/php-iconv_aarch-64_ virtual/php-json virtual/php-json_aarch-64_ virtual/php-libxml virtual/php-mhash virtual/php-openssl virtual/php-pcre virtual/php-phar virtual/php-reflection virtual/php-session virtual/php-sockets virtual/php-sockets_aarch-64_ virtual/php-spl virtual/php-spl_aarch-64_ virtual/php-tokenizer virtual/php-tokenizer_aarch-64_ virtual/php-zlib virtual/php_language__ge_5.3.0 virtual/php_language__ge_5.3.1 virtual/php_language__ge_5.3.3 virtual/php_language__ge_7.1 virtual/php_language__ge_7.2 virtual/php_language__ge_7.2.5 virtual/php_language__ge_7.3 virtual/php_language__ge_7.4 virtual/php_language__ge_8.1 virtual/php_language__gt_5.3 virtual/php_language__gt_5.4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-dba-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-dba;unpack=0"
SRC_URI[aarch64_php-dba.sha256sum] = "bc0225ebe5b2691a399a69e316f70216c6edc02bdbf818d0652b316c001ae233"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-dbg-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-dbg;unpack=0"
SRC_URI[aarch64_php-dbg.sha256sum] = "34f76c0e2b8ede41785bec62de0e1d5b39415c37e9f855ed7e7f4729294920a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-devel-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-devel;unpack=0"
SRC_URI[aarch64_php-devel.sha256sum] = "ce3cdfe1b9c807ef98514a9e90585559d2936958188a8cbc7fafc891e5844877"
RPROVIDES:php-devel:append:aarch64 = " virtual/php-devel_aarch-64_ virtual/php-devel_aarch-64__ge_5.3.0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-embedded-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-embedded;unpack=0"
SRC_URI[aarch64_php-embedded.sha256sum] = "22e3f9d82abcef43bd561624900de5c5f527473e44e9e579192adc8bcb60bf6e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-enchant-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-enchant;unpack=0"
SRC_URI[aarch64_php-enchant.sha256sum] = "d574156b406886fd938b0bdd060334ea3aa735c92498fe4e3d7a05fa3c2a7991"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-ffi-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-ffi;unpack=0"
SRC_URI[aarch64_php-ffi.sha256sum] = "fd110eeac16f3177fac75b7f727a23c6fdc3c69e16b9d871f7b3fe46b7443a3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-fpm-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-fpm;unpack=0"
SRC_URI[aarch64_php-fpm.sha256sum] = "2d532d1704ef708d0eb5fa7fc5f76fcb6abd659e47db1d7c490da40e3731e439"
RPROVIDES:php-fpm:append:aarch64 = " virtual/php-fpm virtual/php-fpm_ge_8.0 virtual/php_httpd_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-gd-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-gd;unpack=0"
SRC_URI[aarch64_php-gd.sha256sum] = "da5de42798b63448002209a3993b75c4a3db6ba788b29544507d54b00090593e"
RPROVIDES:php-gd:append:aarch64 = " virtual/php-gd virtual/php-gd_aarch-64_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-gmp-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-gmp;unpack=0"
SRC_URI[aarch64_php-gmp.sha256sum] = "d3235249cea98479d1795b6a2b63f729094471ae582e7adf1fd93e6f324781de"
RPROVIDES:php-gmp:append:aarch64 = " virtual/php-gmp"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-intl-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-intl;unpack=0"
SRC_URI[aarch64_php-intl.sha256sum] = "b0d3e40328fc35e027468bf325fec24d835d373808585f2e736cafa4b933bf67"
RPROVIDES:php-intl:append:aarch64 = " virtual/php-intl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-ldap-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-ldap;unpack=0"
SRC_URI[aarch64_php-ldap.sha256sum] = "7c46704638ad479673baceb69a41b2e475605cfa1e8da92e4582de2b58c8dd92"
RPROVIDES:php-ldap:append:aarch64 = " virtual/php-ldap"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-mbstring-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-mbstring;unpack=0"
SRC_URI[aarch64_php-mbstring.sha256sum] = "f5ddae806e5d1ae1cfaaef1933d16e967c35ae9a8f67badac363d33e722ea553"
RPROVIDES:php-mbstring:append:aarch64 = " virtual/php-mbstring"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-mysqlnd-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-mysqlnd;unpack=0"
SRC_URI[aarch64_php-mysqlnd.sha256sum] = "d644652849c0b30185aaaa972106451d8781fae8679b99e411aa33d535c9e3b6"
RPROVIDES:php-mysqlnd:append:aarch64 = " virtual/php-mysqli virtual/php-mysqlnd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-odbc-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-odbc;unpack=0"
SRC_URI[aarch64_php-odbc.sha256sum] = "4196b735f5bfdcb7060cf2c79b5ff9704b8360109779adcc52f2a464e53c6956"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-opcache-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-opcache;unpack=0"
SRC_URI[aarch64_php-opcache.sha256sum] = "df87233b486d3e3e440acead63c86ce6c4a1eb05c8279dc0a76d2140338b7a0f"
RPROVIDES:php-opcache:append:aarch64 = " virtual/php-opcache"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pdo-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-pdo;unpack=0"
SRC_URI[aarch64_php-pdo.sha256sum] = "4a36e260aebc62cde6bdd4b713e1017c99bbb85227bbeb4ce2d28e374de2d0f9"
RPROVIDES:php-pdo:append:aarch64 = " virtual/php-pdo virtual/php-sqlite3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pgsql-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-pgsql;unpack=0"
SRC_URI[aarch64_php-pgsql.sha256sum] = "4d3cbe7d79003e13db4a83b6099e0b0e9ef7a62d074e2d8b6a11b7ed452feacf"
RPROVIDES:php-pgsql:append:aarch64 = " virtual/php-pgsql"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-process-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-process;unpack=0"
SRC_URI[aarch64_php-process.sha256sum] = "2277ab0b550821ea7031e0c87ce41f18c22e5ce059438ef64051694fe374d5aa"
RPROVIDES:php-process:append:aarch64 = " virtual/php-posix virtual/php-process"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-snmp-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-snmp;unpack=0"
SRC_URI[aarch64_php-snmp.sha256sum] = "0aed38e26b4e053f9548fe8d96a0de3d0d98fa0dd75ff53413ef4762915980c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-soap-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-soap;unpack=0"
SRC_URI[aarch64_php-soap.sha256sum] = "9fa66a8b35b00105337d00640621bad72b0d37e7019385088a27917e0eddb6e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-xml-8.3.33-1.el10_2.aarch64.rpm;name=aarch64_php-xml;unpack=0"
SRC_URI[aarch64_php-xml.sha256sum] = "104ce5e943e7791c6ad11c5262733e2e239b455c4e454bf217c91b8932f70429"
RPROVIDES:php-xml:append:aarch64 = " virtual/php-dom virtual/php-simplexml virtual/php-xml virtual/php-xmlreader virtual/php-xmlwriter virtual/php-xsl"

RDEPENDS:php = " \
 php-common \
 "
RDEPENDS:php-bcmath = " \
 glibc \
 php-common \
 "
RDEPENDS:php-cli = " \
 bash \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-common = " \
 bzip2-libs \
 glibc \
 openssl-libs \
 tzdata \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:php-dba = " \
 glibc \
 lmdb-libs \
 php-common \
 tokyocabinet \
 "
RDEPENDS:php-dbg = " \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-devel = " \
 autoconf \
 automake \
 bash \
 gcc \
 gcc-c++ \
 krb5-devel \
 libtool \
 libxml2-devel \
 make \
 openssl-devel \
 pcre2-devel \
 php-cli \
 zlib-ng-compat-devel \
 "
RDEPENDS:php-embedded = " \
 glibc \
 krb5-libs \
 libcom_err \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-enchant = " \
 enchant2 \
 glibc \
 php-common \
 "
RDEPENDS:php-ffi = " \
 glibc \
 libffi \
 php-common \
 "
RDEPENDS:php-fpm = " \
 bash \
 glibc \
 httpd-filesystem \
 libacl \
 libselinux \
 libxcrypt \
 libxml2 \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 php-common \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:php-gd = " \
 gd \
 glibc \
 php-common \
 "
RDEPENDS:php-gmp = " \
 glibc \
 gmp \
 php-common \
 "
RDEPENDS:php-intl = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 php-common \
 "
RDEPENDS:php-ldap = " \
 cyrus-sasl-lib \
 glibc \
 openldap \
 php-common \
 "
RDEPENDS:php-mbstring = " \
 glibc \
 oniguruma \
 php-common \
 "
RDEPENDS:php-mysqlnd = " \
 glibc \
 php-pdo \
 "
RDEPENDS:php-odbc = " \
 glibc \
 php-pdo \
 unixODBC \
 "
RDEPENDS:php-opcache:x86_64_v2 = " \
 capstone \
 glibc \
 libgcc \
 php-common \
"
RDEPENDS:php-opcache:aarch64 = " \
 capstone \
 glibc \
 php-common \
"
RDEPENDS:php-pdo = " \
 glibc \
 php-common \
 sqlite-libs \
 "
RDEPENDS:php-pgsql = " \
 glibc \
 libpq \
 php-pdo \
 "
RDEPENDS:php-process = " \
 glibc \
 php-common \
 "
RDEPENDS:php-snmp = " \
 glibc \
 net-snmp \
 net-snmp-libs \
 openssl-libs \
 php-common \
 "
RDEPENDS:php-soap = " \
 glibc \
 libxml2 \
 php-common \
 "
RDEPENDS:php-xml = " \
 glibc \
 libxml2 \
 libxslt \
 php-common \
 "
