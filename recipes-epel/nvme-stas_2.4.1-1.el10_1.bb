# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nvme-stas"
PV = "2.4.1"
PR = "1.el10_1"
PACKAGES = " \
 nvme-stas \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nvme-stas-2.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6420db4083de8aecc03b11b39b2efde8640e5371b83357d7043812df0dc66cef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nvme-stas-2.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nvme-stas;unpack=0"
SRC_URI[x86_64_v2_nvme-stas.sha256sum] = "2191b8748c414f41bbf5f1745297e68cef24f8415c583c061b546709e5849be2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nvme-stas-2.4.1-1.el10_1.noarch.rpm;name=aarch64_nvme-stas;unpack=0"
SRC_URI[aarch64_nvme-stas.sha256sum] = "0e13f2a10a1ff8f986fb092e0c212cb54b108f95040fc46217df9cd1b3a20876"

RDEPENDS:nvme-stas = " \
 avahi \
 bash \
 python3 \
 python3-dasbus \
 python3-gobject \
 python3-libnvme \
 python3-lxml \
 python3-pyudev \
 python3-systemd \
 "
