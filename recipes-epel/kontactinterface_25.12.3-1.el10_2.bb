# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kontactinterface"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kontactinterface \
 kontactinterface-devel \
 kontactinterface-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kontactinterface-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e83afae8d2185534ca05910fb29da0e75724dd8a2d0e32876dc7ec6d7742aaf0"

URI_x86_64_v2_kontactinterface = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontactinterface;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontactinterface}"
SRC_URI[x86_64_v2_kontactinterface.sha256sum] = "69577b75f090fbfdb77d14468a22529be88f83d31f2cabf6f8e5af0949e89b56"

URI_x86_64_v2_kontactinterface-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontactinterface-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontactinterface-devel}"
SRC_URI[x86_64_v2_kontactinterface-devel.sha256sum] = "88be8806bd4b939790db01e8f12db2b0616d0e58ac6c1a9e900ae059bb5d13bc"

URI_x86_64_v2_kontactinterface-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kontactinterface-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontactinterface-doc}"
SRC_URI[x86_64_v2_kontactinterface-doc.sha256sum] = "6e976aed565b28062e8e02ba269bf954da55b7dd9880f856eae18b9694d80478"

URI_aarch64_kontactinterface = "${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kontactinterface;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontactinterface}"
SRC_URI[aarch64_kontactinterface.sha256sum] = "1e1f42ee3ade61df2bb103926ef8258c470862d3ad3e314a2ad2d931d6b0dcab"

URI_aarch64_kontactinterface-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kontactinterface-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontactinterface-devel}"
SRC_URI[aarch64_kontactinterface-devel.sha256sum] = "2c87f8f2239bff2b6e102e9ad13c01b3f6166ec3f7ef4efaa6cc290dca9f7f66"

URI_aarch64_kontactinterface-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kontactinterface-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontactinterface-doc}"
SRC_URI[aarch64_kontactinterface-doc.sha256sum] = "88bb8295a8ceefe2851a1e421de660cb46d78efda2a25416f7ce2c14990d0e49"

RDEPENDS:kontactinterface = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kontactinterface-devel = " \
 cmake-filesystem \
 kf6-kparts-devel \
 kontactinterface \
 "
RDEPENDS:kontactinterface-doc = " \
 "
