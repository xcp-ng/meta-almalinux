# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-lt"
PV = "0.20100531"
PR = "29.el10"
PACKAGES = " \
 hyphen-lt \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-lt-0.20100531-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3dc46ee6f14dca0c08cdb2aa50e2d11b888b91069bc584729463ffcb58546d09"

URI_x86_64_v2_hyphen-lt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-lt-0.20100531-29.el10.noarch.rpm;name=x86_64_v2_hyphen-lt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-lt}"
SRC_URI[x86_64_v2_hyphen-lt.sha256sum] = "80458b962f0c9a5bfcb961a205ce03c20bfb68c3d361928ae9fadbe117748f84"

URI_aarch64_hyphen-lt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-lt-0.20100531-29.el10.noarch.rpm;name=aarch64_hyphen-lt;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-lt}"
SRC_URI[aarch64_hyphen-lt.sha256sum] = "80458b962f0c9a5bfcb961a205ce03c20bfb68c3d361928ae9fadbe117748f84"

RDEPENDS:hyphen-lt = " \
 hyphen \
 "
