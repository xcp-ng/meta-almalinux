# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-community-internal_test_tools"
PV = "0.19.0"
PR = "1.el10_3"
PACKAGES = " \
 ansible-collection-community-internal_test_tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-collection-community-internal_test_tools-0.19.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "226c5992f8370fc2f97709de0e1deaec05796f929093a8e6dba6847cdd817fd2"

URI_x86_64_v2_ansible-collection-community-internal_test_tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-collection-community-internal_test_tools-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-collection-community-internal_test_tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-community-internal_test_tools}"
SRC_URI[x86_64_v2_ansible-collection-community-internal_test_tools.sha256sum] = "c6f2043c8ae09a3fbeb6cb3a0ae1b76640b022a6d8c940fc3a1b5e93b3ff3237"

URI_aarch64_ansible-collection-community-internal_test_tools = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-collection-community-internal_test_tools-0.19.0-1.el10_3.noarch.rpm;name=aarch64_ansible-collection-community-internal_test_tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-community-internal_test_tools}"
SRC_URI[aarch64_ansible-collection-community-internal_test_tools.sha256sum] = "dbf3635d0ba1b69648e9059eb68a81db7b73ef6d3ca344d04651d84baf4b7273"

RDEPENDS:ansible-collection-community-internal_test_tools = " \
 ansible-core \
 "
