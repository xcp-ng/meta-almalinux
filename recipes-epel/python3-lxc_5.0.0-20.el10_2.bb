# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3-lxc"
PV = "5.0.0"
PR = "20.el10_2"
PACKAGES = " \
 python3-lxc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python3-lxc-5.0.0-20.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aa3eac9ca5ee81f27a9cbd62af90c84fc3058948bc61332db348c74b8140e027"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lxc-5.0.0-20.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lxc;unpack=0"
SRC_URI[x86_64_v2_python3-lxc.sha256sum] = "27ab97feaff44497b4434b8be82fbd241c4656755063f7b0a1db8e78997bcf9b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-lxc-5.0.0-20.el10_2.aarch64.rpm;name=aarch64_python3-lxc;unpack=0"
SRC_URI[aarch64_python3-lxc.sha256sum] = "12f065567878b54fdfe2937e79f96be95936f4fbc79122229157402e82bbfad9"

RDEPENDS:python3-lxc = " \
 glibc \
 lxc-libs \
 python3 \
 "
