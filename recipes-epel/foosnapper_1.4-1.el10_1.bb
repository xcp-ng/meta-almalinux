# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "foosnapper"
PV = "1.4"
PR = "1.el10_1"
PACKAGES = " \
 foosnapper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/foosnapper-1.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c934703e13ad295b13f35166a3236ce32c8a4098ea1e702c3dd316567a4964cc"

URI_x86_64_v2_foosnapper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/foosnapper-1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_foosnapper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foosnapper}"
SRC_URI[x86_64_v2_foosnapper.sha256sum] = "84e5f3e6f86bb086196da0df78455fe60c55a39f05d04f0a8c2f0801d3e306a7"

URI_aarch64_foosnapper = "${EPEL_MIRROR}/aarch64/Packages/f/foosnapper-1.4-1.el10_1.noarch.rpm;name=aarch64_foosnapper;unpack=0"
SRC_URI:append = " ${URI_aarch64_foosnapper}"
SRC_URI[aarch64_foosnapper.sha256sum] = "d0a796a0a4bad045907a32e5a05654162cf8b1637664f9cc76a46b54003ae2ad"

RDEPENDS:foosnapper = " \
 bash \
 python3 \
 systemd \
 "
