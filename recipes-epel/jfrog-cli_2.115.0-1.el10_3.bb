# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jfrog-cli"
PV = "2.115.0"
PR = "1.el10_3"
PACKAGES = " \
 jfrog-cli \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/jfrog-cli-2.115.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f16ba387e13c02a0a72d5f482c2e8f243fdac311410ee367cd31c3003a24a81d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/jfrog-cli-2.115.0-1.el10_3.aarch64.rpm;name=aarch64_jfrog-cli;unpack=0"
SRC_URI[aarch64_jfrog-cli.sha256sum] = "8b137588ba5b9fa7163b38563279244908864071d9ef72edddd86b56c34b4dc1"

RDEPENDS:jfrog-cli = " \
 glibc \
 "
