# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-defmac"
PV = "0.2.1"
PR = "16.el10_3"
PACKAGES = " \
 rust-defmac+default-devel \
 rust-defmac-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-defmac-0.2.1-16.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3f70afe2f178be27d38c03a25b682d3b249c0c164d9b2ff0f66253e3677f15a"

URI_x86_64_v2_rust-defmac+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-defmac+default-devel-0.2.1-16.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-defmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-defmac+default-devel}"
SRC_URI[x86_64_v2_rust-defmac+default-devel.sha256sum] = "b8214afbf0816dcff3c7be1253f5da1f51293927456053ed1e548059731bbed2"

URI_x86_64_v2_rust-defmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-defmac-devel-0.2.1-16.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-defmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-defmac-devel}"
SRC_URI[x86_64_v2_rust-defmac-devel.sha256sum] = "fcab2e17b2bbe4af849e6897b8c3191ba4293645796de674abaf714f1ce67372"

URI_aarch64_rust-defmac+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-defmac+default-devel-0.2.1-16.el10_3.noarch.rpm;name=aarch64_rust-defmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-defmac+default-devel}"
SRC_URI[aarch64_rust-defmac+default-devel.sha256sum] = "17fced1082354c05583672725a856ecac125ed17f9d7a1cc9af18a024e479e57"

URI_aarch64_rust-defmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-defmac-devel-0.2.1-16.el10_3.noarch.rpm;name=aarch64_rust-defmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-defmac-devel}"
SRC_URI[aarch64_rust-defmac-devel.sha256sum] = "6e474c69dfaadfc56b6c9614b40b735d2a2f14b6c961a1d11c3033510f9cd649"

RDEPENDS:rust-defmac+default-devel = " \
 cargo \
 rust-defmac-devel \
 "
RDEPENDS:rust-defmac-devel = " \
 cargo \
 "
