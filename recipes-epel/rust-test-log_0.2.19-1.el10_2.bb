# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-test-log"
PV = "0.2.19"
PR = "1.el10_2"
PACKAGES = " \
 rust-test-log+color-devel \
 rust-test-log+default-devel \
 rust-test-log+log-devel \
 rust-test-log+trace-devel \
 rust-test-log+unstable-devel \
 rust-test-log-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-test-log-0.2.19-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b3523325ec6cf03774fbf3f73b7669d6433f0bc94d50b38dff2fe5d9336984d"

URI_x86_64_v2_rust-test-log+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log+color-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log+color-devel}"
SRC_URI[x86_64_v2_rust-test-log+color-devel.sha256sum] = "eac04b05447ef433e2dcdf8354085a34c3ff075ee56a7f63835ff2ee2000ed45"

URI_x86_64_v2_rust-test-log+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log+default-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log+default-devel}"
SRC_URI[x86_64_v2_rust-test-log+default-devel.sha256sum] = "31fb357076bb7de6d9002874f65f8abc6c0c7a273a8188c1da78639cf4bcdde5"

URI_x86_64_v2_rust-test-log+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log+log-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log+log-devel}"
SRC_URI[x86_64_v2_rust-test-log+log-devel.sha256sum] = "92ca6f3400d08cd3091ffe64477ddaf5db024864c17c0bf8bf4af94f354f74be"

URI_x86_64_v2_rust-test-log+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log+trace-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log+trace-devel}"
SRC_URI[x86_64_v2_rust-test-log+trace-devel.sha256sum] = "5228e4d21a701461eb916a73c40ec1d26399ec0f5cec58cb2cfad7613a7c04ff"

URI_x86_64_v2_rust-test-log+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log+unstable-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log+unstable-devel}"
SRC_URI[x86_64_v2_rust-test-log+unstable-devel.sha256sum] = "6c3141e7100eea99407d73ae03c63ab8466197f5209580fb42022acf0f88db6c"

URI_x86_64_v2_rust-test-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-devel}"
SRC_URI[x86_64_v2_rust-test-log-devel.sha256sum] = "c5f70b6259c2e2aed76b78f6bacd90e624aa2cfe2788026aea4802a1b3b412b3"

URI_aarch64_rust-test-log+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+color-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-test-log+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+color-devel}"
SRC_URI[aarch64_rust-test-log+color-devel.sha256sum] = "9a7093121401fc6b98a986940e27df7ed81748d31664f9dab41559870367697b"

URI_aarch64_rust-test-log+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+default-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-test-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+default-devel}"
SRC_URI[aarch64_rust-test-log+default-devel.sha256sum] = "73dbe3e07f53afe8a92049f0d3ca51f3658dbe3202776391d8c28484ad7b8de9"

URI_aarch64_rust-test-log+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+log-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-test-log+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+log-devel}"
SRC_URI[aarch64_rust-test-log+log-devel.sha256sum] = "301a3a00530f32cb03a0b865c1f0820c739562ae2dc2d7fb550c60572e5a8f1b"

URI_aarch64_rust-test-log+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+trace-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-test-log+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+trace-devel}"
SRC_URI[aarch64_rust-test-log+trace-devel.sha256sum] = "35f12e51c9c04f2be49391243532eaa48a4b3f859c1b2dd5fc6b20a111148ca9"

URI_aarch64_rust-test-log+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+unstable-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-test-log+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+unstable-devel}"
SRC_URI[aarch64_rust-test-log+unstable-devel.sha256sum] = "bbb5890cd798930206b85cdb0c64e5b0f954cdf13bd662ef18559e607411c41c"

URI_aarch64_rust-test-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-test-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-devel}"
SRC_URI[aarch64_rust-test-log-devel.sha256sum] = "b1be6f9dd5bf06ee52e288f5bafcf27a94aed2fddd4c59e392832179a3161c17"

RDEPENDS:rust-test-log+color-devel = " \
 cargo \
 rust-env_logger+auto-color-devel \
 rust-env_logger-devel \
 rust-test-log-devel \
 rust-tracing-subscriber+ansi-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-test-log+default-devel = " \
 cargo \
 rust-test-log+color-devel \
 rust-test-log+log-devel \
 rust-test-log-devel \
 "
RDEPENDS:rust-test-log+log-devel = " \
 cargo \
 rust-env_logger-devel \
 rust-test-log-devel \
 rust-test-log-macros+log-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+tracing-log-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-test-log+trace-devel = " \
 cargo \
 rust-test-log-devel \
 rust-test-log-macros+trace-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-test-log+unstable-devel = " \
 cargo \
 rust-test-log-devel \
 rust-test-log-macros+unstable-devel \
 "
RDEPENDS:rust-test-log-devel = " \
 cargo \
 rust \
 rust-test-log-macros+default-devel \
 "
