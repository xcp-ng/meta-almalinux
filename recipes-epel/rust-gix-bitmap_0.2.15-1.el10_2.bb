# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-bitmap"
PV = "0.2.15"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-bitmap+default-devel \
 rust-gix-bitmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-bitmap-0.2.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0010d0cf94bfe2cfdc565005c6548d8a012d7b9a01346282c81f13d08ad1fd2"

URI_x86_64_v2_rust-gix-bitmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-bitmap+default-devel-0.2.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-bitmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-bitmap+default-devel}"
SRC_URI[x86_64_v2_rust-gix-bitmap+default-devel.sha256sum] = "c05c074c80f60bfa4aab96cffd09b97d1f5907d2a094736e61f925cde9e61819"

URI_x86_64_v2_rust-gix-bitmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-bitmap-devel-0.2.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-bitmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-bitmap-devel}"
SRC_URI[x86_64_v2_rust-gix-bitmap-devel.sha256sum] = "d7b874785de0e65c248349deacdecba76d55b10b74c11242d96b3cd0f8a5a614"

URI_aarch64_rust-gix-bitmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-bitmap+default-devel-0.2.15-1.el10_2.noarch.rpm;name=aarch64_rust-gix-bitmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-bitmap+default-devel}"
SRC_URI[aarch64_rust-gix-bitmap+default-devel.sha256sum] = "f1a155c4407c760d6b56648efc884d3911b4349bf7bb21d518793bb34461e7ce"

URI_aarch64_rust-gix-bitmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-bitmap-devel-0.2.15-1.el10_2.noarch.rpm;name=aarch64_rust-gix-bitmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-bitmap-devel}"
SRC_URI[aarch64_rust-gix-bitmap-devel.sha256sum] = "f9365e69ccd206bbb7950a66eeb71144e714dd66092badc26091c6ec09249761"

RDEPENDS:rust-gix-bitmap+default-devel = " \
 cargo \
 rust-gix-bitmap-devel \
 "
RDEPENDS:rust-gix-bitmap-devel = " \
 cargo \
 rust \
 rust-thiserror+default-devel \
 "
