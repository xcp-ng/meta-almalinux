# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-model"
PV = "0.9.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-below-model+default-devel \
 rust-below-model-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-model-0.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ebc99100a4589ddd4f127d018834c061ffa76f05b10f516720817b79fa17632"

URI_x86_64_v2_rust-below-model+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-model+default-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-model+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-model+default-devel}"
SRC_URI[x86_64_v2_rust-below-model+default-devel.sha256sum] = "3041fe3357cd357e72ed2d7f0e96a1cb00a2aa70947503e065e4ec0b003e63ae"

URI_x86_64_v2_rust-below-model-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-model-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-model-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-model-devel}"
SRC_URI[x86_64_v2_rust-below-model-devel.sha256sum] = "bfbcfbb8b14a91ed27df8beb3748345e6d908abe7c2777b87c1511ac794970e3"

URI_aarch64_rust-below-model+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-model+default-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below-model+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-model+default-devel}"
SRC_URI[aarch64_rust-below-model+default-devel.sha256sum] = "0a8055b37e04fad1fdbb4a26bf4b4e5ad347df812b93fa3c80b31f0f725e8cf6"

URI_aarch64_rust-below-model-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-model-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below-model-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-model-devel}"
SRC_URI[aarch64_rust-below-model-devel.sha256sum] = "357efe9ac3e8c5fb80621fdf729952b47e5e7dd4b149881941029f5bc7573656"

RDEPENDS:rust-below-model+default-devel = " \
 cargo \
 rust-below-model-devel \
 "
RDEPENDS:rust-below-model-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-below-btrfs+default-devel \
 rust-below-common+default-devel \
 rust-below-ethtool+default-devel \
 rust-below-gpu-stats+default-devel \
 rust-below-tc+default-devel \
 rust-below_derive+default-devel \
 rust-cgroupfs+default-devel \
 rust-enum-iterator+default-devel \
 rust-fb_procfs+default-devel \
 rust-hostname+default-devel \
 rust-os_info+default-devel \
 rust-regex+default-devel \
 rust-resctrlfs+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde_json+default-devel \
 rust-serde_json+float_roundtrip-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-slog+default-devel \
 rust-slog+max_level_trace-devel \
 rust-slog+nested-values-devel \
 "
