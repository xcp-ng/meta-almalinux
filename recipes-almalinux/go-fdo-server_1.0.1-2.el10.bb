# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-fdo-server"
PV = "1.0.1"
PR = "2.el10"
PACKAGES = " \
 go-fdo-server \
 go-fdo-server-manufacturer \
 go-fdo-server-owner \
 go-fdo-server-rendezvous \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/go-fdo-server-1.0.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ecf7fac29186ad4a522bdd28b7c62f1a28542953e1bcd043ac81a14006cf921f"

URI_x86_64_v2_go-fdo-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-1.0.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_go-fdo-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-fdo-server}"
SRC_URI[x86_64_v2_go-fdo-server.sha256sum] = "e6b2cbd0b44832ae5975694621bdd8b6294271681dc8cc72c393a5543d35ba29"

URI_x86_64_v2_go-fdo-server-manufacturer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-manufacturer-1.0.1-2.el10.noarch.rpm;name=x86_64_v2_go-fdo-server-manufacturer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-fdo-server-manufacturer}"
SRC_URI[x86_64_v2_go-fdo-server-manufacturer.sha256sum] = "801a3aa8a4c75e87ba9b1a7b18912cebf84e18fef5825559ea1c44fefe5779bc"

URI_x86_64_v2_go-fdo-server-owner = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-owner-1.0.1-2.el10.noarch.rpm;name=x86_64_v2_go-fdo-server-owner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-fdo-server-owner}"
SRC_URI[x86_64_v2_go-fdo-server-owner.sha256sum] = "7c412640874ab8f7a075b87e77c7f0af55a55d7d8073d7b76bc794a94ef2094f"

URI_x86_64_v2_go-fdo-server-rendezvous = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-rendezvous-1.0.1-2.el10.noarch.rpm;name=x86_64_v2_go-fdo-server-rendezvous;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-fdo-server-rendezvous}"
SRC_URI[x86_64_v2_go-fdo-server-rendezvous.sha256sum] = "6d2bd9b87b3502c16d481447939b5772b972ab2217e1da650be7bd5484a46aa1"

URI_aarch64_go-fdo-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-1.0.1-2.el10.aarch64.rpm;name=aarch64_go-fdo-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-fdo-server}"
SRC_URI[aarch64_go-fdo-server.sha256sum] = "f582c356c5125c7b3f03ae7e271a5ccbee8a1b7f72a0a2056a7f2d9bb1919386"

URI_aarch64_go-fdo-server-manufacturer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-manufacturer-1.0.1-2.el10.noarch.rpm;name=aarch64_go-fdo-server-manufacturer;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-fdo-server-manufacturer}"
SRC_URI[aarch64_go-fdo-server-manufacturer.sha256sum] = "801a3aa8a4c75e87ba9b1a7b18912cebf84e18fef5825559ea1c44fefe5779bc"

URI_aarch64_go-fdo-server-owner = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-owner-1.0.1-2.el10.noarch.rpm;name=aarch64_go-fdo-server-owner;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-fdo-server-owner}"
SRC_URI[aarch64_go-fdo-server-owner.sha256sum] = "7c412640874ab8f7a075b87e77c7f0af55a55d7d8073d7b76bc794a94ef2094f"

URI_aarch64_go-fdo-server-rendezvous = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-rendezvous-1.0.1-2.el10.noarch.rpm;name=aarch64_go-fdo-server-rendezvous;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-fdo-server-rendezvous}"
SRC_URI[aarch64_go-fdo-server-rendezvous.sha256sum] = "6d2bd9b87b3502c16d481447939b5772b972ab2217e1da650be7bd5484a46aa1"

RDEPENDS:go-fdo-server = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:go-fdo-server-manufacturer = " \
 bash \
 go-fdo-server \
 openssl \
 "
RDEPENDS:go-fdo-server-owner = " \
 bash \
 go-fdo-server \
 "
RDEPENDS:go-fdo-server-rendezvous = " \
 bash \
 go-fdo-server \
 "
