# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-just"
PV = "1.39.0"
PR = "1.el10_0"
PACKAGES = " \
 just \
 rust-just+default-devel \
 rust-just-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-just-1.39.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91d0a32c5b5ec207102d0380dcb55302529f5e6758f7990d993e48869f309683"

URI_x86_64_v2_just = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/just-1.39.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_just;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_just}"
SRC_URI[x86_64_v2_just.sha256sum] = "ea0961d8e5e28cd14912b2d438d4eadaa0ee826525441516e40dcf3f34ee567f"

URI_x86_64_v2_rust-just+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-just+default-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-just+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-just+default-devel}"
SRC_URI[x86_64_v2_rust-just+default-devel.sha256sum] = "4365aa13b2239ec2f948fc6e9991094741cf61e73cb04e92517eb0bd1b09883f"

URI_x86_64_v2_rust-just-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-just-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-just-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-just-devel}"
SRC_URI[x86_64_v2_rust-just-devel.sha256sum] = "1a9242765cd6b796cef4ed764f6c39a4fa92e1baa5f36469227e1b33233c12f0"

URI_aarch64_just = "${EPEL_MIRROR}/aarch64/Packages/j/just-1.39.0-1.el10_0.aarch64.rpm;name=aarch64_just;unpack=0"
SRC_URI:append = " ${URI_aarch64_just}"
SRC_URI[aarch64_just.sha256sum] = "a1a70172eacd24284db90b682a5c3b2f791c505a3bb2510e8db90551d0560964"

URI_aarch64_rust-just+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-just+default-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-just+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-just+default-devel}"
SRC_URI[aarch64_rust-just+default-devel.sha256sum] = "641898b6a9b9cbbcd17ab9cf45490b1576a0b7bcf423b6b00ac9ef5732b05d78"

URI_aarch64_rust-just-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-just-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-just-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-just-devel}"
SRC_URI[aarch64_rust-just-devel.sha256sum] = "f94a60a644f279e46f5f0efb92fd7d02530d3faf08829509e2e88053ed488e3a"

RDEPENDS:just = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-just+default-devel = " \
 cargo \
 rust-just-devel \
 "
RDEPENDS:rust-just-devel = " \
 bash \
 cargo \
 rust \
 rust-ansi_term+default-devel \
 rust-blake3+default-devel \
 rust-blake3+mmap-devel \
 rust-blake3+rayon-devel \
 rust-camino+default-devel \
 rust-chrono+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+wrap_help-devel \
 rust-clap_complete+default-devel \
 rust-clap_mangen+default-devel \
 rust-ctrlc+default-devel \
 rust-ctrlc+termination-devel \
 rust-derive-where+default-devel \
 rust-dirs+default-devel \
 rust-dotenvy+default-devel \
 rust-edit-distance+default-devel \
 rust-heck+default-devel \
 rust-is_executable+default-devel \
 rust-lexiclean+default-devel \
 rust-libc+default-devel \
 rust-num_cpus+default-devel \
 rust-once_cell+default-devel \
 rust-percent-encoding+default-devel \
 rust-rand0.8+default-devel \
 rust-regex+default-devel \
 rust-rustversion+default-devel \
 rust-semver+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde_json+default-devel \
 rust-sha2+default-devel \
 rust-shellexpand+default-devel \
 rust-similar+default-devel \
 rust-similar+unicode-devel \
 rust-snafu+default-devel \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 rust-target+default-devel \
 rust-tempfile+default-devel \
 rust-typed-arena+default-devel \
 rust-unicode-width+default-devel \
 rust-uuid+default-devel \
 rust-uuid+v4-devel \
 "
