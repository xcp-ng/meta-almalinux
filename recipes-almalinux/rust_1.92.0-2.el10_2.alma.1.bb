# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust"
PV = "1.92.0"
PR = "2.el10_2.alma.1"
PACKAGES:x86_64_v2 = " \
 cargo \
 clippy \
 rust \
 rust-analyzer \
 rust-debugger-common \
 rust-doc \
 rust-gdb \
 rust-lldb \
 rust-src \
 rust-std-static \
 rust-std-static-wasm32-unknown-unknown \
 rust-std-static-wasm32-wasip1 \
 rust-std-static-x86_64-unknown-none \
 rust-toolset \
 rust-toolset-srpm-macros \
 rustfmt \
"
PACKAGES:aarch64 = " \
 cargo \
 clippy \
 rust \
 rust-analyzer \
 rust-debugger-common \
 rust-doc \
 rust-gdb \
 rust-lldb \
 rust-src \
 rust-std-static \
 rust-std-static-aarch64-unknown-none-softfloat \
 rust-std-static-wasm32-unknown-unknown \
 rust-std-static-wasm32-wasip1 \
 rust-toolset \
 rust-toolset-srpm-macros \
 rustfmt \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-1.92.0-2.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f68a23c4f1155b5cf57a68c141b216950f85d664aa653a5eba48095ecf50f796"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cargo-1.92.0-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_cargo;unpack=0"
SRC_URI[x86_64_v2_cargo.sha256sum] = "bc60e1a1dca99b78db43b505de220b98a41abe47db4119d32907eb944407279a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clippy-1.92.0-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_clippy;unpack=0"
SRC_URI[x86_64_v2_clippy.sha256sum] = "60ea7c92eec3d2275d323cee41117ce0b6f3c2597c0265822ae964152f858daf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-1.92.0-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust;unpack=0"
SRC_URI[x86_64_v2_rust.sha256sum] = "cf889edcbfc49756079098765ff88a14fdd75f16c68d18f35e975c8645308d52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-analyzer-1.92.0-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-analyzer;unpack=0"
SRC_URI[x86_64_v2_rust-analyzer.sha256sum] = "bf96fc8af0f56e8f1f2827bf5ef27d2103258a708f5a7481385de088de9e3364"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-debugger-common-1.92.0-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_rust-debugger-common;unpack=0"
SRC_URI[x86_64_v2_rust-debugger-common.sha256sum] = "066364c3cf81426f4483e19c67d727520f30fb4946106f8163cb8d7ef1b57c3e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-doc-1.92.0-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-doc;unpack=0"
SRC_URI[x86_64_v2_rust-doc.sha256sum] = "b2118f824814da0d977b10aadab2a4a320bbc24763b4332c7ffcc53dbeb85985"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-gdb-1.92.0-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_rust-gdb;unpack=0"
SRC_URI[x86_64_v2_rust-gdb.sha256sum] = "36416c11e35f5a7ed2f73b8fd1e17ac9c268d87e61a02b736141c00f43e837d0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-lldb-1.92.0-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_rust-lldb;unpack=0"
SRC_URI[x86_64_v2_rust-lldb.sha256sum] = "b5fd5f65f431e4ce5bf5b35b1763ab998bd818db537d321ba792bf0a1f0ed29c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-src-1.92.0-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_rust-src;unpack=0"
SRC_URI[x86_64_v2_rust-src.sha256sum] = "3a191c97568b6ef7689a8161ad1e6f84a2c0b0d8d589b9b2c435126799f2afce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-1.92.0-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-std-static;unpack=0"
SRC_URI[x86_64_v2_rust-std-static.sha256sum] = "e691cb23e543008588615748ea4319af066dcffe08d3225bf24f2020020b1964"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-wasm32-unknown-unknown-1.92.0-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_rust-std-static-wasm32-unknown-unknown;unpack=0"
SRC_URI[x86_64_v2_rust-std-static-wasm32-unknown-unknown.sha256sum] = "0138e6cca138e3a8bd6140d713af45cad285722fdf927f02ee745a5170eaaf11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-wasm32-wasip1-1.92.0-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_rust-std-static-wasm32-wasip1;unpack=0"
SRC_URI[x86_64_v2_rust-std-static-wasm32-wasip1.sha256sum] = "6b59c9879cc5f8495b5c0dd0629cda1e72584f6b770fba245605007f4c8b070b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rust-std-static-x86_64-unknown-none-1.92.0-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-std-static-x86_64-unknown-none;unpack=0"
SRC_URI[x86_64_v2_rust-std-static-x86_64-unknown-none.sha256sum] = "7b3f6246b1e27d750aec00ad5cc44418eb4d0b6ea550d8125558ff168475114e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-toolset-1.92.0-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_rust-toolset;unpack=0"
SRC_URI[x86_64_v2_rust-toolset.sha256sum] = "076c2a9168005bc63f127403b7ba6ed47e6888351515f4e711c7257770e7a693"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-toolset-srpm-macros-1.92.0-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_rust-toolset-srpm-macros;unpack=0"
SRC_URI[x86_64_v2_rust-toolset-srpm-macros.sha256sum] = "0ceeb326c7211eeb9140d0ea6d45b8d21a41469f24b87463f3b664fe7fd67c4d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rustfmt-1.92.0-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_rustfmt;unpack=0"
SRC_URI[x86_64_v2_rustfmt.sha256sum] = "2b5f8c590991c605277984d2df91e67d00ed93336bef979ae411cfd2f41e80ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cargo-1.92.0-2.el10_2.alma.1.aarch64.rpm;name=aarch64_cargo;unpack=0"
SRC_URI[aarch64_cargo.sha256sum] = "cbb9e1200a9c76ed54fd9730fb93cd64116c6145d5853c6c5c4f509d6c96f980"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clippy-1.92.0-2.el10_2.alma.1.aarch64.rpm;name=aarch64_clippy;unpack=0"
SRC_URI[aarch64_clippy.sha256sum] = "33ee9a61ae80026b8bf5cc0acfd7f02c5d207b757c94394a648ab2f381995344"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-1.92.0-2.el10_2.alma.1.aarch64.rpm;name=aarch64_rust;unpack=0"
SRC_URI[aarch64_rust.sha256sum] = "4cff696b24e856af25ca780fc9f3460ec58214aea25c2fe128daec3efcdfdcab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-analyzer-1.92.0-2.el10_2.alma.1.aarch64.rpm;name=aarch64_rust-analyzer;unpack=0"
SRC_URI[aarch64_rust-analyzer.sha256sum] = "ceb6c88b550f220b712f0bf1201115679c318528880564b5b1b4ccf232ef79a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-debugger-common-1.92.0-2.el10_2.alma.1.noarch.rpm;name=aarch64_rust-debugger-common;unpack=0"
SRC_URI[aarch64_rust-debugger-common.sha256sum] = "066364c3cf81426f4483e19c67d727520f30fb4946106f8163cb8d7ef1b57c3e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-doc-1.92.0-2.el10_2.alma.1.aarch64.rpm;name=aarch64_rust-doc;unpack=0"
SRC_URI[aarch64_rust-doc.sha256sum] = "5d135acc0cc98208dbb52878859287f8b2693651552653d1982924b28904ff89"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-gdb-1.92.0-2.el10_2.alma.1.noarch.rpm;name=aarch64_rust-gdb;unpack=0"
SRC_URI[aarch64_rust-gdb.sha256sum] = "36416c11e35f5a7ed2f73b8fd1e17ac9c268d87e61a02b736141c00f43e837d0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-lldb-1.92.0-2.el10_2.alma.1.noarch.rpm;name=aarch64_rust-lldb;unpack=0"
SRC_URI[aarch64_rust-lldb.sha256sum] = "b5fd5f65f431e4ce5bf5b35b1763ab998bd818db537d321ba792bf0a1f0ed29c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-src-1.92.0-2.el10_2.alma.1.noarch.rpm;name=aarch64_rust-src;unpack=0"
SRC_URI[aarch64_rust-src.sha256sum] = "3a191c97568b6ef7689a8161ad1e6f84a2c0b0d8d589b9b2c435126799f2afce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-1.92.0-2.el10_2.alma.1.aarch64.rpm;name=aarch64_rust-std-static;unpack=0"
SRC_URI[aarch64_rust-std-static.sha256sum] = "aec40af8c71ee17bd86b9a65fabedc1fa06503a60140cf24144579cff927020a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rust-std-static-aarch64-unknown-none-softfloat-1.92.0-2.el10_2.alma.1.aarch64.rpm;name=aarch64_rust-std-static-aarch64-unknown-none-softfloat;unpack=0"
SRC_URI[aarch64_rust-std-static-aarch64-unknown-none-softfloat.sha256sum] = "d1e4993726a50024753619130625138d678f372a707ed969ade072c3b006ff96"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-wasm32-unknown-unknown-1.92.0-2.el10_2.alma.1.noarch.rpm;name=aarch64_rust-std-static-wasm32-unknown-unknown;unpack=0"
SRC_URI[aarch64_rust-std-static-wasm32-unknown-unknown.sha256sum] = "0138e6cca138e3a8bd6140d713af45cad285722fdf927f02ee745a5170eaaf11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-wasm32-wasip1-1.92.0-2.el10_2.alma.1.noarch.rpm;name=aarch64_rust-std-static-wasm32-wasip1;unpack=0"
SRC_URI[aarch64_rust-std-static-wasm32-wasip1.sha256sum] = "6b59c9879cc5f8495b5c0dd0629cda1e72584f6b770fba245605007f4c8b070b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-toolset-1.92.0-2.el10_2.alma.1.noarch.rpm;name=aarch64_rust-toolset;unpack=0"
SRC_URI[aarch64_rust-toolset.sha256sum] = "076c2a9168005bc63f127403b7ba6ed47e6888351515f4e711c7257770e7a693"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-toolset-srpm-macros-1.92.0-2.el10_2.alma.1.noarch.rpm;name=aarch64_rust-toolset-srpm-macros;unpack=0"
SRC_URI[aarch64_rust-toolset-srpm-macros.sha256sum] = "0ceeb326c7211eeb9140d0ea6d45b8d21a41469f24b87463f3b664fe7fd67c4d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rustfmt-1.92.0-2.el10_2.alma.1.aarch64.rpm;name=aarch64_rustfmt;unpack=0"
SRC_URI[aarch64_rustfmt.sha256sum] = "cc382a11000076f04978d435d8eb0e4d7dede5077f839773ea186a09b95faed9"

RDEPENDS:cargo = " \
 glibc \
 libgcc \
 openssl-libs \
 rust \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clippy = " \
 cargo \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust = " \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 rust-std-static \
 "
RDEPENDS:rust-analyzer = " \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust-debugger-common = " \
 "
RDEPENDS:rust-doc = " \
 "
RDEPENDS:rust-gdb = " \
 bash \
 gdb \
 rust \
 rust-debugger-common \
 "
RDEPENDS:rust-lldb = " \
 bash \
 lldb \
 python3-lldb \
 rust \
 rust-debugger-common \
 "
RDEPENDS:rust-src = " \
 "
RDEPENDS:rust-std-static = " \
 glibc \
 glibc-devel \
 libgcc \
 rust \
 "
RDEPENDS:rust-std-static-wasm32-unknown-unknown = " \
 lld \
 rust \
 "
RDEPENDS:rust-std-static-wasm32-wasip1 = " \
 lld \
 rust \
 "
RDEPENDS:rust-std-static-x86_64-unknown-none = " \
 lld \
 rust \
 "
RDEPENDS:rust-toolset = " \
 cargo \
 python3 \
 rust \
 rust-toolset-srpm-macros \
 "
RDEPENDS:rust-toolset-srpm-macros = " \
 "
RDEPENDS:rustfmt = " \
 cargo \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust-std-static-aarch64-unknown-none-softfloat = " \
 lld \
 rust \
 "
