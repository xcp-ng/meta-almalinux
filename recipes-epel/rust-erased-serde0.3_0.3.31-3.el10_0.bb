# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-erased-serde0.3"
PV = "0.3.31"
PR = "3.el10_0"
PACKAGES = " \
 rust-erased-serde0.3+alloc-devel \
 rust-erased-serde0.3+default-devel \
 rust-erased-serde0.3+std-devel \
 rust-erased-serde0.3+unstable-debug-devel \
 rust-erased-serde0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-erased-serde0.3-0.3.31-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5b21cd2a5a6bfa6101f8e88e44f9faf8873f323cbc32124bf276e25274facce"

URI_x86_64_v2_rust-erased-serde0.3+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde0.3+alloc-devel-0.3.31-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde0.3+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde0.3+alloc-devel}"
SRC_URI[x86_64_v2_rust-erased-serde0.3+alloc-devel.sha256sum] = "a25593e3dcc88cbb978a31352d3a5d25aa41d460618e29940fb56a001bdd721f"

URI_x86_64_v2_rust-erased-serde0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde0.3+default-devel-0.3.31-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde0.3+default-devel}"
SRC_URI[x86_64_v2_rust-erased-serde0.3+default-devel.sha256sum] = "3535203a4ba6d3fd768538c995c56c87027d05cd23262b985a4bae071e0ca697"

URI_x86_64_v2_rust-erased-serde0.3+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde0.3+std-devel-0.3.31-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde0.3+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde0.3+std-devel}"
SRC_URI[x86_64_v2_rust-erased-serde0.3+std-devel.sha256sum] = "355867ba596719098b551ccf1cfddb72c682ebed418d7cf09b2d2da44ec9e006"

URI_x86_64_v2_rust-erased-serde0.3+unstable-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde0.3+unstable-debug-devel-0.3.31-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde0.3+unstable-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde0.3+unstable-debug-devel}"
SRC_URI[x86_64_v2_rust-erased-serde0.3+unstable-debug-devel.sha256sum] = "676758379fc97434119259307a0cb7de07718235bc8330516d0edd45625489ad"

URI_x86_64_v2_rust-erased-serde0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde0.3-devel-0.3.31-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde0.3-devel}"
SRC_URI[x86_64_v2_rust-erased-serde0.3-devel.sha256sum] = "8821bbbd4338ed1db58ca8e2c7dc98b97323b44c7379b74f8c587f23be225b87"

URI_aarch64_rust-erased-serde0.3+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde0.3+alloc-devel-0.3.31-3.el10_0.noarch.rpm;name=aarch64_rust-erased-serde0.3+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde0.3+alloc-devel}"
SRC_URI[aarch64_rust-erased-serde0.3+alloc-devel.sha256sum] = "000765b0cf04976fe918194319ba96805e1da8ee48bbe65cd59ec7b8534cd8c4"

URI_aarch64_rust-erased-serde0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde0.3+default-devel-0.3.31-3.el10_0.noarch.rpm;name=aarch64_rust-erased-serde0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde0.3+default-devel}"
SRC_URI[aarch64_rust-erased-serde0.3+default-devel.sha256sum] = "891970756b80a44afec5f3eca4ae0d49fd6bcf2729e7483d6f245da7f0c3e2cf"

URI_aarch64_rust-erased-serde0.3+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde0.3+std-devel-0.3.31-3.el10_0.noarch.rpm;name=aarch64_rust-erased-serde0.3+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde0.3+std-devel}"
SRC_URI[aarch64_rust-erased-serde0.3+std-devel.sha256sum] = "61a5eecec2dbe5c899a74c0f56682b4775c232e5d2fb2342179c23ab44f6d584"

URI_aarch64_rust-erased-serde0.3+unstable-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde0.3+unstable-debug-devel-0.3.31-3.el10_0.noarch.rpm;name=aarch64_rust-erased-serde0.3+unstable-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde0.3+unstable-debug-devel}"
SRC_URI[aarch64_rust-erased-serde0.3+unstable-debug-devel.sha256sum] = "d091a9c2fe9e871b10d1e271fb944febfffac9d7fb1532670a27f2cfca34f294"

URI_aarch64_rust-erased-serde0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde0.3-devel-0.3.31-3.el10_0.noarch.rpm;name=aarch64_rust-erased-serde0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde0.3-devel}"
SRC_URI[aarch64_rust-erased-serde0.3-devel.sha256sum] = "fa2d7c3dfa5007b17698615bc89058c36dc2bd4a65a3ebd3c5a051ae9670f56f"

RDEPENDS:rust-erased-serde0.3+alloc-devel = " \
 cargo \
 rust-erased-serde0.3-devel \
 rust-serde+alloc-devel \
 "
RDEPENDS:rust-erased-serde0.3+default-devel = " \
 cargo \
 rust-erased-serde0.3+std-devel \
 rust-erased-serde0.3-devel \
 "
RDEPENDS:rust-erased-serde0.3+std-devel = " \
 cargo \
 rust-erased-serde0.3-devel \
 rust-serde+std-devel \
 "
RDEPENDS:rust-erased-serde0.3+unstable-debug-devel = " \
 cargo \
 rust-erased-serde0.3-devel \
 "
RDEPENDS:rust-erased-serde0.3-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 "
