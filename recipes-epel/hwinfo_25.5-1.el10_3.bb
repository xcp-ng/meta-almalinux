# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hwinfo"
PV = "25.5"
PR = "1.el10_3"
PACKAGES = " \
 hwinfo \
 hwinfo-devel \
 hwinfo-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/h/hwinfo-25.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "38c4f9333c9f70f6c806d2cc073d78b9d38014734bb40c2d8f0b7d304ed42630"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hwinfo-25.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hwinfo;unpack=0"
SRC_URI[x86_64_v2_hwinfo.sha256sum] = "40d5e736aa7e6b608e5b5a2d15086efca580439df958513a7bac3b59645a45a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hwinfo-devel-25.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hwinfo-devel;unpack=0"
SRC_URI[x86_64_v2_hwinfo-devel.sha256sum] = "6087ccffa6741031f2c096f10ce8c6f559b1c128873cc889ba76b524ee249107"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hwinfo-libs-25.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hwinfo-libs;unpack=0"
SRC_URI[x86_64_v2_hwinfo-libs.sha256sum] = "b4736ba79988739a8e4aa51b3627b0686cdf6e0b178119e5a4fa3eb568e9ecbf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hwinfo-25.5-1.el10_3.aarch64.rpm;name=aarch64_hwinfo;unpack=0"
SRC_URI[aarch64_hwinfo.sha256sum] = "12abe8b2ac1595265ba91553d6b617b5246d10a3d2a7ed3e5cae481b0350d247"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hwinfo-devel-25.5-1.el10_3.aarch64.rpm;name=aarch64_hwinfo-devel;unpack=0"
SRC_URI[aarch64_hwinfo-devel.sha256sum] = "56cefa75ba1c78563692bb760139778b48cbd0e4c06ce6375abd36c4db82d21f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hwinfo-libs-25.5-1.el10_3.aarch64.rpm;name=aarch64_hwinfo-libs;unpack=0"
SRC_URI[aarch64_hwinfo-libs.sha256sum] = "9c61cb5233a7331235e9abbbf7f85bc1371f1dcac94588abfdbed3c1551da5c0"

RDEPENDS:hwinfo = " \
 bash \
 glibc \
 hwinfo-libs \
 perl-interpreter \
 "
RDEPENDS:hwinfo-devel = " \
 hwinfo-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:hwinfo-libs:x86_64_v2 = " \
 glibc \
 libuuid \
 libx86emu \
"
RDEPENDS:hwinfo-libs:aarch64 = " \
 glibc \
 libuuid \
"
