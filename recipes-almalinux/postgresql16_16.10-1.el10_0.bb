# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql16"
PV = "16.10"
PR = "1.el10_0"
PACKAGES = " \
 postgresql \
 postgresql-contrib \
 postgresql-docs \
 postgresql-plperl \
 postgresql-plpython3 \
 postgresql-pltcl \
 postgresql-private-devel \
 postgresql-private-libs \
 postgresql-server \
 postgresql-server-devel \
 postgresql-static \
 postgresql-test \
 postgresql-test-rpm-macros \
 postgresql-upgrade \
 postgresql-upgrade-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql16-16.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f03a10acd2bbec2b8371b78c1b28f2f2bb47db326453ea094512ad376fdab93c"

URI_x86_64_v2_postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-16.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql}"
SRC_URI[x86_64_v2_postgresql.sha256sum] = "34ac485f5ee794b738508ec52491db3d7276cae70a5f8e53c492a54330f481f2"

URI_x86_64_v2_postgresql-contrib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-contrib-16.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_postgresql-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-contrib}"
SRC_URI[x86_64_v2_postgresql-contrib.sha256sum] = "c5f542e05ea572fdad6f302406e973ea6bd3ac3aeb8256ab0582cd311cdb6e94"

URI_x86_64_v2_postgresql-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-docs-16.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_postgresql-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-docs}"
SRC_URI[x86_64_v2_postgresql-docs.sha256sum] = "e091c51634679e62cc87f856726978115e355c7757a81eb7bc989e95f68f08cc"

URI_x86_64_v2_postgresql-plperl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-plperl-16.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_postgresql-plperl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-plperl}"
SRC_URI[x86_64_v2_postgresql-plperl.sha256sum] = "e80f43fae6d03f8330f8575e95110d3c69f00791997a09480dfed8160b8645c2"

URI_x86_64_v2_postgresql-plpython3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-plpython3-16.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_postgresql-plpython3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-plpython3}"
SRC_URI[x86_64_v2_postgresql-plpython3.sha256sum] = "062ff30eedd06f13c83026f71b383bee3c9fa3388449af44b61aa4ef8dc5be83"

URI_x86_64_v2_postgresql-pltcl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-pltcl-16.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_postgresql-pltcl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-pltcl}"
SRC_URI[x86_64_v2_postgresql-pltcl.sha256sum] = "c45a02a7df65e3ef3718015ead35a3ca43ca05f474b6a96800bbdee0a9c56f02"

URI_x86_64_v2_postgresql-private-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-private-devel-16.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_postgresql-private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-private-devel}"
SRC_URI[x86_64_v2_postgresql-private-devel.sha256sum] = "d589eb24a9b50daf7b7d8a2fa0cbf0ca7d1b3d54e8d672d9b97a29a8b8888158"

URI_x86_64_v2_postgresql-private-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-private-libs-16.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_postgresql-private-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-private-libs}"
SRC_URI[x86_64_v2_postgresql-private-libs.sha256sum] = "be32fe717ae90f63cb925e367218327b809259e5c75cf6bd996def4215ad6542"

URI_x86_64_v2_postgresql-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-server-16.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_postgresql-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-server}"
SRC_URI[x86_64_v2_postgresql-server.sha256sum] = "671952fe10a4df9de8a3febce522ee9fd3ae43ecc66209f4fd6fa33e249ece0d"

URI_x86_64_v2_postgresql-server-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-server-devel-16.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_postgresql-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-server-devel}"
SRC_URI[x86_64_v2_postgresql-server-devel.sha256sum] = "244bfd215b4a357e4dc192ccd7ecdf4a0526e80b58e914db33fc4e78ca6bf638"

URI_x86_64_v2_postgresql-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-static-16.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_postgresql-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-static}"
SRC_URI[x86_64_v2_postgresql-static.sha256sum] = "9346855312bdfcb4d295a3e23dad91990ca37f5a6c7437159e6f36bd4ae2d0db"

URI_x86_64_v2_postgresql-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-test-16.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_postgresql-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-test}"
SRC_URI[x86_64_v2_postgresql-test.sha256sum] = "db4aeaa1b894f377b82c2e9b97604ff72af844b1501751bdb84fa6e3f3fa4dfb"

URI_x86_64_v2_postgresql-test-rpm-macros = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/postgresql-test-rpm-macros-16.10-1.el10_0.noarch.rpm;name=x86_64_v2_postgresql-test-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-test-rpm-macros}"
SRC_URI[x86_64_v2_postgresql-test-rpm-macros.sha256sum] = "0a91c240bcbf51741f9381860e8d2d1a39b462ac2513d4c5e84faba5a11096c3"

URI_x86_64_v2_postgresql-upgrade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-upgrade-16.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_postgresql-upgrade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-upgrade}"
SRC_URI[x86_64_v2_postgresql-upgrade.sha256sum] = "b29aec3cdb8de7db3102bd9c1392b2f84b490374053cfbdfe70134ea0bd2251c"

URI_x86_64_v2_postgresql-upgrade-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-upgrade-devel-16.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_postgresql-upgrade-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-upgrade-devel}"
SRC_URI[x86_64_v2_postgresql-upgrade-devel.sha256sum] = "ce9ad2be24e0705e37158cbd1e4bc1a3de5fe71fe36e4d879a8ecad41dfbcfce"

URI_aarch64_postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-16.10-1.el10_0.aarch64.rpm;name=aarch64_postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql}"
SRC_URI[aarch64_postgresql.sha256sum] = "efa85ee02657313f84a99305e884a8cf74e9c96c501dcdde1b5cc8965e140cfc"

URI_aarch64_postgresql-contrib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-contrib-16.10-1.el10_0.aarch64.rpm;name=aarch64_postgresql-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-contrib}"
SRC_URI[aarch64_postgresql-contrib.sha256sum] = "6c39d1b9cc7564ff5d65dfdafbffdff1a4c73d178853f04710974ed8d6111e85"

URI_aarch64_postgresql-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-docs-16.10-1.el10_0.aarch64.rpm;name=aarch64_postgresql-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-docs}"
SRC_URI[aarch64_postgresql-docs.sha256sum] = "17c79a7bda09315e051ac17d28b4073e8d096872b41fd77ad28db55f175fb580"

URI_aarch64_postgresql-plperl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-plperl-16.10-1.el10_0.aarch64.rpm;name=aarch64_postgresql-plperl;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-plperl}"
SRC_URI[aarch64_postgresql-plperl.sha256sum] = "02e781c9db338b6549b1876511f2f1091fcff04e9e3f484ce6fd3fd0fe88cc46"

URI_aarch64_postgresql-plpython3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-plpython3-16.10-1.el10_0.aarch64.rpm;name=aarch64_postgresql-plpython3;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-plpython3}"
SRC_URI[aarch64_postgresql-plpython3.sha256sum] = "52491fc2ae0d2692119e58131ac92fabca9c9dfbe5af6afa391ecc3c98a61938"

URI_aarch64_postgresql-pltcl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-pltcl-16.10-1.el10_0.aarch64.rpm;name=aarch64_postgresql-pltcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-pltcl}"
SRC_URI[aarch64_postgresql-pltcl.sha256sum] = "b3fdac4c32e1da73a67371524f280c4f2f1247d149ba9b0f997b1d3f539536db"

URI_aarch64_postgresql-private-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-private-devel-16.10-1.el10_0.aarch64.rpm;name=aarch64_postgresql-private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-private-devel}"
SRC_URI[aarch64_postgresql-private-devel.sha256sum] = "999a2c3849319447da920b6d5e5e196588406d344f12a710d8853e6d1bfd875d"

URI_aarch64_postgresql-private-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-private-libs-16.10-1.el10_0.aarch64.rpm;name=aarch64_postgresql-private-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-private-libs}"
SRC_URI[aarch64_postgresql-private-libs.sha256sum] = "aa0df0c3eb77f553d1a3ef44929b3bc116cd470b8ce193f7e3cc19c7ebae69ee"

URI_aarch64_postgresql-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-server-16.10-1.el10_0.aarch64.rpm;name=aarch64_postgresql-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-server}"
SRC_URI[aarch64_postgresql-server.sha256sum] = "0e42d52164a9c5c63d06ab32f9dee1529f771deef094d058a17870f2e7748610"

URI_aarch64_postgresql-server-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-server-devel-16.10-1.el10_0.aarch64.rpm;name=aarch64_postgresql-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-server-devel}"
SRC_URI[aarch64_postgresql-server-devel.sha256sum] = "4c1e81eed85f015beded8cbb9dc7248dc97b1c886b704be89b4cf627a58f3d0a"

URI_aarch64_postgresql-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-static-16.10-1.el10_0.aarch64.rpm;name=aarch64_postgresql-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-static}"
SRC_URI[aarch64_postgresql-static.sha256sum] = "9cd23294c79617969dabd2815dafb87014531c489c4ceff5d9c29be54fbe196d"

URI_aarch64_postgresql-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-test-16.10-1.el10_0.aarch64.rpm;name=aarch64_postgresql-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-test}"
SRC_URI[aarch64_postgresql-test.sha256sum] = "0f2a1484ad2338378dd5147b9aaac971c8cb908aa76863179cb42faf711130c9"

URI_aarch64_postgresql-test-rpm-macros = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/postgresql-test-rpm-macros-16.10-1.el10_0.noarch.rpm;name=aarch64_postgresql-test-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-test-rpm-macros}"
SRC_URI[aarch64_postgresql-test-rpm-macros.sha256sum] = "0a91c240bcbf51741f9381860e8d2d1a39b462ac2513d4c5e84faba5a11096c3"

URI_aarch64_postgresql-upgrade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-upgrade-16.10-1.el10_0.aarch64.rpm;name=aarch64_postgresql-upgrade;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-upgrade}"
SRC_URI[aarch64_postgresql-upgrade.sha256sum] = "1fc5f3f0a3652cc16dbc496783d099c06c2f8b4e725a21827c04cc6761c609dc"

URI_aarch64_postgresql-upgrade-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-upgrade-devel-16.10-1.el10_0.aarch64.rpm;name=aarch64_postgresql-upgrade-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-upgrade-devel}"
SRC_URI[aarch64_postgresql-upgrade-devel.sha256sum] = "85f53e4cf16aaddb45017dc45f157282f3c3935a466793a111483adf8b25d591"

RDEPENDS:postgresql = " \
 glibc \
 libzstd \
 lz4-libs \
 openssl-libs \
 postgresql-private-libs \
 readline \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-contrib = " \
 glibc \
 libselinux \
 libxml2 \
 libxslt \
 libzstd \
 lz4-libs \
 openssl-libs \
 perl-libs \
 postgresql \
 postgresql-private-libs \
 python3-libs \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-docs = " \
 glibc \
 postgresql \
 "
RDEPENDS:postgresql-plperl = " \
 glibc \
 perl-libs \
 postgresql-server \
 "
RDEPENDS:postgresql-plpython3 = " \
 glibc \
 postgresql-server \
 python3-libs \
 "
RDEPENDS:postgresql-pltcl = " \
 glibc \
 postgresql-server \
 tcl \
 "
RDEPENDS:postgresql-private-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 postgresql-private-libs \
 "
RDEPENDS:postgresql-private-libs = " \
 glibc \
 krb5-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:postgresql-server = " \
 bash \
 glibc \
 krb5-libs \
 libicu \
 libxml2 \
 libzstd \
 lz4-libs \
 openldap \
 openssl-libs \
 pam-libs \
 postgresql \
 postgresql-private-libs \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-server-devel = " \
 bash \
 glibc \
 krb5-devel \
 libicu-devel \
 postgresql-private-devel \
 postgresql-private-libs \
 "
RDEPENDS:postgresql-static = " \
 postgresql-server-devel \
 "
RDEPENDS:postgresql-test = " \
 bash \
 glibc \
 postgresql-contrib \
 postgresql-server \
 postgresql-server-devel \
 "
RDEPENDS:postgresql-test-rpm-macros = " \
 postgresql-server \
 "
RDEPENDS:postgresql-upgrade = " \
 glibc \
 krb5-libs \
 libicu \
 libselinux \
 libxml2 \
 libxslt \
 openldap \
 pam-libs \
 perl-libs \
 postgresql-private-libs \
 postgresql-server \
 python3-libs \
 tcl \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-upgrade-devel = " \
 bash \
 glibc \
 postgresql-upgrade \
 "
