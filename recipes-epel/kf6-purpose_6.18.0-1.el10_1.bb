# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-purpose"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-purpose \
 kf6-purpose-devel \
 kf6-purpose-doc \
 kf6-purpose-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-purpose-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0646e95602e040183f1e3f8558bcd805363f0da7345f520a6377d5dfd98ecef4"

URI_x86_64_v2_kf6-purpose = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-purpose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-purpose}"
SRC_URI[x86_64_v2_kf6-purpose.sha256sum] = "f9875794dfb67a02d686722a465373898a27db9304f0a68e729ff06fdd26e497"

URI_x86_64_v2_kf6-purpose-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-purpose-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-purpose-devel}"
SRC_URI[x86_64_v2_kf6-purpose-devel.sha256sum] = "2cb7d17dcebf65909d07f176677b3227f416acc40d9ff0d59c72f3650f581a4d"

URI_x86_64_v2_kf6-purpose-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-purpose-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-purpose-doc}"
SRC_URI[x86_64_v2_kf6-purpose-doc.sha256sum] = "5dd31112236c8221c6554231697f1ffc9f65c94edc09efac855d25ac88b947a3"

URI_x86_64_v2_kf6-purpose-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-purpose-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-purpose-html}"
SRC_URI[x86_64_v2_kf6-purpose-html.sha256sum] = "989239f2cba201fefa6937d8c8d0ebe7b55bebb734bb699c32d2a5289cf9975e"

URI_aarch64_kf6-purpose = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-purpose;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-purpose}"
SRC_URI[aarch64_kf6-purpose.sha256sum] = "1acaf2bd34a3e542c069d1fc93469ec4348709c267e8dc60d6b8d4a0d81bb838"

URI_aarch64_kf6-purpose-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-purpose-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-purpose-devel}"
SRC_URI[aarch64_kf6-purpose-devel.sha256sum] = "d6fe62e083e571721bd1ec323a2ddd90e6dae168040b691a991cd243a055f387"

URI_aarch64_kf6-purpose-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-purpose-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-purpose-doc}"
SRC_URI[aarch64_kf6-purpose-doc.sha256sum] = "41e56c05c257d71144086f8b2d7f42b505b7382efc99e853bc330cddcbd6e7d2"

URI_aarch64_kf6-purpose-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-purpose-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-purpose-html}"
SRC_URI[aarch64_kf6-purpose-html.sha256sum] = "be3b47c4af23681e9013280e9c655f2b07ce7041833faefbbe8469333dd62d84"

RDEPENDS:kf6-purpose = " \
 accounts-qml-module-qt6 \
 glibc \
 hicolor-icon-theme \
 kaccounts-integration-qt6 \
 kf6-bluez-qt \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdeclarative \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kservice \
 kf6-prison \
 libaccounts-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-purpose-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-purpose \
 "
RDEPENDS:kf6-purpose-doc = " \
 "
RDEPENDS:kf6-purpose-html = " \
 "
