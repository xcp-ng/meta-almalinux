# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkexiv2"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 libkexiv2-qt6 \
 libkexiv2-qt6-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libkexiv2-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9d4c4acdf397e67a268e9c2df030b764e994df6607a92edf5d15fd79a32ef600"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkexiv2-qt6-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkexiv2-qt6;unpack=0"
SRC_URI[x86_64_v2_libkexiv2-qt6.sha256sum] = "7741897c2c734dabb3621c2fda52233fe436227b13598a00eadbd3d277d1cbed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkexiv2-qt6-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkexiv2-qt6-devel;unpack=0"
SRC_URI[x86_64_v2_libkexiv2-qt6-devel.sha256sum] = "55b79ec3d5f19c9af04b1fa5fbfe40c9f6bc3e9e596f5511b055a1ffd8430759"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkexiv2-qt6-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkexiv2-qt6;unpack=0"
SRC_URI[aarch64_libkexiv2-qt6.sha256sum] = "cc727855626b32de1ed09c438f5cfd2fa1d25e2b580df7091cb5268cd2ac8713"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkexiv2-qt6-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkexiv2-qt6-devel;unpack=0"
SRC_URI[aarch64_libkexiv2-qt6-devel.sha256sum] = "383f26fc592f524bee0ef1cac48c51300405795850a7889ab418a6a3a27e1a76"

RDEPENDS:libkexiv2-qt6 = " \
 exiv2-libs \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkexiv2-qt6-devel = " \
 cmake-filesystem \
 libkexiv2-qt6 \
 qt6-qtbase-devel \
 "
