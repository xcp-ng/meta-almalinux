# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libbz2-rs-sys"
PV = "0.1.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-libbz2-rs-sys+c-allocator-devel \
 rust-libbz2-rs-sys+default-devel \
 rust-libbz2-rs-sys+rust-allocator-devel \
 rust-libbz2-rs-sys+semver-prefix-devel \
 rust-libbz2-rs-sys+std-devel \
 rust-libbz2-rs-sys+stdio-devel \
 rust-libbz2-rs-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libbz2-rs-sys-0.1.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "949054c13f60e52138be5bc38aa4b93d413e71818e0f1345a8f8d2b186440130"

URI_x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+c-allocator-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel.sha256sum] = "250a9f41e9273e88fa269e87284ffdc869b0f142b0318fa49e6ea98472581d66"

URI_x86_64_v2_rust-libbz2-rs-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+default-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+default-devel.sha256sum] = "a6d1a3610ac03aa7d231bc6f7adc70ed9049e7fa1360f311de8624a8e288bc17"

URI_x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+rust-allocator-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel.sha256sum] = "370c1765045f7a856132371233cb11856907e0b88e1ed384e2aa5b73a330a323"

URI_x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+semver-prefix-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel.sha256sum] = "a430dcccee170db6929e6cfd17d1d65492e6c90a50565ea9341b31b59ebd98de"

URI_x86_64_v2_rust-libbz2-rs-sys+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+std-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+std-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+std-devel.sha256sum] = "bd7a1f8d7d3c640c81b2b574562718020cdebc6f928086301f9c08035465d942"

URI_x86_64_v2_rust-libbz2-rs-sys+stdio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+stdio-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+stdio-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+stdio-devel.sha256sum] = "c75f850cb9bd40c4a91c0cede21d62e84d0ada37b9d9f3d755a1b0eefde4c7d0"

URI_x86_64_v2_rust-libbz2-rs-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys-devel.sha256sum] = "b6daac53717403031a382580edb16ab1f21c7d41550720e67772c17817285c32"

URI_aarch64_rust-libbz2-rs-sys+c-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+c-allocator-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+c-allocator-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+c-allocator-devel.sha256sum] = "d587d013d33d71806c993c480ce29545ead82c405040be096ed1bda2a8c86df5"

URI_aarch64_rust-libbz2-rs-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+default-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+default-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+default-devel.sha256sum] = "6507f937551638bf349abd29161290cce96b75318c11d4124d3455c046a0cd16"

URI_aarch64_rust-libbz2-rs-sys+rust-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+rust-allocator-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+rust-allocator-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+rust-allocator-devel.sha256sum] = "aac0936026ad0b14ef51df7c95834d3cd407ef834a64f111b89935661f2c8957"

URI_aarch64_rust-libbz2-rs-sys+semver-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+semver-prefix-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+semver-prefix-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+semver-prefix-devel.sha256sum] = "63053b6d52dda05c136393bdae206a4886a57d47ce25af05c1added3bb50e10d"

URI_aarch64_rust-libbz2-rs-sys+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+std-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+std-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+std-devel.sha256sum] = "a93cb0410c6b2a12da0e730c25fc8877c55507ff6da82d532223a031d013ff9f"

URI_aarch64_rust-libbz2-rs-sys+stdio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+stdio-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+stdio-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+stdio-devel.sha256sum] = "100c9ac3ba75a834ee51806927e851a9d8e7b5c5d5b62cafce4e07773c19a5dc"

URI_aarch64_rust-libbz2-rs-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-libbz2-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys-devel.sha256sum] = "078b8ceabf694d797970988728893966c5d0ae99fdf751c49850fe2351f0aab8"

RDEPENDS:rust-libbz2-rs-sys+c-allocator-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+default-devel = " \
 cargo \
 rust-libbz2-rs-sys+std-devel \
 rust-libbz2-rs-sys+stdio-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+rust-allocator-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+semver-prefix-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+std-devel = " \
 cargo \
 rust-libbz2-rs-sys+rust-allocator-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+stdio-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-libbz2-rs-sys-devel = " \
 cargo \
 rust \
 "
