# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shim"
PV = "16.1"
PR = "2.el10_1.alma.1"
PACKAGES:x86_64_v2 = " \
 shim-x64 \
"
PACKAGES:aarch64 = " \
 shim-aa64 \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/shim-16.1-2.el10_1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9b606c2f43740f72a7682bbefcee44572c1fbfe4a8a221039f1f9b2287cbe4d"

URI_x86_64_v2_shim-x64 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/shim-x64-16.1-2.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_shim-x64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shim-x64}"
SRC_URI[x86_64_v2_shim-x64.sha256sum] = "54672dddad6733031dfd553f530e904c14662e09a50895a0b609096bc00958a6"

URI_aarch64_shim-aa64 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/shim-aa64-16.1-2.el10_1.alma.1.aarch64.rpm;name=aarch64_shim-aa64;unpack=0"
SRC_URI:append = " ${URI_aarch64_shim-aa64}"
SRC_URI[aarch64_shim-aa64.sha256sum] = "744abb9d9d349b668377a60b00099e542351e9f6303c21ff6a5f5dd11b3c6322"

RDEPENDS:shim-x64 = " \
 efi-filesystem \
 fwupd \
 mokutil \
 "
RDEPENDS:shim-aa64 = " \
 efi-filesystem \
 fwupd \
 mokutil \
 "
