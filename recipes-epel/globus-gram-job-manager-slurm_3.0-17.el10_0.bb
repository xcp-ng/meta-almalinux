# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager-slurm"
PV = "3.0"
PR = "17.el10_0"
PACKAGES = " \
 globus-gram-job-manager-slurm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-slurm-3.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2696add03af6f5ef2f6a633e62806105d24072d69bfac52b3d695a3a8b042c36"

URI_x86_64_v2_globus-gram-job-manager-slurm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-slurm-3.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-slurm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-slurm}"
SRC_URI[x86_64_v2_globus-gram-job-manager-slurm.sha256sum] = "837ffe69268ef07a0ddc2ce79a1cbb907ebad7763e626883e04b2b0e6edaf272"

URI_aarch64_globus-gram-job-manager-slurm = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-slurm-3.0-17.el10_0.noarch.rpm;name=aarch64_globus-gram-job-manager-slurm;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-slurm}"
SRC_URI[aarch64_globus-gram-job-manager-slurm.sha256sum] = "98997e2ef8cffda0eea14a0b14bd3e35a6d20580921eb7916fb831182021e3ea"

RDEPENDS:globus-gram-job-manager-slurm = " \
 bash \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IO \
 perl-IPC-Open3 \
 perl-libs \
 "
