# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hashicorp-version"
PV = "1.7.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-hashicorp-version-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-hashicorp-version-1.7.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "89754d27e0637dbacd3c84b1cd7a11e45040c6bcee8333849acbf332ef2e173d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hashicorp-version-devel-1.7.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hashicorp-version-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-hashicorp-version-devel.sha256sum] = "b09125902439522ed333dd77e0dd927072494c4086c0d261518c9f4f8e87af25"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hashicorp-version-devel-1.7.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-hashicorp-version-devel;unpack=0"
SRC_URI[aarch64_golang-github-hashicorp-version-devel.sha256sum] = "ad96924a6b92746b1fdaae38b83268896971ad01376e7b7d2733c5a1b6ca7ce9"

RDEPENDS:golang-github-hashicorp-version-devel = " \
 go-filesystem \
 "
