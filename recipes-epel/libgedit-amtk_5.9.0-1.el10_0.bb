# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgedit-amtk"
PV = "5.9.0"
PR = "1.el10_0"
PACKAGES = " \
 libgedit-amtk \
 libgedit-amtk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgedit-amtk-5.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1ce314254561c8b4fd3376ddec7f0013d06a5825760f80689aa472b90d7b59e"

URI_x86_64_v2_libgedit-amtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-amtk-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-amtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-amtk}"
SRC_URI[x86_64_v2_libgedit-amtk.sha256sum] = "0850f38f5439c850a41a879fcd483c37e8838e9989fa974669bc84fa1ffa6bb1"

URI_x86_64_v2_libgedit-amtk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-amtk-devel-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-amtk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-amtk-devel}"
SRC_URI[x86_64_v2_libgedit-amtk-devel.sha256sum] = "643e0053deea410ee2e038a07af3ff23adc2fd54bfbc7f6b0cd2001c921742db"

URI_aarch64_libgedit-amtk = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-amtk-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_libgedit-amtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-amtk}"
SRC_URI[aarch64_libgedit-amtk.sha256sum] = "e9420eac28e75b3aa504bf1ce7202b1cd1811e97724e1cc07799f6f1546a8898"

URI_aarch64_libgedit-amtk-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-amtk-devel-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_libgedit-amtk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-amtk-devel}"
SRC_URI[aarch64_libgedit-amtk-devel.sha256sum] = "2dc9156088cfa6e21d199e086b38aeab25671a215635c0ef714bfbdc92a2bc75"

RDEPENDS:libgedit-amtk = " \
 glib2 \
 glibc \
 gtk3 \
 "
RDEPENDS:libgedit-amtk-devel = " \
 glib2-devel \
 gtk3-devel \
 libgedit-amtk \
 pkgconf-pkg-config \
 "
