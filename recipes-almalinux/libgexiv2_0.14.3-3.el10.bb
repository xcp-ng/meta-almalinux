# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgexiv2"
PV = "0.14.3"
PR = "3.el10"
PACKAGES = " \
 libgexiv2 \
 libgexiv2-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libgexiv2-0.14.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6292c059e3ee55dc1170b3a2669542ca7dbb3698869b8734b64954c485b400c"

URI_x86_64_v2_libgexiv2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgexiv2-0.14.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_libgexiv2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgexiv2}"
SRC_URI[x86_64_v2_libgexiv2.sha256sum] = "b036f2dbaa0c765100964714774dd02d11711e4a5e5f400b9bc7a15de3e34d71"

URI_x86_64_v2_libgexiv2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgexiv2-devel-0.14.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_libgexiv2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgexiv2-devel}"
SRC_URI[x86_64_v2_libgexiv2-devel.sha256sum] = "aabb847d86edbc43c5e254ca88616a83d4f80ef71ca3451309efb899872ed80a"

URI_aarch64_libgexiv2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgexiv2-0.14.3-3.el10.aarch64.rpm;name=aarch64_libgexiv2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgexiv2}"
SRC_URI[aarch64_libgexiv2.sha256sum] = "740d6a21ea6d19a6e8f551c146d881238cfe32a13637ce8c4dfd835d6b4d4dc2"

URI_aarch64_libgexiv2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgexiv2-devel-0.14.3-3.el10.aarch64.rpm;name=aarch64_libgexiv2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgexiv2-devel}"
SRC_URI[aarch64_libgexiv2-devel.sha256sum] = "be7ebb3e1585f6d6070a317a7be11aff885e9944ca29cd885a4e6dd378e8eb23"

RDEPENDS:libgexiv2 = " \
 exiv2-libs \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libgexiv2-devel = " \
 exiv2-devel \
 glib2-devel \
 libgexiv2 \
 pkgconf-pkg-config \
 "
