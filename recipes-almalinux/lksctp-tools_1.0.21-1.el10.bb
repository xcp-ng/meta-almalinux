# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lksctp-tools"
PV = "1.0.21"
PR = "1.el10"
PACKAGES = " \
 lksctp-tools \
 lksctp-tools-devel \
 lksctp-tools-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lksctp-tools-1.0.21-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "437c28b80141a242016644093cd263499f575b9eb34b3be3ed186f3215c60684"

URI_x86_64_v2_lksctp-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lksctp-tools-1.0.21-1.el10.x86_64_v2.rpm;name=x86_64_v2_lksctp-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lksctp-tools}"
SRC_URI[x86_64_v2_lksctp-tools.sha256sum] = "21254d6ebf7586fe11e92a01564e3fedf8a6565a2645344067fa1b144a074d01"

URI_x86_64_v2_lksctp-tools-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lksctp-tools-devel-1.0.21-1.el10.x86_64_v2.rpm;name=x86_64_v2_lksctp-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lksctp-tools-devel}"
SRC_URI[x86_64_v2_lksctp-tools-devel.sha256sum] = "db8f269f3a6fcf029a8293ec16888faa9791acc9d29b70d0d080429a48d7be8c"

URI_x86_64_v2_lksctp-tools-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lksctp-tools-doc-1.0.21-1.el10.x86_64_v2.rpm;name=x86_64_v2_lksctp-tools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lksctp-tools-doc}"
SRC_URI[x86_64_v2_lksctp-tools-doc.sha256sum] = "4c1f5c9521fc62df054f2a24d6d1078224ec75b8ff15dd51978d35cb0a4a9cfe"

URI_aarch64_lksctp-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lksctp-tools-1.0.21-1.el10.aarch64.rpm;name=aarch64_lksctp-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_lksctp-tools}"
SRC_URI[aarch64_lksctp-tools.sha256sum] = "fa751cfaaa989304bc6f8f8f3454e4218127e7c0f0c2cee7b98c287403d2c471"

URI_aarch64_lksctp-tools-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lksctp-tools-devel-1.0.21-1.el10.aarch64.rpm;name=aarch64_lksctp-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lksctp-tools-devel}"
SRC_URI[aarch64_lksctp-tools-devel.sha256sum] = "befb954459fc4bb4d10da4c9e3c99452c1ed74f57e3dffae0acb876ce52bf006"

URI_aarch64_lksctp-tools-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lksctp-tools-doc-1.0.21-1.el10.aarch64.rpm;name=aarch64_lksctp-tools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lksctp-tools-doc}"
SRC_URI[aarch64_lksctp-tools-doc.sha256sum] = "1be41fb2ddd8c6c7438669fce7647f53dcd36374e0c6bde2ba322cf0696b9516"

RDEPENDS:lksctp-tools = " \
 bash \
 glibc \
 "
RDEPENDS:lksctp-tools-devel = " \
 lksctp-tools \
 pkgconf-pkg-config \
 "
RDEPENDS:lksctp-tools-doc = " \
 lksctp-tools \
 "
