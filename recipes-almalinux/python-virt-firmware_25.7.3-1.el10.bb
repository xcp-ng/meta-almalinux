# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-virt-firmware"
PV = "25.7.3"
PR = "1.el10"
PACKAGES = " \
 python3-virt-firmware \
 uki-direct \
 virt-sb-certs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-virt-firmware-25.7.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6feda0704fcda25c3e0f1424eb34439ca20ed5d6d5563839462cd84f4983503"

URI_x86_64_v2_python3-virt-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-virt-firmware-25.7.3-1.el10.noarch.rpm;name=x86_64_v2_python3-virt-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-virt-firmware}"
SRC_URI[x86_64_v2_python3-virt-firmware.sha256sum] = "fd55d4b5e837165ac3f14af8b503f7a8cfaa2049c626a4f73bcf823eb9039202"

URI_x86_64_v2_uki-direct = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/uki-direct-25.7.3-1.el10.noarch.rpm;name=x86_64_v2_uki-direct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uki-direct}"
SRC_URI[x86_64_v2_uki-direct.sha256sum] = "527a98a2bdc0afc2ec762dd32c97badbf67eb8389d36f41937174a3626920a05"

URI_x86_64_v2_virt-sb-certs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-sb-certs-25.7.3-1.el10.noarch.rpm;name=x86_64_v2_virt-sb-certs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-sb-certs}"
SRC_URI[x86_64_v2_virt-sb-certs.sha256sum] = "aff63f86885bd3aae300eb31f1323997525a8bf87471ff311ef6608375981cc6"

URI_aarch64_python3-virt-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-virt-firmware-25.7.3-1.el10.noarch.rpm;name=aarch64_python3-virt-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-virt-firmware}"
SRC_URI[aarch64_python3-virt-firmware.sha256sum] = "fd55d4b5e837165ac3f14af8b503f7a8cfaa2049c626a4f73bcf823eb9039202"

URI_aarch64_uki-direct = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/uki-direct-25.7.3-1.el10.noarch.rpm;name=aarch64_uki-direct;unpack=0"
SRC_URI:append = " ${URI_aarch64_uki-direct}"
SRC_URI[aarch64_uki-direct.sha256sum] = "527a98a2bdc0afc2ec762dd32c97badbf67eb8389d36f41937174a3626920a05"

URI_aarch64_virt-sb-certs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-sb-certs-25.7.3-1.el10.noarch.rpm;name=aarch64_virt-sb-certs;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-sb-certs}"
SRC_URI[aarch64_virt-sb-certs.sha256sum] = "aff63f86885bd3aae300eb31f1323997525a8bf87471ff311ef6608375981cc6"

RDEPENDS:python3-virt-firmware = " \
 python3 \
 python3-cryptography \
 python3-pefile \
 python3-setuptools \
 virt-sb-certs \
 "
RDEPENDS:uki-direct = " \
 bash \
 python3-virt-firmware \
 "
RDEPENDS:virt-sb-certs = " \
 "
