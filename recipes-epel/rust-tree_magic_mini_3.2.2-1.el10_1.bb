# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree_magic_mini"
PV = "3.2.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree_magic_mini+default-devel \
 rust-tree_magic_mini+with-gpl-data-devel \
 rust-tree_magic_mini-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree_magic_mini-3.2.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b4e39be1f339bbd7e2dacaf49f8b36afd280ec2481483a82a21936c583b8a0f"

URI_x86_64_v2_rust-tree_magic_mini+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree_magic_mini+default-devel-3.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree_magic_mini+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree_magic_mini+default-devel}"
SRC_URI[x86_64_v2_rust-tree_magic_mini+default-devel.sha256sum] = "597e6ef7665bccd044975bec254d1af15793c3efa9effa8ff3ba0f435be0b147"

URI_x86_64_v2_rust-tree_magic_mini+with-gpl-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree_magic_mini+with-gpl-data-devel-3.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree_magic_mini+with-gpl-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree_magic_mini+with-gpl-data-devel}"
SRC_URI[x86_64_v2_rust-tree_magic_mini+with-gpl-data-devel.sha256sum] = "357a6bfde3de0e094fd2fcabe46236b6e853950f2034b4088bec74d7c490e889"

URI_x86_64_v2_rust-tree_magic_mini-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree_magic_mini-devel-3.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree_magic_mini-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree_magic_mini-devel}"
SRC_URI[x86_64_v2_rust-tree_magic_mini-devel.sha256sum] = "78e2aef5177ce2bfe451a258b6be881a06e6ced415ecc694f49b5996e4907ec6"

URI_aarch64_rust-tree_magic_mini+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree_magic_mini+default-devel-3.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree_magic_mini+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree_magic_mini+default-devel}"
SRC_URI[aarch64_rust-tree_magic_mini+default-devel.sha256sum] = "01e3c9f42bde5c04c7c5a16c1160a3db62e12c974a10b579aa7f09d401eb2c9d"

URI_aarch64_rust-tree_magic_mini+with-gpl-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree_magic_mini+with-gpl-data-devel-3.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree_magic_mini+with-gpl-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree_magic_mini+with-gpl-data-devel}"
SRC_URI[aarch64_rust-tree_magic_mini+with-gpl-data-devel.sha256sum] = "09f0068b43b38a0a5169c686d6788049bb12eb1838c8be9b43bbaf7ca7102afd"

URI_aarch64_rust-tree_magic_mini-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree_magic_mini-devel-3.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree_magic_mini-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree_magic_mini-devel}"
SRC_URI[aarch64_rust-tree_magic_mini-devel.sha256sum] = "2d6477c5287dd41b400261a16616895c361b9cb27f5828e16f9619ff4e826dc4"

RDEPENDS:rust-tree_magic_mini+default-devel = " \
 cargo \
 rust-tree_magic_mini-devel \
 "
RDEPENDS:rust-tree_magic_mini+with-gpl-data-devel = " \
 cargo \
 rust-tree_magic_db+default-devel \
 rust-tree_magic_mini-devel \
 "
RDEPENDS:rust-tree_magic_mini-devel = " \
 cargo \
 rust \
 rust-memchr+default-devel \
 rust-nom+default-devel \
 rust-petgraph-devel \
 "
