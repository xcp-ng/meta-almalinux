# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-inline"
PV = "0.3.21"
PR = "5.el10_2"
PACKAGES = " \
 R-inline \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/R-inline-0.3.21-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6d98600c6ddf72f662badf141b63cf4195ae39f2f936865abea10eae18d66f9b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-inline-0.3.21-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_R-inline;unpack=0"
SRC_URI[x86_64_v2_R-inline.sha256sum] = "65df98c9b3e7564b5fe12e4ea21dad5dec372e445d3a67254126597f358e4201"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/R-inline-0.3.21-5.el10_2.noarch.rpm;name=aarch64_R-inline;unpack=0"
SRC_URI[aarch64_R-inline.sha256sum] = "b05e750065acdcba771dfd5da688e6aed95eae25058989a0cba398ff9a0f9382"

RDEPENDS:R-inline = " \
 R-core \
 "
