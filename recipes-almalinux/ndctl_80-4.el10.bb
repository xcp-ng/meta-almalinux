# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ndctl"
PV = "80"
PR = "4.el10"
PACKAGES = " \
 cxl-cli \
 cxl-devel \
 cxl-libs \
 daxctl \
 daxctl-devel \
 daxctl-libs \
 ndctl \
 ndctl-devel \
 ndctl-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ndctl-80-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3953cc973cbda265d325cd89157f15774a59bd785e11d00ce9144ac38b1569b"

URI_x86_64_v2_cxl-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cxl-cli-80-4.el10.x86_64_v2.rpm;name=x86_64_v2_cxl-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cxl-cli}"
SRC_URI[x86_64_v2_cxl-cli.sha256sum] = "1f891f7978171014bbc99001ff03d99ea352c59248d1130c3cbc73cfe1a3473c"

URI_x86_64_v2_cxl-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cxl-devel-80-4.el10.x86_64_v2.rpm;name=x86_64_v2_cxl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cxl-devel}"
SRC_URI[x86_64_v2_cxl-devel.sha256sum] = "3ccf55d1ef732846ba8a116dc3742c2c9cb978e833db5d26bc6e5512bbc7ec91"

URI_x86_64_v2_cxl-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cxl-libs-80-4.el10.x86_64_v2.rpm;name=x86_64_v2_cxl-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cxl-libs}"
SRC_URI[x86_64_v2_cxl-libs.sha256sum] = "b69eddc45e3c9ee675c5a29a99fb8762e3e0ce6731626d02ad8e4737a1112d16"

URI_x86_64_v2_daxctl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/daxctl-80-4.el10.x86_64_v2.rpm;name=x86_64_v2_daxctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daxctl}"
SRC_URI[x86_64_v2_daxctl.sha256sum] = "43bf038f056c9bc17f284f7b10a8bbb2cc58f7d727feff2267edf28e8b6672df"

URI_x86_64_v2_daxctl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/daxctl-devel-80-4.el10.x86_64_v2.rpm;name=x86_64_v2_daxctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daxctl-devel}"
SRC_URI[x86_64_v2_daxctl-devel.sha256sum] = "ec10be30b7dca36cb512f362c11112f0594787bb5a1276c6fe41f0950fcb5455"

URI_x86_64_v2_daxctl-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/daxctl-libs-80-4.el10.x86_64_v2.rpm;name=x86_64_v2_daxctl-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daxctl-libs}"
SRC_URI[x86_64_v2_daxctl-libs.sha256sum] = "a8d6736006088de497c729080eb91f5c6751ce4be35991dd4040fa8989aff017"

URI_x86_64_v2_ndctl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ndctl-80-4.el10.x86_64_v2.rpm;name=x86_64_v2_ndctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ndctl}"
SRC_URI[x86_64_v2_ndctl.sha256sum] = "71f56f0aca1d9ced7a2835b58bcb814e68c2691b6463b1ffd8578107e4313de8"

URI_x86_64_v2_ndctl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ndctl-devel-80-4.el10.x86_64_v2.rpm;name=x86_64_v2_ndctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ndctl-devel}"
SRC_URI[x86_64_v2_ndctl-devel.sha256sum] = "982d8bb9fafaac3b1c7ac36e3e03e6ef73b8e4f2593043b333db3f2af7669192"

URI_x86_64_v2_ndctl-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ndctl-libs-80-4.el10.x86_64_v2.rpm;name=x86_64_v2_ndctl-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ndctl-libs}"
SRC_URI[x86_64_v2_ndctl-libs.sha256sum] = "d0c533481065ace38256a8e85a9d0c58bb7e94081793f148e9c2f544f2efa9a5"

URI_aarch64_cxl-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cxl-cli-80-4.el10.aarch64.rpm;name=aarch64_cxl-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_cxl-cli}"
SRC_URI[aarch64_cxl-cli.sha256sum] = "f10224a739617f212055f48a17c533a8727b6cf21d2b434fb3f23b4418883d75"

URI_aarch64_cxl-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cxl-devel-80-4.el10.aarch64.rpm;name=aarch64_cxl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cxl-devel}"
SRC_URI[aarch64_cxl-devel.sha256sum] = "4e6c37e56f23751d77a86bdf5bf77fafc4fe10c5456e207152ae0775098cc42a"

URI_aarch64_cxl-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cxl-libs-80-4.el10.aarch64.rpm;name=aarch64_cxl-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cxl-libs}"
SRC_URI[aarch64_cxl-libs.sha256sum] = "44ec21670f6eed79d749770766be0f84942559f009aa4659934ebd6d7c3eb7a9"

URI_aarch64_daxctl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/daxctl-80-4.el10.aarch64.rpm;name=aarch64_daxctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_daxctl}"
SRC_URI[aarch64_daxctl.sha256sum] = "6801b02b542911bd248476ae69e79d96a79dbb608b71d3afdbd8b80e41bfdc61"

URI_aarch64_daxctl-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/daxctl-devel-80-4.el10.aarch64.rpm;name=aarch64_daxctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_daxctl-devel}"
SRC_URI[aarch64_daxctl-devel.sha256sum] = "5374fe394f43f780e0c74b4af8ccbdf2066aba8da52562d5b7f859c69e010313"

URI_aarch64_daxctl-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/daxctl-libs-80-4.el10.aarch64.rpm;name=aarch64_daxctl-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_daxctl-libs}"
SRC_URI[aarch64_daxctl-libs.sha256sum] = "cab1486e1fbee4a935fbae840f27e63c7cf2ead7033251093db68956de85b84f"

URI_aarch64_ndctl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ndctl-80-4.el10.aarch64.rpm;name=aarch64_ndctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ndctl}"
SRC_URI[aarch64_ndctl.sha256sum] = "5b87196fc2ab2fed996a776b292ffe9123a58a3b6ec8956c193827b548e7d886"

URI_aarch64_ndctl-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ndctl-devel-80-4.el10.aarch64.rpm;name=aarch64_ndctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ndctl-devel}"
SRC_URI[aarch64_ndctl-devel.sha256sum] = "67e4b870837dd6b82197e1c8f0c5f642c706ef85fbabc662f8d5c775745714cf"

URI_aarch64_ndctl-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ndctl-libs-80-4.el10.aarch64.rpm;name=aarch64_ndctl-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ndctl-libs}"
SRC_URI[aarch64_ndctl-libs.sha256sum] = "6073d7c47a08a45976921a50d380ce28371e623a0027ab6c081873702798ed62"

RDEPENDS:cxl-cli = " \
 cxl-libs \
 daxctl-libs \
 glibc \
 json-c \
 libtraceevent \
 libtracefs \
 libuuid \
 "
RDEPENDS:cxl-devel = " \
 cxl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:cxl-libs = " \
 daxctl-libs \
 glibc \
 kmod-libs \
 libuuid \
 systemd-libs \
 "
RDEPENDS:daxctl = " \
 daxctl-libs \
 glibc \
 iniparser \
 json-c \
 libuuid \
 ndctl-libs \
 "
RDEPENDS:daxctl-devel = " \
 daxctl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:daxctl-libs = " \
 glibc \
 kmod-libs \
 libuuid \
 "
RDEPENDS:ndctl = " \
 bash \
 cxl-libs \
 daxctl-libs \
 glibc \
 iniparser \
 json-c \
 keyutils-libs \
 libuuid \
 ndctl-libs \
 "
RDEPENDS:ndctl-devel = " \
 ndctl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:ndctl-libs = " \
 daxctl-libs \
 glibc \
 kmod-libs \
 libuuid \
 systemd-libs \
 "
