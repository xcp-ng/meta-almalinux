# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lxcfs"
PV = "6.0.6"
PR = "1.el10_3"
PACKAGES = " \
 lxcfs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lxcfs-6.0.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63f73bcb83e90c74ca63bc618ed822c5bf8bcf7e64d51c267d2f1264a18b2df8"

URI_x86_64_v2_lxcfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxcfs-6.0.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxcfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxcfs}"
SRC_URI[x86_64_v2_lxcfs.sha256sum] = "16d2a9a015bc399d46f76f24aceb896004eb5219b07e90e3338309b2d067d259"

URI_aarch64_lxcfs = "${EPEL_MIRROR}/aarch64/Packages/l/lxcfs-6.0.6-1.el10_3.aarch64.rpm;name=aarch64_lxcfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxcfs}"
SRC_URI[aarch64_lxcfs.sha256sum] = "bf6547e6ccc4f722f7cc4131529174aed6fbc623407bbbacb86de557d0396618"

RDEPENDS:lxcfs = " \
 bash \
 fuse3-libs \
 glibc \
 libgcc \
 lxc-templates \
 systemd \
 "
