# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libgit2-sys"
PV = "0.17.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-libgit2-sys+default-devel \
 rust-libgit2-sys+https-devel \
 rust-libgit2-sys+libssh2-sys-devel \
 rust-libgit2-sys+openssl-sys-devel \
 rust-libgit2-sys+ssh-devel \
 rust-libgit2-sys+ssh_key_from_memory-devel \
 rust-libgit2-sys+vendored-devel \
 rust-libgit2-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libgit2-sys-0.17.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e061d84eab2cf3d052169082d93120b98bb6c22ca240ff546c3dfe41afe8afe"

URI_x86_64_v2_rust-libgit2-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+default-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+default-devel.sha256sum] = "51fd7876d940281c248e621d63686a87dc68fbc8d7c2c3764c88c326349a435f"

URI_x86_64_v2_rust-libgit2-sys+https-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+https-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+https-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+https-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+https-devel.sha256sum] = "326ceaf42e576a348ce72a6cc78d918ceb002d67428701dcce51a904a23bbdce"

URI_x86_64_v2_rust-libgit2-sys+libssh2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+libssh2-sys-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+libssh2-sys-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+libssh2-sys-devel.sha256sum] = "a53d84e63ddd16e5c49f4613f86a9587d8830b8bc1f272395dca8591374db0f5"

URI_x86_64_v2_rust-libgit2-sys+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+openssl-sys-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+openssl-sys-devel.sha256sum] = "8a81fcbedc2225c876010a6828150ff890733f0dfc6fc0bfe8c8d9c199d9d9cf"

URI_x86_64_v2_rust-libgit2-sys+ssh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+ssh-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+ssh-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+ssh-devel.sha256sum] = "99e8773d0d44b82fb6c46e553fcd4e001ce68f3b394830edd7f4c6b37b30ff1f"

URI_x86_64_v2_rust-libgit2-sys+ssh_key_from_memory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+ssh_key_from_memory-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+ssh_key_from_memory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+ssh_key_from_memory-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+ssh_key_from_memory-devel.sha256sum] = "cd08810d8a41e02e61a39a589b670faa9035ff7056fa881142df981857c87594"

URI_x86_64_v2_rust-libgit2-sys+vendored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+vendored-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+vendored-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+vendored-devel.sha256sum] = "f4b8df6b0a97a92b9962777663788b17cf5211e874e4a3409e54568cbf5ce2f9"

URI_x86_64_v2_rust-libgit2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys-devel.sha256sum] = "56c55d025355079d5aadd90b7fb72f0cff884af54196b7a994c71ba18faea39f"

URI_aarch64_rust-libgit2-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+default-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-libgit2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+default-devel}"
SRC_URI[aarch64_rust-libgit2-sys+default-devel.sha256sum] = "fa48bfd8b2718b6904a1affc646deedf32c475ee56a392dac379e19e1fb70942"

URI_aarch64_rust-libgit2-sys+https-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+https-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-libgit2-sys+https-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+https-devel}"
SRC_URI[aarch64_rust-libgit2-sys+https-devel.sha256sum] = "6009c370a24cec7fb27e88d34e966c0a94cd8aad7615f125f64cd322d10cd9a7"

URI_aarch64_rust-libgit2-sys+libssh2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+libssh2-sys-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-libgit2-sys+libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+libssh2-sys-devel}"
SRC_URI[aarch64_rust-libgit2-sys+libssh2-sys-devel.sha256sum] = "789b3af99bd182c9dcafd3d77e14f5feb0afb348dca7a29f3cc4fc1a71224b01"

URI_aarch64_rust-libgit2-sys+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+openssl-sys-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-libgit2-sys+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+openssl-sys-devel}"
SRC_URI[aarch64_rust-libgit2-sys+openssl-sys-devel.sha256sum] = "88068c0c809fd22cf6accf2dc0cab0867b0ca1c84cf6d861328e310df1336b4f"

URI_aarch64_rust-libgit2-sys+ssh-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+ssh-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-libgit2-sys+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+ssh-devel}"
SRC_URI[aarch64_rust-libgit2-sys+ssh-devel.sha256sum] = "82cf9aaa079b2ebd6933ab068dafa4a34211df74cdb1ff62d715e5d9e417e2df"

URI_aarch64_rust-libgit2-sys+ssh_key_from_memory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+ssh_key_from_memory-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-libgit2-sys+ssh_key_from_memory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+ssh_key_from_memory-devel}"
SRC_URI[aarch64_rust-libgit2-sys+ssh_key_from_memory-devel.sha256sum] = "7390a61f3a0c464798eab8ba8e76114ca4f7d37c91e05f4e5d499131dc2e1c71"

URI_aarch64_rust-libgit2-sys+vendored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+vendored-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-libgit2-sys+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+vendored-devel}"
SRC_URI[aarch64_rust-libgit2-sys+vendored-devel.sha256sum] = "8bc11c0445458b1b7d545b8af78dafe226ab58774f476f7a6658c034c7cd673c"

URI_aarch64_rust-libgit2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-libgit2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys-devel}"
SRC_URI[aarch64_rust-libgit2-sys-devel.sha256sum] = "69bf0769f5e0cac69b74d0334567df5a5cc8c97985de912bad1afaa642667097"

RDEPENDS:rust-libgit2-sys+default-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+https-devel = " \
 cargo \
 rust-libgit2-sys+openssl-sys-devel \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+libssh2-sys-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 rust-libssh2-sys+default-devel \
 "
RDEPENDS:rust-libgit2-sys+openssl-sys-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-libgit2-sys+ssh-devel = " \
 cargo \
 rust-libgit2-sys+libssh2-sys-devel \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+ssh_key_from_memory-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+vendored-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-pkg-config+default-devel \
 "
