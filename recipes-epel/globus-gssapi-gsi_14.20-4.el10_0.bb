# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gssapi-gsi"
PV = "14.20"
PR = "4.el10_0"
PACKAGES = " \
 globus-gssapi-gsi \
 globus-gssapi-gsi-devel \
 globus-gssapi-gsi-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gssapi-gsi-14.20-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04c884323db6156a26e16d760461b10a7c87c3fadf359a031e5aac1249c06d81"

URI_x86_64_v2_globus-gssapi-gsi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gssapi-gsi-14.20-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gssapi-gsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gssapi-gsi}"
SRC_URI[x86_64_v2_globus-gssapi-gsi.sha256sum] = "8ee1aa90e3f7a3077db20397552834804fd5ef5e98cee33a142eaa2cc7e73dff"

URI_x86_64_v2_globus-gssapi-gsi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gssapi-gsi-devel-14.20-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gssapi-gsi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gssapi-gsi-devel}"
SRC_URI[x86_64_v2_globus-gssapi-gsi-devel.sha256sum] = "af526ea404818f9cb8bd9a5ca4bb4c325f7d28574cf04616320b15f688e40886"

URI_x86_64_v2_globus-gssapi-gsi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gssapi-gsi-doc-14.20-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gssapi-gsi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gssapi-gsi-doc}"
SRC_URI[x86_64_v2_globus-gssapi-gsi-doc.sha256sum] = "2aed003938b5c10cccfccc49f5cc9ed71483b75a6fbd83b11f17542a344599d6"

URI_aarch64_globus-gssapi-gsi = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gssapi-gsi-14.20-4.el10_0.aarch64.rpm;name=aarch64_globus-gssapi-gsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gssapi-gsi}"
SRC_URI[aarch64_globus-gssapi-gsi.sha256sum] = "2d2cbcb2c79545bf72b7d82343c7222ae225a719002b1ec818764ce7bb853f48"

URI_aarch64_globus-gssapi-gsi-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gssapi-gsi-devel-14.20-4.el10_0.aarch64.rpm;name=aarch64_globus-gssapi-gsi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gssapi-gsi-devel}"
SRC_URI[aarch64_globus-gssapi-gsi-devel.sha256sum] = "ab1942ac94660ed4f8d3819677dc47c939aab5a29d3dc1435964a0e49c3234db"

URI_aarch64_globus-gssapi-gsi-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gssapi-gsi-doc-14.20-4.el10_0.noarch.rpm;name=aarch64_globus-gssapi-gsi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gssapi-gsi-doc}"
SRC_URI[aarch64_globus-gssapi-gsi-doc.sha256sum] = "4f22ec1bd63167bc5ab768cd9a14771b27986a46627e93a0bad758fba4caf4aa"

RDEPENDS:globus-gssapi-gsi = " \
 glibc \
 globus-common \
 globus-gsi-callback \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gsi-openssl-error \
 globus-gsi-proxy-core \
 globus-gsi-sysconfig \
 globus-openssl-module \
 openssl-libs \
 "
RDEPENDS:globus-gssapi-gsi-devel = " \
 globus-common-devel \
 globus-gsi-callback-devel \
 globus-gsi-cert-utils-devel \
 globus-gsi-credential-devel \
 globus-gsi-openssl-error-devel \
 globus-gsi-proxy-core-devel \
 globus-gsi-sysconfig-devel \
 globus-gssapi-gsi \
 globus-openssl-module-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gssapi-gsi-doc = " \
 "
