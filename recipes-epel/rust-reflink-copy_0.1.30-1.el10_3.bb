# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reflink-copy"
PV = "0.1.30"
PR = "1.el10_3"
PACKAGES = " \
 rust-reflink-copy+default-devel \
 rust-reflink-copy+tracing-devel \
 rust-reflink-copy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reflink-copy-0.1.30-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b42db6736f5b77f7fbe3577f607b564bf11383cd826ab215913534c1626ce97e"

URI_x86_64_v2_rust-reflink-copy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reflink-copy+default-devel-0.1.30-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reflink-copy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reflink-copy+default-devel}"
SRC_URI[x86_64_v2_rust-reflink-copy+default-devel.sha256sum] = "1a4fca09cb014a0a928729a4d1697603a6cf2f5b28267852e7af09aa10afb3c8"

URI_x86_64_v2_rust-reflink-copy+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reflink-copy+tracing-devel-0.1.30-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reflink-copy+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reflink-copy+tracing-devel}"
SRC_URI[x86_64_v2_rust-reflink-copy+tracing-devel.sha256sum] = "6f24438f22eba97f5a626e9b690bfeb6ac1f06aa3e545ac2647dbf8045810024"

URI_x86_64_v2_rust-reflink-copy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reflink-copy-devel-0.1.30-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reflink-copy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reflink-copy-devel}"
SRC_URI[x86_64_v2_rust-reflink-copy-devel.sha256sum] = "3201da7d3012b738f84b012eec8e345488d14c45ee53e8c5592aff5b7449f642"

URI_aarch64_rust-reflink-copy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reflink-copy+default-devel-0.1.30-1.el10_3.noarch.rpm;name=aarch64_rust-reflink-copy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reflink-copy+default-devel}"
SRC_URI[aarch64_rust-reflink-copy+default-devel.sha256sum] = "54873b11dca53fd8ed0cb4da5af9e2945e3a6a5e85cb3fd6214da514a6a019fe"

URI_aarch64_rust-reflink-copy+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reflink-copy+tracing-devel-0.1.30-1.el10_3.noarch.rpm;name=aarch64_rust-reflink-copy+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reflink-copy+tracing-devel}"
SRC_URI[aarch64_rust-reflink-copy+tracing-devel.sha256sum] = "d2adb42ebc5ede1dd1cb55b4acd40e6822d8c42297e141042714bbec5e4b08b3"

URI_aarch64_rust-reflink-copy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reflink-copy-devel-0.1.30-1.el10_3.noarch.rpm;name=aarch64_rust-reflink-copy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reflink-copy-devel}"
SRC_URI[aarch64_rust-reflink-copy-devel.sha256sum] = "3dea785ef67cdd625c0f6ec9ce751266c0a3185f3eab839fc4d6b2934d7ffbaf"

RDEPENDS:rust-reflink-copy+default-devel = " \
 cargo \
 rust-reflink-copy-devel \
 "
RDEPENDS:rust-reflink-copy+tracing-devel = " \
 cargo \
 rust-reflink-copy-devel \
 rust-tracing-attributes+default-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-reflink-copy-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
