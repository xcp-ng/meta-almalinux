# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ts-parser-perl"
PV = "1.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-ts-parser-perl+default-devel \
 rust-ts-parser-perl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ts-parser-perl-1.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4554defb0d00e7ae316038b3d862ae1ad27925509e6535064866eda1c4339780"

URI_x86_64_v2_rust-ts-parser-perl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ts-parser-perl+default-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ts-parser-perl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ts-parser-perl+default-devel}"
SRC_URI[x86_64_v2_rust-ts-parser-perl+default-devel.sha256sum] = "39fb623eb34bd4418544f2ae7fefef5529dfe8e7ab9637e18cfffdef31d566de"

URI_x86_64_v2_rust-ts-parser-perl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ts-parser-perl-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ts-parser-perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ts-parser-perl-devel}"
SRC_URI[x86_64_v2_rust-ts-parser-perl-devel.sha256sum] = "2904dff99a79bac92f04bf9627560c53f4fff209803a045fc433283baf62a379"

URI_aarch64_rust-ts-parser-perl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ts-parser-perl+default-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-ts-parser-perl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ts-parser-perl+default-devel}"
SRC_URI[aarch64_rust-ts-parser-perl+default-devel.sha256sum] = "5cdbd26c18c8e17fac91218dab3b7980f2ebb8eac3daf1a5168c941ad0c04471"

URI_aarch64_rust-ts-parser-perl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ts-parser-perl-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-ts-parser-perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ts-parser-perl-devel}"
SRC_URI[aarch64_rust-ts-parser-perl-devel.sha256sum] = "ad35bf36a20a01f43242c7af2c1432ae0ddb7c20e956aa4ba057714bb9a92639"

RDEPENDS:rust-ts-parser-perl+default-devel = " \
 cargo \
 rust-ts-parser-perl-devel \
 "
RDEPENDS:rust-ts-parser-perl-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
