# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MailTools"
PV = "2.21"
PR = "18.el10"
PACKAGES = " \
 perl-MailTools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-MailTools-2.21-18.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "36cce1eadd1dd84b788454a9eb87889f44555901b1eec467475a398810305b76"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-MailTools-2.21-18.el10.noarch.rpm;name=x86_64_v2_perl-MailTools;unpack=0"
SRC_URI[x86_64_v2_perl-MailTools.sha256sum] = "bfc32bd60c77f671b9b84916341b333df469138ccbbcf24402bd1eb1614044a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-MailTools-2.21-18.el10.noarch.rpm;name=aarch64_perl-MailTools;unpack=0"
SRC_URI[aarch64_perl-MailTools.sha256sum] = "bfc32bd60c77f671b9b84916341b333df469138ccbbcf24402bd1eb1614044a2"

RDEPENDS:perl-MailTools = " \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-MailTools \
 perl-Net-SMTP-SSL \
 perl-POSIX \
 perl-TimeDate \
 perl-base \
 perl-libnet \
 perl-libs \
 perl-vars \
 "
