# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-reno"
PV = "4.1.0"
PR = "11.el10_3"
PACKAGES = " \
 python-reno-doc \
 python3-reno \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-reno-4.1.0-11.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b44ca6374d9d11544cbef639cb7ae8ebe1986b86a8df88dab96f2293ed014e42"

URI_x86_64_v2_python-reno-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-reno-doc-4.1.0-11.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-reno-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-reno-doc}"
SRC_URI[x86_64_v2_python-reno-doc.sha256sum] = "4f25e7ab8c851d1c90335b6c162eb07f82451cf5ae45ae55abdca5821a34a457"

URI_x86_64_v2_python3-reno = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-reno-4.1.0-11.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-reno;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-reno}"
SRC_URI[x86_64_v2_python3-reno.sha256sum] = "ed6f38fbfc1e1ab1b9fc6070f3fe16b18f5422bef5019d1c3b2ae56cbcbc962a"

URI_aarch64_python-reno-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-reno-doc-4.1.0-11.el10_3.noarch.rpm;name=aarch64_python-reno-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-reno-doc}"
SRC_URI[aarch64_python-reno-doc.sha256sum] = "ad2490657ac35bb3558e71b35b4f26ef76bb5a68686201b30dd058c1d4d292bd"

URI_aarch64_python3-reno = "${EPEL_MIRROR}/aarch64/Packages/p/python3-reno-4.1.0-11.el10_3.noarch.rpm;name=aarch64_python3-reno;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-reno}"
SRC_URI[aarch64_python3-reno.sha256sum] = "59cb35d109a6edf537d73dde50f9d439b37ed430416fa58db1192e04297d1ab0"

RDEPENDS:python-reno-doc = " \
 "
RDEPENDS:python3-reno = " \
 git-core \
 python3 \
 python3-dulwich \
 python3-packaging \
 python3-pbr \
 python3-pyyaml \
 "
