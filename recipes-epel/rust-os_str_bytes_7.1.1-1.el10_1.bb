# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-os_str_bytes"
PV = "7.1.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-os_str_bytes+checked_conversions-devel \
 rust-os_str_bytes+conversions-devel \
 rust-os_str_bytes+default-devel \
 rust-os_str_bytes+memchr-devel \
 rust-os_str_bytes+raw_os_str-devel \
 rust-os_str_bytes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-os_str_bytes-7.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e249be3434330bad2b3894a575f436a65c006631efbe6a8ce15fd568b7df3d3"

URI_x86_64_v2_rust-os_str_bytes+checked_conversions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+checked_conversions-devel-7.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+checked_conversions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+checked_conversions-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+checked_conversions-devel.sha256sum] = "c568915bb6247135af2b7c5a097d3ccd205f198486e6a5f3a4ef0d8585cc2af2"

URI_x86_64_v2_rust-os_str_bytes+conversions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+conversions-devel-7.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+conversions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+conversions-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+conversions-devel.sha256sum] = "2d36afaf6d313380e357ed9e47be05abf790e2d88be31f9e9a6a774490c87aad"

URI_x86_64_v2_rust-os_str_bytes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+default-devel-7.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+default-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+default-devel.sha256sum] = "ae17260010e01ac84c5dd09c3b6686d9b417f63a2872e2a80f58025200374cbe"

URI_x86_64_v2_rust-os_str_bytes+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+memchr-devel-7.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+memchr-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+memchr-devel.sha256sum] = "e5fd8e097c8caddedb310321624b8fbffa677bdb83c38f9333ad86c956cb3dee"

URI_x86_64_v2_rust-os_str_bytes+raw_os_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+raw_os_str-devel-7.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+raw_os_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+raw_os_str-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+raw_os_str-devel.sha256sum] = "e8c4daa71aabc234e8e653c1fe9e93dd4933aa00278cace5220c80d788ed412e"

URI_x86_64_v2_rust-os_str_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes-devel-7.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes-devel.sha256sum] = "80f8526ce96ef9629d317596ff82efa6442919038f0188d19a2e85c491d9b0ef"

URI_aarch64_rust-os_str_bytes+checked_conversions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+checked_conversions-devel-7.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-os_str_bytes+checked_conversions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+checked_conversions-devel}"
SRC_URI[aarch64_rust-os_str_bytes+checked_conversions-devel.sha256sum] = "babf408e8cccbdaddbb04f12c6d7ac6a41c4b7b0d90f6596b179294bedf7239c"

URI_aarch64_rust-os_str_bytes+conversions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+conversions-devel-7.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-os_str_bytes+conversions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+conversions-devel}"
SRC_URI[aarch64_rust-os_str_bytes+conversions-devel.sha256sum] = "fd4a40517f99699cd1843c8dfd868b116f7f6f3802c0054dd0359498e8587cd1"

URI_aarch64_rust-os_str_bytes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+default-devel-7.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-os_str_bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+default-devel}"
SRC_URI[aarch64_rust-os_str_bytes+default-devel.sha256sum] = "f06273ce2d0fce1f61bb75afb6dea22b4668e1d9d38051a95332e0c12aa0dba0"

URI_aarch64_rust-os_str_bytes+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+memchr-devel-7.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-os_str_bytes+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+memchr-devel}"
SRC_URI[aarch64_rust-os_str_bytes+memchr-devel.sha256sum] = "45267f1b81dc4d7469c1b958373bbb9111e95ec5f0b0ce6b9793ded69ec41e92"

URI_aarch64_rust-os_str_bytes+raw_os_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+raw_os_str-devel-7.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-os_str_bytes+raw_os_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+raw_os_str-devel}"
SRC_URI[aarch64_rust-os_str_bytes+raw_os_str-devel.sha256sum] = "21a799dce66d0c9f920aa600a570028e98c955eb3172f52c77ad2421e7a9e9e0"

URI_aarch64_rust-os_str_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes-devel-7.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-os_str_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes-devel}"
SRC_URI[aarch64_rust-os_str_bytes-devel.sha256sum] = "d083dd351d7c00774dfccb27dbabca74c34a7545928714cd053fd38b9998543f"

RDEPENDS:rust-os_str_bytes+checked_conversions-devel = " \
 cargo \
 rust-os_str_bytes+conversions-devel \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+conversions-devel = " \
 cargo \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+default-devel = " \
 cargo \
 rust-os_str_bytes+memchr-devel \
 rust-os_str_bytes+raw_os_str-devel \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+memchr-devel = " \
 cargo \
 rust-memchr+default-devel \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+raw_os_str-devel = " \
 cargo \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes-devel = " \
 cargo \
 rust \
 "
