# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktls-utils"
PV = "1.2.1"
PR = "1.el10"
PACKAGES = " \
 ktls-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ktls-utils-1.2.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6745d53011abfc646958fee65994ae201317ddfad53419cad9dc6106241894ce"

URI_x86_64_v2_ktls-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ktls-utils-1.2.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_ktls-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktls-utils}"
SRC_URI[x86_64_v2_ktls-utils.sha256sum] = "50d025e740dde3055168b8f4d28076989740d3cf431225b624b77ebba06b1194"

URI_aarch64_ktls-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ktls-utils-1.2.1-1.el10.aarch64.rpm;name=aarch64_ktls-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktls-utils}"
SRC_URI[aarch64_ktls-utils.sha256sum] = "d48860816c7d7a057d0b8bd19275089640655d36a8599abd9233279a5a32929e"

RDEPENDS:ktls-utils = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 keyutils-libs \
 libnl3 \
 "
