# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ocb3"
PV = "0.1.0"
PR = "3.el10_2"
PACKAGES = " \
 rust-ocb3+alloc-devel \
 rust-ocb3+arrayvec-devel \
 rust-ocb3+default-devel \
 rust-ocb3+getrandom-devel \
 rust-ocb3+heapless-devel \
 rust-ocb3+rand_core-devel \
 rust-ocb3+std-devel \
 rust-ocb3+stream-devel \
 rust-ocb3+zeroize-devel \
 rust-ocb3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ocb3-0.1.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b7e971300e0027481659cf11c2e5912e4185ad717ba26839b2ad9b5c49f2d35"

URI_x86_64_v2_rust-ocb3+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ocb3+alloc-devel-0.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ocb3+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ocb3+alloc-devel}"
SRC_URI[x86_64_v2_rust-ocb3+alloc-devel.sha256sum] = "9a6a16cd2573e30f8fdf41039a96ca9152e21091cef64e175bcf5992fbfef30f"

URI_x86_64_v2_rust-ocb3+arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ocb3+arrayvec-devel-0.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ocb3+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ocb3+arrayvec-devel}"
SRC_URI[x86_64_v2_rust-ocb3+arrayvec-devel.sha256sum] = "e5011b36fe6476947ade10b74c3102e6e18777b39b234d86495419717e98227b"

URI_x86_64_v2_rust-ocb3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ocb3+default-devel-0.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ocb3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ocb3+default-devel}"
SRC_URI[x86_64_v2_rust-ocb3+default-devel.sha256sum] = "590e98db47345e281422d70e7c4d19b86e89d5a15b3f4c03b1a4e1a99d863e85"

URI_x86_64_v2_rust-ocb3+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ocb3+getrandom-devel-0.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ocb3+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ocb3+getrandom-devel}"
SRC_URI[x86_64_v2_rust-ocb3+getrandom-devel.sha256sum] = "c55d37a1500754f569ba096e5641909367a6511da18889bb40a7edd7a898273d"

URI_x86_64_v2_rust-ocb3+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ocb3+heapless-devel-0.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ocb3+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ocb3+heapless-devel}"
SRC_URI[x86_64_v2_rust-ocb3+heapless-devel.sha256sum] = "a3aa03acf254e89ce5e10ff2991f00dd46b06c79bcb3b1db57a4df41ffecb5d0"

URI_x86_64_v2_rust-ocb3+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ocb3+rand_core-devel-0.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ocb3+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ocb3+rand_core-devel}"
SRC_URI[x86_64_v2_rust-ocb3+rand_core-devel.sha256sum] = "56a29a6c3da1347ef6ae70e09054f3145b6d7fe018d65e2b0437bb41b919123c"

URI_x86_64_v2_rust-ocb3+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ocb3+std-devel-0.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ocb3+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ocb3+std-devel}"
SRC_URI[x86_64_v2_rust-ocb3+std-devel.sha256sum] = "f7f97d770f75e224d6ccf8f8cb2b6b6d9cd98bbb4ed9dddd1d81b9e2a518fcff"

URI_x86_64_v2_rust-ocb3+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ocb3+stream-devel-0.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ocb3+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ocb3+stream-devel}"
SRC_URI[x86_64_v2_rust-ocb3+stream-devel.sha256sum] = "824ee72baf8a0bf5d88a4a629097c6017261b3a53217e284036cd35d4d995faf"

URI_x86_64_v2_rust-ocb3+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ocb3+zeroize-devel-0.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ocb3+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ocb3+zeroize-devel}"
SRC_URI[x86_64_v2_rust-ocb3+zeroize-devel.sha256sum] = "8e19010efe8184e482e3f91bade20b94580680d3273840e7766822a3e4c25e2d"

URI_x86_64_v2_rust-ocb3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ocb3-devel-0.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ocb3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ocb3-devel}"
SRC_URI[x86_64_v2_rust-ocb3-devel.sha256sum] = "0b2e6cddfbf70e84caa407ad4ddd638601c6157387926103f8e1d60668474a8b"

URI_aarch64_rust-ocb3+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ocb3+alloc-devel-0.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-ocb3+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ocb3+alloc-devel}"
SRC_URI[aarch64_rust-ocb3+alloc-devel.sha256sum] = "66d4d5d5789aa0cb2630d490b56a811febcc9c9cea66e82d367dc958a91bb59f"

URI_aarch64_rust-ocb3+arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ocb3+arrayvec-devel-0.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-ocb3+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ocb3+arrayvec-devel}"
SRC_URI[aarch64_rust-ocb3+arrayvec-devel.sha256sum] = "7d1bcd4a938f5cb76532d5297a09357582fc5f36422a9f98f842afdc8776fff5"

URI_aarch64_rust-ocb3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ocb3+default-devel-0.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-ocb3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ocb3+default-devel}"
SRC_URI[aarch64_rust-ocb3+default-devel.sha256sum] = "089b537d54f490d3574988e68d2c3ebe258630373379265f90f212d260b3f0cc"

URI_aarch64_rust-ocb3+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ocb3+getrandom-devel-0.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-ocb3+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ocb3+getrandom-devel}"
SRC_URI[aarch64_rust-ocb3+getrandom-devel.sha256sum] = "6f09e08f4e57c12e9c2508881a0376212ecf689bcb09e373c1bb4c86d85fb138"

URI_aarch64_rust-ocb3+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ocb3+heapless-devel-0.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-ocb3+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ocb3+heapless-devel}"
SRC_URI[aarch64_rust-ocb3+heapless-devel.sha256sum] = "27dbf82b6b26910a7464cabcbdca857507c17006221039516f90dcd1bbf02122"

URI_aarch64_rust-ocb3+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ocb3+rand_core-devel-0.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-ocb3+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ocb3+rand_core-devel}"
SRC_URI[aarch64_rust-ocb3+rand_core-devel.sha256sum] = "8fff7e398b9b7fdc7b8acb3087c9d5ead8b6bb896de6c8c811b12f453f1e5cc2"

URI_aarch64_rust-ocb3+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ocb3+std-devel-0.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-ocb3+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ocb3+std-devel}"
SRC_URI[aarch64_rust-ocb3+std-devel.sha256sum] = "34e477ff638b398644042eef5569c3094d23213de2c982f0630a075290184ea5"

URI_aarch64_rust-ocb3+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ocb3+stream-devel-0.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-ocb3+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ocb3+stream-devel}"
SRC_URI[aarch64_rust-ocb3+stream-devel.sha256sum] = "a8ce8ed1b83140f02d46755bbe0d3b4f803c1a741a2fc55a85e960062f225a6d"

URI_aarch64_rust-ocb3+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ocb3+zeroize-devel-0.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-ocb3+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ocb3+zeroize-devel}"
SRC_URI[aarch64_rust-ocb3+zeroize-devel.sha256sum] = "a7c1d9691405c38d39add437e56583929aec0bf2e87048b0d3eb4307b9fd4bdd"

URI_aarch64_rust-ocb3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ocb3-devel-0.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-ocb3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ocb3-devel}"
SRC_URI[aarch64_rust-ocb3-devel.sha256sum] = "5662b80f57cae8d7865af1db3273adf0eed0378260fa03389b7dcbe047cab089"

RDEPENDS:rust-ocb3+alloc-devel = " \
 cargo \
 rust-aead+alloc-devel \
 rust-ocb3-devel \
 "
RDEPENDS:rust-ocb3+arrayvec-devel = " \
 cargo \
 rust-aead+arrayvec-devel \
 rust-ocb3-devel \
 "
RDEPENDS:rust-ocb3+default-devel = " \
 cargo \
 rust-ocb3+alloc-devel \
 rust-ocb3+getrandom-devel \
 rust-ocb3-devel \
 "
RDEPENDS:rust-ocb3+getrandom-devel = " \
 cargo \
 rust-aead+getrandom-devel \
 rust-ocb3+rand_core-devel \
 rust-ocb3-devel \
 "
RDEPENDS:rust-ocb3+heapless-devel = " \
 cargo \
 rust-aead+heapless-devel \
 rust-ocb3-devel \
 "
RDEPENDS:rust-ocb3+rand_core-devel = " \
 cargo \
 rust-aead+rand_core-devel \
 rust-ocb3-devel \
 "
RDEPENDS:rust-ocb3+std-devel = " \
 cargo \
 rust-aead+std-devel \
 rust-ocb3+alloc-devel \
 rust-ocb3-devel \
 "
RDEPENDS:rust-ocb3+stream-devel = " \
 cargo \
 rust-aead+stream-devel \
 rust-ocb3-devel \
 "
RDEPENDS:rust-ocb3+zeroize-devel = " \
 cargo \
 rust-ocb3-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-ocb3-devel = " \
 cargo \
 rust \
 rust-aead-devel \
 rust-cipher0.4+default-devel \
 rust-ctr+default-devel \
 rust-subtle-devel \
 "
