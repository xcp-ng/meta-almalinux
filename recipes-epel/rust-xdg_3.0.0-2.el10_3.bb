# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xdg"
PV = "3.0.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-xdg+default-devel \
 rust-xdg+serde-devel \
 rust-xdg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-xdg-3.0.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05180e685e30fb3d0029e951e1762dabb9392d88bae699933e450a4bf4cf4224"

URI_x86_64_v2_rust-xdg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xdg+default-devel-3.0.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xdg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xdg+default-devel}"
SRC_URI[x86_64_v2_rust-xdg+default-devel.sha256sum] = "b26ee933ab20c96c02635b6d2c720193fe4384b76033ba9e609aa84a9d17bd1c"

URI_x86_64_v2_rust-xdg+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xdg+serde-devel-3.0.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xdg+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xdg+serde-devel}"
SRC_URI[x86_64_v2_rust-xdg+serde-devel.sha256sum] = "e8cddd02c6f216665445908253b19543854f344b5dae4d61ad61dd456338b5d2"

URI_x86_64_v2_rust-xdg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xdg-devel-3.0.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xdg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xdg-devel}"
SRC_URI[x86_64_v2_rust-xdg-devel.sha256sum] = "e11d392b0c326eb758eb9d60ec2479f78e36d76c1e703c4f7e260a4a1f8357ca"

URI_aarch64_rust-xdg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xdg+default-devel-3.0.0-2.el10_3.noarch.rpm;name=aarch64_rust-xdg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xdg+default-devel}"
SRC_URI[aarch64_rust-xdg+default-devel.sha256sum] = "451b875109d4f51d0e1f587b7f689e7407005523d64a151e7a82307bda126aa6"

URI_aarch64_rust-xdg+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xdg+serde-devel-3.0.0-2.el10_3.noarch.rpm;name=aarch64_rust-xdg+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xdg+serde-devel}"
SRC_URI[aarch64_rust-xdg+serde-devel.sha256sum] = "1b4530e4f9a2df436b2aad7ed629d19cc64407adef8a65e3decc0c4ce50a7896"

URI_aarch64_rust-xdg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xdg-devel-3.0.0-2.el10_3.noarch.rpm;name=aarch64_rust-xdg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xdg-devel}"
SRC_URI[aarch64_rust-xdg-devel.sha256sum] = "a96f14c512383cad752832d7f297601d34a47e50553d93dcaa1803234e974a7b"

RDEPENDS:rust-xdg+default-devel = " \
 cargo \
 rust-xdg-devel \
 "
RDEPENDS:rust-xdg+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-xdg-devel \
 "
RDEPENDS:rust-xdg-devel = " \
 cargo \
 rust \
 "
