# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-synstructure"
PV = "0.13.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-synstructure+default-devel \
 rust-synstructure+proc-macro-devel \
 rust-synstructure-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-synstructure-0.13.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cec075a224e3e55e5d041d28df4d4491f70517d9cf6d793838b4e9c87d11700"

URI_x86_64_v2_rust-synstructure+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-synstructure+default-devel-0.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-synstructure+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-synstructure+default-devel}"
SRC_URI[x86_64_v2_rust-synstructure+default-devel.sha256sum] = "4a962f5b7b3f2cfda71f3775add3972c126adccd5534cc9e2f233342f3be6f59"

URI_x86_64_v2_rust-synstructure+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-synstructure+proc-macro-devel-0.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-synstructure+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-synstructure+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-synstructure+proc-macro-devel.sha256sum] = "8f332f6137d7bfc837f742ca657cdf019e40f17cc69e0a5cef26671454c18243"

URI_x86_64_v2_rust-synstructure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-synstructure-devel-0.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-synstructure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-synstructure-devel}"
SRC_URI[x86_64_v2_rust-synstructure-devel.sha256sum] = "0ba032b30cc12fe90fd88f55dd3a60ac233ffde82b1702982163ddd6bc84fce3"

URI_aarch64_rust-synstructure+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-synstructure+default-devel-0.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-synstructure+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-synstructure+default-devel}"
SRC_URI[aarch64_rust-synstructure+default-devel.sha256sum] = "ca07aae79ae631eaf4f54aaabf083a479654799574d2481980505aa98fa58e49"

URI_aarch64_rust-synstructure+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-synstructure+proc-macro-devel-0.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-synstructure+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-synstructure+proc-macro-devel}"
SRC_URI[aarch64_rust-synstructure+proc-macro-devel.sha256sum] = "68f8121843d5e71b0373780e20be1058a02ee90cec862d9edad14ccc0cbc81a0"

URI_aarch64_rust-synstructure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-synstructure-devel-0.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-synstructure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-synstructure-devel}"
SRC_URI[aarch64_rust-synstructure-devel.sha256sum] = "e7978f1a982d94780512dcd7599ffb24743c61ce60a268fa212d58d27a8499fa"

RDEPENDS:rust-synstructure+default-devel = " \
 cargo \
 rust-synstructure+proc-macro-devel \
 rust-synstructure-devel \
 "
RDEPENDS:rust-synstructure+proc-macro-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-quote+proc-macro-devel \
 rust-syn+proc-macro-devel \
 rust-synstructure-devel \
 "
RDEPENDS:rust-synstructure-devel = " \
 cargo \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+visit-devel \
 rust-syn-devel \
 "
