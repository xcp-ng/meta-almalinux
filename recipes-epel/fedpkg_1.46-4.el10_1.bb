# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedpkg"
PV = "1.46"
PR = "4.el10_1"
PACKAGES = " \
 fedpkg \
 fedpkg-completion \
 fedpkg-stage \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedpkg-1.46-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06e72d985f34ff395848466680f9e115d4cee615aeff650d9cedff3c1ae27fff"

URI_x86_64_v2_fedpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedpkg-1.46-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fedpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedpkg}"
SRC_URI[x86_64_v2_fedpkg.sha256sum] = "504435ebb9b155aaac9e874747f25549c5b5c977de6752c5c73a68107aad34bd"

URI_x86_64_v2_fedpkg-completion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedpkg-completion-1.46-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fedpkg-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedpkg-completion}"
SRC_URI[x86_64_v2_fedpkg-completion.sha256sum] = "3a05ed07a92113591229db70681775a42b79493506cd5ea92af24f09d4cd6d6e"

URI_x86_64_v2_fedpkg-stage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedpkg-stage-1.46-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fedpkg-stage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedpkg-stage}"
SRC_URI[x86_64_v2_fedpkg-stage.sha256sum] = "07b506a1be2c04bd8e82851d748861b0493fd8059014986c00324c327375d4e9"

URI_aarch64_fedpkg = "${EPEL_MIRROR}/aarch64/Packages/f/fedpkg-1.46-4.el10_1.noarch.rpm;name=aarch64_fedpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedpkg}"
SRC_URI[aarch64_fedpkg.sha256sum] = "a77f32a1c486b15396bab2db4bcb14688aa4a944364680355b9f9b02c262ff51"

URI_aarch64_fedpkg-completion = "${EPEL_MIRROR}/aarch64/Packages/f/fedpkg-completion-1.46-4.el10_1.noarch.rpm;name=aarch64_fedpkg-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedpkg-completion}"
SRC_URI[aarch64_fedpkg-completion.sha256sum] = "bf838e03c62ea857ba0358114810a4acf5d08a8d6c1da2181dc0cd35c664eefa"

URI_aarch64_fedpkg-stage = "${EPEL_MIRROR}/aarch64/Packages/f/fedpkg-stage-1.46-4.el10_1.noarch.rpm;name=aarch64_fedpkg-stage;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedpkg-stage}"
SRC_URI[aarch64_fedpkg-stage.sha256sum] = "e1a353c28148d2010d0b68497709168902e192f7ddfc0bbc35a6eae4679a9ef5"

RDEPENDS:fedpkg = " \
 bodhi-client \
 koji \
 python3 \
 python3-argcomplete \
 python3-bugzilla \
 python3-distro \
 python3-openidc-client \
 python3-rpkg \
 redhat-rpm-config \
 "
RDEPENDS:fedpkg-completion = " \
 fedpkg \
 "
RDEPENDS:fedpkg-stage = " \
 fedpkg \
 python3 \
 "
