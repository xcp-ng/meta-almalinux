# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcap"
PV = "2.69"
PR = "7.el10.0.1"
PACKAGES:x86_64_v2 = " \
 libcap \
 libcap-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libcap-2.69-7.el10.0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e6d2ceb4b5c0b66943023262b8df7710156f49351606ec4780271bfbec250f4"

URI_x86_64_v2_libcap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcap-2.69-7.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_libcap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap}"
SRC_URI[x86_64_v2_libcap.sha256sum] = "5e7b6c5cb21b9e465671a7e24205fd732b77c2bb663d5930b7f8f4041c789ecb"

URI_x86_64_v2_libcap-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcap-devel-2.69-7.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_libcap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap-devel}"
SRC_URI[x86_64_v2_libcap-devel.sha256sum] = "0650e9dca1d68d800347696445616b9b6a526271ed58f204e41a8e31dde66dda"

RDEPENDS:libcap = " \
 glibc \
 libgcc \
 pam-libs \
 "
RDEPENDS:libcap-devel = " \
 libcap \
 pkgconf-pkg-config \
 "
