# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-WWW-Twilio-TwiML"
PV = "1.05"
PR = "27.el10_0"
PACKAGES = " \
 perl-WWW-Twilio-TwiML \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-WWW-Twilio-TwiML-1.05-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb633fe485044dec029ffa9095e004e9608edbf065f6d58001dbff1e5ced4308"

URI_x86_64_v2_perl-WWW-Twilio-TwiML = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-WWW-Twilio-TwiML-1.05-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-WWW-Twilio-TwiML;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-WWW-Twilio-TwiML}"
SRC_URI[x86_64_v2_perl-WWW-Twilio-TwiML.sha256sum] = "aa42520c7a7db38f5e5cfa93e82c7f9a805c373478dab482fcde79d2972cb171"

URI_aarch64_perl-WWW-Twilio-TwiML = "${EPEL_MIRROR}/aarch64/Packages/p/perl-WWW-Twilio-TwiML-1.05-27.el10_0.noarch.rpm;name=aarch64_perl-WWW-Twilio-TwiML;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-WWW-Twilio-TwiML}"
SRC_URI[aarch64_perl-WWW-Twilio-TwiML.sha256sum] = "0db2e917d7f2d13fbd4c67e92d0d69202ef0bdfe5ae3a7939a55ff25ecc83c9f"

RDEPENDS:perl-WWW-Twilio-TwiML = " \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-libs \
 "
