# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cln"
PV = "1.3.6"
PR = "6.el10_0"
PACKAGES = " \
 cln \
 cln-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cln-1.3.6-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12435fc069e3af188d913044d882207314f7ab4ad0f71a8ef5282728ab149d3e"

URI_x86_64_v2_cln = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cln-1.3.6-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cln;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cln}"
SRC_URI[x86_64_v2_cln.sha256sum] = "a87ad4a1d297a4ffe884c5cb0ec6c866d97e9a422fa28be71f480087fdbcb8a7"

URI_x86_64_v2_cln-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cln-devel-1.3.6-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cln-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cln-devel}"
SRC_URI[x86_64_v2_cln-devel.sha256sum] = "5a020dedf767df8053893b2c67dabbde36a98b61f5f9881eac580dbab5e6600e"

URI_aarch64_cln = "${EPEL_MIRROR}/aarch64/Packages/c/cln-1.3.6-6.el10_0.aarch64.rpm;name=aarch64_cln;unpack=0"
SRC_URI:append = " ${URI_aarch64_cln}"
SRC_URI[aarch64_cln.sha256sum] = "50b2a97f3bd9e89d7916cadd43ce5940afacec587217ed80f09bbad78bc16a1f"

URI_aarch64_cln-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cln-devel-1.3.6-6.el10_0.aarch64.rpm;name=aarch64_cln-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cln-devel}"
SRC_URI[aarch64_cln-devel.sha256sum] = "d99c5975fa51cdd97f3ee3fa3a8a23d2036ac9a63b91a0a509da12754adc9ec8"

RDEPENDS:cln = " \
 glibc \
 gmp \
 libgcc \
 libstdc++ \
 "
RDEPENDS:cln-devel = " \
 cln \
 gmp-devel \
 pkgconf-pkg-config \
 "
