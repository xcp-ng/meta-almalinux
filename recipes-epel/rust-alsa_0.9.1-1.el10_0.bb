# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-alsa"
PV = "0.9.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-alsa+default-devel \
 rust-alsa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-alsa-0.9.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66b161617c42fbd1c90e0899ff77d36a3d6ff98c069a848af3809b0d86102fdf"

URI_x86_64_v2_rust-alsa+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alsa+default-devel-0.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alsa+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-alsa+default-devel}"
SRC_URI[x86_64_v2_rust-alsa+default-devel.sha256sum] = "95f60881e9131479fc05f2b9c5daac5b17c59d34cec30de9b4f9e7f4058d50d0"

URI_x86_64_v2_rust-alsa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alsa-devel-0.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alsa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-alsa-devel}"
SRC_URI[x86_64_v2_rust-alsa-devel.sha256sum] = "56617ba2d6a41b22b814615a5efba8ca1f49f91bf37afe0e3fdac975b4f09f56"

URI_aarch64_rust-alsa+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-alsa+default-devel-0.9.1-1.el10_0.noarch.rpm;name=aarch64_rust-alsa+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-alsa+default-devel}"
SRC_URI[aarch64_rust-alsa+default-devel.sha256sum] = "cd72dcb2fd90d35b200e9fe98887ebe0f68c63450becf5082efce5cd09021b88"

URI_aarch64_rust-alsa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-alsa-devel-0.9.1-1.el10_0.noarch.rpm;name=aarch64_rust-alsa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-alsa-devel}"
SRC_URI[aarch64_rust-alsa-devel.sha256sum] = "469ef0e705f80c05cb451fb144d296badf5685f2f562c4782212678988671136"

RDEPENDS:rust-alsa+default-devel = " \
 cargo \
 rust-alsa-devel \
 "
RDEPENDS:rust-alsa-devel = " \
 cargo \
 rust-alsa-sys+default-devel \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 "
