# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pipewire-epel"
PV = "1.4.11"
PR = "4.el10_3"
PACKAGES = " \
 pipewire-module-filter-chain-lv2 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pipewire-epel-1.4.11-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "330a6c4e76baa2a44354f4b8651c9036416e658fe1fc278ea0d97f90e7244e1c"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - pipewire-module-filter-chain-lv2: pipewire-libs(x86-64) = 1.4.11-1.el10

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - pipewire-module-filter-chain-lv2: pipewire-libs(aarch-64) = 1.4.11-1.el10

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pipewire-module-filter-chain-lv2-1.4.11-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pipewire-module-filter-chain-lv2;unpack=0"
SRC_URI[x86_64_v2_pipewire-module-filter-chain-lv2.sha256sum] = "5e191e5aa1a9e919f1d63f9bc5a4e2656d10fef6b426193bf4d745d71099de04"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pipewire-module-filter-chain-lv2-1.4.11-4.el10_3.aarch64.rpm;name=aarch64_pipewire-module-filter-chain-lv2;unpack=0"
SRC_URI[aarch64_pipewire-module-filter-chain-lv2.sha256sum] = "b2c5380fb4da8ab6e515dc7f3eb51b73872a5235f38b931f515f1d765849a101"

RDEPENDS:pipewire-module-filter-chain-lv2 = " \
 glibc \
 lilv-libs \
 "
