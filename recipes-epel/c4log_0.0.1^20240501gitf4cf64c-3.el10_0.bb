# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c4log"
PV = "0.0.1^20240501gitf4cf64c"
PR = "3.el10_0"
PACKAGES = " \
 c4log \
 c4log-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/c4log-0.0.1^20240501gitf4cf64c-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "146d0b6c7f04ce9df18b61e6f7d4113ee7895449e3f03f7a4fc1e7c34215e0af"

URI_x86_64_v2_c4log = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c4log-0.0.1^20240501gitf4cf64c-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c4log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c4log}"
SRC_URI[x86_64_v2_c4log.sha256sum] = "5880c1b88706f63c2e6e7c14ebbce5d25ccb6d1951fa05086dcc0ad971431949"

URI_x86_64_v2_c4log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c4log-devel-0.0.1^20240501gitf4cf64c-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c4log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c4log-devel}"
SRC_URI[x86_64_v2_c4log-devel.sha256sum] = "f6a51904f96f256c41b4f068f2cd20e3773943eea2c9ba66d01dcbdb5a5f6a5c"

URI_aarch64_c4log = "${EPEL_MIRROR}/aarch64/Packages/c/c4log-0.0.1^20240501gitf4cf64c-3.el10_0.aarch64.rpm;name=aarch64_c4log;unpack=0"
SRC_URI:append = " ${URI_aarch64_c4log}"
SRC_URI[aarch64_c4log.sha256sum] = "40a3187bbc74143bf83b3a0792db191f2de6d14263e5d37a153a328043cb78c8"

URI_aarch64_c4log-devel = "${EPEL_MIRROR}/aarch64/Packages/c/c4log-devel-0.0.1^20240501gitf4cf64c-3.el10_0.aarch64.rpm;name=aarch64_c4log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_c4log-devel}"
SRC_URI[aarch64_c4log-devel.sha256sum] = "557961f72130e4648ca060b4ab2277658848dbaf5af454f7aed17b53d51c8de5"

RDEPENDS:c4log = " \
 c4core \
 glibc \
 libstdc++ \
 "
RDEPENDS:c4log-devel = " \
 c4core-devel \
 c4log \
 cmake-filesystem \
 "
