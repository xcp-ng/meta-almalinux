# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uglify-js"
PV = "3.19.3"
PR = "1.el10_0"
PACKAGES = " \
 js-uglify \
 uglify-js \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uglify-js-3.19.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f79b691518e27ff1f7dec45b0336b0c369f72567a6063453929f38e0eeb09499"

URI_x86_64_v2_js-uglify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/js-uglify-3.19.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_js-uglify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_js-uglify}"
SRC_URI[x86_64_v2_js-uglify.sha256sum] = "dadb41eb8b01cf146679af3ee11e3df830911378d64a15df583a3bbe4bfedb80"

URI_x86_64_v2_uglify-js = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uglify-js-3.19.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_uglify-js;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uglify-js}"
SRC_URI[x86_64_v2_uglify-js.sha256sum] = "c8d2977a0849f258edb8df1505f07d9942aa591f5bc9a10877dcbe41cf70e9e7"

URI_aarch64_js-uglify = "${EPEL_MIRROR}/aarch64/Packages/j/js-uglify-3.19.3-1.el10_0.noarch.rpm;name=aarch64_js-uglify;unpack=0"
SRC_URI:append = " ${URI_aarch64_js-uglify}"
SRC_URI[aarch64_js-uglify.sha256sum] = "f04c26a85bb7205ade620e55f997df202f70eeb7681c01cd6aac52c7a49a61a0"

URI_aarch64_uglify-js = "${EPEL_MIRROR}/aarch64/Packages/u/uglify-js-3.19.3-1.el10_0.noarch.rpm;name=aarch64_uglify-js;unpack=0"
SRC_URI:append = " ${URI_aarch64_uglify-js}"
SRC_URI[aarch64_uglify-js.sha256sum] = "ca05bd1ce19f3af174b5c1ec85a1f2d4b274da4a0d6ed6230cfaa494af255ad8"

RDEPENDS:js-uglify = " \
 web-assets-filesystem \
 "
RDEPENDS:uglify-js = " \
 js-uglify \
 nodejs \
 "
