# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libcramjam"
PV = "0.7.0"
PR = "7.el10_0"
PACKAGES:x86_64_v2 = " \
 libcramjam \
 libcramjam-devel \
 rust-libcramjam+brotli-devel \
 rust-libcramjam+bzip2-devel \
 rust-libcramjam+capi-devel \
 rust-libcramjam+default-devel \
 rust-libcramjam+deflate-devel \
 rust-libcramjam+deflate-shared-devel \
 rust-libcramjam+gzip-devel \
 rust-libcramjam+gzip-shared-devel \
 rust-libcramjam+lz4-devel \
 rust-libcramjam+snappy-devel \
 rust-libcramjam+xz-devel \
 rust-libcramjam+xz-shared-devel \
 rust-libcramjam+zlib-devel \
 rust-libcramjam+zlib-shared-devel \
 rust-libcramjam+zstd-devel \
 rust-libcramjam-devel \
"
PACKAGES:aarch64 = " \
 rust-libcramjam+brotli-devel \
 rust-libcramjam+bzip2-devel \
 rust-libcramjam+capi-devel \
 rust-libcramjam+default-devel \
 rust-libcramjam+deflate-devel \
 rust-libcramjam+deflate-shared-devel \
 rust-libcramjam+gzip-devel \
 rust-libcramjam+gzip-shared-devel \
 rust-libcramjam+lz4-devel \
 rust-libcramjam+snappy-devel \
 rust-libcramjam+xz-devel \
 rust-libcramjam+xz-shared-devel \
 rust-libcramjam+zlib-devel \
 rust-libcramjam+zlib-shared-devel \
 rust-libcramjam+zstd-devel \
 rust-libcramjam-devel \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libcramjam-0.7.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9f397f1aba8c95be6ac57431126ebcead3c3141e6b7efa65193fd82fb10c15a"

URI_x86_64_v2_libcramjam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcramjam-0.7.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcramjam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcramjam}"
SRC_URI[x86_64_v2_libcramjam.sha256sum] = "56bd9b823d17e5303fb492796c1b36f234b2a88611c9495c2bba92c3f2d19eb6"

URI_x86_64_v2_libcramjam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcramjam-devel-0.7.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcramjam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcramjam-devel}"
SRC_URI[x86_64_v2_libcramjam-devel.sha256sum] = "a0579502ef04e3305e41237290bc4b0d123182503cf52c4e416684f8fa28cd6a"

URI_x86_64_v2_rust-libcramjam+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+brotli-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+brotli-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+brotli-devel.sha256sum] = "6a43cde939458535102b2591e635ea48ab7ca9381c5ad5831d0345509cc59604"

URI_x86_64_v2_rust-libcramjam+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+bzip2-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+bzip2-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+bzip2-devel.sha256sum] = "7ff459c3f41736dae6a95e317fb551ea58ab4a398c10437d35dabe6af7b22c69"

URI_x86_64_v2_rust-libcramjam+capi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+capi-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+capi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+capi-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+capi-devel.sha256sum] = "8cb0bdc647a498ffa761b10169fe011fa6bdc1760197e0f76503f16383b49d92"

URI_x86_64_v2_rust-libcramjam+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+default-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+default-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+default-devel.sha256sum] = "474853f3c4459cbcf2c5292bcae16bba749193029d9a680bddb559950a7ccfe0"

URI_x86_64_v2_rust-libcramjam+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+deflate-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+deflate-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+deflate-devel.sha256sum] = "4dd682f391a9b9e4331c7259c9e0c3f8b90c18564b57e025cb0fe0048cbbc5a0"

URI_x86_64_v2_rust-libcramjam+deflate-shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+deflate-shared-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+deflate-shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+deflate-shared-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+deflate-shared-devel.sha256sum] = "7e5335d4858dab6cab01c1840df41b779de091d5af214b966e2a05c67ec7a5d3"

URI_x86_64_v2_rust-libcramjam+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+gzip-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+gzip-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+gzip-devel.sha256sum] = "bd0a9d6722f6c3c3ce962f101bc0c69e814c2d568ba811f1ff92f1f989ac1169"

URI_x86_64_v2_rust-libcramjam+gzip-shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+gzip-shared-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+gzip-shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+gzip-shared-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+gzip-shared-devel.sha256sum] = "193e244603cb0752ceb8b659e56ce5840e3d7961a30b751367a357ad19df6792"

URI_x86_64_v2_rust-libcramjam+lz4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+lz4-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+lz4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+lz4-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+lz4-devel.sha256sum] = "11c347259b75ca961520369f1a1ba4f49bf04865711b4d101a645bb07277d967"

URI_x86_64_v2_rust-libcramjam+snappy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+snappy-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+snappy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+snappy-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+snappy-devel.sha256sum] = "504829a91baf45412781d1777cc7bb3ca14395c0bd9e090432b889354adad686"

URI_x86_64_v2_rust-libcramjam+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+xz-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+xz-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+xz-devel.sha256sum] = "73906d6354d8f90126077a6d1ce2031806e38259512bbb119623dd1b65121ad4"

URI_x86_64_v2_rust-libcramjam+xz-shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+xz-shared-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+xz-shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+xz-shared-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+xz-shared-devel.sha256sum] = "97af633d10b721dec38cd62da0125d9aa52ef2e1cfa4158a2b45f7aa3f74aa65"

URI_x86_64_v2_rust-libcramjam+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+zlib-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+zlib-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+zlib-devel.sha256sum] = "02fc36b00d3b3fff5cc2b5caf23212cd74d1c406a87082b50288fdfa388e8082"

URI_x86_64_v2_rust-libcramjam+zlib-shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+zlib-shared-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+zlib-shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+zlib-shared-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+zlib-shared-devel.sha256sum] = "108879d8d69c8ffdba852a423f5e284a8c0b51694c9950fcf66dbc75dde101ea"

URI_x86_64_v2_rust-libcramjam+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+zstd-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+zstd-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+zstd-devel.sha256sum] = "d80d8d87cad2b0339b46e6d01457be8e79f468baf4482590771e9cd6eb0d5078"

URI_x86_64_v2_rust-libcramjam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam-devel-0.7.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam-devel}"
SRC_URI[x86_64_v2_rust-libcramjam-devel.sha256sum] = "9fa4882268abf57cb79ed61543318be53e043abd1c548277079b489e223ef198"

URI_aarch64_rust-libcramjam+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+brotli-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+brotli-devel}"
SRC_URI[aarch64_rust-libcramjam+brotli-devel.sha256sum] = "7a831c263774abafe06d9070c3f81fe19c7dd4b6cced32f48af93267e2e7de07"

URI_aarch64_rust-libcramjam+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+bzip2-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+bzip2-devel}"
SRC_URI[aarch64_rust-libcramjam+bzip2-devel.sha256sum] = "1d20a893e118c7ba3f145231c964d1c7d2f4ec8b91c1d70eac879de00cfaaff4"

URI_aarch64_rust-libcramjam+capi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+capi-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+capi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+capi-devel}"
SRC_URI[aarch64_rust-libcramjam+capi-devel.sha256sum] = "aae8c837b57d58dda06feed3927bf1e520c9d495c3c3fd86891705f461689adf"

URI_aarch64_rust-libcramjam+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+default-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+default-devel}"
SRC_URI[aarch64_rust-libcramjam+default-devel.sha256sum] = "34c97b25199235fcf7a11bd3a75139df708138b40714b58939a3e76396eb0322"

URI_aarch64_rust-libcramjam+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+deflate-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+deflate-devel}"
SRC_URI[aarch64_rust-libcramjam+deflate-devel.sha256sum] = "f2559657f56f1358104541c97a7155a37f52bfdb8f180f2045b56daf75567141"

URI_aarch64_rust-libcramjam+deflate-shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+deflate-shared-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+deflate-shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+deflate-shared-devel}"
SRC_URI[aarch64_rust-libcramjam+deflate-shared-devel.sha256sum] = "530a1df4751d31584899d5520500ea55b0c17fa462bf9d563b441110d841d0ab"

URI_aarch64_rust-libcramjam+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+gzip-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+gzip-devel}"
SRC_URI[aarch64_rust-libcramjam+gzip-devel.sha256sum] = "cf6ad4ab6b275cdcced606da8669ed625e52ba0ecf998e20c76c85a5e277e4b7"

URI_aarch64_rust-libcramjam+gzip-shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+gzip-shared-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+gzip-shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+gzip-shared-devel}"
SRC_URI[aarch64_rust-libcramjam+gzip-shared-devel.sha256sum] = "171c88945b7cd6285cf53508708caa54df1bf975fb08e53adbf2dd8737a0f897"

URI_aarch64_rust-libcramjam+lz4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+lz4-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+lz4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+lz4-devel}"
SRC_URI[aarch64_rust-libcramjam+lz4-devel.sha256sum] = "60e56d6d549e080d561755175e97cb8ee043ac1fd2c4ad6b3251302a786d59ef"

URI_aarch64_rust-libcramjam+snappy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+snappy-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+snappy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+snappy-devel}"
SRC_URI[aarch64_rust-libcramjam+snappy-devel.sha256sum] = "0d9fdc555f85ffbf3659830c35c4552651a66645395011878377a2f3da44cbff"

URI_aarch64_rust-libcramjam+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+xz-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+xz-devel}"
SRC_URI[aarch64_rust-libcramjam+xz-devel.sha256sum] = "cc0ee6192cb827a1923f406c9c9c191f00cd440c62f5e00aca1f69a1d311222f"

URI_aarch64_rust-libcramjam+xz-shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+xz-shared-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+xz-shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+xz-shared-devel}"
SRC_URI[aarch64_rust-libcramjam+xz-shared-devel.sha256sum] = "4f30a3051d1cab7299a831d5e5dab07bc280f6f5f1cecdd356204e5785ddc78e"

URI_aarch64_rust-libcramjam+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+zlib-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+zlib-devel}"
SRC_URI[aarch64_rust-libcramjam+zlib-devel.sha256sum] = "a55fb55b916963e0b5c4f7fa034b65e41debcf217d8fddf447e3eb3c09470151"

URI_aarch64_rust-libcramjam+zlib-shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+zlib-shared-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+zlib-shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+zlib-shared-devel}"
SRC_URI[aarch64_rust-libcramjam+zlib-shared-devel.sha256sum] = "3e74d105a19aab1f502b0b913c4f516f8150045bdc7fcf5563313f5ab22f7d2d"

URI_aarch64_rust-libcramjam+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+zstd-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+zstd-devel}"
SRC_URI[aarch64_rust-libcramjam+zstd-devel.sha256sum] = "bdb6fab214c468620e46a000699272440c27cb42b6e194c933109749aa2ed16f"

URI_aarch64_rust-libcramjam-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam-devel-0.7.0-7.el10_0.noarch.rpm;name=aarch64_rust-libcramjam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam-devel}"
SRC_URI[aarch64_rust-libcramjam-devel.sha256sum] = "61c4442544c1ae9b556513156ccece5cc80b4c5b5ef0fe1cdd37a490414d9f2b"

RDEPENDS:libcramjam = " \
 bzip2-libs \
 glibc \
 libdeflate \
 libgcc \
 libzstd \
 lz4-libs \
 "
RDEPENDS:libcramjam-devel = " \
 libcramjam \
 pkgconf-pkg-config \
 "
RDEPENDS:rust-libcramjam+brotli-devel = " \
 cargo \
 rust-brotli+ffi-api-devel \
 rust-brotli+std-devel \
 rust-brotli-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+capi-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+default-devel = " \
 cargo \
 rust-libcramjam+brotli-devel \
 rust-libcramjam+bzip2-devel \
 rust-libcramjam+deflate-devel \
 rust-libcramjam+gzip-devel \
 rust-libcramjam+lz4-devel \
 rust-libcramjam+snappy-devel \
 rust-libcramjam+xz-devel \
 rust-libcramjam+zlib-devel \
 rust-libcramjam+zstd-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+deflate-devel = " \
 cargo \
 rust-libcramjam+deflate-shared-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+deflate-shared-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-libcramjam-devel \
 rust-libdeflate-sys+default-devel \
 rust-libdeflate-sys+dynamic-devel \
 rust-libdeflater+default-devel \
 "
RDEPENDS:rust-libcramjam+gzip-devel = " \
 cargo \
 rust-libcramjam+gzip-shared-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+gzip-shared-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-libcramjam-devel \
 rust-libdeflate-sys+default-devel \
 rust-libdeflate-sys+dynamic-devel \
 rust-libdeflater+default-devel \
 "
RDEPENDS:rust-libcramjam+lz4-devel = " \
 cargo \
 rust-libcramjam-devel \
 rust-lz4+default-devel \
 "
RDEPENDS:rust-libcramjam+snappy-devel = " \
 cargo \
 rust-libcramjam-devel \
 rust-snap+default-devel \
 "
RDEPENDS:rust-libcramjam+xz-devel = " \
 cargo \
 rust-libcramjam+xz-shared-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+xz-shared-devel = " \
 cargo \
 rust-libcramjam-devel \
 rust-xz2+default-devel \
 "
RDEPENDS:rust-libcramjam+zlib-devel = " \
 cargo \
 rust-libcramjam+zlib-shared-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+zlib-shared-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-libcramjam-devel \
 rust-libdeflate-sys+default-devel \
 rust-libdeflate-sys+dynamic-devel \
 rust-libdeflater+default-devel \
 "
RDEPENDS:rust-libcramjam+zstd-devel = " \
 cargo \
 rust-libcramjam-devel \
 rust-zstd+default-devel \
 "
RDEPENDS:rust-libcramjam-devel = " \
 cargo \
 "
