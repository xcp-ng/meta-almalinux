# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lv2-sys"
PV = "2.0.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-lv2-sys+default-devel \
 rust-lv2-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lv2-sys-2.0.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8714d1c36bd3eef4e3c0a396ab1b2f06b0a7ba52801b1a060ecefbc450c6b274"

URI_x86_64_v2_rust-lv2-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-sys+default-devel-2.0.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-sys+default-devel}"
SRC_URI[x86_64_v2_rust-lv2-sys+default-devel.sha256sum] = "569fb233cd6fa8f903d7bbd7b5680bb228cf5a22382684f879b9f8a10b7b6fd3"

URI_x86_64_v2_rust-lv2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-sys-devel-2.0.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-sys-devel}"
SRC_URI[x86_64_v2_rust-lv2-sys-devel.sha256sum] = "b133c45c313dba4614450aa9ff54084e4ef71691d955c41bd13aafc34de05c22"

URI_aarch64_rust-lv2-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-sys+default-devel-2.0.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-sys+default-devel}"
SRC_URI[aarch64_rust-lv2-sys+default-devel.sha256sum] = "c544ad6cb271c16e3f8c326bfdbc8151cc94ad4adf972fda0d615f700e43854b"

URI_aarch64_rust-lv2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-sys-devel-2.0.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-sys-devel}"
SRC_URI[aarch64_rust-lv2-sys-devel.sha256sum] = "e4137ebded360aeb1b60abca3a2c8041c83c043ab5bca9a86eb72cc4bace0bf3"

RDEPENDS:rust-lv2-sys+default-devel = " \
 cargo \
 rust-lv2-sys-devel \
 "
RDEPENDS:rust-lv2-sys-devel = " \
 cargo \
 "
