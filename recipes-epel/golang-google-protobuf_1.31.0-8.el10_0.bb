# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-google-protobuf"
PV = "1.31.0"
PR = "8.el10_0"
PACKAGES = " \
 golang-google-protobuf \
 golang-google-protobuf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-google-protobuf-1.31.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0e4f611a3efeb3e738dd4691b7e22cc382ec60a948589a0b12ce2947362cb8c"

URI_x86_64_v2_golang-google-protobuf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-google-protobuf-1.31.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-google-protobuf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-google-protobuf}"
SRC_URI[x86_64_v2_golang-google-protobuf.sha256sum] = "180a1f058fd696437eb49d95d502f8e9fff21db868fa85890876427c781e42a3"

URI_x86_64_v2_golang-google-protobuf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-google-protobuf-devel-1.31.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-google-protobuf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-google-protobuf-devel}"
SRC_URI[x86_64_v2_golang-google-protobuf-devel.sha256sum] = "d7039caad92dac15a6ab9941b9aab4138afa5346bb0de4bf09efac0b52145c8c"

URI_aarch64_golang-google-protobuf = "${EPEL_MIRROR}/aarch64/Packages/g/golang-google-protobuf-1.31.0-8.el10_0.aarch64.rpm;name=aarch64_golang-google-protobuf;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-google-protobuf}"
SRC_URI[aarch64_golang-google-protobuf.sha256sum] = "46f2c5426189dcaf351946dccb05886e6037c7999b217540caec874a639dba40"

URI_aarch64_golang-google-protobuf-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-google-protobuf-devel-1.31.0-8.el10_0.noarch.rpm;name=aarch64_golang-google-protobuf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-google-protobuf-devel}"
SRC_URI[aarch64_golang-google-protobuf-devel.sha256sum] = "4f8afd78eb9eb3ffe4a5caeeeca5cf4cbc1a4803da89e9ec6279192e5b3436a5"

RDEPENDS:golang-google-protobuf = " \
 glibc \
 protobuf \
 "
RDEPENDS:golang-google-protobuf-devel = " \
 go-filesystem \
 golang-github-google-cmp-devel \
 "
