# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cpp-httplib"
PV = "0.18.0"
PR = "1.el10_0"
PACKAGES = " \
 cpp-httplib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cpp-httplib-0.18.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f94207d8c9ab43af011fd456b73558093612d5c7e6403844b0d75fbeb49c93ce"

URI_x86_64_v2_cpp-httplib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cpp-httplib-devel-0.18.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cpp-httplib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpp-httplib-devel}"
SRC_URI[x86_64_v2_cpp-httplib-devel.sha256sum] = "5bd6d915de086261648e641a6d6d9026aef034657786f238dcaaf8599740be52"

URI_aarch64_cpp-httplib-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cpp-httplib-devel-0.18.0-1.el10_0.aarch64.rpm;name=aarch64_cpp-httplib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpp-httplib-devel}"
SRC_URI[aarch64_cpp-httplib-devel.sha256sum] = "c7058e8eab36afe41e5df9ced6f383b91601097b6a69b357ae1ece853516226d"

RDEPENDS:cpp-httplib-devel = " \
 brotli-devel \
 cmake-filesystem \
 openssl-devel \
 zlib-ng-compat-devel \
 "
