# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-multer"
PV = "3.1.0"
PR = "3.el10_1"
PACKAGES = " \
 rust-multer+all-devel \
 rust-multer+default-devel \
 rust-multer+json-devel \
 rust-multer+log-devel \
 rust-multer+serde-devel \
 rust-multer+serde_json-devel \
 rust-multer+tokio-devel \
 rust-multer+tokio-io-devel \
 rust-multer+tokio-util-devel \
 rust-multer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-multer-3.1.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebccbafddd1d1c4f102d34248630e04b8873482e3259772b42c20ddcfbb9ba1d"

URI_x86_64_v2_rust-multer+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+all-devel-3.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+all-devel}"
SRC_URI[x86_64_v2_rust-multer+all-devel.sha256sum] = "d8739087debaa6dc0a4b9722cb3831a38a3cc7926f44fce2b70362a75e29cc7b"

URI_x86_64_v2_rust-multer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+default-devel-3.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+default-devel}"
SRC_URI[x86_64_v2_rust-multer+default-devel.sha256sum] = "acd2da087ecef890148e6096ff22e3bc8896d39ee4e61de5324c1fb141e6723f"

URI_x86_64_v2_rust-multer+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+json-devel-3.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+json-devel}"
SRC_URI[x86_64_v2_rust-multer+json-devel.sha256sum] = "943ad4132f165c37855eb8f1f7339173740b18bfb985469714cb9b807826ea53"

URI_x86_64_v2_rust-multer+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+log-devel-3.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+log-devel}"
SRC_URI[x86_64_v2_rust-multer+log-devel.sha256sum] = "7043e08bdeda55eacc6ea0a40500f7c3af03e2feaff92f716136ec23b55506de"

URI_x86_64_v2_rust-multer+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+serde-devel-3.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+serde-devel}"
SRC_URI[x86_64_v2_rust-multer+serde-devel.sha256sum] = "78d333445297f70b476d86e09b0268b5043933457a030e4c2e6d7a3076dffe8b"

URI_x86_64_v2_rust-multer+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+serde_json-devel-3.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+serde_json-devel}"
SRC_URI[x86_64_v2_rust-multer+serde_json-devel.sha256sum] = "511ccb645436d5890d95efbfb3d43a1da0af483cf6f745fcea9fae1d6f2610b6"

URI_x86_64_v2_rust-multer+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+tokio-devel-3.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+tokio-devel}"
SRC_URI[x86_64_v2_rust-multer+tokio-devel.sha256sum] = "6340def12781efc75a5c179457f80887827b583b503eb86fd7f49368f811bed1"

URI_x86_64_v2_rust-multer+tokio-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+tokio-io-devel-3.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+tokio-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+tokio-io-devel}"
SRC_URI[x86_64_v2_rust-multer+tokio-io-devel.sha256sum] = "408888f35dd7a9ee82a26105dc11d55270b2c2cd6d235efa92fef1c9fb002ed3"

URI_x86_64_v2_rust-multer+tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+tokio-util-devel-3.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+tokio-util-devel}"
SRC_URI[x86_64_v2_rust-multer+tokio-util-devel.sha256sum] = "779bd22d7063e405ba4e43c47d63a7965d7496f7fcbf77e54aac713ce40b4a91"

URI_x86_64_v2_rust-multer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer-devel-3.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer-devel}"
SRC_URI[x86_64_v2_rust-multer-devel.sha256sum] = "ba9cd3dfe98908d36990a8ded34c18ef8312a2c3f6995d2043733089b6c42a25"

URI_aarch64_rust-multer+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+all-devel-3.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-multer+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+all-devel}"
SRC_URI[aarch64_rust-multer+all-devel.sha256sum] = "27125c0d64e02ef43ab2fe58fe24d6d351b615728e30b79f5efa66b9eb780639"

URI_aarch64_rust-multer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+default-devel-3.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-multer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+default-devel}"
SRC_URI[aarch64_rust-multer+default-devel.sha256sum] = "889525d4473be9e320330a7bf165acee495ad62929951b406aa74f022bfb26ed"

URI_aarch64_rust-multer+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+json-devel-3.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-multer+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+json-devel}"
SRC_URI[aarch64_rust-multer+json-devel.sha256sum] = "6831224814dc0516e23e0ec60f8f2cfaa0c788ea7e8a99cf1042e6650e614280"

URI_aarch64_rust-multer+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+log-devel-3.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-multer+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+log-devel}"
SRC_URI[aarch64_rust-multer+log-devel.sha256sum] = "1f92ecf2966963b1842c3005499ed16d406521d1995972823bd2fced09c3a5e8"

URI_aarch64_rust-multer+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+serde-devel-3.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-multer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+serde-devel}"
SRC_URI[aarch64_rust-multer+serde-devel.sha256sum] = "edfd39bbb1f57859d980e3236a2cffa3786f539b7094d489eda841a24a869d63"

URI_aarch64_rust-multer+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+serde_json-devel-3.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-multer+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+serde_json-devel}"
SRC_URI[aarch64_rust-multer+serde_json-devel.sha256sum] = "8374515dfa8ff9b028a549aace66d7c28b07aea475c39985e49c872a7b58d259"

URI_aarch64_rust-multer+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+tokio-devel-3.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-multer+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+tokio-devel}"
SRC_URI[aarch64_rust-multer+tokio-devel.sha256sum] = "17263c84574765e3a97f8bbefbdefbba041b833ddd8e87f9472985bf683ee032"

URI_aarch64_rust-multer+tokio-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+tokio-io-devel-3.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-multer+tokio-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+tokio-io-devel}"
SRC_URI[aarch64_rust-multer+tokio-io-devel.sha256sum] = "ca26a35eba4f04b39d7c983cfe2eaa4e13f28761197ab7e4f93caa3025e7cb83"

URI_aarch64_rust-multer+tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+tokio-util-devel-3.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-multer+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+tokio-util-devel}"
SRC_URI[aarch64_rust-multer+tokio-util-devel.sha256sum] = "d6d82e11ca611f44684375fa208e8c3471d6a8487a2d38413d2b468c34120af6"

URI_aarch64_rust-multer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer-devel-3.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-multer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer-devel}"
SRC_URI[aarch64_rust-multer-devel.sha256sum] = "d8bb66d53eea17bfc2527de7baad33930e07b5bf052e1b3acc273bf50472ac2a"

RDEPENDS:rust-multer+all-devel = " \
 cargo \
 rust-multer+json-devel \
 rust-multer-devel \
 "
RDEPENDS:rust-multer+default-devel = " \
 cargo \
 rust-multer-devel \
 "
RDEPENDS:rust-multer+json-devel = " \
 cargo \
 rust-multer+serde-devel \
 rust-multer+serde_json-devel \
 rust-multer-devel \
 "
RDEPENDS:rust-multer+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-multer-devel \
 "
RDEPENDS:rust-multer+serde-devel = " \
 cargo \
 rust-multer-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-multer+serde_json-devel = " \
 cargo \
 rust-multer-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-multer+tokio-devel = " \
 cargo \
 rust-multer-devel \
 rust-tokio+default-devel \
 "
RDEPENDS:rust-multer+tokio-io-devel = " \
 cargo \
 rust-multer+tokio-devel \
 rust-multer+tokio-util-devel \
 rust-multer-devel \
 "
RDEPENDS:rust-multer+tokio-util-devel = " \
 cargo \
 rust-multer-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+io-devel \
 "
RDEPENDS:rust-multer-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-encoding_rs+default-devel \
 rust-futures-util-devel \
 rust-http+default-devel \
 rust-httparse+default-devel \
 rust-memchr+default-devel \
 rust-mime+default-devel \
 rust-spin+spin_mutex-devel \
 rust-spin-devel \
 rust-version_check+default-devel \
 "
