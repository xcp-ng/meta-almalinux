# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx-gen"
PV = "0.7.142"
PR = "1.el10_0"
PACKAGES = " \
 rust-cxx-gen+default-devel \
 rust-cxx-gen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-gen-0.7.142-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e7fe28678fdb0083104c81f78c3ace10a7aba294eb66bce225fe29989c10918"

URI_x86_64_v2_rust-cxx-gen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-gen+default-devel-0.7.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-gen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-gen+default-devel}"
SRC_URI[x86_64_v2_rust-cxx-gen+default-devel.sha256sum] = "1384e41788b5e4754a6b3c72d5a203e671d4f26a242c4bb54f193dbe15679fbf"

URI_x86_64_v2_rust-cxx-gen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-gen-devel-0.7.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-gen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-gen-devel}"
SRC_URI[x86_64_v2_rust-cxx-gen-devel.sha256sum] = "2405b2b8545e4e254029247427aa006db550910cf364e3529608473452e63afc"

URI_aarch64_rust-cxx-gen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-gen+default-devel-0.7.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxx-gen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-gen+default-devel}"
SRC_URI[aarch64_rust-cxx-gen+default-devel.sha256sum] = "f822c66ef90b18d381fa7fa00d745277f471e2d40db381d4d5afa08e31414661"

URI_aarch64_rust-cxx-gen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-gen-devel-0.7.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxx-gen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-gen-devel}"
SRC_URI[aarch64_rust-cxx-gen-devel.sha256sum] = "130c88d4668d54ce39925534c2e6d212e648ba3cd34168b8834ae66f680251f6"

RDEPENDS:rust-cxx-gen+default-devel = " \
 cargo \
 rust-cxx-gen-devel \
 "
RDEPENDS:rust-cxx-gen-devel = " \
 cargo \
 rust \
 rust-codespan-reporting+default-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
