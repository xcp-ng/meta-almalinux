# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nettle"
PV = "3.10.1"
PR = "1.el10"
PACKAGES = " \
 nettle \
 nettle-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nettle-3.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62eb9fe6a221aab60ea8b6c2991fab50e60d4dc0d2325ec12d1e81d72c9a7ebd"

URI_x86_64_v2_nettle = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nettle-3.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_nettle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nettle}"
SRC_URI[x86_64_v2_nettle.sha256sum] = "04a7913d1348dfa5c83b97f8167b3f2c2ff377880c04b63ec44303ca928c5ae5"

URI_x86_64_v2_nettle-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nettle-devel-3.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_nettle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nettle-devel}"
SRC_URI[x86_64_v2_nettle-devel.sha256sum] = "7b4bdd7b91b7ad9314fbf30828c327c4e01eef84069cf1e64d5846ca19be26fb"

URI_aarch64_nettle = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nettle-3.10.1-1.el10.aarch64.rpm;name=aarch64_nettle;unpack=0"
SRC_URI:append = " ${URI_aarch64_nettle}"
SRC_URI[aarch64_nettle.sha256sum] = "e0777ee79e0d7ef74964034bc439656ad5bb1eae3fdd27d8c16ed7a699b6ba7a"

URI_aarch64_nettle-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nettle-devel-3.10.1-1.el10.aarch64.rpm;name=aarch64_nettle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nettle-devel}"
SRC_URI[aarch64_nettle-devel.sha256sum] = "494e2abcd28d1db075a05f7e09d32cd39aa671cf03a780909b60ed3d25bfbe20"

RDEPENDS:nettle = " \
 glibc \
 "
RDEPENDS:nettle-devel = " \
 gmp-devel \
 nettle \
 nettle-devel \
 pkgconf-pkg-config \
 "
