# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_dir"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_dir+default-devel \
 rust-uu_dir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_dir-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32d0cd811b4edd811803f3e4df585155d1d2669c7ce155250d4547a245fb803a"

URI_x86_64_v2_rust-uu_dir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_dir+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_dir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_dir+default-devel}"
SRC_URI[x86_64_v2_rust-uu_dir+default-devel.sha256sum] = "ad6fcbbc620a2af34203efb19665f030c666740ad7967ba27ab1b5d729540bfe"

URI_x86_64_v2_rust-uu_dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_dir-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_dir-devel}"
SRC_URI[x86_64_v2_rust-uu_dir-devel.sha256sum] = "f960bde8fec228184000122ed796c1a8741edf3ddcf953b9d7f2adaf35965015"

URI_aarch64_rust-uu_dir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_dir+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_dir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_dir+default-devel}"
SRC_URI[aarch64_rust-uu_dir+default-devel.sha256sum] = "f2be44778f57d856693a58ab33e234957130bc847fa4ec150269b3d94b721d73"

URI_aarch64_rust-uu_dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_dir-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_dir-devel}"
SRC_URI[aarch64_rust-uu_dir-devel.sha256sum] = "18bfbe4420c5327c0c567890e0b7c0c81de2559f5256a9a99d97c0c5af6068dd"

RDEPENDS:rust-uu_dir+default-devel = " \
 cargo \
 rust-uu_dir-devel \
 "
RDEPENDS:rust-uu_dir-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+env-devel \
 rust-clap+wrap_help-devel \
 rust-uu_ls+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+fs-devel \
 rust-uucore+quoting-style-devel \
 "
