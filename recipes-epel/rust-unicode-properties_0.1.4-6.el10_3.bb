# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-properties"
PV = "0.1.4"
PR = "6.el10_3"
PACKAGES = " \
 rust-unicode-properties+default-devel \
 rust-unicode-properties+emoji-devel \
 rust-unicode-properties+general-category-devel \
 rust-unicode-properties-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-properties-0.1.4-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aabc2234eeae43ecbdffb41dee3423fdfb034bfc194165743ea88cb41027fe0b"

URI_x86_64_v2_rust-unicode-properties+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-properties+default-devel-0.1.4-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-properties+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-properties+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-properties+default-devel.sha256sum] = "ee23b8a384fa31ae1ea1e5777d6970af3a9d76d140c6db1d4500d73da30f0748"

URI_x86_64_v2_rust-unicode-properties+emoji-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-properties+emoji-devel-0.1.4-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-properties+emoji-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-properties+emoji-devel}"
SRC_URI[x86_64_v2_rust-unicode-properties+emoji-devel.sha256sum] = "e6246f26b86b583bc6c875e41189152e26989da66d315aab6400b2c2c72ff709"

URI_x86_64_v2_rust-unicode-properties+general-category-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-properties+general-category-devel-0.1.4-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-properties+general-category-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-properties+general-category-devel}"
SRC_URI[x86_64_v2_rust-unicode-properties+general-category-devel.sha256sum] = "e0161866efcf5f329013f5fdcc6e78345182920c646e7bb52cf74fe3ea5083fe"

URI_x86_64_v2_rust-unicode-properties-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-properties-devel-0.1.4-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-properties-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-properties-devel}"
SRC_URI[x86_64_v2_rust-unicode-properties-devel.sha256sum] = "95dbd83fc35a5ca7154e94012c013e2b33aa78c5d79ae32a8f870dffefe141e6"

URI_aarch64_rust-unicode-properties+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-properties+default-devel-0.1.4-6.el10_3.noarch.rpm;name=aarch64_rust-unicode-properties+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-properties+default-devel}"
SRC_URI[aarch64_rust-unicode-properties+default-devel.sha256sum] = "4e5d569c488605e81b7e4d0b4aefd1ab772157c05f2111372ba335fa5f375120"

URI_aarch64_rust-unicode-properties+emoji-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-properties+emoji-devel-0.1.4-6.el10_3.noarch.rpm;name=aarch64_rust-unicode-properties+emoji-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-properties+emoji-devel}"
SRC_URI[aarch64_rust-unicode-properties+emoji-devel.sha256sum] = "10fa8c810c87c5a4ca310162c169e6176f39319e0520cc4bd6cd770777e80dc8"

URI_aarch64_rust-unicode-properties+general-category-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-properties+general-category-devel-0.1.4-6.el10_3.noarch.rpm;name=aarch64_rust-unicode-properties+general-category-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-properties+general-category-devel}"
SRC_URI[aarch64_rust-unicode-properties+general-category-devel.sha256sum] = "c00e7b35c60dcb73be701b102277706a63c34fe39833726187511fa154dadd31"

URI_aarch64_rust-unicode-properties-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-properties-devel-0.1.4-6.el10_3.noarch.rpm;name=aarch64_rust-unicode-properties-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-properties-devel}"
SRC_URI[aarch64_rust-unicode-properties-devel.sha256sum] = "bf73e298a8604eb8506c26a4eb4f71d45da0fad3f36ab9b45c5802b9350c33ec"

RDEPENDS:rust-unicode-properties+default-devel = " \
 cargo \
 rust-unicode-properties+emoji-devel \
 rust-unicode-properties+general-category-devel \
 rust-unicode-properties-devel \
 "
RDEPENDS:rust-unicode-properties+emoji-devel = " \
 cargo \
 rust-unicode-properties-devel \
 "
RDEPENDS:rust-unicode-properties+general-category-devel = " \
 cargo \
 rust-unicode-properties-devel \
 "
RDEPENDS:rust-unicode-properties-devel = " \
 cargo \
 "
