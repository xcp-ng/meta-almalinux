# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "elfutils"
PV = "0.192"
PR = "6.el10_0"
PACKAGES = " \
 elfutils \
 elfutils-debuginfod \
 elfutils-debuginfod-client \
 elfutils-debuginfod-client-devel \
 elfutils-default-yama-scope \
 elfutils-devel \
 elfutils-libelf \
 elfutils-libelf-devel \
 elfutils-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/elfutils-0.192-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8c4140149c4d4476532734bb9d8316aabe14afde550493ce4370861740c76aa"

URI_x86_64_v2_elfutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-0.192-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_elfutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils}"
SRC_URI[x86_64_v2_elfutils.sha256sum] = "679e9accbda4817d58364ac5816140ca6929b8bcb7f8de149cd967efcc740290"

URI_x86_64_v2_elfutils-debuginfod = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-debuginfod-0.192-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_elfutils-debuginfod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-debuginfod}"
SRC_URI[x86_64_v2_elfutils-debuginfod.sha256sum] = "ec8fd5c41ae832bac5878c15acbd2b8d3d68c4dea33c9ee06247a9506e92af99"

URI_x86_64_v2_elfutils-debuginfod-client = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-debuginfod-client-0.192-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_elfutils-debuginfod-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-debuginfod-client}"
SRC_URI[x86_64_v2_elfutils-debuginfod-client.sha256sum] = "b2c24452d20adc8ae218b3eb25c5e4c46014a2f6536873757e00bd9d7e50a853"

URI_x86_64_v2_elfutils-debuginfod-client-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-debuginfod-client-devel-0.192-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_elfutils-debuginfod-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-debuginfod-client-devel}"
SRC_URI[x86_64_v2_elfutils-debuginfod-client-devel.sha256sum] = "296839ce0120e0468ec0d59c271f7426c8e043db077c172fdc2f0d414aa42595"

URI_x86_64_v2_elfutils-default-yama-scope = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-default-yama-scope-0.192-6.el10_0.noarch.rpm;name=x86_64_v2_elfutils-default-yama-scope;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-default-yama-scope}"
SRC_URI[x86_64_v2_elfutils-default-yama-scope.sha256sum] = "bf7d2987ef0005650d785c97eb780691cfe106ba20bd4db88e7d607ac2048eca"

URI_x86_64_v2_elfutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-devel-0.192-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_elfutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-devel}"
SRC_URI[x86_64_v2_elfutils-devel.sha256sum] = "faad0330afbeddf2930192d95d8a69222db9eaf46fd9c10d208559d666d0fe0f"

URI_x86_64_v2_elfutils-libelf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-libelf-0.192-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_elfutils-libelf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-libelf}"
SRC_URI[x86_64_v2_elfutils-libelf.sha256sum] = "830a3b8b96a866b01c301674251bfc9a28419049fb9e53c633cfe8928b4291d8"

URI_x86_64_v2_elfutils-libelf-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-libelf-devel-0.192-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_elfutils-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-libelf-devel}"
SRC_URI[x86_64_v2_elfutils-libelf-devel.sha256sum] = "e04c79a2cece40a0b02d56e28ae91068ceb897d356e1b7f38ceeb1bcc47ff5ba"

URI_x86_64_v2_elfutils-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-libs-0.192-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_elfutils-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-libs}"
SRC_URI[x86_64_v2_elfutils-libs.sha256sum] = "e4f47da39e4a4cf2ee4cb22326751c9f03134f899e5760bae87abc5bf92f42e1"

URI_aarch64_elfutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-0.192-6.el10_0.aarch64.rpm;name=aarch64_elfutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils}"
SRC_URI[aarch64_elfutils.sha256sum] = "c7b2e8ea4ce1a21345a42261045755aff6b1b93a78b419162c3e56c54d0df8c6"

URI_aarch64_elfutils-debuginfod = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-debuginfod-0.192-6.el10_0.aarch64.rpm;name=aarch64_elfutils-debuginfod;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-debuginfod}"
SRC_URI[aarch64_elfutils-debuginfod.sha256sum] = "61de9c112e1a42c1deaefc6f700942ae458991dd81ce43f2a35734217c60d1ad"

URI_aarch64_elfutils-debuginfod-client = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-debuginfod-client-0.192-6.el10_0.aarch64.rpm;name=aarch64_elfutils-debuginfod-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-debuginfod-client}"
SRC_URI[aarch64_elfutils-debuginfod-client.sha256sum] = "133f35a6294c73d6f9edca968a0d89f8096119391da5d6a76d4a498276d3fe67"

URI_aarch64_elfutils-debuginfod-client-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-debuginfod-client-devel-0.192-6.el10_0.aarch64.rpm;name=aarch64_elfutils-debuginfod-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-debuginfod-client-devel}"
SRC_URI[aarch64_elfutils-debuginfod-client-devel.sha256sum] = "bf50eb1f2da41b47b72c88a095853058cf60e3b4c6253ba04e5d1a88b25098ff"

URI_aarch64_elfutils-default-yama-scope = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-default-yama-scope-0.192-6.el10_0.noarch.rpm;name=aarch64_elfutils-default-yama-scope;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-default-yama-scope}"
SRC_URI[aarch64_elfutils-default-yama-scope.sha256sum] = "bf7d2987ef0005650d785c97eb780691cfe106ba20bd4db88e7d607ac2048eca"

URI_aarch64_elfutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-devel-0.192-6.el10_0.aarch64.rpm;name=aarch64_elfutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-devel}"
SRC_URI[aarch64_elfutils-devel.sha256sum] = "d89fca211b6a90126646b77785409a556146d1c38ca9cc9b3814e463b3e918fb"

URI_aarch64_elfutils-libelf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-libelf-0.192-6.el10_0.aarch64.rpm;name=aarch64_elfutils-libelf;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-libelf}"
SRC_URI[aarch64_elfutils-libelf.sha256sum] = "32b626ede7468c783953cb0390974ad8721516d862e2c7525ba45dedcfbdf51c"

URI_aarch64_elfutils-libelf-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-libelf-devel-0.192-6.el10_0.aarch64.rpm;name=aarch64_elfutils-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-libelf-devel}"
SRC_URI[aarch64_elfutils-libelf-devel.sha256sum] = "b916931a8944e2954c4ae1b9ebba12951a4cbedb58dd1967b967ed45f4202483"

URI_aarch64_elfutils-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-libs-0.192-6.el10_0.aarch64.rpm;name=aarch64_elfutils-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-libs}"
SRC_URI[aarch64_elfutils-libs.sha256sum] = "b65457bf95ab838e6bdb444b66b5f831f8533ffeaa7635b629692365e250469d"

RDEPENDS:elfutils = " \
 bash \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libarchive \
 libgcc \
 libstdc++ \
 "
RDEPENDS:elfutils-debuginfod = " \
 bash \
 bsdtar \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 json-c \
 libarchive \
 libgcc \
 libmicrohttpd \
 libstdc++ \
 rpm-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 xz-libs \
 "
RDEPENDS:elfutils-debuginfod-client = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 json-c \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:elfutils-debuginfod-client-devel = " \
 elfutils-debuginfod-client \
 pkgconf-pkg-config \
 "
RDEPENDS:elfutils-default-yama-scope = " \
 bash \
 "
RDEPENDS:elfutils-devel = " \
 elfutils-libelf-devel \
 elfutils-libs \
 libzstd-devel \
 pkgconf-pkg-config \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:elfutils-libelf = " \
 glibc \
 libzstd \
 zlib-ng-compat \
 "
RDEPENDS:elfutils-libelf-devel = " \
 elfutils-libelf \
 libzstd-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:elfutils-libs = " \
 bzip2-libs \
 elfutils-default-yama-scope \
 elfutils-libelf \
 glibc \
 libzstd \
 xz-libs \
 zlib-ng-compat \
 "
