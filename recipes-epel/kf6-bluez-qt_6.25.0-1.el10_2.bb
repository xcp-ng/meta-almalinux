# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-bluez-qt"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-bluez-qt \
 kf6-bluez-qt-devel \
 kf6-bluez-qt-doc \
 kf6-bluez-qt-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-bluez-qt-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdd0aa9ddf0cf90222590bbf0261c042b92a6c90d2f0d12288b12756f0fcd954"

URI_x86_64_v2_kf6-bluez-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-bluez-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt}"
SRC_URI[x86_64_v2_kf6-bluez-qt.sha256sum] = "d67c0d085cd281330e063e84f398f5c3693d56f1e5e787e2826dd0945aa6c4c9"

URI_x86_64_v2_kf6-bluez-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-bluez-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt-devel}"
SRC_URI[x86_64_v2_kf6-bluez-qt-devel.sha256sum] = "bb1d4ad7dfc5e3a0f09e7c3935bab38812e7abcf8ecd9bf088326b2fcd40059f"

URI_x86_64_v2_kf6-bluez-qt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-bluez-qt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt-doc}"
SRC_URI[x86_64_v2_kf6-bluez-qt-doc.sha256sum] = "d6d14a91be26318b279bda3b710d16d22e2a51be456a2e7c558605e4cd35b142"

URI_x86_64_v2_kf6-bluez-qt-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-bluez-qt-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt-html}"
SRC_URI[x86_64_v2_kf6-bluez-qt-html.sha256sum] = "6261faf97a933fcc41c144c95dbae36ab94a82097265c3890b222e77c644f72c"

URI_aarch64_kf6-bluez-qt = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-bluez-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt}"
SRC_URI[aarch64_kf6-bluez-qt.sha256sum] = "f79879c3393470684926934768150ad683587174e9fc84211f79f4bd020e437f"

URI_aarch64_kf6-bluez-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-bluez-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt-devel}"
SRC_URI[aarch64_kf6-bluez-qt-devel.sha256sum] = "68d8329d9ac37421ab06504a10c386b54beb96c62c30ee7dc4e3575582287ed3"

URI_aarch64_kf6-bluez-qt-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-bluez-qt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt-doc}"
SRC_URI[aarch64_kf6-bluez-qt-doc.sha256sum] = "7c916e889dec108c029f6273d7b6dd81a2efc71dab3539b3b48f6611f4fb3b2e"

URI_aarch64_kf6-bluez-qt-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-bluez-qt-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt-html}"
SRC_URI[aarch64_kf6-bluez-qt-html.sha256sum] = "fb697da8be7934d8b79cef9c440837673926ff3b7eec216099c28cb06d383b5a"

RDEPENDS:kf6-bluez-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-bluez-qt-devel = " \
 cmake-filesystem \
 kf6-bluez-qt \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-bluez-qt-doc = " \
 "
RDEPENDS:kf6-bluez-qt-html = " \
 "
