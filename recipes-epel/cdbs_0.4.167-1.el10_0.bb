# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cdbs"
PV = "0.4.167"
PR = "1.el10_0"
PACKAGES = " \
 cdbs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cdbs-0.4.167-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcd4e325cd2ba528ce8c2ab0fbe3ebfb6f84e73871d44dc7cf423b10f9e3abd5"

URI_x86_64_v2_cdbs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cdbs-0.4.167-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cdbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cdbs}"
SRC_URI[x86_64_v2_cdbs.sha256sum] = "f26fd00c12ba12d6b32cbc0af94b135f5a0cee5b41aa563fc736461b32b5560e"

URI_aarch64_cdbs = "${EPEL_MIRROR}/aarch64/Packages/c/cdbs-0.4.167-1.el10_0.noarch.rpm;name=aarch64_cdbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cdbs}"
SRC_URI[aarch64_cdbs.sha256sum] = "40508ddbf21af71a8d5c9cc71d10d5872c3b4d84a26706352ee5ea4a91962fa4"

RDEPENDS:cdbs = " \
 bash \
 perl-FileHandle \
 perl-Font-TTF \
 perl-Getopt-Long \
 perl-Image-ExifTool \
 perl-Pod-Usage \
 perl-Regexp-Assemble \
 perl-autodie \
 perl-interpreter \
 perl-libs \
 perl-open \
 python3 \
 "
