# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-os_info"
PV = "3.15.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-os_info+default-devel \
 rust-os_info+schemars-devel \
 rust-os_info+serde-devel \
 rust-os_info-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-os_info-3.15.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b231ccf68d6991b02b780e7db6000435d159b6d5a82659616aa1a02b890510f"

URI_x86_64_v2_rust-os_info+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_info+default-devel-3.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_info+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_info+default-devel}"
SRC_URI[x86_64_v2_rust-os_info+default-devel.sha256sum] = "38ab184aa31edf7e170ea3ad598c95719d1a9fc5392db1a2cffbb00fb8ca33bd"

URI_x86_64_v2_rust-os_info+schemars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_info+schemars-devel-3.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_info+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_info+schemars-devel}"
SRC_URI[x86_64_v2_rust-os_info+schemars-devel.sha256sum] = "7bf146b8f3698c8d6490730d169638278f56209e9729282d841b689fae2b9119"

URI_x86_64_v2_rust-os_info+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_info+serde-devel-3.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_info+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_info+serde-devel}"
SRC_URI[x86_64_v2_rust-os_info+serde-devel.sha256sum] = "9b5b0cfb4ce72c02598d631f0643354f6ea73bd18c50776fc552c10167c2166f"

URI_x86_64_v2_rust-os_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_info-devel-3.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_info-devel}"
SRC_URI[x86_64_v2_rust-os_info-devel.sha256sum] = "a646056ab5626e1a9fc7bbf36c4bbddcbe67204344ca7239d4ca7efc58c3e09d"

URI_aarch64_rust-os_info+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_info+default-devel-3.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-os_info+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_info+default-devel}"
SRC_URI[aarch64_rust-os_info+default-devel.sha256sum] = "717257b9a64066b99a7fc3cfc77afc8df0a25899562334b80f3186a0debf1cdc"

URI_aarch64_rust-os_info+schemars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_info+schemars-devel-3.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-os_info+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_info+schemars-devel}"
SRC_URI[aarch64_rust-os_info+schemars-devel.sha256sum] = "0fd5d7c388453e30061d22a41674cc7d5bbe3d20dc1a2b975ba8ddfe12f0804b"

URI_aarch64_rust-os_info+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_info+serde-devel-3.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-os_info+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_info+serde-devel}"
SRC_URI[aarch64_rust-os_info+serde-devel.sha256sum] = "a1a6a399f924433edf9721df0fafd558ae20ff11dc5ab722ae760dabd2071038"

URI_aarch64_rust-os_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_info-devel-3.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-os_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_info-devel}"
SRC_URI[aarch64_rust-os_info-devel.sha256sum] = "bf2284df72ddbb8da19fd0fe19d0c6fca7b900234c4df557c833bdce959d3962"

RDEPENDS:rust-os_info+default-devel = " \
 cargo \
 rust-os_info+serde-devel \
 rust-os_info-devel \
 "
RDEPENDS:rust-os_info+schemars-devel = " \
 cargo \
 rust-os_info-devel \
 rust-schemars+default-devel \
 "
RDEPENDS:rust-os_info+serde-devel = " \
 cargo \
 rust-os_info-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-os_info-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-nix+default-devel \
 rust-nix+feature-devel \
 "
