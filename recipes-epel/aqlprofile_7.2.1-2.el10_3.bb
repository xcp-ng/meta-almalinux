# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aqlprofile"
PV = "7.2.1"
PR = "2.el10_3"
PACKAGES:x86_64_v2 = " \
 aqlprofile \
 aqlprofile-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/a/aqlprofile-7.2.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b27052d52c60fea00398fd883f8a2a3335bdf7a6662abfa8c4ee0010942617c"

URI_x86_64_v2_aqlprofile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aqlprofile-7.2.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aqlprofile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aqlprofile}"
SRC_URI[x86_64_v2_aqlprofile.sha256sum] = "25609f9ce6fa8385c11bbe6cefc32dd989a41f94d4d3b1637c98dfdf7162e671"

URI_x86_64_v2_aqlprofile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aqlprofile-devel-7.2.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aqlprofile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aqlprofile-devel}"
SRC_URI[x86_64_v2_aqlprofile-devel.sha256sum] = "6ea2599d98552cf6b3c4c3d3290490dc3a27c0959e45a651534f917aa83ac49a"

RDEPENDS:aqlprofile = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-filesystem \
 rocm-runtime \
 "
RDEPENDS:aqlprofile-devel = " \
 aqlprofile \
 "
