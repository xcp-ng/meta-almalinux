# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trustfall-rustdoc-adapter"
PV = "61.0.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-trustfall-rustdoc-adapter+default-devel \
 rust-trustfall-rustdoc-adapter+rayon-devel \
 rust-trustfall-rustdoc-adapter+rustc-hash-devel \
 rust-trustfall-rustdoc-adapter-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-trustfall-rustdoc-adapter-61.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c70faa4ec3bc8916f2f2254b9b1dd6b9ab7b5af1187ac18b336e7c1b264a401e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall-rustdoc-adapter+default-devel-61.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall-rustdoc-adapter+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall-rustdoc-adapter+default-devel.sha256sum] = "792c34a2168172a8755aca0a29a994051d4defa77c53cf189959776716f748c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall-rustdoc-adapter+rayon-devel-61.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall-rustdoc-adapter+rayon-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall-rustdoc-adapter+rayon-devel.sha256sum] = "1c15f1727a9ae435e7dab5fd0b0bd8eaa463369417018f0f9f58b8ce6f928df7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall-rustdoc-adapter+rustc-hash-devel-61.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall-rustdoc-adapter+rustc-hash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall-rustdoc-adapter+rustc-hash-devel.sha256sum] = "ae409f656d47b925718807eaf1e2d93f374af9b8647b94b69485746d3f3e5712"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall-rustdoc-adapter-devel-61.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall-rustdoc-adapter-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall-rustdoc-adapter-devel.sha256sum] = "b5e84a09032cf9cf2351178f7d0ac7c8d2dd5ea487984a78dce8dbf553d5eea0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall-rustdoc-adapter+default-devel-61.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall-rustdoc-adapter+default-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall-rustdoc-adapter+default-devel.sha256sum] = "31b191a22d3862095167c33274d891b78b940cc1b8abd9708ea0dc4d4674391c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall-rustdoc-adapter+rayon-devel-61.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall-rustdoc-adapter+rayon-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall-rustdoc-adapter+rayon-devel.sha256sum] = "504e2b9fdebebd574d07da027ee704fc43d3e679bba219301ad66bf0df1cb0ba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall-rustdoc-adapter+rustc-hash-devel-61.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall-rustdoc-adapter+rustc-hash-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall-rustdoc-adapter+rustc-hash-devel.sha256sum] = "4b58b3aa5580cde8d135adf076db19dfbd962fa2702b402bfa995a4424b1f4ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall-rustdoc-adapter-devel-61.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall-rustdoc-adapter-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall-rustdoc-adapter-devel.sha256sum] = "932214a55793267353085151f506f78b79b4d8b6a65023c1381c05d6af467e35"

RDEPENDS:rust-trustfall-rustdoc-adapter+default-devel = " \
 cargo \
 rust-trustfall-rustdoc-adapter-devel \
 "
RDEPENDS:rust-trustfall-rustdoc-adapter+rayon-devel = " \
 cargo \
 rust-rayon+default-devel \
 rust-trustfall-rustdoc-adapter-devel \
 "
RDEPENDS:rust-trustfall-rustdoc-adapter+rustc-hash-devel = " \
 cargo \
 rust-rustc-hash+default-devel \
 rust-rustdoc-types+rustc-hash-devel \
 rust-trustfall-rustdoc-adapter-devel \
 "
RDEPENDS:rust-trustfall-rustdoc-adapter-devel = " \
 cargo \
 rust \
 rust-cargo_metadata+default-devel \
 rust-cargo_toml+default-devel \
 rust-cargo_toml+features-devel \
 rust-indexmap+default-devel \
 rust-rustdoc-types+default-devel \
 rust-trustfall+default-devel \
 "
