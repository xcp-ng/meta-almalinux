# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dhcpd-pools"
PV = "3.3"
PR = "1.el10_1"
PACKAGES = " \
 dhcpd-pools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dhcpd-pools-3.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47bf8b9090c3efbc1698e29cc2e6257c89b04f4a53e71f25a762ddfe46ec7b77"

URI_x86_64_v2_dhcpd-pools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dhcpd-pools-3.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dhcpd-pools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dhcpd-pools}"
SRC_URI[x86_64_v2_dhcpd-pools.sha256sum] = "98f03e7fe7c1c7bb62aa8d04d35f6d1eaa312c9211f61e387bab34990e239424"

URI_aarch64_dhcpd-pools = "${EPEL_MIRROR}/aarch64/Packages/d/dhcpd-pools-3.3-1.el10_1.aarch64.rpm;name=aarch64_dhcpd-pools;unpack=0"
SRC_URI:append = " ${URI_aarch64_dhcpd-pools}"
SRC_URI[aarch64_dhcpd-pools.sha256sum] = "db4f8b6385b9cab924efab401d953b3e91f104b4aba1fd1a860f1a7ea9a2daca"

RDEPENDS:dhcpd-pools = " \
 glibc \
 net-snmp-perl-module \
 perl-interpreter \
 perl-libs \
 "
