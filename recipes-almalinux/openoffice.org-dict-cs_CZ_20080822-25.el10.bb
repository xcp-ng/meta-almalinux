# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openoffice.org-dict-cs_CZ"
PV = "20080822"
PR = "25.el10"
PACKAGES = " \
 hunspell-cs \
 hyphen-cs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openoffice.org-dict-cs_CZ-20080822-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ae609f65bc4d35b86a9a5c8014e9ae0f900f209bbdcc102f205af1e6478b835"

URI_x86_64_v2_hunspell-cs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-cs-20080822-25.el10.noarch.rpm;name=x86_64_v2_hunspell-cs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-cs}"
SRC_URI[x86_64_v2_hunspell-cs.sha256sum] = "702cbe24549458922fa0a143de851b2b1ac3cf6f41acdd8e85c182044ef374f3"

URI_x86_64_v2_hyphen-cs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-cs-20080822-25.el10.noarch.rpm;name=x86_64_v2_hyphen-cs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-cs}"
SRC_URI[x86_64_v2_hyphen-cs.sha256sum] = "c49abc559185c801b9942f1f6ee0b3a9a7b7d9d5a0ba58b1edf45596cba11b3e"

URI_aarch64_hunspell-cs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-cs-20080822-25.el10.noarch.rpm;name=aarch64_hunspell-cs;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-cs}"
SRC_URI[aarch64_hunspell-cs.sha256sum] = "702cbe24549458922fa0a143de851b2b1ac3cf6f41acdd8e85c182044ef374f3"

URI_aarch64_hyphen-cs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-cs-20080822-25.el10.noarch.rpm;name=aarch64_hyphen-cs;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-cs}"
SRC_URI[aarch64_hyphen-cs.sha256sum] = "c49abc559185c801b9942f1f6ee0b3a9a7b7d9d5a0ba58b1edf45596cba11b3e"

RDEPENDS:hunspell-cs = " \
 hunspell \
 "
RDEPENDS:hyphen-cs = " \
 hyphen \
 "
