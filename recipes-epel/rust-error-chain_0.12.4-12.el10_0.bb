# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-error-chain"
PV = "0.12.4"
PR = "12.el10_0"
PACKAGES = " \
 rust-error-chain+backtrace-devel \
 rust-error-chain+default-devel \
 rust-error-chain+example_generated-devel \
 rust-error-chain-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-error-chain-0.12.4-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2caa6ce960f7edf48292689ccfe5e74992504fad00d6f573f884cf7dbbac37dc"

URI_x86_64_v2_rust-error-chain+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-error-chain+backtrace-devel-0.12.4-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-error-chain+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-error-chain+backtrace-devel}"
SRC_URI[x86_64_v2_rust-error-chain+backtrace-devel.sha256sum] = "72844bea2cc714e2188a4489186d7d8b9e3e2c4fb6dd547b6a4f39d06fa5194c"

URI_x86_64_v2_rust-error-chain+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-error-chain+default-devel-0.12.4-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-error-chain+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-error-chain+default-devel}"
SRC_URI[x86_64_v2_rust-error-chain+default-devel.sha256sum] = "c3802a58b354335404fb0891a81d137d1e2583bbb7afa6be520a494a6aac8ae1"

URI_x86_64_v2_rust-error-chain+example_generated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-error-chain+example_generated-devel-0.12.4-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-error-chain+example_generated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-error-chain+example_generated-devel}"
SRC_URI[x86_64_v2_rust-error-chain+example_generated-devel.sha256sum] = "ae4d968a03655d8871bf429e48830524a6d9cc8da7c848e7b75c7f96096dca96"

URI_x86_64_v2_rust-error-chain-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-error-chain-devel-0.12.4-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-error-chain-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-error-chain-devel}"
SRC_URI[x86_64_v2_rust-error-chain-devel.sha256sum] = "f4767c36a6adf74b2ea089b8109847773c6967e72e276074e136897e4ee8fd62"

URI_aarch64_rust-error-chain+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-error-chain+backtrace-devel-0.12.4-12.el10_0.noarch.rpm;name=aarch64_rust-error-chain+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-error-chain+backtrace-devel}"
SRC_URI[aarch64_rust-error-chain+backtrace-devel.sha256sum] = "13a5423839837d330902fd57de4a6b287b401cd0c555c8c632d2342631d7c844"

URI_aarch64_rust-error-chain+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-error-chain+default-devel-0.12.4-12.el10_0.noarch.rpm;name=aarch64_rust-error-chain+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-error-chain+default-devel}"
SRC_URI[aarch64_rust-error-chain+default-devel.sha256sum] = "27279521daaec3266beeaf542363327d1b71b96750957b8eda1296fb8882ab6d"

URI_aarch64_rust-error-chain+example_generated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-error-chain+example_generated-devel-0.12.4-12.el10_0.noarch.rpm;name=aarch64_rust-error-chain+example_generated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-error-chain+example_generated-devel}"
SRC_URI[aarch64_rust-error-chain+example_generated-devel.sha256sum] = "09cccdefa24e810283e039a9914febcc9641ae264ec2ef78aceb0baf283c402a"

URI_aarch64_rust-error-chain-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-error-chain-devel-0.12.4-12.el10_0.noarch.rpm;name=aarch64_rust-error-chain-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-error-chain-devel}"
SRC_URI[aarch64_rust-error-chain-devel.sha256sum] = "e69bee5ff50295976251d303e221fa286d2cceda06afa595e054378221418762"

RDEPENDS:rust-error-chain+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-error-chain-devel \
 "
RDEPENDS:rust-error-chain+default-devel = " \
 cargo \
 rust-error-chain+backtrace-devel \
 rust-error-chain+example_generated-devel \
 rust-error-chain-devel \
 "
RDEPENDS:rust-error-chain+example_generated-devel = " \
 cargo \
 rust-error-chain-devel \
 "
RDEPENDS:rust-error-chain-devel = " \
 cargo \
 rust-version_check+default-devel \
 "
