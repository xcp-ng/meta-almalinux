# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-eapache-queue"
PV = "1.1.0"
PR = "17.el10_0"
PACKAGES = " \
 golang-github-eapache-queue-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-eapache-queue-1.1.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4c03003f6b46f179b6d0dff8a8763129f9c82685cd301d80c2451ded648cafac"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-eapache-queue-devel-1.1.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-eapache-queue-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-eapache-queue-devel.sha256sum] = "9c0a2a2a752481b5be5aadd52e9e963c89cfc6b207a7cc75fa739c8c9f2ef080"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-eapache-queue-devel-1.1.0-17.el10_0.noarch.rpm;name=aarch64_golang-github-eapache-queue-devel;unpack=0"
SRC_URI[aarch64_golang-github-eapache-queue-devel.sha256sum] = "2b705d988f2a4a070cf65f05acc9fec2700f334782469d21fe62ab6af05330a1"

RDEPENDS:golang-github-eapache-queue-devel = " \
 go-filesystem \
 "
