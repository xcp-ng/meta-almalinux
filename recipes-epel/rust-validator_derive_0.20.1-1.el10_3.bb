# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-validator_derive"
PV = "0.20.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-validator_derive+default-devel \
 rust-validator_derive-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-validator_derive-0.20.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4b4984f871a75d11fbbcb96c55f7ec66c7f0e046960f918ef30ed95931f62553"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-validator_derive+default-devel-0.20.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-validator_derive+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-validator_derive+default-devel.sha256sum] = "ff0d102338cd65e4b5456cf8d9449785bdd5692f5baf6248590737eee7d6f027"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-validator_derive-devel-0.20.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-validator_derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-validator_derive-devel.sha256sum] = "24b32e1d1d4cc4840d701942d676bb536e218a2eb3a1478a92986e94b52c3eb1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-validator_derive+default-devel-0.20.1-1.el10_3.noarch.rpm;name=aarch64_rust-validator_derive+default-devel;unpack=0"
SRC_URI[aarch64_rust-validator_derive+default-devel.sha256sum] = "3f57d02ee3d7c24260ef0f2f6cf91a1c3c27b56154b4d6aa08506336c1219e37"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-validator_derive-devel-0.20.1-1.el10_3.noarch.rpm;name=aarch64_rust-validator_derive-devel;unpack=0"
SRC_URI[aarch64_rust-validator_derive-devel.sha256sum] = "a388da2e105f61235fd6a188fba6fc15fe968dbd99c196d926158d9be08d6481"

RDEPENDS:rust-validator_derive+default-devel = " \
 cargo \
 rust-validator_derive-devel \
 "
RDEPENDS:rust-validator_derive-devel = " \
 cargo \
 rust \
 rust-darling+default-devel \
 rust-darling+suggestions-devel \
 rust-proc-macro-error3+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
