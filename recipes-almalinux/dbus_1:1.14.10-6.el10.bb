# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dbus"
PE = "1"
PV = "1.14.10"
PR = "6.el10"
PACKAGES = " \
 dbus \
 dbus-common \
 dbus-daemon \
 dbus-devel \
 dbus-doc \
 dbus-libs \
 dbus-tools \
 dbus-x11 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dbus-1.14.10-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cd8bd84d667b0738afb19bcb9d40cd7675f2fc954e5901c961867d91d22fbb2f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dbus-1.14.10-6.el10.x86_64_v2.rpm;name=x86_64_v2_dbus;unpack=0"
SRC_URI[x86_64_v2_dbus.sha256sum] = "cd4017a6ea1cb63beae0a3b8c4fc9ac7b8d5c78eefb1cf258b2f0d2d86152bf9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dbus-common-1.14.10-6.el10.noarch.rpm;name=x86_64_v2_dbus-common;unpack=0"
SRC_URI[x86_64_v2_dbus-common.sha256sum] = "80e184c8c1c9aef292e533e073429ccde318f7e044e218ea21e273d464378889"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dbus-daemon-1.14.10-6.el10.x86_64_v2.rpm;name=x86_64_v2_dbus-daemon;unpack=0"
SRC_URI[x86_64_v2_dbus-daemon.sha256sum] = "21725cb2c2ee46a335eb30972a2a206535f09c47e591e2e26a8c1b5de76b2eed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dbus-devel-1.14.10-6.el10.x86_64_v2.rpm;name=x86_64_v2_dbus-devel;unpack=0"
SRC_URI[x86_64_v2_dbus-devel.sha256sum] = "289601af617bf552e03da9173a29c68e1af4d9e4eec60b81f198d816a78b1dde"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dbus-doc-1.14.10-6.el10.noarch.rpm;name=x86_64_v2_dbus-doc;unpack=0"
SRC_URI[x86_64_v2_dbus-doc.sha256sum] = "f2a4c3c139a765d01151247aba9ab370deea6f69a405844ede25bb949d23dbba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dbus-libs-1.14.10-6.el10.x86_64_v2.rpm;name=x86_64_v2_dbus-libs;unpack=0"
SRC_URI[x86_64_v2_dbus-libs.sha256sum] = "3171a8413b6a67a331211858b219b277de0b5d3b0d8db4a950517b7cf424a094"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dbus-tools-1.14.10-6.el10.x86_64_v2.rpm;name=x86_64_v2_dbus-tools;unpack=0"
SRC_URI[x86_64_v2_dbus-tools.sha256sum] = "1b96f17103628d314c6b34817759988ac0334f528c3768164dd1a548abc9c1ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dbus-x11-1.14.10-6.el10.x86_64_v2.rpm;name=x86_64_v2_dbus-x11;unpack=0"
SRC_URI[x86_64_v2_dbus-x11.sha256sum] = "add80d1da4423707c4feba9303e6936d02e148e0baddba35d4186b124ca94436"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dbus-1.14.10-6.el10.aarch64.rpm;name=aarch64_dbus;unpack=0"
SRC_URI[aarch64_dbus.sha256sum] = "9a8d645cddec9938ba457c5777a2d5055237c799cb592d8dcf090181acf6a466"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dbus-common-1.14.10-6.el10.noarch.rpm;name=aarch64_dbus-common;unpack=0"
SRC_URI[aarch64_dbus-common.sha256sum] = "80e184c8c1c9aef292e533e073429ccde318f7e044e218ea21e273d464378889"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dbus-daemon-1.14.10-6.el10.aarch64.rpm;name=aarch64_dbus-daemon;unpack=0"
SRC_URI[aarch64_dbus-daemon.sha256sum] = "ce5c1a3e854ea33e8e6ca0f081e4c4af4319986fbbd8601956d58f578433c4b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dbus-devel-1.14.10-6.el10.aarch64.rpm;name=aarch64_dbus-devel;unpack=0"
SRC_URI[aarch64_dbus-devel.sha256sum] = "5cf0b64d52133262979f2bc7daa2fa34af1a6d428e829adc2c6bdf7bc5accd13"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dbus-doc-1.14.10-6.el10.noarch.rpm;name=aarch64_dbus-doc;unpack=0"
SRC_URI[aarch64_dbus-doc.sha256sum] = "f2a4c3c139a765d01151247aba9ab370deea6f69a405844ede25bb949d23dbba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dbus-libs-1.14.10-6.el10.aarch64.rpm;name=aarch64_dbus-libs;unpack=0"
SRC_URI[aarch64_dbus-libs.sha256sum] = "bad0ad14d6d010c95a7e5b8a14894c88a99bda1abc9ca2ac1b5a2af36a6181b8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dbus-tools-1.14.10-6.el10.aarch64.rpm;name=aarch64_dbus-tools;unpack=0"
SRC_URI[aarch64_dbus-tools.sha256sum] = "2626bd4b541dbab9ebb41a74f6b1c7f2a6aa159d6b98d5b01c205ac662579ae5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dbus-x11-1.14.10-6.el10.aarch64.rpm;name=aarch64_dbus-x11;unpack=0"
SRC_URI[aarch64_dbus-x11.sha256sum] = "1d515f10dbc7810801694302a860bee693eec160eebf13bdbf7614d81d13c297"

RDEPENDS:dbus = " \
 dbus-broker \
 "
RDEPENDS:dbus-common = " \
 bash \
 "
RDEPENDS:dbus-daemon = " \
 audit-libs \
 bash \
 dbus-common \
 dbus-libs \
 dbus-tools \
 expat \
 glibc \
 libcap-ng \
 libselinux \
 shadow-utils \
 systemd-libs \
 "
RDEPENDS:dbus-devel = " \
 cmake-filesystem \
 dbus-libs \
 pkgconf-pkg-config \
 xml-common \
 "
RDEPENDS:dbus-doc = " \
 dbus-daemon \
 "
RDEPENDS:dbus-libs = " \
 glibc \
 systemd-libs \
 "
RDEPENDS:dbus-tools = " \
 dbus-libs \
 glibc \
 "
RDEPENDS:dbus-x11 = " \
 bash \
 dbus-daemon \
 dbus-libs \
 glibc \
 libX11 \
 "
