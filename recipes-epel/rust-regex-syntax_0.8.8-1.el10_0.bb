# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex-syntax"
PV = "0.8.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-regex-syntax+arbitrary-devel \
 rust-regex-syntax+default-devel \
 rust-regex-syntax+std-devel \
 rust-regex-syntax+unicode-age-devel \
 rust-regex-syntax+unicode-bool-devel \
 rust-regex-syntax+unicode-case-devel \
 rust-regex-syntax+unicode-devel \
 rust-regex-syntax+unicode-gencat-devel \
 rust-regex-syntax+unicode-perl-devel \
 rust-regex-syntax+unicode-script-devel \
 rust-regex-syntax+unicode-segment-devel \
 rust-regex-syntax-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-syntax-0.8.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ec4325a025e2197857c858fb411d9f70c792b157cb955019c20022505745a31"

URI_x86_64_v2_rust-regex-syntax+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+arbitrary-devel-0.8.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+arbitrary-devel.sha256sum] = "f066940e14d8e074179a181e1221f01932901898df305b5ef6e8b0a256fa4170"

URI_x86_64_v2_rust-regex-syntax+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+default-devel-0.8.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+default-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+default-devel.sha256sum] = "a1d890660bcf9abe8eb66904c06db6721644a66fd9b04670fc5e4857294d40f5"

URI_x86_64_v2_rust-regex-syntax+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+std-devel-0.8.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+std-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+std-devel.sha256sum] = "576be8932a553cc7945e8690cb4fa461151ddaf997e0964c88bfdae9354684c4"

URI_x86_64_v2_rust-regex-syntax+unicode-age-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-age-devel-0.8.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-age-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-age-devel.sha256sum] = "b2a3acdbfb66ab99fb0a3c18a525bdf30e42de3301439b404ca3829fc0d78ee8"

URI_x86_64_v2_rust-regex-syntax+unicode-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-bool-devel-0.8.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-bool-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-bool-devel.sha256sum] = "bf436701cc154ae7d3de0a5a961f11602a3a646c7b0487566301fada89810ad7"

URI_x86_64_v2_rust-regex-syntax+unicode-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-case-devel-0.8.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-case-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-case-devel.sha256sum] = "26ad5ea99e4f5dc2d1f076ae5302be6c7757e945537f1ade6e4b4929cd066d06"

URI_x86_64_v2_rust-regex-syntax+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-devel-0.8.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-devel.sha256sum] = "0312da46b1d772bc518f975f231cf9bf4a7ea0c9daa98c5395eb3d43781f1a35"

URI_x86_64_v2_rust-regex-syntax+unicode-gencat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-gencat-devel-0.8.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-gencat-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-gencat-devel.sha256sum] = "42f09290bc82d7e9d399060b72ecba24174fdd0d03e7ac58256210fb46c43249"

URI_x86_64_v2_rust-regex-syntax+unicode-perl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-perl-devel-0.8.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-perl-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-perl-devel.sha256sum] = "7fb7032c7d66a3e01f9d2b7c27e4ee00788b9b31f76d02c4e597b5be09f65e08"

URI_x86_64_v2_rust-regex-syntax+unicode-script-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-script-devel-0.8.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-script-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-script-devel.sha256sum] = "0a1c2758fd861a7cc0912120f80c228dff74e3d745add6c490215f4e47636d5a"

URI_x86_64_v2_rust-regex-syntax+unicode-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-segment-devel-0.8.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-segment-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-segment-devel.sha256sum] = "d75ddb981b549eda5dc7fefefe64fd73670b6bb3b801ea7c6faaf09b31c1ead1"

URI_x86_64_v2_rust-regex-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax-devel-0.8.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax-devel.sha256sum] = "06ffea29899fca15b88a5fecabd5b5f6f4e37871c5cbab3a0bc7b0e9ea5a4e5c"

URI_aarch64_rust-regex-syntax+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+arbitrary-devel-0.8.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+arbitrary-devel}"
SRC_URI[aarch64_rust-regex-syntax+arbitrary-devel.sha256sum] = "b6a91a8a20bab0e55fe59a03954978ef88ce991f97d09a1be69b776844a096f9"

URI_aarch64_rust-regex-syntax+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+default-devel-0.8.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+default-devel}"
SRC_URI[aarch64_rust-regex-syntax+default-devel.sha256sum] = "5b7a4c9ffebc2f185c3b8dbb95a958afd1c2f38f3faa7bd87febf8fe0d27434b"

URI_aarch64_rust-regex-syntax+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+std-devel-0.8.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+std-devel}"
SRC_URI[aarch64_rust-regex-syntax+std-devel.sha256sum] = "cbd5b314ba291a4446b6601862eefb25058cf74f8ba3574365b9926101748aba"

URI_aarch64_rust-regex-syntax+unicode-age-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-age-devel-0.8.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-age-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-age-devel.sha256sum] = "6d196b500825bca19d1844beee2c7fffe6dd18a0b03fb9929e269a163e1d740a"

URI_aarch64_rust-regex-syntax+unicode-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-bool-devel-0.8.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-bool-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-bool-devel.sha256sum] = "a56b55249c8f41f815d236d898e760732d4419dd9ba3f668a7e0f20a18072b14"

URI_aarch64_rust-regex-syntax+unicode-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-case-devel-0.8.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-case-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-case-devel.sha256sum] = "8b52dca7c6adac0b6f9885db64f7ef1f9ce7f45119d9a38e1edfd85ceb273f01"

URI_aarch64_rust-regex-syntax+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-devel-0.8.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-devel.sha256sum] = "e6a05388c2bac85d23cdfdd66460aaf0fcb0e0dfe4f06340ad1de401d28c930c"

URI_aarch64_rust-regex-syntax+unicode-gencat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-gencat-devel-0.8.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-gencat-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-gencat-devel.sha256sum] = "bbee63e5b4186650263ea34a941bbc5fa81ec606151b19dafa4d42b09e493c98"

URI_aarch64_rust-regex-syntax+unicode-perl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-perl-devel-0.8.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-perl-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-perl-devel.sha256sum] = "0cbf55018b6866c81348a93772c76ea45d7ecf7aeec6cc3432f478733c55d1ff"

URI_aarch64_rust-regex-syntax+unicode-script-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-script-devel-0.8.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-script-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-script-devel.sha256sum] = "1056f4b74c193145cc42a94c0179c2f48e1abf706b8bbc769258d76e52ed5450"

URI_aarch64_rust-regex-syntax+unicode-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-segment-devel-0.8.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-segment-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-segment-devel.sha256sum] = "e97dc81151fdfa4e2bae77bdfe691ec65ca98b6415212b3957b5d4bf6b03da7a"

URI_aarch64_rust-regex-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax-devel-0.8.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax-devel}"
SRC_URI[aarch64_rust-regex-syntax-devel.sha256sum] = "37a2197e5f097e8c4bec828fd3d9e6db89e4943dba646e65760d8a8a41a05445"

RDEPENDS:rust-regex-syntax+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+default-devel = " \
 cargo \
 rust-regex-syntax+std-devel \
 rust-regex-syntax+unicode-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+std-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-age-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-bool-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-case-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-devel = " \
 cargo \
 rust-regex-syntax+unicode-age-devel \
 rust-regex-syntax+unicode-bool-devel \
 rust-regex-syntax+unicode-case-devel \
 rust-regex-syntax+unicode-gencat-devel \
 rust-regex-syntax+unicode-perl-devel \
 rust-regex-syntax+unicode-script-devel \
 rust-regex-syntax+unicode-segment-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-gencat-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-perl-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-script-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-segment-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax-devel = " \
 bash \
 cargo \
 rust \
 "
