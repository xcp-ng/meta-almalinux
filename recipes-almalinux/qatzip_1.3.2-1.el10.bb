# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qatzip"
PV = "1.3.2"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 qatzip \
 qatzip-devel \
 qatzip-libs \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qatzip-1.3.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5719cd8b7f82826d3c01a1bdb10e8251863d75f403f11de71cc2830a001ad9da"

URI_x86_64_v2_qatzip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatzip-1.3.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatzip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatzip}"
SRC_URI[x86_64_v2_qatzip.sha256sum] = "9d80475a3cb8b119a0ab6a3021a9977d5a83483b03ba48b51d725c1b44bd8228"

URI_x86_64_v2_qatzip-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qatzip-devel-1.3.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatzip-devel}"
SRC_URI[x86_64_v2_qatzip-devel.sha256sum] = "d52617e39e6f46aaa772e48338309c8ee7109de387faaf194fb4dc9ab5611830"

URI_x86_64_v2_qatzip-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatzip-libs-1.3.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatzip-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatzip-libs}"
SRC_URI[x86_64_v2_qatzip-libs.sha256sum] = "e6d3a311e5f740af8ef0472283b2623b93543f02c1c54c0d3b001f5fe1ee8e18"

RDEPENDS:qatzip = " \
 glibc \
 lz4-libs \
 numactl-libs \
 qatlib \
 zlib-ng-compat \
 "
RDEPENDS:qatzip-devel = " \
 lz4-devel \
 pkgconf-pkg-config \
 qatzip-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:qatzip-libs = " \
 glibc \
 lz4-libs \
 numactl-libs \
 qatlib \
 zlib-ng-compat \
 "
