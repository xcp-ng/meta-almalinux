# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jupyterlab_pygments"
PV = "0.3.0"
PR = "8.el10_1"
PACKAGES = " \
 python3-jupyterlab_pygments \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jupyterlab_pygments-0.3.0-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d73ff11627c54ed22d3359ea5ed1e7a2dd196ac7878d98ce72f349ecf053974"

URI_x86_64_v2_python3-jupyterlab_pygments = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jupyterlab_pygments-0.3.0-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jupyterlab_pygments;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jupyterlab_pygments}"
SRC_URI[x86_64_v2_python3-jupyterlab_pygments.sha256sum] = "367d44c31f1b1a2f15ff3e66c677dbd63bea7e096b94abf925a25b90e55972b7"

URI_aarch64_python3-jupyterlab_pygments = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jupyterlab_pygments-0.3.0-8.el10_1.noarch.rpm;name=aarch64_python3-jupyterlab_pygments;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jupyterlab_pygments}"
SRC_URI[aarch64_python3-jupyterlab_pygments.sha256sum] = "158eaa4c2e46b56c33c6462de3705f8dfcea5858d9077e250c52088294394d6e"

RDEPENDS:python3-jupyterlab_pygments = " \
 python3 \
 python3-pygments \
 "
