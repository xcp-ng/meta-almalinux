# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_tee"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_tee+default-devel \
 rust-uu_tee-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_tee-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26a2c76145e5c9540c0ddf72069fec4735452c8e3a4c9a923282309a53be5dcf"

URI_x86_64_v2_rust-uu_tee+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_tee+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_tee+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_tee+default-devel}"
SRC_URI[x86_64_v2_rust-uu_tee+default-devel.sha256sum] = "d73bdc85dc2e09b68aba0322a446dc1c18e48dce65932a78bf8a30899621757a"

URI_x86_64_v2_rust-uu_tee-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_tee-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_tee-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_tee-devel}"
SRC_URI[x86_64_v2_rust-uu_tee-devel.sha256sum] = "aa555917d1b84ed6ec9a0cc82a4af85453d8f455b0676dc959000d1365520929"

URI_aarch64_rust-uu_tee+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_tee+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_tee+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_tee+default-devel}"
SRC_URI[aarch64_rust-uu_tee+default-devel.sha256sum] = "5108e0bf9d467ed1e0fabfff5e34c75f444d59a2b236f3398f98d384fc221727"

URI_aarch64_rust-uu_tee-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_tee-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_tee-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_tee-devel}"
SRC_URI[aarch64_rust-uu_tee-devel.sha256sum] = "1becea663346930d0a3c18d03f16983aa2c5e6f4795a2f07938f19c6e5aa0946"

RDEPENDS:rust-uu_tee+default-devel = " \
 cargo \
 rust-uu_tee-devel \
 "
RDEPENDS:rust-uu_tee-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+libc-devel \
 rust-uucore+parser-devel \
 rust-uucore+signals-devel \
 "
