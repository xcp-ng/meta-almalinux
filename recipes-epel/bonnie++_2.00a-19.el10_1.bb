# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bonnie++"
PV = "2.00a"
PR = "19.el10_1"
PACKAGES = " \
 bonnie++ \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bonnie++-2.00a-19.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92e0dba69a4c8f857971aafd69acd09376987ecbd5898fe53a25bc55464fbaec"

URI_x86_64_v2_bonnie++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bonnie++-2.00a-19.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bonnie++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bonnie++}"
SRC_URI[x86_64_v2_bonnie++.sha256sum] = "fa5c98d8cd418d7601a05e12a620e9c687969ef058fbf7ea60fa88684613f660"

URI_aarch64_bonnie++ = "${EPEL_MIRROR}/aarch64/Packages/b/bonnie++-2.00a-19.el10_1.aarch64.rpm;name=aarch64_bonnie++;unpack=0"
SRC_URI:append = " ${URI_aarch64_bonnie++}"
SRC_URI[aarch64_bonnie++.sha256sum] = "6bd1abff9310579fc086f488c5d2ae9738cb8dc7d8e9dc02cc1de618ee35c23d"

RDEPENDS:bonnie++ = " \
 glibc \
 libgcc \
 libstdc++ \
 perl-interpreter \
 "
