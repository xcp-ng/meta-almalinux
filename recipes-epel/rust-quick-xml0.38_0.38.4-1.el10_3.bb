# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quick-xml0.38"
PV = "0.38.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-quick-xml0.38+arbitrary-devel \
 rust-quick-xml0.38+async-tokio-devel \
 rust-quick-xml0.38+default-devel \
 rust-quick-xml0.38+document-features-devel \
 rust-quick-xml0.38+encoding-devel \
 rust-quick-xml0.38+encoding_rs-devel \
 rust-quick-xml0.38+escape-html-devel \
 rust-quick-xml0.38+overlapped-lists-devel \
 rust-quick-xml0.38+serde-devel \
 rust-quick-xml0.38+serde-types-devel \
 rust-quick-xml0.38+serialize-devel \
 rust-quick-xml0.38+tokio-devel \
 rust-quick-xml0.38-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quick-xml0.38-0.38.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edd41d7e0c0a0024014455c00021e2d07a4df2e5366329db770fcdf70e3925f4"

URI_x86_64_v2_rust-quick-xml0.38+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.38+arbitrary-devel-0.38.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.38+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.38+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.38+arbitrary-devel.sha256sum] = "fa5052bcd2bdbd871fb76d42ac8ddd326409894ce99a1d7f5e834b308646e884"

URI_x86_64_v2_rust-quick-xml0.38+async-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.38+async-tokio-devel-0.38.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.38+async-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.38+async-tokio-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.38+async-tokio-devel.sha256sum] = "28027dce8d461baf1399ca58af2142d6b7e0799d138cc798119e1ebec499e729"

URI_x86_64_v2_rust-quick-xml0.38+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.38+default-devel-0.38.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.38+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.38+default-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.38+default-devel.sha256sum] = "1ddb2baa70e5a1d385aa729dfc50641aadc9bb87e172c7af6c050e4255cf6e11"

URI_x86_64_v2_rust-quick-xml0.38+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.38+document-features-devel-0.38.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.38+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.38+document-features-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.38+document-features-devel.sha256sum] = "724da3eafb7ec75c5a60d6985664039e784ed52750420a79a20ed5939acc6927"

URI_x86_64_v2_rust-quick-xml0.38+encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.38+encoding-devel-0.38.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.38+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.38+encoding-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.38+encoding-devel.sha256sum] = "1965b2de3a36d10f7dbcb6427da83537c97b14ad1fcf5a161621bc40c642fd4a"

URI_x86_64_v2_rust-quick-xml0.38+encoding_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.38+encoding_rs-devel-0.38.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.38+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.38+encoding_rs-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.38+encoding_rs-devel.sha256sum] = "7e11f1481d6f66ef2f26f17a8acb8d3744612f55bca184edfb76a307c479313d"

URI_x86_64_v2_rust-quick-xml0.38+escape-html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.38+escape-html-devel-0.38.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.38+escape-html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.38+escape-html-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.38+escape-html-devel.sha256sum] = "48fa355298fd6dce5c064c712f6ee120280b1354be6e08ed83f5ae7e76a0ca0d"

URI_x86_64_v2_rust-quick-xml0.38+overlapped-lists-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.38+overlapped-lists-devel-0.38.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.38+overlapped-lists-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.38+overlapped-lists-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.38+overlapped-lists-devel.sha256sum] = "8bddfa2c279960128d9a967fd07a6a3a205452c617563882f73df35a44119515"

URI_x86_64_v2_rust-quick-xml0.38+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.38+serde-devel-0.38.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.38+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.38+serde-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.38+serde-devel.sha256sum] = "a1625c8ed548f8c0eeb8f59879772afc9efd6d414d71226ba000b2c7f3d50514"

URI_x86_64_v2_rust-quick-xml0.38+serde-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.38+serde-types-devel-0.38.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.38+serde-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.38+serde-types-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.38+serde-types-devel.sha256sum] = "e7b775bae563da1f8e9fd083788a90ffdf730efd01ce2de295e465986aeec08c"

URI_x86_64_v2_rust-quick-xml0.38+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.38+serialize-devel-0.38.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.38+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.38+serialize-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.38+serialize-devel.sha256sum] = "78b9853818e54484155c6c8eae25776653f4bea070e58b7179b42d49748978f0"

URI_x86_64_v2_rust-quick-xml0.38+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.38+tokio-devel-0.38.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.38+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.38+tokio-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.38+tokio-devel.sha256sum] = "9003785f38035711d230d7a37fbf687d26fd19a6652aa74122561c1498b53d79"

URI_x86_64_v2_rust-quick-xml0.38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.38-devel-0.38.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.38-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.38-devel.sha256sum] = "42a21509c764ff3f4a8170b90a27a625a42009099c3a530767d24ef03a67a344"

URI_aarch64_rust-quick-xml0.38+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.38+arbitrary-devel-0.38.4-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml0.38+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.38+arbitrary-devel}"
SRC_URI[aarch64_rust-quick-xml0.38+arbitrary-devel.sha256sum] = "1435865cb3d593d14fbd74fe40ff7c7c609fa016276ce172db0f3f8c34248e96"

URI_aarch64_rust-quick-xml0.38+async-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.38+async-tokio-devel-0.38.4-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml0.38+async-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.38+async-tokio-devel}"
SRC_URI[aarch64_rust-quick-xml0.38+async-tokio-devel.sha256sum] = "f3c36787c471bcd5f815a35cb7936affbeaf70cedf4648f5c07b74f9e4deb28b"

URI_aarch64_rust-quick-xml0.38+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.38+default-devel-0.38.4-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml0.38+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.38+default-devel}"
SRC_URI[aarch64_rust-quick-xml0.38+default-devel.sha256sum] = "36e8567d25ed702f5ae1d2308e56a50cf6b92175827d69686374e63f1b9a7225"

URI_aarch64_rust-quick-xml0.38+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.38+document-features-devel-0.38.4-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml0.38+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.38+document-features-devel}"
SRC_URI[aarch64_rust-quick-xml0.38+document-features-devel.sha256sum] = "abf42f74000242425e62f2d4938a560a0088a201bb1ba200ca707fd330bce579"

URI_aarch64_rust-quick-xml0.38+encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.38+encoding-devel-0.38.4-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml0.38+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.38+encoding-devel}"
SRC_URI[aarch64_rust-quick-xml0.38+encoding-devel.sha256sum] = "34d0167b889b34da6f65240559e5b272a5a7a0018e8219ea4610bf924ada18b2"

URI_aarch64_rust-quick-xml0.38+encoding_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.38+encoding_rs-devel-0.38.4-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml0.38+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.38+encoding_rs-devel}"
SRC_URI[aarch64_rust-quick-xml0.38+encoding_rs-devel.sha256sum] = "77b8a54af1f4c35bbc3b919485d24fb49fe3e707637c59617b555bcc13c0770b"

URI_aarch64_rust-quick-xml0.38+escape-html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.38+escape-html-devel-0.38.4-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml0.38+escape-html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.38+escape-html-devel}"
SRC_URI[aarch64_rust-quick-xml0.38+escape-html-devel.sha256sum] = "4c3a21568d6a73a357258258013a4174b5e62d44cfc18b492af6b94cd7d73c70"

URI_aarch64_rust-quick-xml0.38+overlapped-lists-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.38+overlapped-lists-devel-0.38.4-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml0.38+overlapped-lists-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.38+overlapped-lists-devel}"
SRC_URI[aarch64_rust-quick-xml0.38+overlapped-lists-devel.sha256sum] = "10b6573e0d79e6def882e7a1730a9929d27e8a07aa701cc7cb3e2ea8b48a386a"

URI_aarch64_rust-quick-xml0.38+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.38+serde-devel-0.38.4-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml0.38+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.38+serde-devel}"
SRC_URI[aarch64_rust-quick-xml0.38+serde-devel.sha256sum] = "7b9630530484c838ce4c65b7d07d92ee155cb5f924246d4ef03b3f48625d0b3b"

URI_aarch64_rust-quick-xml0.38+serde-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.38+serde-types-devel-0.38.4-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml0.38+serde-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.38+serde-types-devel}"
SRC_URI[aarch64_rust-quick-xml0.38+serde-types-devel.sha256sum] = "6a130449c6048c684476b74834a4bb9f9c6096245780f06492bdb543aaf2aa9a"

URI_aarch64_rust-quick-xml0.38+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.38+serialize-devel-0.38.4-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml0.38+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.38+serialize-devel}"
SRC_URI[aarch64_rust-quick-xml0.38+serialize-devel.sha256sum] = "2021eb8c40cf017c59d19cdb5fff4d30a41b8f9aee73e6c6b45d3f48de031613"

URI_aarch64_rust-quick-xml0.38+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.38+tokio-devel-0.38.4-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml0.38+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.38+tokio-devel}"
SRC_URI[aarch64_rust-quick-xml0.38+tokio-devel.sha256sum] = "2c54a7ea29c727b26c29fbd1c779bd78a1632a4b9480d2ad8efa83128354cc67"

URI_aarch64_rust-quick-xml0.38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.38-devel-0.38.4-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml0.38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.38-devel}"
SRC_URI[aarch64_rust-quick-xml0.38-devel.sha256sum] = "4649394f4203874208b89d4859c1d35cb12abd4fb578cc426476d47dd884dff5"

RDEPENDS:rust-quick-xml0.38+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-quick-xml0.38-devel \
 "
RDEPENDS:rust-quick-xml0.38+async-tokio-devel = " \
 cargo \
 rust-quick-xml0.38+tokio-devel \
 rust-quick-xml0.38-devel \
 "
RDEPENDS:rust-quick-xml0.38+default-devel = " \
 cargo \
 rust-quick-xml0.38-devel \
 "
RDEPENDS:rust-quick-xml0.38+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-quick-xml0.38-devel \
 "
RDEPENDS:rust-quick-xml0.38+encoding-devel = " \
 cargo \
 rust-quick-xml0.38+encoding_rs-devel \
 rust-quick-xml0.38-devel \
 "
RDEPENDS:rust-quick-xml0.38+encoding_rs-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-quick-xml0.38-devel \
 "
RDEPENDS:rust-quick-xml0.38+escape-html-devel = " \
 cargo \
 rust-quick-xml0.38-devel \
 "
RDEPENDS:rust-quick-xml0.38+overlapped-lists-devel = " \
 cargo \
 rust-quick-xml0.38-devel \
 "
RDEPENDS:rust-quick-xml0.38+serde-devel = " \
 cargo \
 rust-quick-xml0.38-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-quick-xml0.38+serde-types-devel = " \
 cargo \
 rust-quick-xml0.38-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-quick-xml0.38+serialize-devel = " \
 cargo \
 rust-quick-xml0.38+serde-devel \
 rust-quick-xml0.38-devel \
 "
RDEPENDS:rust-quick-xml0.38+tokio-devel = " \
 cargo \
 rust-quick-xml0.38-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-quick-xml0.38-devel = " \
 cargo \
 rust \
 rust-memchr+default-devel \
 "
