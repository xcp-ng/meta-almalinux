# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Lingua-EN-Sentence"
PV = "0.34"
PR = "2.el10_0"
PACKAGES = " \
 perl-Lingua-EN-Sentence \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Lingua-EN-Sentence-0.34-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66b026ace8c2c057f199fa4e8056f0e8770813fb6f95332ecaa00c031af7da97"

URI_x86_64_v2_perl-Lingua-EN-Sentence = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Lingua-EN-Sentence-0.34-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Lingua-EN-Sentence;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Lingua-EN-Sentence}"
SRC_URI[x86_64_v2_perl-Lingua-EN-Sentence.sha256sum] = "b43aa8f2dad2eefa8552debd2d188c2d12ec2d02229fffbf2f7d045c66e18c4c"

URI_aarch64_perl-Lingua-EN-Sentence = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Lingua-EN-Sentence-0.34-2.el10_0.noarch.rpm;name=aarch64_perl-Lingua-EN-Sentence;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Lingua-EN-Sentence}"
SRC_URI[aarch64_perl-Lingua-EN-Sentence.sha256sum] = "048b01fdc9bf9a1665e6504595faaa96f2700959e3371f6a58376c531061eefb"

RDEPENDS:perl-Lingua-EN-Sentence = " \
 perl-Carp \
 perl-English \
 perl-Exporter \
 perl-POSIX \
 perl-libs \
 perl-locale \
 perl-vars \
 "
