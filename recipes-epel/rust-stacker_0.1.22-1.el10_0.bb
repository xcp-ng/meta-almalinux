# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-stacker"
PV = "0.1.22"
PR = "1.el10_0"
PACKAGES = " \
 rust-stacker+default-devel \
 rust-stacker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-stacker-0.1.22-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54e1f138aa82bb9457a94fe676fdb07abf5ed18fa94845aee477ae9dd3b3c9e9"

URI_x86_64_v2_rust-stacker+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stacker+default-devel-0.1.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stacker+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stacker+default-devel}"
SRC_URI[x86_64_v2_rust-stacker+default-devel.sha256sum] = "2aa87e11b1be16b370094a41b410deea12cbb62b83e0cb11a2e8715b2dda504f"

URI_x86_64_v2_rust-stacker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stacker-devel-0.1.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stacker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stacker-devel}"
SRC_URI[x86_64_v2_rust-stacker-devel.sha256sum] = "009e8a3de89d1ee9a74bb7dd8b20b16aa77b390ee69d9b431cefd03d606c19c4"

URI_aarch64_rust-stacker+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stacker+default-devel-0.1.22-1.el10_0.noarch.rpm;name=aarch64_rust-stacker+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stacker+default-devel}"
SRC_URI[aarch64_rust-stacker+default-devel.sha256sum] = "7f42e4e3dd4a729fc390f357136786f772c701f2e5e7cbedadf76d3dde3d66e7"

URI_aarch64_rust-stacker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stacker-devel-0.1.22-1.el10_0.noarch.rpm;name=aarch64_rust-stacker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stacker-devel}"
SRC_URI[aarch64_rust-stacker-devel.sha256sum] = "a8d76ee4aba64ebd7bae79c8caed30cae673635c7c7aabace2e2ad635ec5ae57"

RDEPENDS:rust-stacker+default-devel = " \
 cargo \
 rust-stacker-devel \
 "
RDEPENDS:rust-stacker-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-psm+default-devel \
 "
