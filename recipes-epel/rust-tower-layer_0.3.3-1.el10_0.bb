# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tower-layer"
PV = "0.3.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-tower-layer+default-devel \
 rust-tower-layer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tower-layer-0.3.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c1106af4f47e4b8105a68b62833a775e81c875ad7d2b70ef673d60eb169f59a"

URI_x86_64_v2_rust-tower-layer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-layer+default-devel-0.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-layer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-layer+default-devel}"
SRC_URI[x86_64_v2_rust-tower-layer+default-devel.sha256sum] = "320d39d17b16ce6b08327f20b3497c4131fe09e3d154807c84a615eebe202a34"

URI_x86_64_v2_rust-tower-layer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-layer-devel-0.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-layer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-layer-devel}"
SRC_URI[x86_64_v2_rust-tower-layer-devel.sha256sum] = "515254ad6f0a57cc5e3129bd1330f77bd4ff0fe3315969eaa8b15283d5853f7f"

URI_aarch64_rust-tower-layer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-layer+default-devel-0.3.3-1.el10_0.noarch.rpm;name=aarch64_rust-tower-layer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-layer+default-devel}"
SRC_URI[aarch64_rust-tower-layer+default-devel.sha256sum] = "24de1d2c14c99fa31ce179967c49a814e998960fde2bfef2cd0d35170f9055b8"

URI_aarch64_rust-tower-layer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-layer-devel-0.3.3-1.el10_0.noarch.rpm;name=aarch64_rust-tower-layer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-layer-devel}"
SRC_URI[aarch64_rust-tower-layer-devel.sha256sum] = "c515e2ca4d95948422d4e3ff27bbe8d13d7840e4912c3891df16786361fe98c3"

RDEPENDS:rust-tower-layer+default-devel = " \
 cargo \
 rust-tower-layer-devel \
 "
RDEPENDS:rust-tower-layer-devel = " \
 cargo \
 "
