# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fs-err2"
PV = "2.11.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-fs-err2+default-devel \
 rust-fs-err2+io_safety-devel \
 rust-fs-err2+tokio-devel \
 rust-fs-err2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fs-err2-2.11.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ea9d892f3f3b434739464f75820caf46801bca1335f8d49a5812e02cf0492e7"

URI_x86_64_v2_rust-fs-err2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err2+default-devel-2.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs-err2+default-devel}"
SRC_URI[x86_64_v2_rust-fs-err2+default-devel.sha256sum] = "ac07615672ab9830b605d8de6a0589645545646e7bd418c4fe1917a34f70d8df"

URI_x86_64_v2_rust-fs-err2+io_safety-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err2+io_safety-devel-2.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err2+io_safety-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs-err2+io_safety-devel}"
SRC_URI[x86_64_v2_rust-fs-err2+io_safety-devel.sha256sum] = "3d482704520433b51bd6be1eb1b3c253635d73e7682b3351787a61fade94d785"

URI_x86_64_v2_rust-fs-err2+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err2+tokio-devel-2.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err2+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs-err2+tokio-devel}"
SRC_URI[x86_64_v2_rust-fs-err2+tokio-devel.sha256sum] = "779f4c18af5b1cc17c3224e744d503c309b04768ae9688fa8ee289477fd80d9d"

URI_x86_64_v2_rust-fs-err2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err2-devel-2.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs-err2-devel}"
SRC_URI[x86_64_v2_rust-fs-err2-devel.sha256sum] = "33739eaee94dca9ac6acf391a2be583c8a0aedc2b690380f35d41cd6eb3a4024"

URI_aarch64_rust-fs-err2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err2+default-devel-2.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-fs-err2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs-err2+default-devel}"
SRC_URI[aarch64_rust-fs-err2+default-devel.sha256sum] = "815d3096d9e7fcc82ed176cd98220b675ece51ff4c65f0f7d1bf32a430e633c7"

URI_aarch64_rust-fs-err2+io_safety-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err2+io_safety-devel-2.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-fs-err2+io_safety-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs-err2+io_safety-devel}"
SRC_URI[aarch64_rust-fs-err2+io_safety-devel.sha256sum] = "7278f5dce6085b6793d9c0f0c710c80bcef995a54f161d91ffdf5a08f32e2a3b"

URI_aarch64_rust-fs-err2+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err2+tokio-devel-2.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-fs-err2+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs-err2+tokio-devel}"
SRC_URI[aarch64_rust-fs-err2+tokio-devel.sha256sum] = "542892b6d6d06c94c7c8731af45138d6b5084980454406c918b5a9b9fc315f5f"

URI_aarch64_rust-fs-err2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err2-devel-2.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-fs-err2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs-err2-devel}"
SRC_URI[aarch64_rust-fs-err2-devel.sha256sum] = "785612ddbeeb054acd72111c1c28e9bdd3255c175d9242aea3ff7f2934ac5b0e"

RDEPENDS:rust-fs-err2+default-devel = " \
 cargo \
 rust-fs-err2-devel \
 "
RDEPENDS:rust-fs-err2+io_safety-devel = " \
 cargo \
 rust-fs-err2-devel \
 "
RDEPENDS:rust-fs-err2+tokio-devel = " \
 cargo \
 rust-fs-err2-devel \
 rust-tokio+fs-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-fs-err2-devel = " \
 cargo \
 rust-autocfg+default-devel \
 "
