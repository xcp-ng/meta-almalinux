# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest"
PV = "0.13.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqwest+__native-tls-alpn-devel \
 rust-reqwest+__native-tls-devel \
 rust-reqwest+__rustls-devel \
 rust-reqwest+__rustls-ring-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+brotli-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+cookies-devel \
 rust-reqwest+default-devel \
 rust-reqwest+default-tls-devel \
 rust-reqwest+deflate-devel \
 rust-reqwest+form-devel \
 rust-reqwest+gzip-devel \
 rust-reqwest+hickory-dns-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+json-devel \
 rust-reqwest+multipart-devel \
 rust-reqwest+native-tls-devel \
 rust-reqwest+native-tls-no-alpn-devel \
 rust-reqwest+query-devel \
 rust-reqwest+rustls-devel \
 rust-reqwest+rustls-no-provider-devel \
 rust-reqwest+socks-devel \
 rust-reqwest+stream-devel \
 rust-reqwest+system-proxy-devel \
 rust-reqwest+zstd-devel \
 rust-reqwest-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-0.13.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "64f6d7cc9f65fb58b8511cd664e506cdb27da074410028a95e04fcfe79c24db6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__native-tls-alpn-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__native-tls-alpn-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+__native-tls-alpn-devel.sha256sum] = "3fd828fa71eff5ee874db28ab0027967fa64908ac56cbad482db7b2da5e6f460"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__native-tls-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__native-tls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+__native-tls-devel.sha256sum] = "c87ccb56267cc8cdefea05d731c035449a984a36fcf3539c131247be16002e6a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__rustls-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__rustls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+__rustls-devel.sha256sum] = "1a31438e6cce9ed565cfa88c1da008bfe9e16fb93b62f9a1e1522bcf868db204"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__rustls-ring-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__rustls-ring-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+__rustls-ring-devel.sha256sum] = "150a544b17498d6fe5725f0dc8a93211af140dbf8c97300ede46ad51aa2bc2e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__tls-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__tls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+__tls-devel.sha256sum] = "388571fc1ef4c574aa66a770f8d2a815490fb66473004264478c804768667eab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+blocking-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+blocking-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+blocking-devel.sha256sum] = "6397393cb0bd4edba0c93e9e1555fca880254b73e5c88a40a9adaa191a40ceed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+brotli-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+brotli-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+brotli-devel.sha256sum] = "fb9c8c4b9f56a7dd1bce8747f04493beaa607e442043dca79f4a454b4bd717c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+charset-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+charset-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+charset-devel.sha256sum] = "46d90bac09055b827db5d10783cbedbf534728b30ee1c04bbbdcd87b70322429"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+cookies-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+cookies-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+cookies-devel.sha256sum] = "536dc91d9386a0d269804305ed8da302d327cbb3ff34528446336263404599cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+default-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+default-devel.sha256sum] = "5d160a6d2cc0f41257f9f5b61c2f7cfa92aff8c331e3d9522bef413ef1e457e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+default-tls-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+default-tls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+default-tls-devel.sha256sum] = "876220f53d0338ca419fb8b5662106abebb347f78df39e570e3c21f28dc05632"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+deflate-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+deflate-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+deflate-devel.sha256sum] = "386a844ff1aca40cf30ad70a9dda6edfadd7ff1d706a920113cd580cf19e7894"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+form-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+form-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+form-devel.sha256sum] = "86e9215fccfa36fecfcb8c59e63209429f040b6a85be163175c686f3c9271844"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+gzip-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+gzip-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+gzip-devel.sha256sum] = "b1d0920cfd5f6ce155eafa1c22fafb08a89793c16cf1efd73f1afe219db1f0aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+hickory-dns-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+hickory-dns-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+hickory-dns-devel.sha256sum] = "3e2d75ed0f112ad8936ecad4599bd57e118e6601d915b8d1e53ff7747f8e7117"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+http2-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+http2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+http2-devel.sha256sum] = "d2cbd40f6a69b6e4fe59d309dba98e150e23ca0f53659908938b5f84020d8173"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+json-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+json-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+json-devel.sha256sum] = "ecaf97702af6be0a23391856eb3e27d67711ea9775260269f05f524d99c1252a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+multipart-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+multipart-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+multipart-devel.sha256sum] = "e20daef2ce29629f8b36015cb55ada2625c3174725a756899e6caa14145a79c8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+native-tls-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+native-tls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+native-tls-devel.sha256sum] = "3c277ddf772ad170f069b45ec00b5d3bd985d3d9b661e49be0a41996b91c3c83"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+native-tls-no-alpn-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+native-tls-no-alpn-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+native-tls-no-alpn-devel.sha256sum] = "9f891b83691d2d90698791d7dcfa50588043a4fca29518ea873ac4dc8e2c4776"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+query-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+query-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+query-devel.sha256sum] = "b1752ad9e6d94a34f33cdc02958e3c3d5f2504f944cfcb0eecf2a6418f18da32"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+rustls-devel.sha256sum] = "76a683c3a54b3db476c70334a3238a44a173be9ce2b55e9e52305295095bc434"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-no-provider-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-no-provider-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+rustls-no-provider-devel.sha256sum] = "c8bf3536761636a1d37eb3dfa7e0f2d76f6aea71cd92ebcd95bffc549a0e24e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+socks-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+socks-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+socks-devel.sha256sum] = "0a3d2e4de5bf29cad38a641a2e11d12ed1377f0fe94b9e53258e493765d4ccfd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+stream-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+stream-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+stream-devel.sha256sum] = "01e7abbe23a2b35d2709805297801ea7b956cdeee46dac6f46310bffafc936c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+system-proxy-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+system-proxy-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+system-proxy-devel.sha256sum] = "f0bbb97e93c5ddc9ea6b42810fa29cd0ec90d3e5f610f39db377fb4ac3c99497"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+zstd-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+zstd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest+zstd-devel.sha256sum] = "24966ccbdced4a42d2f39e91b56b65acd473c59334c752bc773a8c4cb3255eaa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-devel-0.13.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqwest-devel.sha256sum] = "578f127ac1c8d1d0b7f3722ea777eabd300f904d40aa2f04f65ff189217573ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__native-tls-alpn-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+__native-tls-alpn-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+__native-tls-alpn-devel.sha256sum] = "5e80e1e928272222ac2b63c904b8a0cf95157917c7b024b1d8c886611cc8ac1c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__native-tls-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+__native-tls-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+__native-tls-devel.sha256sum] = "69d61fe42f61e58a82852a27959d9cb9cf21261a7cdc68018c7bd7f3b1b80ff0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__rustls-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+__rustls-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+__rustls-devel.sha256sum] = "1260d885ce4b6bba78e84149e30655f35908074edbc237269fa047a4328a2444"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__rustls-ring-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+__rustls-ring-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+__rustls-ring-devel.sha256sum] = "380e29c5beedc71f376a0b361c2965ecc83e86e67b40857524b06b23fa671488"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__tls-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+__tls-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+__tls-devel.sha256sum] = "053525a5017bfcf2f93d6e57081622018e175731d8ce1432b97817cce3021776"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+blocking-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+blocking-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+blocking-devel.sha256sum] = "d19452af9c2623ed4b570823c9a438d2a1cef3d1650490865b909dfe1b10a438"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+brotli-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+brotli-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+brotli-devel.sha256sum] = "7adce08426f33e3a741909775e9d30e0249787da637dd058336dc47e8dc2b794"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+charset-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+charset-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+charset-devel.sha256sum] = "919a3f7484ea7a79af491f9ea5468065d9e35a579f7de7997385c256683730a1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+cookies-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+cookies-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+cookies-devel.sha256sum] = "f089155563f96e4ab014ff8dc3c4358778ddfd757d9ae80398c0a723252f6f30"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+default-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+default-devel.sha256sum] = "acdb609a5cf094e073258fd6496f0ae40dae19bfa2112063f60140c8b604cb39"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+default-tls-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+default-tls-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+default-tls-devel.sha256sum] = "b6b27adc37e67eca0fcef661fda36b4f9152dc6785a91e0b6aa12df253390374"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+deflate-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+deflate-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+deflate-devel.sha256sum] = "25cd0b7b5ba9ef6673bc0f80530aa4714ab129a7d507b9e804545a1135b45d1c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+form-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+form-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+form-devel.sha256sum] = "72381c68581b4e08bf2616d21560432a01cd247212fd0756e7b52ac2c77d0298"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+gzip-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+gzip-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+gzip-devel.sha256sum] = "bae5897b6c2bab4c07e4b960eea81c38ae0c4ce69b66be5775edd16b9dd6af2b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+hickory-dns-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+hickory-dns-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+hickory-dns-devel.sha256sum] = "f207a6cd15f403cc7ce06966cb3e3f95640b8e94c031b9955405c81ccf985093"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+http2-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+http2-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+http2-devel.sha256sum] = "f7f4345f03afd0e8c971e0eb1f7ae27426152557d8b0d56002bfd525c0718e96"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+json-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+json-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+json-devel.sha256sum] = "8285d54d7ab659a0c80e415c4d1089753146a243d4281ac4c0f440f46aaf6cb2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+multipart-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+multipart-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+multipart-devel.sha256sum] = "58fd0f6a09a2599b1358225ff76a5517abc742bd549935e5d914053504a7bcc0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+native-tls-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+native-tls-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+native-tls-devel.sha256sum] = "57e151f0b4c4fb1d566fe54265647b2578f3de02878fd3aeaa56577a88ad5da5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+native-tls-no-alpn-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+native-tls-no-alpn-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+native-tls-no-alpn-devel.sha256sum] = "5fcc9ab121e2e2d0258ac3aa52c7805fddd10284c81aa14927c87d704678a3da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+query-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+query-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+query-devel.sha256sum] = "4a70a6e2315fd96f46c796bf8aa9603974f0bc743962dae67ed22759f85d0945"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+rustls-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+rustls-devel.sha256sum] = "481675b5ab5f48526f24c99b59e94b9d0e1d63b7d2032b1efb40fa95b277d8b2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-no-provider-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+rustls-no-provider-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+rustls-no-provider-devel.sha256sum] = "854ff1d00625a765d79ca711a8951344b6551cc913585e4a19601f33de8085fd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+socks-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+socks-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+socks-devel.sha256sum] = "a4101262288224be251a5705d8c6011951f305264cb58134c6e0f161f7e4b550"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+stream-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+stream-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+stream-devel.sha256sum] = "4e621f3c9442a7a3f2cc4fe1c47d5fcadec0b54bad2975e9524a6093da8e0455"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+system-proxy-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+system-proxy-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+system-proxy-devel.sha256sum] = "8d6357166dc2a3c4e59e3eae018d77b9138ce3963b56f18d26b8d1ed40c979d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+zstd-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+zstd-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest+zstd-devel.sha256sum] = "540274264edb94b0438e152eefad9382d4da3cf79a6e4b082e5be4811560eccb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-devel-0.13.5-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest-devel;unpack=0"
SRC_URI[aarch64_rust-reqwest-devel.sha256sum] = "c10cee539634be7ea10c4fcbebe8e1b630a6aea0a98dbfe5f62e0a31c52c665b"

RDEPENDS:rust-reqwest+__native-tls-alpn-devel = " \
 cargo \
 rust-hyper-tls+alpn-devel \
 rust-hyper-tls+default-devel \
 rust-native-tls+alpn-devel \
 rust-native-tls+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+__native-tls-devel = " \
 cargo \
 rust-hyper-tls+default-devel \
 rust-native-tls+default-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest-devel \
 rust-tokio-native-tls+default-devel \
 "
RDEPENDS:rust-reqwest+__rustls-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-reqwest+__rustls-ring-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+ring-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest-devel \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-reqwest+__tls-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-pki-types+std-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-reqwest+blocking-devel = " \
 cargo \
 rust-futures-channel+default-devel \
 rust-futures-channel+sink-devel \
 rust-futures-util+io-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 rust-reqwest-devel \
 rust-tokio+sync-devel \
 "
RDEPENDS:rust-reqwest+brotli-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-tower-http+decompression-br-devel \
 "
RDEPENDS:rust-reqwest+charset-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-mime+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+cookies-devel = " \
 cargo \
 rust-cookie+default-devel \
 rust-cookie_store+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+default-devel = " \
 cargo \
 rust-reqwest+charset-devel \
 rust-reqwest+default-tls-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+system-proxy-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+default-tls-devel = " \
 cargo \
 rust-reqwest+native-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+deflate-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-tower-http+decompression-deflate-devel \
 "
RDEPENDS:rust-reqwest+form-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-serde+default-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-reqwest+gzip-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-tower-http+decompression-gzip-devel \
 "
RDEPENDS:rust-reqwest+hickory-dns-devel = " \
 cargo \
 rust-hickory-resolver+default-devel \
 rust-hickory-resolver+tokio-devel \
 rust-once_cell+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+http2-devel = " \
 cargo \
 rust-h2+default-devel \
 rust-hyper+http2-devel \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+http2-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-hyper-util+http2-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+json-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-reqwest+multipart-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-mime_guess-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+native-tls-devel = " \
 cargo \
 rust-reqwest+__native-tls-alpn-devel \
 rust-reqwest+__native-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+native-tls-no-alpn-devel = " \
 cargo \
 rust-reqwest+__native-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+query-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-serde+default-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-reqwest+rustls-devel = " \
 cargo \
 rust-reqwest+__rustls-devel \
 rust-reqwest+__rustls-ring-devel \
 rust-reqwest-devel \
 rust-rustls-platform-verifier+default-devel \
 "
RDEPENDS:rust-reqwest+rustls-no-provider-devel = " \
 cargo \
 rust-reqwest+__rustls-devel \
 rust-reqwest-devel \
 rust-rustls-platform-verifier+default-devel \
 "
RDEPENDS:rust-reqwest+socks-devel = " \
 cargo \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+stream-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-reqwest-devel \
 rust-tokio+fs-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-reqwest+system-proxy-devel = " \
 cargo \
 rust-hyper-util+client-proxy-system-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+zstd-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-tower-http+decompression-zstd-devel \
 "
RDEPENDS:rust-reqwest-devel = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-bytes+default-devel \
 rust-futures-core-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-hyper+client-devel \
 rust-hyper+default-devel \
 rust-hyper+http1-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+client-proxy-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+tokio-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-pin-project-lite+default-devel \
 rust-sync_wrapper+default-devel \
 rust-sync_wrapper+futures-devel \
 rust-tokio+net-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tower+retry-devel \
 rust-tower+timeout-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http-devel \
 rust-tower-service+default-devel \
 rust-url+default-devel \
 "
