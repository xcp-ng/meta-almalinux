# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-bigint"
PV = "0.4.6"
PR = "2.el10_0"
PACKAGES = " \
 rust-num-bigint+arbitrary-devel \
 rust-num-bigint+default-devel \
 rust-num-bigint+quickcheck-devel \
 rust-num-bigint+rand-devel \
 rust-num-bigint+serde-devel \
 rust-num-bigint+std-devel \
 rust-num-bigint-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-bigint-0.4.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0ce2c07e1ebf0d10c95520b9c17d46962087275b6b1c2f0ce7e3743a531a2c2"

URI_x86_64_v2_rust-num-bigint+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+arbitrary-devel-0.4.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+arbitrary-devel.sha256sum] = "54f4dd6a8eb356f409344a80303e59e7c655d544203daa7c9de847a8facab87c"

URI_x86_64_v2_rust-num-bigint+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+default-devel-0.4.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+default-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+default-devel.sha256sum] = "9aa700927c72648ac1c4833448d011cf68459fbf31cd0b173681f5e2dc75b757"

URI_x86_64_v2_rust-num-bigint+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+quickcheck-devel-0.4.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+quickcheck-devel.sha256sum] = "e42afb2c44127c3cccb51d31a602897301d6e258be34227052b698748a3530d7"

URI_x86_64_v2_rust-num-bigint+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+rand-devel-0.4.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+rand-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+rand-devel.sha256sum] = "665d9ad0276be85169f8b9ca2e13d5a77c6f92f8846d75f27c956d8ac48087e8"

URI_x86_64_v2_rust-num-bigint+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+serde-devel-0.4.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+serde-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+serde-devel.sha256sum] = "8a0c1822c7c2aa399ad95685703fda598ef1ea7728b6ab6e3e81d027a4128c65"

URI_x86_64_v2_rust-num-bigint+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+std-devel-0.4.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+std-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+std-devel.sha256sum] = "1c99f1a1ac8a694e239780298ada23d33c02e1bc5bf0577e6f73a8ef6a91c6a8"

URI_x86_64_v2_rust-num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-devel-0.4.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-devel.sha256sum] = "d6b8e5df8a6174a16b82fedea24101c00e36839cee649b9b6a56e14df5c6f782"

URI_aarch64_rust-num-bigint+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+arbitrary-devel-0.4.6-2.el10_0.noarch.rpm;name=aarch64_rust-num-bigint+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+arbitrary-devel}"
SRC_URI[aarch64_rust-num-bigint+arbitrary-devel.sha256sum] = "66ebf99f54454ebe03dfc0db53d93b7749497d7086eff7cd0ad1740ca2a037f9"

URI_aarch64_rust-num-bigint+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+default-devel-0.4.6-2.el10_0.noarch.rpm;name=aarch64_rust-num-bigint+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+default-devel}"
SRC_URI[aarch64_rust-num-bigint+default-devel.sha256sum] = "2f43a40036acd6973beae8307756c89c8704be496cb2b7f29415771bd13ae033"

URI_aarch64_rust-num-bigint+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+quickcheck-devel-0.4.6-2.el10_0.noarch.rpm;name=aarch64_rust-num-bigint+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+quickcheck-devel}"
SRC_URI[aarch64_rust-num-bigint+quickcheck-devel.sha256sum] = "b8caae936e0079b4c27238c215214d551af52cc72b52f532196dfb38d0ee1f7a"

URI_aarch64_rust-num-bigint+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+rand-devel-0.4.6-2.el10_0.noarch.rpm;name=aarch64_rust-num-bigint+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+rand-devel}"
SRC_URI[aarch64_rust-num-bigint+rand-devel.sha256sum] = "7ec6e869e86fb0a7709bb285f77d090a094786ec92926d9c67cc4bfb282c3f71"

URI_aarch64_rust-num-bigint+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+serde-devel-0.4.6-2.el10_0.noarch.rpm;name=aarch64_rust-num-bigint+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+serde-devel}"
SRC_URI[aarch64_rust-num-bigint+serde-devel.sha256sum] = "e65e02ed5cf49682a8314c4cb666a90ffa903a3061c7278a0f0391e1fd5f14e8"

URI_aarch64_rust-num-bigint+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+std-devel-0.4.6-2.el10_0.noarch.rpm;name=aarch64_rust-num-bigint+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+std-devel}"
SRC_URI[aarch64_rust-num-bigint+std-devel.sha256sum] = "a3bdeb146aadbe953e81e7953b4cd08178e5d2bf6ff4bd0b30cb2733363fbeb4"

URI_aarch64_rust-num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-devel-0.4.6-2.el10_0.noarch.rpm;name=aarch64_rust-num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-devel}"
SRC_URI[aarch64_rust-num-bigint-devel.sha256sum] = "67d3207d5c6097723de4916c37edb3464f37d15b737d693e9e3db17087dc076f"

RDEPENDS:rust-num-bigint+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-num-bigint-devel \
 "
RDEPENDS:rust-num-bigint+default-devel = " \
 cargo \
 rust-num-bigint+std-devel \
 rust-num-bigint-devel \
 "
RDEPENDS:rust-num-bigint+quickcheck-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-num-bigint+rand-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-num-bigint+serde-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-num-bigint+std-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-num-integer+std-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-num-bigint-devel = " \
 cargo \
 rust \
 rust-num-integer+i128-devel \
 rust-num-integer-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
