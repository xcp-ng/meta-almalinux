# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-rs-xid"
PV = "1.5.0"
PR = "5.el10_0"
PACKAGES = " \
 golang-github-rs-xid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-rs-xid-1.5.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f32faa7a520bb4f3631372f6db13cff58b13beb813242a753ef62756591ec6d6"

URI_x86_64_v2_golang-github-rs-xid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-rs-xid-devel-1.5.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-rs-xid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-rs-xid-devel}"
SRC_URI[x86_64_v2_golang-github-rs-xid-devel.sha256sum] = "e050ecbd6b3e307282ed1b43fc12ba25ad178d8f5a8737a1516f812e4b0adee9"

URI_aarch64_golang-github-rs-xid-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-rs-xid-devel-1.5.0-5.el10_0.noarch.rpm;name=aarch64_golang-github-rs-xid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-rs-xid-devel}"
SRC_URI[aarch64_golang-github-rs-xid-devel.sha256sum] = "2ce42c99575a21e66255858ffd736883bd2655bc4d43d061e9ff7ac7bbed1e41"

RDEPENDS:golang-github-rs-xid-devel = " \
 go-filesystem \
 "
