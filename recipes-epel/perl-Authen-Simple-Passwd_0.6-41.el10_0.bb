# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Authen-Simple-Passwd"
PV = "0.6"
PR = "41.el10_0"
PACKAGES = " \
 perl-Authen-Simple-Passwd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Authen-Simple-Passwd-0.6-41.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5e772df2b4605bb7c28a0b54aa3bd81b2d703c3e31a7025be931edf187491fd"

URI_x86_64_v2_perl-Authen-Simple-Passwd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Authen-Simple-Passwd-0.6-41.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Authen-Simple-Passwd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Authen-Simple-Passwd}"
SRC_URI[x86_64_v2_perl-Authen-Simple-Passwd.sha256sum] = "8a28f8b7439408c5645e314f85135461bc9db36e60a6c2fadf5235a17ed00631"

URI_aarch64_perl-Authen-Simple-Passwd = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Authen-Simple-Passwd-0.6-41.el10_0.noarch.rpm;name=aarch64_perl-Authen-Simple-Passwd;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Authen-Simple-Passwd}"
SRC_URI[aarch64_perl-Authen-Simple-Passwd.sha256sum] = "8a348ca07c6ffdb757201526ce745aae5d7eeaf3e981e8e07991c0e12d326a93"

RDEPENDS:perl-Authen-Simple-Passwd = " \
 perl-Authen-Simple \
 perl-Carp \
 perl-Fcntl \
 perl-IO \
 perl-Params-Validate \
 perl-base \
 perl-libs \
 "
