# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netavark"
PE = "2"
PV = "1.14.1"
PR = "1.el10_0"
PACKAGES = " \
 netavark \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/netavark-1.14.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15e708cc00f18b390a6b176e33faf4b7845ca02e48089c2873c42320054a72ca"

URI_x86_64_v2_netavark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/netavark-1.14.1-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_netavark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netavark}"
SRC_URI[x86_64_v2_netavark.sha256sum] = "aeddbcb32f8ab8acfb1966e2515a5a7518be6f6e8b441223fa7f4dfad966d974"

URI_aarch64_netavark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/netavark-1.14.1-1.el10_0.aarch64.rpm;name=aarch64_netavark;unpack=0"
SRC_URI:append = " ${URI_aarch64_netavark}"
SRC_URI[aarch64_netavark.sha256sum] = "005e27381ac7472d9865f206335b21169418d70a37b47e45adc62d3544317830"

RDEPENDS:netavark = " \
 aardvark-dns \
 bash \
 glibc \
 libgcc \
 nftables \
 "
