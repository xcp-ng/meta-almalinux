# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyftpdlib"
PV = "2.0.1"
PR = "3.el10_1"
PACKAGES = " \
 python3-pyftpdlib \
 python3-pyftpdlib+ssl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyftpdlib-2.0.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "caea87ca4c3e42dd7135f21ea2e5505bfe33c38d67470f3705feaeee7392b2f5"

URI_x86_64_v2_python3-pyftpdlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyftpdlib-2.0.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyftpdlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyftpdlib}"
SRC_URI[x86_64_v2_python3-pyftpdlib.sha256sum] = "05b9a5fa7e5c2cd10e4caf83dae005ca3314c6073793cdd525ef752fae7707cd"

URI_x86_64_v2_python3-pyftpdlib+ssl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyftpdlib+ssl-2.0.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyftpdlib+ssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyftpdlib+ssl}"
SRC_URI[x86_64_v2_python3-pyftpdlib+ssl.sha256sum] = "5c267d104e0fa4c86312e24150a45ad4af8ce0685fbbd97efb05e2612792bd1d"

URI_aarch64_python3-pyftpdlib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyftpdlib-2.0.1-3.el10_1.noarch.rpm;name=aarch64_python3-pyftpdlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyftpdlib}"
SRC_URI[aarch64_python3-pyftpdlib.sha256sum] = "5885fbeadcad6dc1db0090e36e74a677b186cf970e9a091d67c5a116bbc79a52"

URI_aarch64_python3-pyftpdlib+ssl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyftpdlib+ssl-2.0.1-3.el10_1.noarch.rpm;name=aarch64_python3-pyftpdlib+ssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyftpdlib+ssl}"
SRC_URI[aarch64_python3-pyftpdlib+ssl.sha256sum] = "804608eedd226719987d8ca4ee91cec9e9f2ce769f877e5b6e3e57aaac0eee26"

RDEPENDS:python3-pyftpdlib = " \
 python3 \
 python3-pyasynchat \
 python3-pyasyncore \
 "
RDEPENDS:python3-pyftpdlib+ssl = " \
 python3 \
 python3-pyOpenSSL \
 python3-pyftpdlib \
 "
