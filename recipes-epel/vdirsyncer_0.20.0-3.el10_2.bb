# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vdirsyncer"
PV = "0.20.0"
PR = "3.el10_2"
PACKAGES = " \
 python3-vdirsyncer \
 vdirsyncer \
 vdirsyncer-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vdirsyncer-0.20.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4242d16121ed3348afd0a103915d8b8c302c234ee58b1266e21e385229e631f4"

URI_x86_64_v2_python3-vdirsyncer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-vdirsyncer-0.20.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-vdirsyncer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-vdirsyncer}"
SRC_URI[x86_64_v2_python3-vdirsyncer.sha256sum] = "71a9c241fb932de30b47cc5593ba40797ac5e446acb624499edb4c531f516b84"

URI_x86_64_v2_vdirsyncer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vdirsyncer-0.20.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_vdirsyncer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vdirsyncer}"
SRC_URI[x86_64_v2_vdirsyncer.sha256sum] = "0861d13c7afd1971e88c2e019aab490641a349790aa5fb29b03c9dfc85ee8c01"

URI_x86_64_v2_vdirsyncer-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vdirsyncer-doc-0.20.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_vdirsyncer-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vdirsyncer-doc}"
SRC_URI[x86_64_v2_vdirsyncer-doc.sha256sum] = "eef382f78956faa89eabc9d53b21eb698983cf6ad3dee04465836bce32262a8d"

URI_aarch64_python3-vdirsyncer = "${EPEL_MIRROR}/aarch64/Packages/p/python3-vdirsyncer-0.20.0-3.el10_2.noarch.rpm;name=aarch64_python3-vdirsyncer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-vdirsyncer}"
SRC_URI[aarch64_python3-vdirsyncer.sha256sum] = "d62398e4afb7521f68f9022fb2c0d9a1c4cddc0e22297d3935e649fe63c6b6ab"

URI_aarch64_vdirsyncer = "${EPEL_MIRROR}/aarch64/Packages/v/vdirsyncer-0.20.0-3.el10_2.noarch.rpm;name=aarch64_vdirsyncer;unpack=0"
SRC_URI:append = " ${URI_aarch64_vdirsyncer}"
SRC_URI[aarch64_vdirsyncer.sha256sum] = "1a33be0a51a6c6a9142b038c5a9e26588393861e6a825901e8aa3e74a5ec23d9"

URI_aarch64_vdirsyncer-doc = "${EPEL_MIRROR}/aarch64/Packages/v/vdirsyncer-doc-0.20.0-3.el10_2.noarch.rpm;name=aarch64_vdirsyncer-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_vdirsyncer-doc}"
SRC_URI[aarch64_vdirsyncer-doc.sha256sum] = "63b6f358996a9fb04592983ccca4b75b0020810244fa2003257a8f2576d055d1"

RDEPENDS:python3-vdirsyncer = " \
 python3 \
 python3-aiohttp \
 python3-aiohttp-oauthlib \
 python3-aiostream \
 python3-click \
 python3-click-log \
 python3-click-threading \
 python3-icalendar \
 python3-lxml \
 python3-requests \
 python3-requests-toolbelt \
 "
RDEPENDS:vdirsyncer = " \
 python3 \
 python3-aiohttp-oauthlib \
 python3-click \
 python3-click-log \
 python3-click-threading \
 python3-icalendar \
 python3-lxml \
 python3-requests \
 python3-requests-toolbelt \
 python3-vdirsyncer \
 sqlite \
 "
RDEPENDS:vdirsyncer-doc = " \
 "
