# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ramalama"
PV = "0.14.0"
PR = "1.el10_0"
PACKAGES = " \
 ramalama \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/ramalama-0.14.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8c824f53c31d83e508d955e29c9c066d8b230cb2efd90c31999d2d4fb251347b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ramalama-0.14.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ramalama;unpack=0"
SRC_URI[x86_64_v2_ramalama.sha256sum] = "2fb2783789c4ec50f0bae428e7c48c8071daa673357fe46ef42cab2e049f5d4a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ramalama-0.14.0-1.el10_0.noarch.rpm;name=aarch64_ramalama;unpack=0"
SRC_URI[aarch64_ramalama.sha256sum] = "edff115793e97f441050a19e9390cfa440a66727596725a9757493342e8b773e"

RDEPENDS:ramalama = " \
 podman \
 python3 \
 python3-argcomplete \
 python3-jinja2 \
 python3-jsonschema \
 python3-pyyaml \
 "
