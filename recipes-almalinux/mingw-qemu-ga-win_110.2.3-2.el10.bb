# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-qemu-ga-win"
PV = "110.2.3"
PR = "2.el10"
PACKAGES = " \
 mingw-qemu-ga-win \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mingw-qemu-ga-win-110.2.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e73480936a206e67b6b370d9df840f5d6f45b3892cd7aa1b0d1e421973ea0c2d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mingw-qemu-ga-win-110.2.3-2.el10.noarch.rpm;name=x86_64_v2_mingw-qemu-ga-win;unpack=0"
SRC_URI[x86_64_v2_mingw-qemu-ga-win.sha256sum] = "958a04a74e12aa49ca6f7f1db46009646776851c1cedfe587840dc495068a8fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mingw-qemu-ga-win-110.2.3-2.el10.noarch.rpm;name=aarch64_mingw-qemu-ga-win;unpack=0"
SRC_URI[aarch64_mingw-qemu-ga-win.sha256sum] = "958a04a74e12aa49ca6f7f1db46009646776851c1cedfe587840dc495068a8fe"

RDEPENDS:mingw-qemu-ga-win = " \
 systemd \
 "
