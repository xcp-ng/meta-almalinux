# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zeal"
PV = "0.8.0"
PR = "1.el10_2"
PACKAGES = " \
 zeal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zeal-0.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4dfec0c1c32edf24f98ed299e485dd3ca487b6b4e20efcf9a18f27bcca82dc50"

URI_x86_64_v2_zeal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zeal-0.8.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zeal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zeal}"
SRC_URI[x86_64_v2_zeal.sha256sum] = "6fb88ae6212d794ca44ca660354f4bcf422931e2de061df7fd67d6ba4eaa3b1d"

URI_aarch64_zeal = "${EPEL_MIRROR}/aarch64/Packages/z/zeal-0.8.0-1.el10_2.aarch64.rpm;name=aarch64_zeal;unpack=0"
SRC_URI:append = " ${URI_aarch64_zeal}"
SRC_URI[aarch64_zeal.sha256sum] = "043add000482a9fb773fc3acea33ae219cfbb74342f8da58fa700f3e64f5dd5b"

RDEPENDS:zeal = " \
 glibc \
 hicolor-icon-theme \
 libX11 \
 libarchive \
 libgcc \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 sqlite-libs \
 xcb-util-keysyms \
 "
