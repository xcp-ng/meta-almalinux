# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crates-io"
PV = "0.40.18"
PR = "1.el10_3"
PACKAGES = " \
 rust-crates-io+default-devel \
 rust-crates-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crates-io-0.40.18-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16c8413e30e3f31ff899aa889652f520d1a6319856f8033286a50896b4906423"

URI_x86_64_v2_rust-crates-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crates-io+default-devel-0.40.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crates-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crates-io+default-devel}"
SRC_URI[x86_64_v2_rust-crates-io+default-devel.sha256sum] = "e460a7063af4bec5484c81fdcd32b636e8453e4738a064bf4e7b8743b3d662dc"

URI_x86_64_v2_rust-crates-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crates-io-devel-0.40.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crates-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crates-io-devel}"
SRC_URI[x86_64_v2_rust-crates-io-devel.sha256sum] = "0f29c02fb96ec910ae63d779c6e0e789d231a3d7cfa3c9ae9f4340ec02d2d8a6"

URI_aarch64_rust-crates-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crates-io+default-devel-0.40.18-1.el10_3.noarch.rpm;name=aarch64_rust-crates-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crates-io+default-devel}"
SRC_URI[aarch64_rust-crates-io+default-devel.sha256sum] = "95a83b93d29d6daf999cbedc67aae462570f1ef5b3d5b18fb0686656dedb261a"

URI_aarch64_rust-crates-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crates-io-devel-0.40.18-1.el10_3.noarch.rpm;name=aarch64_rust-crates-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crates-io-devel}"
SRC_URI[aarch64_rust-crates-io-devel.sha256sum] = "2b9d3352dd4952ef2af8c3c8bffb1e99d2b946145898f166739ada25f4f7260d"

RDEPENDS:rust-crates-io+default-devel = " \
 cargo \
 rust-crates-io-devel \
 "
RDEPENDS:rust-crates-io-devel = " \
 cargo \
 rust \
 rust-curl+default-devel \
 rust-percent-encoding+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 rust-url+default-devel \
 "
