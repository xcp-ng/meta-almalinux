# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-argon2-cffi-bindings"
PV = "21.2.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-argon2-cffi-bindings \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-argon2-cffi-bindings-21.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61ca11dae046b04d71e9e6fd5e20370c857e59aacff8d6655057484653a1f87f"

URI_x86_64_v2_python3-argon2-cffi-bindings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-argon2-cffi-bindings-21.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-argon2-cffi-bindings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-argon2-cffi-bindings}"
SRC_URI[x86_64_v2_python3-argon2-cffi-bindings.sha256sum] = "96cdb0c7cafc1352d5633eb356bcb6d3c6a5914eb3b078f9db9f8654be1c744a"

URI_aarch64_python3-argon2-cffi-bindings = "${EPEL_MIRROR}/aarch64/Packages/p/python3-argon2-cffi-bindings-21.2.0-1.el10_0.aarch64.rpm;name=aarch64_python3-argon2-cffi-bindings;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-argon2-cffi-bindings}"
SRC_URI[aarch64_python3-argon2-cffi-bindings.sha256sum] = "803e64dd6ee5905f2c98ebfcab786c6797fe43d9057cd462b8a785e22bb2de9e"

RDEPENDS:python3-argon2-cffi-bindings = " \
 glibc \
 libargon2 \
 python3 \
 python3-cffi \
 "
