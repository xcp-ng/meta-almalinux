# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zune-core0.4"
PV = "0.4.12"
PR = "1.el10_2"
PACKAGES = " \
 rust-zune-core0.4+default-devel \
 rust-zune-core0.4+log-devel \
 rust-zune-core0.4+serde-devel \
 rust-zune-core0.4+std-devel \
 rust-zune-core0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zune-core0.4-0.4.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb84094b724b34d3732b5c3a190b1b18320887638e2e2fd675d78485e15006be"

URI_x86_64_v2_rust-zune-core0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core0.4+default-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core0.4+default-devel}"
SRC_URI[x86_64_v2_rust-zune-core0.4+default-devel.sha256sum] = "43f86680f47ffb9eddbba31c1dce4344b3b0c2be1c00c3c2da92367100e2457b"

URI_x86_64_v2_rust-zune-core0.4+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core0.4+log-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core0.4+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core0.4+log-devel}"
SRC_URI[x86_64_v2_rust-zune-core0.4+log-devel.sha256sum] = "a00741f57b6011c72cdbfde6a6055fab54dc17271e58cd852cad9d9cbc3867b3"

URI_x86_64_v2_rust-zune-core0.4+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core0.4+serde-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core0.4+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core0.4+serde-devel}"
SRC_URI[x86_64_v2_rust-zune-core0.4+serde-devel.sha256sum] = "0f332147ef7dfce004a21d0d5e80d1a5130524b04ff5f4a52745f301485e0316"

URI_x86_64_v2_rust-zune-core0.4+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core0.4+std-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core0.4+std-devel}"
SRC_URI[x86_64_v2_rust-zune-core0.4+std-devel.sha256sum] = "41f09fe3da245c48db1607d576db84096c9940eda3bc32c0ae646741621e4aa2"

URI_x86_64_v2_rust-zune-core0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core0.4-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core0.4-devel}"
SRC_URI[x86_64_v2_rust-zune-core0.4-devel.sha256sum] = "fbf51703faa08e40d5f25f2543e58c6bea7d362a4b14ac23e5e01ff560675aa0"

URI_aarch64_rust-zune-core0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core0.4+default-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-zune-core0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core0.4+default-devel}"
SRC_URI[aarch64_rust-zune-core0.4+default-devel.sha256sum] = "a438569e2154dce952d3bccd058f1f1e38192078b358bb6fed26deae51a66d03"

URI_aarch64_rust-zune-core0.4+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core0.4+log-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-zune-core0.4+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core0.4+log-devel}"
SRC_URI[aarch64_rust-zune-core0.4+log-devel.sha256sum] = "64bbbf5e4c75e8842e9dff26ffa3b9591e1f20e459216fd549743da7b8f90e9f"

URI_aarch64_rust-zune-core0.4+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core0.4+serde-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-zune-core0.4+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core0.4+serde-devel}"
SRC_URI[aarch64_rust-zune-core0.4+serde-devel.sha256sum] = "8b76440b0b49fc0129ea61f9e73bd4cd55a00ea6920a979f7e57914c6cfa68a8"

URI_aarch64_rust-zune-core0.4+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core0.4+std-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-zune-core0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core0.4+std-devel}"
SRC_URI[aarch64_rust-zune-core0.4+std-devel.sha256sum] = "ce1ce742100e9d66791f1d2ffe8ab3a8345a4b5d2f48c5868d80687b7cbcb88d"

URI_aarch64_rust-zune-core0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core0.4-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-zune-core0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core0.4-devel}"
SRC_URI[aarch64_rust-zune-core0.4-devel.sha256sum] = "10b6af897774873a36feb5b8c6707d49fdcda039f780d6edb459c738833eaa56"

RDEPENDS:rust-zune-core0.4+default-devel = " \
 cargo \
 rust-zune-core0.4-devel \
 "
RDEPENDS:rust-zune-core0.4+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-zune-core0.4-devel \
 "
RDEPENDS:rust-zune-core0.4+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-zune-core0.4-devel \
 "
RDEPENDS:rust-zune-core0.4+std-devel = " \
 cargo \
 rust-zune-core0.4-devel \
 "
RDEPENDS:rust-zune-core0.4-devel = " \
 cargo \
 "
