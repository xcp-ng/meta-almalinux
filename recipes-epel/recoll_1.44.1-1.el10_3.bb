# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "recoll"
PV = "1.44.1"
PR = "1.el10_3"
PACKAGES = " \
 recoll \
 recoll-devel \
 recoll-gssp \
 recoll-helpers \
 recoll-kio \
 recoll-krunner \
 recoll-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/recoll-1.44.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75aec492b13b51271acd64ad0e3240bb5f8a8353c47aff11c34eaee95e61bec2"

URI_x86_64_v2_recoll = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-1.44.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recoll}"
SRC_URI[x86_64_v2_recoll.sha256sum] = "e205b3e05abfc2338b601014bd944ab016b700565496c9b2f844bcd3a4909c60"

URI_x86_64_v2_recoll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-devel-1.44.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recoll-devel}"
SRC_URI[x86_64_v2_recoll-devel.sha256sum] = "405712908f33490c21c36e3cf3ba08cc1dfe314c8d6f73468730da4b839db5f5"

URI_x86_64_v2_recoll-gssp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-gssp-1.44.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-gssp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recoll-gssp}"
SRC_URI[x86_64_v2_recoll-gssp.sha256sum] = "3831ce2090d1e0cd42ceece7b04fdf54b979f809375ba8f5697d96421e90a03c"

URI_x86_64_v2_recoll-helpers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-helpers-1.44.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-helpers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recoll-helpers}"
SRC_URI[x86_64_v2_recoll-helpers.sha256sum] = "4086eba3a5438e0b674b20cf2ecbbe3d3da6771c3539b06c3854887b5943b133"

URI_x86_64_v2_recoll-kio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-kio-1.44.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-kio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recoll-kio}"
SRC_URI[x86_64_v2_recoll-kio.sha256sum] = "77d7e9809f729d49aec81999aff26d0a328c3d4cfc5a2ac0025df5ca2438d32c"

URI_x86_64_v2_recoll-krunner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-krunner-1.44.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-krunner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recoll-krunner}"
SRC_URI[x86_64_v2_recoll-krunner.sha256sum] = "5781425a76d914fdab96cef611ceaadbc33b5859383301e08140ba5c34dbb2d6"

URI_x86_64_v2_recoll-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-libs-1.44.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recoll-libs}"
SRC_URI[x86_64_v2_recoll-libs.sha256sum] = "b603439320d8301a22cc9319f998f1a1888d8a9f3761a69374c59eb485490113"

URI_aarch64_recoll = "${EPEL_MIRROR}/aarch64/Packages/r/recoll-1.44.1-1.el10_3.aarch64.rpm;name=aarch64_recoll;unpack=0"
SRC_URI:append = " ${URI_aarch64_recoll}"
SRC_URI[aarch64_recoll.sha256sum] = "24801357e862d38b25018f89c64f67702cc6af0665d904408aecc2edb2434ea9"

URI_aarch64_recoll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/recoll-devel-1.44.1-1.el10_3.aarch64.rpm;name=aarch64_recoll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_recoll-devel}"
SRC_URI[aarch64_recoll-devel.sha256sum] = "4e492749b50c7ea5793091b201de222255785c9c835e431bf076e42bd0b7960e"

URI_aarch64_recoll-gssp = "${EPEL_MIRROR}/aarch64/Packages/r/recoll-gssp-1.44.1-1.el10_3.aarch64.rpm;name=aarch64_recoll-gssp;unpack=0"
SRC_URI:append = " ${URI_aarch64_recoll-gssp}"
SRC_URI[aarch64_recoll-gssp.sha256sum] = "f03e2be25b8730130c65f085d4a6226c0c32d2228d63eec949764433ce28490a"

URI_aarch64_recoll-helpers = "${EPEL_MIRROR}/aarch64/Packages/r/recoll-helpers-1.44.1-1.el10_3.aarch64.rpm;name=aarch64_recoll-helpers;unpack=0"
SRC_URI:append = " ${URI_aarch64_recoll-helpers}"
SRC_URI[aarch64_recoll-helpers.sha256sum] = "a9f164d03ed00842a86cdf35ae14f4d2d36e239a779f59d08bf86e8075a21d09"

URI_aarch64_recoll-kio = "${EPEL_MIRROR}/aarch64/Packages/r/recoll-kio-1.44.1-1.el10_3.aarch64.rpm;name=aarch64_recoll-kio;unpack=0"
SRC_URI:append = " ${URI_aarch64_recoll-kio}"
SRC_URI[aarch64_recoll-kio.sha256sum] = "784fc590fac19cc6b7562e9c10eee088ff0ee6bb0dac0d5c8a4b7e45527cff82"

URI_aarch64_recoll-krunner = "${EPEL_MIRROR}/aarch64/Packages/r/recoll-krunner-1.44.1-1.el10_3.aarch64.rpm;name=aarch64_recoll-krunner;unpack=0"
SRC_URI:append = " ${URI_aarch64_recoll-krunner}"
SRC_URI[aarch64_recoll-krunner.sha256sum] = "f1458c700b3438c82f7bd5ed3728298ce84d495004c86c5ac95f582ecec35d7f"

URI_aarch64_recoll-libs = "${EPEL_MIRROR}/aarch64/Packages/r/recoll-libs-1.44.1-1.el10_3.aarch64.rpm;name=aarch64_recoll-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_recoll-libs}"
SRC_URI[aarch64_recoll-libs.sha256sum] = "ccaeb1aa4d3485d2811383eb17044c70cc6b33df6fcd9d621744394c2623ab10"

RDEPENDS:recoll = " \
 aspell \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 perl-interpreter \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 recoll-libs \
 xdg-utils \
 "
RDEPENDS:recoll-devel = " \
 recoll-libs \
 "
RDEPENDS:recoll-gssp = " \
 gnome-shell \
 python3 \
 python3-gobject-base \
 recoll \
 "
RDEPENDS:recoll-helpers = " \
 recoll \
 "
RDEPENDS:recoll-kio = " \
 glibc \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 recoll \
 recoll-libs \
 "
RDEPENDS:recoll-krunner = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-krunner \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 recoll \
 recoll-libs \
 "
RDEPENDS:recoll-libs = " \
 file-libs \
 glibc \
 jsoncpp \
 libX11 \
 libgcc \
 libstdc++ \
 libxml2 \
 libxslt \
 xapian-core-libs \
 zlib-ng-compat \
 "
