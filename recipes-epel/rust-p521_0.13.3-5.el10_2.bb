# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-p521"
PV = "0.13.3"
PR = "5.el10_2"
PACKAGES = " \
 rust-p521+alloc-devel \
 rust-p521+arithmetic-devel \
 rust-p521+default-devel \
 rust-p521+digest-devel \
 rust-p521+ecdh-devel \
 rust-p521+ecdsa-core-devel \
 rust-p521+ecdsa-devel \
 rust-p521+getrandom-devel \
 rust-p521+hash2curve-devel \
 rust-p521+jwk-devel \
 rust-p521+pem-devel \
 rust-p521+pkcs8-devel \
 rust-p521+rand_core-devel \
 rust-p521+serde-devel \
 rust-p521+serdect-devel \
 rust-p521+sha512-devel \
 rust-p521+std-devel \
 rust-p521+test-vectors-devel \
 rust-p521+voprf-devel \
 rust-p521-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-p521-0.13.3-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "302363dc613b821f0c85ad82473c7bb879001c4ba50a5a373cdf38b15a1ff59a"

URI_x86_64_v2_rust-p521+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+alloc-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+alloc-devel}"
SRC_URI[x86_64_v2_rust-p521+alloc-devel.sha256sum] = "0c5a3c7fb1b2191de447e673503d8ab885764e09d7baa45703bbb624ed7fc986"

URI_x86_64_v2_rust-p521+arithmetic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+arithmetic-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+arithmetic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+arithmetic-devel}"
SRC_URI[x86_64_v2_rust-p521+arithmetic-devel.sha256sum] = "d879730c5f7d6ad41e70dcf4daf9513ac04a1264dfa7b67c2d5ba68fa0fef5f3"

URI_x86_64_v2_rust-p521+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+default-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+default-devel}"
SRC_URI[x86_64_v2_rust-p521+default-devel.sha256sum] = "d85522951d22d2335fad3fd0c21178e3ead4952e36e88b3df42878db8ff8d5ed"

URI_x86_64_v2_rust-p521+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+digest-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+digest-devel}"
SRC_URI[x86_64_v2_rust-p521+digest-devel.sha256sum] = "dc5fe12e68cc770e0a1c83af411c40c36bfabfedce931565ab979d5bc9da748b"

URI_x86_64_v2_rust-p521+ecdh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+ecdh-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+ecdh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+ecdh-devel}"
SRC_URI[x86_64_v2_rust-p521+ecdh-devel.sha256sum] = "3382b7ad4df2a3194646ff6ef5697bb71c47cbf4dcabc0f5de2efd339c02c7e5"

URI_x86_64_v2_rust-p521+ecdsa-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+ecdsa-core-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+ecdsa-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+ecdsa-core-devel}"
SRC_URI[x86_64_v2_rust-p521+ecdsa-core-devel.sha256sum] = "26ae26fa8ea49b2420eafaef8bb841b20720be018d21ef7fd52333676ad2d6f5"

URI_x86_64_v2_rust-p521+ecdsa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+ecdsa-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+ecdsa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+ecdsa-devel}"
SRC_URI[x86_64_v2_rust-p521+ecdsa-devel.sha256sum] = "195edfcb65cc5f9e3e9c410c523085046196cb4a42e1b07aef4c8eced4224cfe"

URI_x86_64_v2_rust-p521+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+getrandom-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+getrandom-devel}"
SRC_URI[x86_64_v2_rust-p521+getrandom-devel.sha256sum] = "31c7d3cef8f448f6f8225e51f6802bc93af816ea1b5ca9df58e66542e21a6c44"

URI_x86_64_v2_rust-p521+hash2curve-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+hash2curve-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+hash2curve-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+hash2curve-devel}"
SRC_URI[x86_64_v2_rust-p521+hash2curve-devel.sha256sum] = "ab10f62a662effb6f93fc4e70a7b56fbc1afd8c830ec31e01ea1d30696ff1514"

URI_x86_64_v2_rust-p521+jwk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+jwk-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+jwk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+jwk-devel}"
SRC_URI[x86_64_v2_rust-p521+jwk-devel.sha256sum] = "338f1427f17f9efb9d0542fd3a3abe0cec97b0fc181585dd5d4a42e31fa38ec2"

URI_x86_64_v2_rust-p521+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+pem-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+pem-devel}"
SRC_URI[x86_64_v2_rust-p521+pem-devel.sha256sum] = "cfac03a7b0f704a7594df31083641ba6d42af3436acac1a797e3ac0fafccd6c9"

URI_x86_64_v2_rust-p521+pkcs8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+pkcs8-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+pkcs8-devel}"
SRC_URI[x86_64_v2_rust-p521+pkcs8-devel.sha256sum] = "4f2c451459ccb601f00f42cc966aff29cfc206b10b0e482e436e9b67c374969a"

URI_x86_64_v2_rust-p521+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+rand_core-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+rand_core-devel}"
SRC_URI[x86_64_v2_rust-p521+rand_core-devel.sha256sum] = "14492bedb97ec83535f840df6738eace5c070e6d4710c68da3b86463653468df"

URI_x86_64_v2_rust-p521+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+serde-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+serde-devel}"
SRC_URI[x86_64_v2_rust-p521+serde-devel.sha256sum] = "00f4bf1c95c71b560b64ac27dc0f5df3ebef7339e85ba97fbb32d49da9daafa2"

URI_x86_64_v2_rust-p521+serdect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+serdect-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+serdect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+serdect-devel}"
SRC_URI[x86_64_v2_rust-p521+serdect-devel.sha256sum] = "b9fc9d3bf8b852137183ee9c89971f68800f9a277886dbe20879403a148ea392"

URI_x86_64_v2_rust-p521+sha512-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+sha512-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+sha512-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+sha512-devel}"
SRC_URI[x86_64_v2_rust-p521+sha512-devel.sha256sum] = "0835753c7d73d33061fbd3fcfbafb27853fe54a28c4d5827a0c27d5357534433"

URI_x86_64_v2_rust-p521+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+std-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+std-devel}"
SRC_URI[x86_64_v2_rust-p521+std-devel.sha256sum] = "32023daf7394607067403be282687f8c7042406a387db2437dbbc1780b7f027f"

URI_x86_64_v2_rust-p521+test-vectors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+test-vectors-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+test-vectors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+test-vectors-devel}"
SRC_URI[x86_64_v2_rust-p521+test-vectors-devel.sha256sum] = "32a07f5c01eb7c427f4dfb494a57e43d2f55381ec46bdfb48a59bbb72e5edb19"

URI_x86_64_v2_rust-p521+voprf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521+voprf-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521+voprf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521+voprf-devel}"
SRC_URI[x86_64_v2_rust-p521+voprf-devel.sha256sum] = "a73148a3ad26dd8da1c1f70b88dc3f9eec84f9c2cc28d10cdbd3f0703ba395ee"

URI_x86_64_v2_rust-p521-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p521-devel-0.13.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p521-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p521-devel}"
SRC_URI[x86_64_v2_rust-p521-devel.sha256sum] = "a4b93b44169457b566a3e3457bae67825434dbec52c8f61f6775bdc3b3790523"

URI_aarch64_rust-p521+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+alloc-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+alloc-devel}"
SRC_URI[aarch64_rust-p521+alloc-devel.sha256sum] = "dc783cf830cc876639547d1bed2d350576daf1a9a6391883445a2c11a320cba3"

URI_aarch64_rust-p521+arithmetic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+arithmetic-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+arithmetic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+arithmetic-devel}"
SRC_URI[aarch64_rust-p521+arithmetic-devel.sha256sum] = "d14d8804eb61a2cf9df9bab917ff52b67758edbf2a2a9877a9827ac162685a0d"

URI_aarch64_rust-p521+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+default-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+default-devel}"
SRC_URI[aarch64_rust-p521+default-devel.sha256sum] = "713231f61ac011e7df1dd087900a20bef847528adaaa3c16568ddfff8e481c39"

URI_aarch64_rust-p521+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+digest-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+digest-devel}"
SRC_URI[aarch64_rust-p521+digest-devel.sha256sum] = "a45a8e14dbd4ab68acfb2f9d5236d9663d5a311169c5ab1b4868a1259fb0b4df"

URI_aarch64_rust-p521+ecdh-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+ecdh-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+ecdh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+ecdh-devel}"
SRC_URI[aarch64_rust-p521+ecdh-devel.sha256sum] = "ba8c1bcbcde7bfcf846e30cf0880193d258a29b31c04966c813b98567f294eb2"

URI_aarch64_rust-p521+ecdsa-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+ecdsa-core-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+ecdsa-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+ecdsa-core-devel}"
SRC_URI[aarch64_rust-p521+ecdsa-core-devel.sha256sum] = "2e2c2659e295c6b1b8c5f5abe98390127206a39bed12a5be5a6e4ca9f95015b0"

URI_aarch64_rust-p521+ecdsa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+ecdsa-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+ecdsa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+ecdsa-devel}"
SRC_URI[aarch64_rust-p521+ecdsa-devel.sha256sum] = "97af0e663c67c3262f6b676ffab9fc612ab025c60c9925dd8f596d0c208beff0"

URI_aarch64_rust-p521+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+getrandom-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+getrandom-devel}"
SRC_URI[aarch64_rust-p521+getrandom-devel.sha256sum] = "e48ae7f8cd5c29943468ed39031727b2ab6a391444463745bf264c54e56bcca7"

URI_aarch64_rust-p521+hash2curve-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+hash2curve-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+hash2curve-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+hash2curve-devel}"
SRC_URI[aarch64_rust-p521+hash2curve-devel.sha256sum] = "75d286fff72a507414a13a4cfc2420e8762cc2460b0e743006f6fccf49627dc1"

URI_aarch64_rust-p521+jwk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+jwk-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+jwk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+jwk-devel}"
SRC_URI[aarch64_rust-p521+jwk-devel.sha256sum] = "d7c407364b66f7507d2ea323e4b705fa7e9c9b73944cdade5912c90085e48836"

URI_aarch64_rust-p521+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+pem-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+pem-devel}"
SRC_URI[aarch64_rust-p521+pem-devel.sha256sum] = "8f36f45283051e46ed88c60cae069c0f490dcb0422a81ad682a71fd9252880ec"

URI_aarch64_rust-p521+pkcs8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+pkcs8-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+pkcs8-devel}"
SRC_URI[aarch64_rust-p521+pkcs8-devel.sha256sum] = "99ad3b99c2c507589870fcfa4e65e5b4efaae83f65424a6f86f7e6ab4aa75bac"

URI_aarch64_rust-p521+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+rand_core-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+rand_core-devel}"
SRC_URI[aarch64_rust-p521+rand_core-devel.sha256sum] = "552cfadc32b9168cacd5ce13286e93978f4c7045cfa55b97398796545997e4b1"

URI_aarch64_rust-p521+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+serde-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+serde-devel}"
SRC_URI[aarch64_rust-p521+serde-devel.sha256sum] = "69c47d8b77df2792015376da147adcc955a42d0d40b180d73231cc5c02f0d7b0"

URI_aarch64_rust-p521+serdect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+serdect-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+serdect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+serdect-devel}"
SRC_URI[aarch64_rust-p521+serdect-devel.sha256sum] = "f09d04ef26d853588175bcdbfc2205e383904f577046b946063f03f6879f5eff"

URI_aarch64_rust-p521+sha512-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+sha512-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+sha512-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+sha512-devel}"
SRC_URI[aarch64_rust-p521+sha512-devel.sha256sum] = "cc457e767a1df5d18aea6b9da656b32c575b9992ac085b29f2ee877a5f5ce83c"

URI_aarch64_rust-p521+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+std-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+std-devel}"
SRC_URI[aarch64_rust-p521+std-devel.sha256sum] = "a128481ea518c475a6026b723089bc99a3cea2141be98251f8dae5be0bbd3512"

URI_aarch64_rust-p521+test-vectors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+test-vectors-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+test-vectors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+test-vectors-devel}"
SRC_URI[aarch64_rust-p521+test-vectors-devel.sha256sum] = "c407f328ecc74f875357fb7148d5a69a9eed5f50f2496916e709b1d0fff86e9d"

URI_aarch64_rust-p521+voprf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521+voprf-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521+voprf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521+voprf-devel}"
SRC_URI[aarch64_rust-p521+voprf-devel.sha256sum] = "fa7704fe4440765e95f01d46331308f1d313a606859c5e500f8181a763535459"

URI_aarch64_rust-p521-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p521-devel-0.13.3-5.el10_2.noarch.rpm;name=aarch64_rust-p521-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p521-devel}"
SRC_URI[aarch64_rust-p521-devel.sha256sum] = "d4bea3630c8da9f11f8eab72faa8babf2abe7ccd1055b6653c3156bd579d75d7"

RDEPENDS:rust-p521+alloc-devel = " \
 cargo \
 rust-ecdsa+alloc-devel \
 rust-ecdsa+der-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+alloc-devel \
 rust-p521-devel \
 "
RDEPENDS:rust-p521+arithmetic-devel = " \
 cargo \
 rust-p521-devel \
 rust-primeorder+default-devel \
 "
RDEPENDS:rust-p521+default-devel = " \
 cargo \
 rust-p521+arithmetic-devel \
 rust-p521+ecdsa-devel \
 rust-p521+getrandom-devel \
 rust-p521+pem-devel \
 rust-p521+std-devel \
 rust-p521-devel \
 "
RDEPENDS:rust-p521+digest-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+digest-devel \
 rust-ecdsa+hazmat-devel \
 rust-ecdsa-devel \
 rust-p521-devel \
 "
RDEPENDS:rust-p521+ecdh-devel = " \
 cargo \
 rust-elliptic-curve+ecdh-devel \
 rust-p521+arithmetic-devel \
 rust-p521-devel \
 "
RDEPENDS:rust-p521+ecdsa-core-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa-devel \
 rust-p521-devel \
 "
RDEPENDS:rust-p521+ecdsa-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+signing-devel \
 rust-ecdsa+verifying-devel \
 rust-ecdsa-devel \
 rust-p521+arithmetic-devel \
 rust-p521+sha512-devel \
 rust-p521-devel \
 "
RDEPENDS:rust-p521+getrandom-devel = " \
 cargo \
 rust-p521-devel \
 rust-rand_core0.6+getrandom-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-p521+hash2curve-devel = " \
 cargo \
 rust-elliptic-curve+hash2curve-devel \
 rust-p521+arithmetic-devel \
 rust-p521-devel \
 "
RDEPENDS:rust-p521+jwk-devel = " \
 cargo \
 rust-elliptic-curve+jwk-devel \
 rust-p521-devel \
 "
RDEPENDS:rust-p521+pem-devel = " \
 cargo \
 rust-elliptic-curve+pem-devel \
 rust-p521+pkcs8-devel \
 rust-p521-devel \
 "
RDEPENDS:rust-p521+pkcs8-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+pkcs8-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+pkcs8-devel \
 rust-p521-devel \
 "
RDEPENDS:rust-p521+rand_core-devel = " \
 cargo \
 rust-p521-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-p521+serde-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+serde-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+serde-devel \
 rust-p521+serdect-devel \
 rust-p521-devel \
 rust-primeorder+default-devel \
 rust-primeorder+serde-devel \
 "
RDEPENDS:rust-p521+serdect-devel = " \
 cargo \
 rust-p521-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-p521+sha512-devel = " \
 cargo \
 rust-p521+digest-devel \
 rust-p521-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-p521+std-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+std-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+std-devel \
 rust-p521+alloc-devel \
 rust-p521-devel \
 "
RDEPENDS:rust-p521+test-vectors-devel = " \
 cargo \
 rust-hex-literal+default-devel \
 rust-p521-devel \
 "
RDEPENDS:rust-p521+voprf-devel = " \
 cargo \
 rust-elliptic-curve+voprf-devel \
 rust-p521-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-p521-devel = " \
 cargo \
 rust \
 rust-base16ct+default-devel \
 rust-elliptic-curve+hazmat-devel \
 rust-elliptic-curve+sec1-devel \
 rust-elliptic-curve-devel \
 "
