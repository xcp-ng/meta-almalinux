# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "t1lib"
PV = "5.1.2"
PR = "43.el10_2"
PACKAGES = " \
 t1lib \
 t1lib-apps \
 t1lib-devel \
 t1lib-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/t1lib-5.1.2-43.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c984e42b7f867514d96503ae0d7749c16fb7ae8e1c91d8b099e1871b330971c"

URI_x86_64_v2_t1lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/t1lib-5.1.2-43.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_t1lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_t1lib}"
SRC_URI[x86_64_v2_t1lib.sha256sum] = "be12b5ad6de3085f41e98c7487208f5087d24e21633b23ba3b4c5a10003c8f14"

URI_x86_64_v2_t1lib-apps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/t1lib-apps-5.1.2-43.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_t1lib-apps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_t1lib-apps}"
SRC_URI[x86_64_v2_t1lib-apps.sha256sum] = "8a629d084555d6e650d53bdae4c2ef2aae304727b609317b05450900299db919"

URI_x86_64_v2_t1lib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/t1lib-devel-5.1.2-43.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_t1lib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_t1lib-devel}"
SRC_URI[x86_64_v2_t1lib-devel.sha256sum] = "6bbf307899ab92787debf02d895faaa9c852d3b967e133da7b69bad0f48da189"

URI_x86_64_v2_t1lib-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/t1lib-static-5.1.2-43.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_t1lib-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_t1lib-static}"
SRC_URI[x86_64_v2_t1lib-static.sha256sum] = "bdbd17471968c487d67f564db0555e99fd048afe7eac5424589db4dbbebc68cf"

URI_aarch64_t1lib = "${EPEL_MIRROR}/aarch64/Packages/t/t1lib-5.1.2-43.el10_2.aarch64.rpm;name=aarch64_t1lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_t1lib}"
SRC_URI[aarch64_t1lib.sha256sum] = "a4ebbda1efef2b0d796604067cd5563c566631e30c1937b179f80f9abc7a7c52"

URI_aarch64_t1lib-apps = "${EPEL_MIRROR}/aarch64/Packages/t/t1lib-apps-5.1.2-43.el10_2.aarch64.rpm;name=aarch64_t1lib-apps;unpack=0"
SRC_URI:append = " ${URI_aarch64_t1lib-apps}"
SRC_URI[aarch64_t1lib-apps.sha256sum] = "43e5812e309589b6108a0a6d7e1e5e0dd15e59c7531d1c433d3ff5b66741c605"

URI_aarch64_t1lib-devel = "${EPEL_MIRROR}/aarch64/Packages/t/t1lib-devel-5.1.2-43.el10_2.aarch64.rpm;name=aarch64_t1lib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_t1lib-devel}"
SRC_URI[aarch64_t1lib-devel.sha256sum] = "a5f5756f38469e317c20fa68557bfbe0a0e957e99d04d28935dc1d0e5d3aaddf"

URI_aarch64_t1lib-static = "${EPEL_MIRROR}/aarch64/Packages/t/t1lib-static-5.1.2-43.el10_2.aarch64.rpm;name=aarch64_t1lib-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_t1lib-static}"
SRC_URI[aarch64_t1lib-static.sha256sum] = "56ab96fbfec5d58b3765fda7adca47160ec3af128fa36bceda823114e170e7f2"

RDEPENDS:t1lib = " \
 bash \
 findutils \
 glibc \
 libX11 \
 virtual/coreutils \
 "
RDEPENDS:t1lib-apps = " \
 glibc \
 libX11 \
 libXaw \
 libXt \
 t1lib \
 "
RDEPENDS:t1lib-devel = " \
 t1lib \
 "
RDEPENDS:t1lib-static = " \
 t1lib-devel \
 "
