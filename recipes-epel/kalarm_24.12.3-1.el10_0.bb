# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalarm"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kalarm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kalarm-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b595552543c0c489a5b3ced33b17d49bc81ea743e973809e72b71ee6e95e1bae"

URI_x86_64_v2_kalarm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalarm-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalarm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalarm}"
SRC_URI[x86_64_v2_kalarm.sha256sum] = "2c19840bbdcfb0ccea889888c5762acb941bf9eefca023606171985ba0866d5f"

URI_aarch64_kalarm = "${EPEL_MIRROR}/aarch64/Packages/k/kalarm-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kalarm;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalarm}"
SRC_URI[aarch64_kalarm.sha256sum] = "133e63dc190a7bda7717635bbb51d83674a2a72673859a50e2c1f0c858a18f51"

RDEPENDS:kalarm = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 glibc \
 kcalutils \
 kf6-kauth \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 vlc-libs \
 "
