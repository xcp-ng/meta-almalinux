# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_lex"
PV = "1.1.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-clap_lex+default-devel \
 rust-clap_lex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_lex-1.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "991b6b406fc4b24538910349753a2c859b7b21f8094afbafa4e1ad2da03dedd9"

URI_x86_64_v2_rust-clap_lex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_lex+default-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_lex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_lex+default-devel}"
SRC_URI[x86_64_v2_rust-clap_lex+default-devel.sha256sum] = "eecba15d2ac8425885344269676a39d5f42019b17a0673c0fa36d9f16d28b93c"

URI_x86_64_v2_rust-clap_lex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_lex-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_lex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_lex-devel}"
SRC_URI[x86_64_v2_rust-clap_lex-devel.sha256sum] = "5cc4d61726c0a6ad8453baa70d684044d985ff1fc5d85ee2a0969e7226b4af0b"

URI_aarch64_rust-clap_lex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_lex+default-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-clap_lex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_lex+default-devel}"
SRC_URI[aarch64_rust-clap_lex+default-devel.sha256sum] = "568c15a5a6a26b05ebbb67ad95d23209ef717542826183d881b6e74174d0f3bf"

URI_aarch64_rust-clap_lex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_lex-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-clap_lex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_lex-devel}"
SRC_URI[aarch64_rust-clap_lex-devel.sha256sum] = "62eaed234917057639725b0e0bfd21945ef6b02c03ffa4045f65938c04e9c80a"

RDEPENDS:rust-clap_lex+default-devel = " \
 cargo \
 rust-clap_lex-devel \
 "
RDEPENDS:rust-clap_lex-devel = " \
 cargo \
 rust \
 "
