# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bind"
PE = "32"
PV = "9.18.33"
PR = "10.el10_1.3"
PACKAGES = " \
 bind \
 bind-chroot \
 bind-devel \
 bind-dnssec-utils \
 bind-doc \
 bind-libs \
 bind-license \
 bind-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bind-9.18.33-10.el10_1.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b48a775dcfa63329c960dad474d62435845bd863e1376d7c8fb91d6cf015c46"

URI_x86_64_v2_bind = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-9.18.33-10.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_bind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind}"
SRC_URI[x86_64_v2_bind.sha256sum] = "521e51edc639b6f7901346e2e8d47a376edb7e540598f306968e7a1ce8138965"

URI_x86_64_v2_bind-chroot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-chroot-9.18.33-10.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_bind-chroot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-chroot}"
SRC_URI[x86_64_v2_bind-chroot.sha256sum] = "4e94b93dbcf7f602a6220ec99f804151da86c96864602a8f1ac4460f68320479"

URI_x86_64_v2_bind-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bind-devel-9.18.33-10.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_bind-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-devel}"
SRC_URI[x86_64_v2_bind-devel.sha256sum] = "bbe79c2437051370cad308f95217c93300f55706cc335457556e35eabd608fa7"

URI_x86_64_v2_bind-dnssec-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-dnssec-utils-9.18.33-10.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_bind-dnssec-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-dnssec-utils}"
SRC_URI[x86_64_v2_bind-dnssec-utils.sha256sum] = "af2d8ad38e61146d019e8d3dfe04ba5fbe93dde425a89244995b88fb756855a2"

URI_x86_64_v2_bind-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bind-doc-9.18.33-10.el10_1.3.noarch.rpm;name=x86_64_v2_bind-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-doc}"
SRC_URI[x86_64_v2_bind-doc.sha256sum] = "3549e4b4978409acd2e511cadcea55a443f39a9696adf0cf561c23384f896ffa"

URI_x86_64_v2_bind-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-libs-9.18.33-10.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_bind-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-libs}"
SRC_URI[x86_64_v2_bind-libs.sha256sum] = "628b13b9f93083a8b941d7aa1e0dc74995859053563f391f7b31cae1967f2d33"

URI_x86_64_v2_bind-license = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-license-9.18.33-10.el10_1.3.noarch.rpm;name=x86_64_v2_bind-license;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-license}"
SRC_URI[x86_64_v2_bind-license.sha256sum] = "abc94c9f7733fc2d0095320266bf3fc77e992d872d44fb168ad42df6fa0c619c"

URI_x86_64_v2_bind-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-utils-9.18.33-10.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_bind-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-utils}"
SRC_URI[x86_64_v2_bind-utils.sha256sum] = "f1ca8a29798579442d91bee7eed5eac4dd15d6fe7549636686610f766185daea"

URI_aarch64_bind = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-9.18.33-10.el10_1.3.aarch64.rpm;name=aarch64_bind;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind}"
SRC_URI[aarch64_bind.sha256sum] = "67bd76a76bec07373254842aaa24b0b58631e620d8a1d463d0b4455c76b56999"

URI_aarch64_bind-chroot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-chroot-9.18.33-10.el10_1.3.aarch64.rpm;name=aarch64_bind-chroot;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-chroot}"
SRC_URI[aarch64_bind-chroot.sha256sum] = "d3e6171412138b6d66651b4b0b027fc623bd352218472a8868402e71a7022dec"

URI_aarch64_bind-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bind-devel-9.18.33-10.el10_1.3.aarch64.rpm;name=aarch64_bind-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-devel}"
SRC_URI[aarch64_bind-devel.sha256sum] = "e0075f932b28004acf9dba6d9958695cf7d260d03e04235748e81c09b5425828"

URI_aarch64_bind-dnssec-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-dnssec-utils-9.18.33-10.el10_1.3.aarch64.rpm;name=aarch64_bind-dnssec-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-dnssec-utils}"
SRC_URI[aarch64_bind-dnssec-utils.sha256sum] = "50fe3464b94d638ca02d719e1ec447e83dc4272849a8ae2c30f70f92bce52389"

URI_aarch64_bind-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bind-doc-9.18.33-10.el10_1.3.noarch.rpm;name=aarch64_bind-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-doc}"
SRC_URI[aarch64_bind-doc.sha256sum] = "3549e4b4978409acd2e511cadcea55a443f39a9696adf0cf561c23384f896ffa"

URI_aarch64_bind-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-libs-9.18.33-10.el10_1.3.aarch64.rpm;name=aarch64_bind-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-libs}"
SRC_URI[aarch64_bind-libs.sha256sum] = "cbe2971085bd48b95c7b4cf6879328241d2dfe1392f45498440256e6bad550c9"

URI_aarch64_bind-license = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-license-9.18.33-10.el10_1.3.noarch.rpm;name=aarch64_bind-license;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-license}"
SRC_URI[aarch64_bind-license.sha256sum] = "abc94c9f7733fc2d0095320266bf3fc77e992d872d44fb168ad42df6fa0c619c"

URI_aarch64_bind-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-utils-9.18.33-10.el10_1.3.aarch64.rpm;name=aarch64_bind-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-utils}"
SRC_URI[aarch64_bind-utils.sha256sum] = "da19a672d5c7f7a0ef7a9495f19776a034c57a4215c16afab6a78e40206bb586"

RDEPENDS:bind = " \
 bash \
 bind-libs \
 fstrm \
 glibc \
 glibc-common \
 grep \
 json-c \
 libcap \
 libmaxminddb \
 libnghttp2 \
 libuv \
 libxml2 \
 lmdb-libs \
 openssl-libs \
 protobuf-c \
 shadow-utils \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:bind-chroot = " \
 bash \
 bind \
 grep \
 "
RDEPENDS:bind-devel = " \
 bind-libs \
 fstrm-devel \
 json-c-devel \
 krb5-devel \
 libcap-devel \
 libmaxminddb-devel \
 libxml2-devel \
 lmdb-devel \
 openssl-devel \
 protobuf-c-devel \
 "
RDEPENDS:bind-dnssec-utils = " \
 bind-libs \
 glibc \
 "
RDEPENDS:bind-doc = " \
 bind-license \
 python3-sphinx_rtd_theme \
 "
RDEPENDS:bind-libs = " \
 bind-license \
 fstrm \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libmaxminddb \
 libnghttp2 \
 libuv \
 libxml2 \
 lmdb-libs \
 openssl-libs \
 protobuf-c \
 zlib-ng-compat \
 "
RDEPENDS:bind-license = " \
 "
RDEPENDS:bind-utils = " \
 bind-libs \
 glibc \
 krb5-libs \
 libidn2 \
 lmdb-libs \
 protobuf-c \
 "
