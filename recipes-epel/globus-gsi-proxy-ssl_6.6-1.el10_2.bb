# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gsi-proxy-ssl"
PV = "6.6"
PR = "1.el10_2"
PACKAGES = " \
 globus-gsi-proxy-ssl \
 globus-gsi-proxy-ssl-devel \
 globus-gsi-proxy-ssl-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gsi-proxy-ssl-6.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac1caa9bbfbae129e108c51d0ee0fa5fcb03dd4e616d2a0cc1eea2178f2c1a50"

URI_x86_64_v2_globus-gsi-proxy-ssl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-ssl-6.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-proxy-ssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-ssl}"
SRC_URI[x86_64_v2_globus-gsi-proxy-ssl.sha256sum] = "c8db2dcfd44fd4ee3d1738395bcefebd8c1039b9d541dc46cf0f4125830ecc6b"

URI_x86_64_v2_globus-gsi-proxy-ssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-ssl-devel-6.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-proxy-ssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-ssl-devel}"
SRC_URI[x86_64_v2_globus-gsi-proxy-ssl-devel.sha256sum] = "bc532b8da3d934e13d4cd68d91c1bf895ace8cff982fbf6b3729663a755b5bec"

URI_x86_64_v2_globus-gsi-proxy-ssl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-ssl-doc-6.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gsi-proxy-ssl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-ssl-doc}"
SRC_URI[x86_64_v2_globus-gsi-proxy-ssl-doc.sha256sum] = "6a21bf64a461a6f8ff0ae436c8d86b70030203c95eb6e3607f39dedfbd814c22"

URI_aarch64_globus-gsi-proxy-ssl = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-ssl-6.6-1.el10_2.aarch64.rpm;name=aarch64_globus-gsi-proxy-ssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-ssl}"
SRC_URI[aarch64_globus-gsi-proxy-ssl.sha256sum] = "09ae1d6d6b1ad60e91f849290e550df7f4c629ce4f036b80d0a1e738862eb822"

URI_aarch64_globus-gsi-proxy-ssl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-ssl-devel-6.6-1.el10_2.aarch64.rpm;name=aarch64_globus-gsi-proxy-ssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-ssl-devel}"
SRC_URI[aarch64_globus-gsi-proxy-ssl-devel.sha256sum] = "29199201efa3064c0821b4a49c01743b573629a9ca13373406c3bc2af7cb9d24"

URI_aarch64_globus-gsi-proxy-ssl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-ssl-doc-6.6-1.el10_2.noarch.rpm;name=aarch64_globus-gsi-proxy-ssl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-ssl-doc}"
SRC_URI[aarch64_globus-gsi-proxy-ssl-doc.sha256sum] = "0111d5081c2949de6dcfc15cc004265ef0ca7ed2bb5257480dc7b98d141e7113"

RDEPENDS:globus-gsi-proxy-ssl = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:globus-gsi-proxy-ssl-devel = " \
 globus-gsi-proxy-ssl \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gsi-proxy-ssl-doc = " \
 "
