# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kompare"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kompare \
 kompare-devel \
 kompare-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kompare-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "895c5e3525f83d9c36ac01fff191e5409ed0f90714ea91ba3d361756b1ee12ac"

URI_x86_64_v2_kompare = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kompare}"
SRC_URI[x86_64_v2_kompare.sha256sum] = "1a5d3cf4d12736ca7894e0d563e7ab06f6619512818932a8d57e8752760206f3"

URI_x86_64_v2_kompare-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kompare-devel}"
SRC_URI[x86_64_v2_kompare-devel.sha256sum] = "03f34dfb7c6acb42fd0a8b4913b5c69f7fdbe80a1e10a305725b56ff9a2d7018"

URI_x86_64_v2_kompare-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-libs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kompare-libs}"
SRC_URI[x86_64_v2_kompare-libs.sha256sum] = "3812264107288ae055a41b5f2c08ba8ed6b5545021c891ea54c5a74fa1bcfb98"

URI_aarch64_kompare = "${EPEL_MIRROR}/aarch64/Packages/k/kompare-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kompare;unpack=0"
SRC_URI:append = " ${URI_aarch64_kompare}"
SRC_URI[aarch64_kompare.sha256sum] = "993abeb92909faaf88826b0e373d7ae54482dc0e8d4026016c21f1d021ff4b62"

URI_aarch64_kompare-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kompare-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kompare-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kompare-devel}"
SRC_URI[aarch64_kompare-devel.sha256sum] = "5dcc8cccfd1c94a9e2065b3b507ccd47a181b50c88543dde6d9b2e8e406d153c"

URI_aarch64_kompare-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kompare-libs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kompare-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kompare-libs}"
SRC_URI[aarch64_kompare-libs.sha256sum] = "e3117c877a862a0cd3e7d4656cba587e5aaf534e382512319610785e58d75e48"

RDEPENDS:kompare = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kompare-libs \
 libkomparediff2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kompare-devel = " \
 kompare-libs \
 qt6-qtbase-devel \
 "
RDEPENDS:kompare-libs = " \
 glibc \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkomparediff2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
