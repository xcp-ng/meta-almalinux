# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksane"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 libksane \
 libksane-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libksane-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c36875ddc8cc91709e50467e4b3ec10f09d4ee457d7a43620bc732c6be4342f"

URI_x86_64_v2_libksane = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksane-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksane;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksane}"
SRC_URI[x86_64_v2_libksane.sha256sum] = "0d35a9ed88cbb793d12be4439af81657d5746e284a343fdc3defd0b4464b6a02"

URI_x86_64_v2_libksane-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksane-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksane-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksane-devel}"
SRC_URI[x86_64_v2_libksane-devel.sha256sum] = "c0d9d3d9f0763eefa53f522ac7520c6b9e39f32d8415f291634811f01302aceb"

URI_aarch64_libksane = "${EPEL_MIRROR}/aarch64/Packages/l/libksane-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libksane;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksane}"
SRC_URI[aarch64_libksane.sha256sum] = "beb24e3c945b5d1a114ce64df4b14d4326a55ac5974ba373822be79edab0b9e2"

URI_aarch64_libksane-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libksane-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libksane-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksane-devel}"
SRC_URI[aarch64_libksane-devel.sha256sum] = "2e502c334dab1b20b496f895788f0d05f17c6803e800eaaad882767b7ad937ae"

RDEPENDS:libksane = " \
 glibc \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 ksanecore \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libksane-devel = " \
 cmake-filesystem \
 libksane \
 qt6-qtbase-devel \
 "
