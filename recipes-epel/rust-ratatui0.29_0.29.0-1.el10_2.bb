# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ratatui0.29"
PV = "0.29.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-ratatui0.29+all-widgets-devel \
 rust-ratatui0.29+crossterm-devel \
 rust-ratatui0.29+default-devel \
 rust-ratatui0.29+document-features-devel \
 rust-ratatui0.29+macros-devel \
 rust-ratatui0.29+palette-devel \
 rust-ratatui0.29+scrolling-regions-devel \
 rust-ratatui0.29+serde-devel \
 rust-ratatui0.29+termion-devel \
 rust-ratatui0.29+underline-color-devel \
 rust-ratatui0.29+unstable-backend-writer-devel \
 rust-ratatui0.29+unstable-devel \
 rust-ratatui0.29+unstable-rendered-line-info-devel \
 rust-ratatui0.29+unstable-widget-ref-devel \
 rust-ratatui0.29+widget-calendar-devel \
 rust-ratatui0.29-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ratatui0.29-0.29.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d18b1c194328c26114eab8895e09dcb99dfb6aaf0a77836e3d8bcfb441819e83"

URI_x86_64_v2_rust-ratatui0.29+all-widgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+all-widgets-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+all-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+all-widgets-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+all-widgets-devel.sha256sum] = "43bcbe79a75949682e160d49dfb8e95fe3b1ff9c07f86fc77f676cf75574bd6a"

URI_x86_64_v2_rust-ratatui0.29+crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+crossterm-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+crossterm-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+crossterm-devel.sha256sum] = "88a941e0ce50965122b23b1dbc8e1f7d850a81fbcf5b7111e04b102bbceb6037"

URI_x86_64_v2_rust-ratatui0.29+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+default-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+default-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+default-devel.sha256sum] = "938ffd5eeb59939f7666153d487aae24a8eb2db7aa9225277362dcf1a7d03b48"

URI_x86_64_v2_rust-ratatui0.29+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+document-features-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+document-features-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+document-features-devel.sha256sum] = "6b9919ed2f2e97859ca7cb488d8eddfd54ba2102e78438d7bb5dc981527f31ff"

URI_x86_64_v2_rust-ratatui0.29+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+macros-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+macros-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+macros-devel.sha256sum] = "1d4642c91da26441cafca91ce0a296dfb9188ebc95fce28094b5afaca94a6fba"

URI_x86_64_v2_rust-ratatui0.29+palette-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+palette-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+palette-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+palette-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+palette-devel.sha256sum] = "26df03151352a33945e4c892e5b62072f6109b889fb77a26148e03388ef34c60"

URI_x86_64_v2_rust-ratatui0.29+scrolling-regions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+scrolling-regions-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+scrolling-regions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+scrolling-regions-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+scrolling-regions-devel.sha256sum] = "14c052e3a1e01dbd6a1aa1a2934624e1c6ee09d933fd2dc306da6309c4b45a1d"

URI_x86_64_v2_rust-ratatui0.29+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+serde-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+serde-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+serde-devel.sha256sum] = "1c7c8cc11f9240ae6c9e0d64cbde049fc994c954bc5c7b808546f371b40046e4"

URI_x86_64_v2_rust-ratatui0.29+termion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+termion-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+termion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+termion-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+termion-devel.sha256sum] = "00d5dd2cd734ed75fc20f78bfad4232e492f8636a9c2f852bcb6718d32958fd8"

URI_x86_64_v2_rust-ratatui0.29+underline-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+underline-color-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+underline-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+underline-color-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+underline-color-devel.sha256sum] = "dda4cdc3eaa7b6d68ed5979051fcd6376c9f030ab33086ef1c9d613bc3ca7bbc"

URI_x86_64_v2_rust-ratatui0.29+unstable-backend-writer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+unstable-backend-writer-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+unstable-backend-writer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+unstable-backend-writer-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+unstable-backend-writer-devel.sha256sum] = "fe108aaacf6b2dd609d931b1b9382d942c079ce8b8c564456dde4cf7dc5e8638"

URI_x86_64_v2_rust-ratatui0.29+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+unstable-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+unstable-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+unstable-devel.sha256sum] = "41caa8cdba51ee43311b87d224f5ca2668e201f2a6875f281838fdcb75b2c2a7"

URI_x86_64_v2_rust-ratatui0.29+unstable-rendered-line-info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+unstable-rendered-line-info-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+unstable-rendered-line-info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+unstable-rendered-line-info-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+unstable-rendered-line-info-devel.sha256sum] = "a0b5dcdd8677b3059a6a18fd7a7920bc91600a5ff554e030cef91e3457ed5e65"

URI_x86_64_v2_rust-ratatui0.29+unstable-widget-ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+unstable-widget-ref-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+unstable-widget-ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+unstable-widget-ref-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+unstable-widget-ref-devel.sha256sum] = "9c02c5352505cb2b8e607fb30148fe4c9e1a470c0d97f6a4f1c0524302042d71"

URI_x86_64_v2_rust-ratatui0.29+widget-calendar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29+widget-calendar-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29+widget-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29+widget-calendar-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29+widget-calendar-devel.sha256sum] = "39501ab29fee19697a20abb896b8b5794f573ecf487cc4b63a917e357d27bc05"

URI_x86_64_v2_rust-ratatui0.29-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.29-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.29-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.29-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.29-devel.sha256sum] = "4c896d48e29a23d1950ca2a11f5aff0f46a2bef0b2b59f02cf2d310a85a5e9c0"

URI_aarch64_rust-ratatui0.29+all-widgets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+all-widgets-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+all-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+all-widgets-devel}"
SRC_URI[aarch64_rust-ratatui0.29+all-widgets-devel.sha256sum] = "99f8f116499fc31d5863de7b26df3aac2222fa867983720fa744c5918219a209"

URI_aarch64_rust-ratatui0.29+crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+crossterm-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+crossterm-devel}"
SRC_URI[aarch64_rust-ratatui0.29+crossterm-devel.sha256sum] = "410580c738fe7b99adc92cfe896cbeb351b328b1dff8ccb89bdd6aaa2cfa3fd7"

URI_aarch64_rust-ratatui0.29+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+default-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+default-devel}"
SRC_URI[aarch64_rust-ratatui0.29+default-devel.sha256sum] = "04ece4a7e6fda7d0293f148995756df51afe3ce9139da34e55fb87385dabecf5"

URI_aarch64_rust-ratatui0.29+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+document-features-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+document-features-devel}"
SRC_URI[aarch64_rust-ratatui0.29+document-features-devel.sha256sum] = "7fdd41bcbb97b656aa7b32df01ca98474490879529961dca110432f42227caa0"

URI_aarch64_rust-ratatui0.29+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+macros-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+macros-devel}"
SRC_URI[aarch64_rust-ratatui0.29+macros-devel.sha256sum] = "0ad6fc5fb804f96ce0988958495b4b17849254e18fd7f20ad0904028ed2022f2"

URI_aarch64_rust-ratatui0.29+palette-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+palette-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+palette-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+palette-devel}"
SRC_URI[aarch64_rust-ratatui0.29+palette-devel.sha256sum] = "ee04b9ae4925caaa731494eaafba9d0b98da3131eb2fd8accd3d3d25f006784a"

URI_aarch64_rust-ratatui0.29+scrolling-regions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+scrolling-regions-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+scrolling-regions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+scrolling-regions-devel}"
SRC_URI[aarch64_rust-ratatui0.29+scrolling-regions-devel.sha256sum] = "d9ff960da22e3215eb666805efccf1c120f820aa91c71bfa4cf7771de55ae981"

URI_aarch64_rust-ratatui0.29+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+serde-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+serde-devel}"
SRC_URI[aarch64_rust-ratatui0.29+serde-devel.sha256sum] = "cdcb93fe5906986eb1a9f6960dca49f67e292515ed11d2cd0bb10d5e2074b089"

URI_aarch64_rust-ratatui0.29+termion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+termion-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+termion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+termion-devel}"
SRC_URI[aarch64_rust-ratatui0.29+termion-devel.sha256sum] = "cfbbf4a4ccb799b067328f20b37c3207a106503afb19ffda5feadc8dfd8b0291"

URI_aarch64_rust-ratatui0.29+underline-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+underline-color-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+underline-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+underline-color-devel}"
SRC_URI[aarch64_rust-ratatui0.29+underline-color-devel.sha256sum] = "bf358dc9204efb8c501fe87aafd0cf9b14d76ed4d7d4161be3a81ff5d6d11015"

URI_aarch64_rust-ratatui0.29+unstable-backend-writer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+unstable-backend-writer-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+unstable-backend-writer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+unstable-backend-writer-devel}"
SRC_URI[aarch64_rust-ratatui0.29+unstable-backend-writer-devel.sha256sum] = "ac72f04ae2ac9d38271516ada249a31309dcf23d9ca940807bb5c8296d85e6f7"

URI_aarch64_rust-ratatui0.29+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+unstable-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+unstable-devel}"
SRC_URI[aarch64_rust-ratatui0.29+unstable-devel.sha256sum] = "54eca73ba22069738a41efb1517ef85ad99de0b5924aae3fa864cf4c6a6fbe07"

URI_aarch64_rust-ratatui0.29+unstable-rendered-line-info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+unstable-rendered-line-info-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+unstable-rendered-line-info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+unstable-rendered-line-info-devel}"
SRC_URI[aarch64_rust-ratatui0.29+unstable-rendered-line-info-devel.sha256sum] = "8ae82841554cec198685867e10e1668891310762c29fccf12978d9633123f6e9"

URI_aarch64_rust-ratatui0.29+unstable-widget-ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+unstable-widget-ref-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+unstable-widget-ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+unstable-widget-ref-devel}"
SRC_URI[aarch64_rust-ratatui0.29+unstable-widget-ref-devel.sha256sum] = "205d536062628dee9f7adfa7d4b176ab8c53720657ed38fc1abbeb6c201aeacb"

URI_aarch64_rust-ratatui0.29+widget-calendar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29+widget-calendar-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29+widget-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29+widget-calendar-devel}"
SRC_URI[aarch64_rust-ratatui0.29+widget-calendar-devel.sha256sum] = "bc203110854ce19000fa8edc3c7d018c30de51d9883790b2f3e67d35bdeb9b60"

URI_aarch64_rust-ratatui0.29-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.29-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui0.29-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.29-devel}"
SRC_URI[aarch64_rust-ratatui0.29-devel.sha256sum] = "26348f520c80e34628a40ce2a29b36e9d3a27676c8ae41bdd585dbcedddb0831"

RDEPENDS:rust-ratatui0.29+all-widgets-devel = " \
 cargo \
 rust-ratatui0.29+widget-calendar-devel \
 rust-ratatui0.29-devel \
 "
RDEPENDS:rust-ratatui0.29+crossterm-devel = " \
 cargo \
 rust-crossterm0.28+default-devel \
 rust-ratatui0.29-devel \
 "
RDEPENDS:rust-ratatui0.29+default-devel = " \
 cargo \
 rust-ratatui0.29+crossterm-devel \
 rust-ratatui0.29+underline-color-devel \
 rust-ratatui0.29-devel \
 "
RDEPENDS:rust-ratatui0.29+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-ratatui0.29-devel \
 "
RDEPENDS:rust-ratatui0.29+macros-devel = " \
 cargo \
 rust-ratatui0.29-devel \
 "
RDEPENDS:rust-ratatui0.29+palette-devel = " \
 cargo \
 rust-palette+default-devel \
 rust-ratatui0.29-devel \
 "
RDEPENDS:rust-ratatui0.29+scrolling-regions-devel = " \
 cargo \
 rust-ratatui0.29-devel \
 "
RDEPENDS:rust-ratatui0.29+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-compact_str+serde-devel \
 rust-ratatui0.29-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-ratatui0.29+termion-devel = " \
 cargo \
 rust-ratatui0.29-devel \
 rust-termion+default-devel \
 "
RDEPENDS:rust-ratatui0.29+underline-color-devel = " \
 cargo \
 rust-crossterm0.28+default-devel \
 rust-ratatui0.29-devel \
 "
RDEPENDS:rust-ratatui0.29+unstable-backend-writer-devel = " \
 cargo \
 rust-ratatui0.29-devel \
 "
RDEPENDS:rust-ratatui0.29+unstable-devel = " \
 cargo \
 rust-ratatui0.29+unstable-backend-writer-devel \
 rust-ratatui0.29+unstable-rendered-line-info-devel \
 rust-ratatui0.29+unstable-widget-ref-devel \
 rust-ratatui0.29-devel \
 "
RDEPENDS:rust-ratatui0.29+unstable-rendered-line-info-devel = " \
 cargo \
 rust-ratatui0.29-devel \
 "
RDEPENDS:rust-ratatui0.29+unstable-widget-ref-devel = " \
 cargo \
 rust-ratatui0.29-devel \
 "
RDEPENDS:rust-ratatui0.29+widget-calendar-devel = " \
 cargo \
 rust-ratatui0.29-devel \
 rust-time+default-devel \
 rust-time+local-offset-devel \
 "
RDEPENDS:rust-ratatui0.29-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cassowary+default-devel \
 rust-compact_str+default-devel \
 rust-indoc+default-devel \
 rust-instability+default-devel \
 rust-itertools0.13+default-devel \
 rust-lru0.12+default-devel \
 rust-paste+default-devel \
 rust-strum0.26+default-devel \
 rust-strum0.26+derive-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-truncate1+default-devel \
 rust-unicode-width+default-devel \
 "
