# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-Format"
PV = "0.63"
PR = "4.el10_1"
PACKAGES = " \
 perl-Text-Format \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-Format-0.63-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e74e8a4a91a73f93b7dbd67633d2eb1e5f453ed85d6645af28e3692e4fb9067"

URI_x86_64_v2_perl-Text-Format = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-Format-0.63-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-Format;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-Format}"
SRC_URI[x86_64_v2_perl-Text-Format.sha256sum] = "08e71deb2d9a2a10484b7400428ffc16f88a8d318817153ed84e51fdcbe69e70"

URI_aarch64_perl-Text-Format = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-Format-0.63-4.el10_1.noarch.rpm;name=aarch64_perl-Text-Format;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-Format}"
SRC_URI[aarch64_perl-Text-Format.sha256sum] = "61f9cf0aa2f54572120c726f8dd5597318bc5c1b0c91602fabfcce4f5857dd98"

RDEPENDS:perl-Text-Format = " \
 perl-Carp \
 perl-libs \
 "
