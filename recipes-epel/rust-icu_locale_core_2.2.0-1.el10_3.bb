# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_locale_core"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_locale_core+alloc-devel \
 rust-icu_locale_core+databake-devel \
 rust-icu_locale_core+default-devel \
 rust-icu_locale_core+serde-devel \
 rust-icu_locale_core+zerovec-devel \
 rust-icu_locale_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_locale_core-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20920cc857adb15b6578dcb3417aae695f83887ae999e8c7f7151baea4c3e133"

URI_x86_64_v2_rust-icu_locale_core+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+alloc-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+alloc-devel.sha256sum] = "a8d73d890e7e36cb31f4f71bbcbc0dcf5808ec724172c3ef3f0c3442401a04b8"

URI_x86_64_v2_rust-icu_locale_core+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+databake-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+databake-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+databake-devel.sha256sum] = "d3f719cad8825efebbcbecc0b5419a209ac8fa26e5ecf9946f772d7c9053e05f"

URI_x86_64_v2_rust-icu_locale_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+default-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+default-devel.sha256sum] = "a5e2df2522ee24f1a2832e0cf3de3b7e4d2901b8874a55b6bf6197822b87bd74"

URI_x86_64_v2_rust-icu_locale_core+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+serde-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+serde-devel.sha256sum] = "1d007945c1945753f66c608bc5ace5ab718ec491dc7973e6e50512b259feb9da"

URI_x86_64_v2_rust-icu_locale_core+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+zerovec-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+zerovec-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+zerovec-devel.sha256sum] = "43cb6af55dd1db7bb6a00d13fa1947719af52c95696ae7a3278d0b2215e7a106"

URI_x86_64_v2_rust-icu_locale_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core-devel.sha256sum] = "04df636dc577f3c05bd9651e4d3f1ba5a42781b17a8e36cabc2ba3b5406a50ca"

URI_aarch64_rust-icu_locale_core+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+alloc-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_locale_core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+alloc-devel}"
SRC_URI[aarch64_rust-icu_locale_core+alloc-devel.sha256sum] = "bcda837118224794cb440e7706dfd0df7d4857a0444966313688a09974ed520c"

URI_aarch64_rust-icu_locale_core+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+databake-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_locale_core+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+databake-devel}"
SRC_URI[aarch64_rust-icu_locale_core+databake-devel.sha256sum] = "59b4f9893069f22a9fcc1df0e93476cb2d7dd77934a2fa2bc1be8abfda1f8dbe"

URI_aarch64_rust-icu_locale_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_locale_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+default-devel}"
SRC_URI[aarch64_rust-icu_locale_core+default-devel.sha256sum] = "356ba44ba058902a2ea95e3f281b8d12d39f41594db42d18e7b923c970272a05"

URI_aarch64_rust-icu_locale_core+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+serde-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_locale_core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+serde-devel}"
SRC_URI[aarch64_rust-icu_locale_core+serde-devel.sha256sum] = "29683cd19d307e29f6bb9556cb96b6e2a2899de9db81c35f7e77d73e6713fcdd"

URI_aarch64_rust-icu_locale_core+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+zerovec-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_locale_core+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+zerovec-devel}"
SRC_URI[aarch64_rust-icu_locale_core+zerovec-devel.sha256sum] = "d4a2d5467549a4bbc505fe785d8bff0c236af6d7ebfcb6c85cfe7444c4561aec"

URI_aarch64_rust-icu_locale_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_locale_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core-devel}"
SRC_URI[aarch64_rust-icu_locale_core-devel.sha256sum] = "e1227a51f25aa711dafc6e07a76c94cbd0d931bb72998945d87a168895a83794"

RDEPENDS:rust-icu_locale_core+alloc-devel = " \
 cargo \
 rust-icu_locale_core-devel \
 rust-litemap+alloc-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-tinystr+alloc-devel \
 rust-writeable+alloc-devel \
 "
RDEPENDS:rust-icu_locale_core+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_locale_core+alloc-devel \
 rust-icu_locale_core-devel \
 "
RDEPENDS:rust-icu_locale_core+default-devel = " \
 cargo \
 rust-icu_locale_core-devel \
 "
RDEPENDS:rust-icu_locale_core+serde-devel = " \
 cargo \
 rust-icu_locale_core-devel \
 rust-serde-devel \
 rust-tinystr+serde-devel \
 "
RDEPENDS:rust-icu_locale_core+zerovec-devel = " \
 cargo \
 rust-icu_locale_core-devel \
 rust-tinystr+zerovec-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-icu_locale_core-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-litemap-devel \
 rust-tinystr-devel \
 rust-writeable-devel \
 "
