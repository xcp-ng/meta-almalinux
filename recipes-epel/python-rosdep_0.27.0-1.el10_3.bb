# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rosdep"
PV = "0.27.0"
PR = "1.el10_3"
PACKAGES = " \
 python-rosdep-doc \
 python3-rosdep \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-rosdep-0.27.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fadcfe7182a20198f69245127557fad00776eb7ca9d8117322c73e922610c072"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-rosdep-doc-0.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-rosdep-doc;unpack=0"
SRC_URI[x86_64_v2_python-rosdep-doc.sha256sum] = "c1dd01c31fcad334519159fdee4cef0b62aa8b5c320eeab5b21ca68370ae612f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rosdep-0.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rosdep;unpack=0"
SRC_URI[x86_64_v2_python3-rosdep.sha256sum] = "f382ff4f9da1e82b62952485c97ba156590b78af1ca80de32c6d26feddc1f669"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-rosdep-doc-0.27.0-1.el10_3.noarch.rpm;name=aarch64_python-rosdep-doc;unpack=0"
SRC_URI[aarch64_python-rosdep-doc.sha256sum] = "4fa7aa08f346e9149af4a07f0721d3f858d5f57a231cdf1f9be61ea7d6f38c6f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-rosdep-0.27.0-1.el10_3.noarch.rpm;name=aarch64_python3-rosdep;unpack=0"
SRC_URI[aarch64_python3-rosdep.sha256sum] = "aa1d3dd6f0e3d06fa9e4531da6428def338ad538dbf64e6551d6ecb8f16315be"

RDEPENDS:python-rosdep-doc = " \
 "
RDEPENDS:python3-rosdep = " \
 python-srpm-macros \
 python3 \
 python3-catkin_pkg \
 python3-pyyaml \
 python3-rosdistro \
 python3-rospkg \
 "
