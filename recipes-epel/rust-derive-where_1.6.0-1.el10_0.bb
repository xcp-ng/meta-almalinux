# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive-where"
PV = "1.6.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-derive-where+default-devel \
 rust-derive-where+nightly-devel \
 rust-derive-where+safe-devel \
 rust-derive-where+serde-devel \
 rust-derive-where+zeroize-devel \
 rust-derive-where+zeroize-on-drop-devel \
 rust-derive-where-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derive-where-1.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f578d31f4d344906ba689ad77c3588a09568e9b6411663d4e3e656e65a9d187"

URI_x86_64_v2_rust-derive-where+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+default-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+default-devel}"
SRC_URI[x86_64_v2_rust-derive-where+default-devel.sha256sum] = "ceebdddbbe6ea13b8bd21cb4d3922a33b0ced50eeb1e2fae91d7c5dec90df93c"

URI_x86_64_v2_rust-derive-where+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+nightly-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+nightly-devel}"
SRC_URI[x86_64_v2_rust-derive-where+nightly-devel.sha256sum] = "243c172748704ec52c0b086f9178433758901e89d03d9cfab560a1f66c0e08e0"

URI_x86_64_v2_rust-derive-where+safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+safe-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+safe-devel}"
SRC_URI[x86_64_v2_rust-derive-where+safe-devel.sha256sum] = "b862ea7c072e7c6019ecbd88987d38a2048c988b6716fd5e2482f7510d47a246"

URI_x86_64_v2_rust-derive-where+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+serde-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+serde-devel}"
SRC_URI[x86_64_v2_rust-derive-where+serde-devel.sha256sum] = "03b185d576596ecc41eb36e61889928de70cb424bed7161e331499c3a078630d"

URI_x86_64_v2_rust-derive-where+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+zeroize-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+zeroize-devel}"
SRC_URI[x86_64_v2_rust-derive-where+zeroize-devel.sha256sum] = "10eb25dee7364908ae40b157e4c9d74b113b18639e073a771facb4cc7a926bdc"

URI_x86_64_v2_rust-derive-where+zeroize-on-drop-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+zeroize-on-drop-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+zeroize-on-drop-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+zeroize-on-drop-devel}"
SRC_URI[x86_64_v2_rust-derive-where+zeroize-on-drop-devel.sha256sum] = "ad93881e0b53b21117c77e44a3ce56e63a4953069a154f863b317a3b7b710fe9"

URI_x86_64_v2_rust-derive-where-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where-devel}"
SRC_URI[x86_64_v2_rust-derive-where-devel.sha256sum] = "4765c86e6c22ac5f6e647f80fad233bd4179bbeb2575cf936bee951d1820035a"

URI_aarch64_rust-derive-where+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+default-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-derive-where+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+default-devel}"
SRC_URI[aarch64_rust-derive-where+default-devel.sha256sum] = "4274e807e07022313037493798e6fa64c7d4d331b7473bcbea41dff2ed74ef49"

URI_aarch64_rust-derive-where+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+nightly-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-derive-where+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+nightly-devel}"
SRC_URI[aarch64_rust-derive-where+nightly-devel.sha256sum] = "ea22a29f76fa1491ebe665e1e7c062ff209e4417af36fe45134f8ce9d42a70e7"

URI_aarch64_rust-derive-where+safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+safe-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-derive-where+safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+safe-devel}"
SRC_URI[aarch64_rust-derive-where+safe-devel.sha256sum] = "6bd194d99d04f9ee3e7e49990f580f3260a1b4df91bff4dfb6ee1f143763da98"

URI_aarch64_rust-derive-where+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+serde-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-derive-where+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+serde-devel}"
SRC_URI[aarch64_rust-derive-where+serde-devel.sha256sum] = "926d987ed17a8e6c82b23031b281b7ca334a1b2f92722b439aaa5aa91174097e"

URI_aarch64_rust-derive-where+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+zeroize-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-derive-where+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+zeroize-devel}"
SRC_URI[aarch64_rust-derive-where+zeroize-devel.sha256sum] = "944c9e22caedca175cb98b02514e6460c58d31b8f34166290ecfe105a59aec0f"

URI_aarch64_rust-derive-where+zeroize-on-drop-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+zeroize-on-drop-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-derive-where+zeroize-on-drop-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+zeroize-on-drop-devel}"
SRC_URI[aarch64_rust-derive-where+zeroize-on-drop-devel.sha256sum] = "dacd5c4ff8fe40296b1f91c9aa284b3fd879a5fdc868e6a09a989e0f9af35578"

URI_aarch64_rust-derive-where-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-derive-where-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where-devel}"
SRC_URI[aarch64_rust-derive-where-devel.sha256sum] = "79b5c5179f0b7de2739d1a099e72172be0424aa492e942ddd80f1726898d7750"

RDEPENDS:rust-derive-where+default-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+nightly-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+safe-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+serde-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+zeroize-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+zeroize-on-drop-devel = " \
 cargo \
 rust-derive-where+zeroize-devel \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
