# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-buffered-reader"
PV = "1.4.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-buffered-reader+bzip2-devel \
 rust-buffered-reader+compression-bzip2-devel \
 rust-buffered-reader+compression-deflate-devel \
 rust-buffered-reader+compression-devel \
 rust-buffered-reader+default-devel \
 rust-buffered-reader+flate2-devel \
 rust-buffered-reader-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-buffered-reader-1.4.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef2dbfbadb242079aa0c2c44e832b0b3d8a34601d3071841d711b4c609a897a0"

URI_x86_64_v2_rust-buffered-reader+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buffered-reader+bzip2-devel-1.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buffered-reader+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buffered-reader+bzip2-devel}"
SRC_URI[x86_64_v2_rust-buffered-reader+bzip2-devel.sha256sum] = "69e616cb19f0996287271e462970df6e5836556896f958cfbdeef83675903c41"

URI_x86_64_v2_rust-buffered-reader+compression-bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buffered-reader+compression-bzip2-devel-1.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buffered-reader+compression-bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buffered-reader+compression-bzip2-devel}"
SRC_URI[x86_64_v2_rust-buffered-reader+compression-bzip2-devel.sha256sum] = "74d98c29c5c48b7fa584e4cd9ba4a6f613055980cb64501cfe1e7c0fb5294e55"

URI_x86_64_v2_rust-buffered-reader+compression-deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buffered-reader+compression-deflate-devel-1.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buffered-reader+compression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buffered-reader+compression-deflate-devel}"
SRC_URI[x86_64_v2_rust-buffered-reader+compression-deflate-devel.sha256sum] = "39bcba5f1fb75db4c64d7bd8a094347b1e3339c4448ed53b9f3ad98387c09696"

URI_x86_64_v2_rust-buffered-reader+compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buffered-reader+compression-devel-1.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buffered-reader+compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buffered-reader+compression-devel}"
SRC_URI[x86_64_v2_rust-buffered-reader+compression-devel.sha256sum] = "e30aa4fa5ac5270f840ab5f9fcd74a61e612243ce773dd9477d6f152f4e2fbb8"

URI_x86_64_v2_rust-buffered-reader+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buffered-reader+default-devel-1.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buffered-reader+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buffered-reader+default-devel}"
SRC_URI[x86_64_v2_rust-buffered-reader+default-devel.sha256sum] = "bab11f0f6932d22506647577d488abe98c2b60687358e8ae54588a139eb9a8b0"

URI_x86_64_v2_rust-buffered-reader+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buffered-reader+flate2-devel-1.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buffered-reader+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buffered-reader+flate2-devel}"
SRC_URI[x86_64_v2_rust-buffered-reader+flate2-devel.sha256sum] = "7e574e683fac27e65b344470f13c77907aac44188aad0a22cf37f3e69095d570"

URI_x86_64_v2_rust-buffered-reader-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buffered-reader-devel-1.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buffered-reader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buffered-reader-devel}"
SRC_URI[x86_64_v2_rust-buffered-reader-devel.sha256sum] = "d8bdab3f9c7a352c0cdb4ca4af12635772b101f369a7bec17003a138d2b99708"

URI_aarch64_rust-buffered-reader+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buffered-reader+bzip2-devel-1.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-buffered-reader+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buffered-reader+bzip2-devel}"
SRC_URI[aarch64_rust-buffered-reader+bzip2-devel.sha256sum] = "5b8462aa446f88b8791c8f4802cfb5e8a07c449441c8341028f5c15f05b79bf1"

URI_aarch64_rust-buffered-reader+compression-bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buffered-reader+compression-bzip2-devel-1.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-buffered-reader+compression-bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buffered-reader+compression-bzip2-devel}"
SRC_URI[aarch64_rust-buffered-reader+compression-bzip2-devel.sha256sum] = "5766d8b280535fd27fd552fa0ac1ce25ec95c58f98232c06e364c97bf886c626"

URI_aarch64_rust-buffered-reader+compression-deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buffered-reader+compression-deflate-devel-1.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-buffered-reader+compression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buffered-reader+compression-deflate-devel}"
SRC_URI[aarch64_rust-buffered-reader+compression-deflate-devel.sha256sum] = "c2692187a864a7a0858335b2c3f13d5f0da7dc341fb3f0f1e5a1793b5e43dd12"

URI_aarch64_rust-buffered-reader+compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buffered-reader+compression-devel-1.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-buffered-reader+compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buffered-reader+compression-devel}"
SRC_URI[aarch64_rust-buffered-reader+compression-devel.sha256sum] = "5e50c19eb9f297e557a0b03f792651e3571a59d20bbfbd5f6d837fd8e987b3cb"

URI_aarch64_rust-buffered-reader+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buffered-reader+default-devel-1.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-buffered-reader+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buffered-reader+default-devel}"
SRC_URI[aarch64_rust-buffered-reader+default-devel.sha256sum] = "cf7c4d458ff86507d2650117e12385a27e703eefeb4110f5d92946c5d4df7785"

URI_aarch64_rust-buffered-reader+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buffered-reader+flate2-devel-1.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-buffered-reader+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buffered-reader+flate2-devel}"
SRC_URI[aarch64_rust-buffered-reader+flate2-devel.sha256sum] = "a9eb0b7a75ecc37ce3083436bba7de2369b5424c4adee1b2ebaab11ed3af6721"

URI_aarch64_rust-buffered-reader-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buffered-reader-devel-1.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-buffered-reader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buffered-reader-devel}"
SRC_URI[aarch64_rust-buffered-reader-devel.sha256sum] = "b2bf8be28f54ab6d0b93cc139d46032c137e002905ad0ae5e4b3554b2714dc07"

RDEPENDS:rust-buffered-reader+bzip2-devel = " \
 cargo \
 rust-buffered-reader-devel \
 rust-bzip2+default-devel \
 "
RDEPENDS:rust-buffered-reader+compression-bzip2-devel = " \
 cargo \
 rust-buffered-reader+bzip2-devel \
 rust-buffered-reader-devel \
 "
RDEPENDS:rust-buffered-reader+compression-deflate-devel = " \
 cargo \
 rust-buffered-reader+flate2-devel \
 rust-buffered-reader-devel \
 "
RDEPENDS:rust-buffered-reader+compression-devel = " \
 cargo \
 rust-buffered-reader+compression-bzip2-devel \
 rust-buffered-reader+compression-deflate-devel \
 rust-buffered-reader-devel \
 "
RDEPENDS:rust-buffered-reader+default-devel = " \
 cargo \
 rust-buffered-reader+compression-devel \
 rust-buffered-reader-devel \
 "
RDEPENDS:rust-buffered-reader+flate2-devel = " \
 cargo \
 rust-buffered-reader-devel \
 rust-flate2+default-devel \
 "
RDEPENDS:rust-buffered-reader-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
