# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-baloo"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-baloo \
 kf6-baloo-devel \
 kf6-baloo-doc \
 kf6-baloo-file \
 kf6-baloo-html \
 kf6-baloo-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-baloo-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb6e4504a05b58c6b3e41a3375337be4d719a7cbbf4a23df6f1912b79d8cf065"

URI_x86_64_v2_kf6-baloo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo}"
SRC_URI[x86_64_v2_kf6-baloo.sha256sum] = "517aa10c77e0ad3d3592cc57d1001207660de274e5ecf9953c1615c455752ead"

URI_x86_64_v2_kf6-baloo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-devel}"
SRC_URI[x86_64_v2_kf6-baloo-devel.sha256sum] = "dd67654bbdc13366e139698e7522cdce9b37113bd710a4e3583166d293000033"

URI_x86_64_v2_kf6-baloo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-baloo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-doc}"
SRC_URI[x86_64_v2_kf6-baloo-doc.sha256sum] = "46f7f9da668d00d7ba0fa1ddd34d9f89d31b87f759af661601e17d444a9ca898"

URI_x86_64_v2_kf6-baloo-file = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-file-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-file}"
SRC_URI[x86_64_v2_kf6-baloo-file.sha256sum] = "163892116a435fd0dc992952977c540374a982674b2fa89cb0c2e57a6a877505"

URI_x86_64_v2_kf6-baloo-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-baloo-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-html}"
SRC_URI[x86_64_v2_kf6-baloo-html.sha256sum] = "5ebaf894394cd7cb585ca44d43644fa446eff32f0123e011d64063cb78815342"

URI_x86_64_v2_kf6-baloo-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-libs-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-libs}"
SRC_URI[x86_64_v2_kf6-baloo-libs.sha256sum] = "11c18dacc4fc1099f091271902864db05afb00cc6704f04973ab80e63594aa17"

URI_aarch64_kf6-baloo = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-baloo;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo}"
SRC_URI[aarch64_kf6-baloo.sha256sum] = "16e96cf1216f05e9a8a4da9293ce900ab05021aa335e1afc1f7a76859ef85cf7"

URI_aarch64_kf6-baloo-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-baloo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-devel}"
SRC_URI[aarch64_kf6-baloo-devel.sha256sum] = "3ef4b77b7cec676f3e1b1a299dcb73048e35975cffb4b174e24f5354f1238475"

URI_aarch64_kf6-baloo-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-baloo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-doc}"
SRC_URI[aarch64_kf6-baloo-doc.sha256sum] = "fa233fddc4a2d251aa0461adb8f57662f5ffde3481c9387d5b5b7284b16962de"

URI_aarch64_kf6-baloo-file = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-file-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-baloo-file;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-file}"
SRC_URI[aarch64_kf6-baloo-file.sha256sum] = "36dc5e42b7abb764a212d8f4c21b7f42f7283ddb7c4992796761307c8083fabd"

URI_aarch64_kf6-baloo-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-baloo-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-html}"
SRC_URI[aarch64_kf6-baloo-html.sha256sum] = "aa5c86405be45a0f2a50f2d4286c0996a23d096aeab91096eb328f28a9069b14"

URI_aarch64_kf6-baloo-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-libs-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-baloo-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-libs}"
SRC_URI[aarch64_kf6-baloo-libs.sha256sum] = "4282e661e1e0bb91a8b4deefdfe67602342c67f38aa0f5932e305dd3ef60be1b"

RDEPENDS:kf6-baloo = " \
 glibc \
 kf6-baloo-libs \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-baloo-devel = " \
 cmake-filesystem \
 kf6-baloo-libs \
 kf6-kcoreaddons-devel \
 kf6-kfilemetadata-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-baloo-doc = " \
 "
RDEPENDS:kf6-baloo-file = " \
 glibc \
 kf6-baloo-libs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kidletime \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-baloo-html = " \
 "
RDEPENDS:kf6-baloo-libs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-solid \
 libstdc++ \
 lmdb-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
