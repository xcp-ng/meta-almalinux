# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "buildah"
PE = "2"
PV = "1.43.1"
PR = "6.el10_2"
PACKAGES = " \
 buildah \
 buildah-tests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/buildah-1.43.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3b9dab91ba98fa36e8858e0f5751309caebff105f0207db1c0affccdfccad2e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/buildah-1.43.1-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_buildah;unpack=0"
SRC_URI[x86_64_v2_buildah.sha256sum] = "d09c61a8322d17cc25df605c8c9e27029886ea366ee9c08ab3fd034cab649845"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/buildah-tests-1.43.1-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_buildah-tests;unpack=0"
SRC_URI[x86_64_v2_buildah-tests.sha256sum] = "5120fb63dc5c4ebcbdfb20eed23f03a25ea8cf422dbb5cca850b1a62d98d9963"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/buildah-1.43.1-6.el10_2.aarch64.rpm;name=aarch64_buildah;unpack=0"
SRC_URI[aarch64_buildah.sha256sum] = "d952db7c65b35d177b6e0782c7df473657e748fd6d66ad01b1bf50aa9d3b3ad5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/buildah-tests-1.43.1-6.el10_2.aarch64.rpm;name=aarch64_buildah-tests;unpack=0"
SRC_URI[aarch64_buildah-tests.sha256sum] = "3087dd7b55119e3c0f723ea9d260303352d5825682c15f28ce2362d7c281784e"

RDEPENDS:buildah = " \
 containers-common-extra \
 glibc \
 gpgme \
 libseccomp \
 podman-sequoia \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:buildah-tests = " \
 bash \
 buildah \
 bzip2 \
 git-daemon \
 glibc \
 golang \
 gpgme \
 httpd-tools \
 jq \
 libseccomp \
 nmap-ncat \
 openssl \
 podman \
 shadow-utils-subid \
 sqlite-libs \
 "
