# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openbao"
PV = "2.6.1"
PR = "1.el10_2"
PACKAGES = " \
 openbao \
 openbao-vault-compat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openbao-2.6.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "674fa13aa7a9a53c690eab5daaa7fc91a7c18252afa833809ae30895c061a289"

URI_x86_64_v2_openbao = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbao-2.6.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbao;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openbao}"
SRC_URI[x86_64_v2_openbao.sha256sum] = "e2e3bc502101c2b979300541b3066f12eedee8613222e2c524493c66b297dfe3"

URI_x86_64_v2_openbao-vault-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbao-vault-compat-2.6.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbao-vault-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openbao-vault-compat}"
SRC_URI[x86_64_v2_openbao-vault-compat.sha256sum] = "89f7ddb1db580f606c6b1a91ad09f921b7be0b9023239a190adfe7f8908f4524"

URI_aarch64_openbao = "${EPEL_MIRROR}/aarch64/Packages/o/openbao-2.6.1-1.el10_2.aarch64.rpm;name=aarch64_openbao;unpack=0"
SRC_URI:append = " ${URI_aarch64_openbao}"
SRC_URI[aarch64_openbao.sha256sum] = "b7d38514be7d851e97234f49d1fc8b531411b64d0c6e834781a3abce0c565e23"

URI_aarch64_openbao-vault-compat = "${EPEL_MIRROR}/aarch64/Packages/o/openbao-vault-compat-2.6.1-1.el10_2.aarch64.rpm;name=aarch64_openbao-vault-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openbao-vault-compat}"
SRC_URI[aarch64_openbao-vault-compat.sha256sum] = "a6f14047ea75624d1f9cbb9c40a23db0be78bb4468a0c55e8cfb103ce0525246"

RDEPENDS:openbao = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:openbao-vault-compat = " \
 openbao \
 "
