# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-snap-server"
PV = "1.1.2.1"
PR = "27.el10_0"
PACKAGES = " \
 ghc-io-streams-haproxy \
 ghc-io-streams-haproxy-devel \
 ghc-io-streams-haproxy-doc \
 ghc-io-streams-haproxy-prof \
 ghc-snap-server \
 ghc-snap-server-devel \
 ghc-snap-server-doc \
 ghc-snap-server-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-snap-server-1.1.2.1-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "591a1a32bb7b5d3b3d92694bc2065ebd0bfac561595129ced71945f24cc030e0"

URI_x86_64_v2_ghc-io-streams-haproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-io-streams-haproxy-1.0.1.0-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-io-streams-haproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-io-streams-haproxy}"
SRC_URI[x86_64_v2_ghc-io-streams-haproxy.sha256sum] = "2d4ca75ad894dcf25a242c1c18dd6dd95cb94d0da8d3414ff1c0776f2892b5c3"

URI_x86_64_v2_ghc-io-streams-haproxy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-io-streams-haproxy-devel-1.0.1.0-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-io-streams-haproxy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-io-streams-haproxy-devel}"
SRC_URI[x86_64_v2_ghc-io-streams-haproxy-devel.sha256sum] = "0a539c2a0c23e3d50f4d762699198e88f2753ec99223a65cfa2c4fe144e7f9f8"

URI_x86_64_v2_ghc-io-streams-haproxy-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-io-streams-haproxy-doc-1.0.1.0-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-io-streams-haproxy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-io-streams-haproxy-doc}"
SRC_URI[x86_64_v2_ghc-io-streams-haproxy-doc.sha256sum] = "74e9606f2645763262e8484c9895f444884620a8f50dee572bac24337a77bae9"

URI_x86_64_v2_ghc-io-streams-haproxy-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-io-streams-haproxy-prof-1.0.1.0-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-io-streams-haproxy-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-io-streams-haproxy-prof}"
SRC_URI[x86_64_v2_ghc-io-streams-haproxy-prof.sha256sum] = "693013172c58b4e11155569937be1080f2e6d930c8ef36f67886c9a6878574f0"

URI_x86_64_v2_ghc-snap-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-snap-server-1.1.2.1-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-snap-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-snap-server}"
SRC_URI[x86_64_v2_ghc-snap-server.sha256sum] = "b700fb09bacdba10a8143a2ea892b311935525f40069d91dc57123ab09f41082"

URI_x86_64_v2_ghc-snap-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-snap-server-devel-1.1.2.1-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-snap-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-snap-server-devel}"
SRC_URI[x86_64_v2_ghc-snap-server-devel.sha256sum] = "ecc43aadc2746b69d4817b82c37d2032147fd9efaa1741426f53dc489e68acef"

URI_x86_64_v2_ghc-snap-server-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-snap-server-doc-1.1.2.1-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-snap-server-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-snap-server-doc}"
SRC_URI[x86_64_v2_ghc-snap-server-doc.sha256sum] = "8e79a073afd4fcab8fdd8906edd5f9be83bcf856880c7c5db2ff6268c4569178"

URI_x86_64_v2_ghc-snap-server-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-snap-server-prof-1.1.2.1-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-snap-server-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-snap-server-prof}"
SRC_URI[x86_64_v2_ghc-snap-server-prof.sha256sum] = "328c429c3ac7fb7f9014995039bc7517375ba9506bfec17a520732aa297af052"

URI_aarch64_ghc-io-streams-haproxy = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-io-streams-haproxy-1.0.1.0-27.el10_0.aarch64.rpm;name=aarch64_ghc-io-streams-haproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-io-streams-haproxy}"
SRC_URI[aarch64_ghc-io-streams-haproxy.sha256sum] = "8da5c7c1c8273ba4d94d58677d17dc12438f14e548ab5b7594bdef40adb2a8d6"

URI_aarch64_ghc-io-streams-haproxy-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-io-streams-haproxy-devel-1.0.1.0-27.el10_0.aarch64.rpm;name=aarch64_ghc-io-streams-haproxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-io-streams-haproxy-devel}"
SRC_URI[aarch64_ghc-io-streams-haproxy-devel.sha256sum] = "c24809ecf86d20aaa58002bdfd64407475f0c575475852457c618714ee34eb9d"

URI_aarch64_ghc-io-streams-haproxy-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-io-streams-haproxy-doc-1.0.1.0-27.el10_0.noarch.rpm;name=aarch64_ghc-io-streams-haproxy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-io-streams-haproxy-doc}"
SRC_URI[aarch64_ghc-io-streams-haproxy-doc.sha256sum] = "0c51afcbc7eaec5d72289dba9fbddfd5b77e2d32ca3a09b401b0584ad2666261"

URI_aarch64_ghc-io-streams-haproxy-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-io-streams-haproxy-prof-1.0.1.0-27.el10_0.aarch64.rpm;name=aarch64_ghc-io-streams-haproxy-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-io-streams-haproxy-prof}"
SRC_URI[aarch64_ghc-io-streams-haproxy-prof.sha256sum] = "be444ed79ca134565c7daf1df7fd48cec450babf5a8c3e6ab71b171077b9a8ca"

URI_aarch64_ghc-snap-server = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-snap-server-1.1.2.1-27.el10_0.aarch64.rpm;name=aarch64_ghc-snap-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-snap-server}"
SRC_URI[aarch64_ghc-snap-server.sha256sum] = "ddcce29ab8c1f679da065e9b26689ca0fcb10904c645bc0c6154f3350ecbe81c"

URI_aarch64_ghc-snap-server-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-snap-server-devel-1.1.2.1-27.el10_0.aarch64.rpm;name=aarch64_ghc-snap-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-snap-server-devel}"
SRC_URI[aarch64_ghc-snap-server-devel.sha256sum] = "f9078ff6fac3c99f5268abdbee327418e89c101fc785195cdecea6c2990a438a"

URI_aarch64_ghc-snap-server-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-snap-server-doc-1.1.2.1-27.el10_0.noarch.rpm;name=aarch64_ghc-snap-server-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-snap-server-doc}"
SRC_URI[aarch64_ghc-snap-server-doc.sha256sum] = "cb39721e10c14a729776242bd8e562cfa78231a2b3975054d2f36572a424aa2f"

URI_aarch64_ghc-snap-server-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-snap-server-prof-1.1.2.1-27.el10_0.aarch64.rpm;name=aarch64_ghc-snap-server-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-snap-server-prof}"
SRC_URI[aarch64_ghc-snap-server-prof.sha256sum] = "f836637138b92aa480827fee607cfe04ffe3e611e784139104e550d3c2415f25"

RDEPENDS:ghc-io-streams-haproxy = " \
 ghc-array \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-io-streams \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-scientific \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-vector \
 ghc-vector-stream \
 ghc-zlib \
 ghc-zlib-bindings \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-io-streams-haproxy-devel = " \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-io-streams-devel \
 ghc-io-streams-haproxy \
 ghc-network-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-io-streams-haproxy-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-io-streams-haproxy-prof = " \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-io-streams-haproxy-devel \
 ghc-io-streams-prof \
 ghc-network-prof \
 ghc-transformers-prof \
 "
RDEPENDS:ghc-snap-server = " \
 ghc-HUnit \
 ghc-array \
 ghc-attoparsec \
 ghc-base \
 ghc-base-orphans \
 ghc-binary \
 ghc-blaze-builder \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-clock \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-io-streams \
 ghc-io-streams-haproxy \
 ghc-lifted-base \
 ghc-monad-control \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-readable \
 ghc-regex-base \
 ghc-regex-posix \
 ghc-scientific \
 ghc-snap-core \
 ghc-splitmix \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-th-compat \
 ghc-time \
 ghc-time-locale-compat \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unix-compat \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-stream \
 ghc-zlib \
 ghc-zlib-bindings \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-snap-server-devel = " \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-blaze-builder-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-clock-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-filepath-devel \
 ghc-io-streams-devel \
 ghc-io-streams-haproxy-devel \
 ghc-lifted-base-devel \
 ghc-mtl-devel \
 ghc-network-devel \
 ghc-old-locale-devel \
 ghc-snap-core-devel \
 ghc-snap-server \
 ghc-text-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unix-compat-devel \
 ghc-unix-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-snap-server-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-snap-server-prof = " \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-blaze-builder-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-clock-prof \
 ghc-containers-prof \
 ghc-filepath-prof \
 ghc-io-streams-haproxy-prof \
 ghc-io-streams-prof \
 ghc-lifted-base-prof \
 ghc-mtl-prof \
 ghc-network-prof \
 ghc-old-locale-prof \
 ghc-snap-core-prof \
 ghc-snap-server-devel \
 ghc-text-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unix-compat-prof \
 ghc-unix-prof \
 ghc-vector-prof \
 "
