# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-hamcrest"
PV = "2.1.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-hamcrest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-hamcrest-2.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e48f6ee51d6109263bf3974815a5a8e132df42f18096b928789c19170eebefd7"

URI_x86_64_v2_python3-hamcrest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hamcrest-2.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hamcrest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hamcrest}"
SRC_URI[x86_64_v2_python3-hamcrest.sha256sum] = "6ae3fe7776ba9a43512f46d878e8275e059355b0302bfd7a637402fd9b0cd946"

URI_aarch64_python3-hamcrest = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hamcrest-2.1.0-1.el10_1.noarch.rpm;name=aarch64_python3-hamcrest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hamcrest}"
SRC_URI[aarch64_python3-hamcrest.sha256sum] = "276bd02d5204cae7cb0ef39d448cf6012af61ce2a73d3751e499b09d5a37db82"

RDEPENDS:python3-hamcrest = " \
 python3 \
 "
