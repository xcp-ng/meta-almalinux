# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-dir"
PV = "0.27.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-dir+default-devel \
 rust-gix-dir+sha1-devel \
 rust-gix-dir+sha256-devel \
 rust-gix-dir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-dir-0.27.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a11d662940ed74aee8827013da52d592d1bc50f1dd595c817cbfa3fad074fd93"

URI_x86_64_v2_rust-gix-dir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-dir+default-devel-0.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-dir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-dir+default-devel}"
SRC_URI[x86_64_v2_rust-gix-dir+default-devel.sha256sum] = "9f2197dbf3b1d29f3edda1f6adaa7feebfb88f3eaf748fcaf5a11fed463737b0"

URI_x86_64_v2_rust-gix-dir+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-dir+sha1-devel-0.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-dir+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-dir+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-dir+sha1-devel.sha256sum] = "9344670ea614bbb0a53f7d58683806a2e4702f3b84147f5363c88992fe2c36c1"

URI_x86_64_v2_rust-gix-dir+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-dir+sha256-devel-0.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-dir+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-dir+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-dir+sha256-devel.sha256sum] = "38fff00a658f4e0e724a851d2012e70489f9711da060e709dd354d5a8365ed84"

URI_x86_64_v2_rust-gix-dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-dir-devel-0.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-dir-devel}"
SRC_URI[x86_64_v2_rust-gix-dir-devel.sha256sum] = "536d14bc046fa47d626cc069c0b148770754cb11fae48044d4dab4f917249b1b"

URI_aarch64_rust-gix-dir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-dir+default-devel-0.27.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-dir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-dir+default-devel}"
SRC_URI[aarch64_rust-gix-dir+default-devel.sha256sum] = "9b25ab41bc36040d21eea4ec67e4e3687917a2c71226371301728ee238490d8f"

URI_aarch64_rust-gix-dir+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-dir+sha1-devel-0.27.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-dir+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-dir+sha1-devel}"
SRC_URI[aarch64_rust-gix-dir+sha1-devel.sha256sum] = "a4925e6da5f7927350b53759830c6fb838736f5c8029e11033fadf7e9479a0e3"

URI_aarch64_rust-gix-dir+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-dir+sha256-devel-0.27.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-dir+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-dir+sha256-devel}"
SRC_URI[aarch64_rust-gix-dir+sha256-devel.sha256sum] = "e52d94b509e53bcbc299eaa1fbe18d31b7ea8ec20dae2113c480c95426ca385f"

URI_aarch64_rust-gix-dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-dir-devel-0.27.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-dir-devel}"
SRC_URI[aarch64_rust-gix-dir-devel.sha256sum] = "6bd3b26919c90166d61588cc03d373011a78e35381a48eb1cdd7014331665137"

RDEPENDS:rust-gix-dir+default-devel = " \
 cargo \
 rust-gix-dir-devel \
 "
RDEPENDS:rust-gix-dir+sha1-devel = " \
 cargo \
 rust-gix-dir-devel \
 rust-gix-index+sha1-devel \
 "
RDEPENDS:rust-gix-dir+sha256-devel = " \
 cargo \
 rust-gix-dir-devel \
 rust-gix-index+sha256-devel \
 "
RDEPENDS:rust-gix-dir-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-discover+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-ignore+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-utils+bstr-devel \
 rust-gix-utils+default-devel \
 rust-gix-worktree-devel \
 rust-thiserror+default-devel \
 "
