# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_stdbuf_libstdbuf"
PV = "0.7.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-uu_stdbuf_libstdbuf+default-devel \
 rust-uu_stdbuf_libstdbuf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_stdbuf_libstdbuf-0.7.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2789ea63436aff05d822f56b6669a83d89deb5d873497f4c868e17c2765d3242"

URI_x86_64_v2_rust-uu_stdbuf_libstdbuf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_stdbuf_libstdbuf+default-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_stdbuf_libstdbuf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_stdbuf_libstdbuf+default-devel}"
SRC_URI[x86_64_v2_rust-uu_stdbuf_libstdbuf+default-devel.sha256sum] = "33ede67b1617f265fbc03e54dc85eeba2442d9b629b650bedcdfa218e7acdfad"

URI_x86_64_v2_rust-uu_stdbuf_libstdbuf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_stdbuf_libstdbuf-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_stdbuf_libstdbuf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_stdbuf_libstdbuf-devel}"
SRC_URI[x86_64_v2_rust-uu_stdbuf_libstdbuf-devel.sha256sum] = "8b35c8365c72799f027e585a985fd34a6569b1af3579ea50308a6ef2befd6224"

URI_aarch64_rust-uu_stdbuf_libstdbuf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_stdbuf_libstdbuf+default-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_stdbuf_libstdbuf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_stdbuf_libstdbuf+default-devel}"
SRC_URI[aarch64_rust-uu_stdbuf_libstdbuf+default-devel.sha256sum] = "d64018fda99382a0a450a3816712a88b6954e059f93dd548c146b02dbd5f22c5"

URI_aarch64_rust-uu_stdbuf_libstdbuf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_stdbuf_libstdbuf-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_stdbuf_libstdbuf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_stdbuf_libstdbuf-devel}"
SRC_URI[aarch64_rust-uu_stdbuf_libstdbuf-devel.sha256sum] = "e0b4ad617549b5fe2c732c1ec78d08b4139b0f4ba59cf4bc691cfe5007c44bb5"

RDEPENDS:rust-uu_stdbuf_libstdbuf+default-devel = " \
 cargo \
 rust-uu_stdbuf_libstdbuf-devel \
 "
RDEPENDS:rust-uu_stdbuf_libstdbuf-devel = " \
 cargo \
 rust \
 rust-ctor+default-devel \
 rust-libc+default-devel \
 "
