# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-pa"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-pa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-pa-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "616a3a66d4b89da466871f15ddbd98fca86344ff224f3d26984264de1faffdd3"

URI_x86_64_v2_plasma-pa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-pa-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-pa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-pa}"
SRC_URI[x86_64_v2_plasma-pa.sha256sum] = "15c5ff9652ddc6d57acdc2adbf8c68320475b2e5621e882dc34c3c6efcd09a7b"

URI_aarch64_plasma-pa = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-pa-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-pa;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-pa}"
SRC_URI[aarch64_plasma-pa.sha256sum] = "0ae7849e1c1c6115d80c56a886c5d10fb574aaba3a3f40e0e21f10d4448fe605"

RDEPENDS:plasma-pa = " \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kstatusnotifieritem \
 libcanberra \
 libplasma \
 libstdc++ \
 pipewire-pulseaudio \
 pulseaudio-libs \
 pulseaudio-qt-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
