# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-epoch"
PV = "0.9.20"
PR = "1.el10_3"
PACKAGES = " \
 rust-crossbeam-epoch+alloc-devel \
 rust-crossbeam-epoch+default-devel \
 rust-crossbeam-epoch+nightly-devel \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-epoch-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-epoch-0.9.20-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b2aa01734836b277e00c1a011b4eb59f49d3583b548fbd84418af40d8a907e0"

URI_x86_64_v2_rust-crossbeam-epoch+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+alloc-devel-0.9.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch+alloc-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+alloc-devel.sha256sum] = "d1028b5a490691bf1e11ddcb5836d1c218011db657c2e82af3197623d75bb64a"

URI_x86_64_v2_rust-crossbeam-epoch+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+default-devel-0.9.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+default-devel.sha256sum] = "6dbef5bf6172b004c3c5bf26b8923291f608f46fd4dc973dd01ecb4e8cb7a4b9"

URI_x86_64_v2_rust-crossbeam-epoch+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+nightly-devel-0.9.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch+nightly-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+nightly-devel.sha256sum] = "82b447d1112178ca58dbf27858decfd812056df1e813cc11b312774410f3bfe2"

URI_x86_64_v2_rust-crossbeam-epoch+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+std-devel-0.9.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+std-devel.sha256sum] = "9a0e989a8ca6349dbf1d8767de4c05919d85fe1942a8ba0f35033195ec9f93f5"

URI_x86_64_v2_rust-crossbeam-epoch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch-devel-0.9.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch-devel.sha256sum] = "75f920291289af59104bd538f4eaf92479a000bc0c491b4cbdd9f35cf9f9ea43"

URI_aarch64_rust-crossbeam-epoch+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+alloc-devel-0.9.20-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-epoch+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch+alloc-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch+alloc-devel.sha256sum] = "9b17ea6418508706dfd5068fe7d799f86e2c30ed183db5a96252822e74c4543c"

URI_aarch64_rust-crossbeam-epoch+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+default-devel-0.9.20-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-epoch+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch+default-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch+default-devel.sha256sum] = "206c1a8001ff68b6b563c91bdd8f4483f337d0d3b73342eb3906fb8e13eb79bc"

URI_aarch64_rust-crossbeam-epoch+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+nightly-devel-0.9.20-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-epoch+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch+nightly-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch+nightly-devel.sha256sum] = "34ec531c759585d1f115958396e4e50521c000c49dc6785b4789416d4fe7fdff"

URI_aarch64_rust-crossbeam-epoch+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+std-devel-0.9.20-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-epoch+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch+std-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch+std-devel.sha256sum] = "69359e702c7f5c5123fa56b8764dcca5c8e4e26e94a1e8b3303aa6587589aec2"

URI_aarch64_rust-crossbeam-epoch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch-devel-0.9.20-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-epoch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch-devel.sha256sum] = "ba69e9b830e2a1232b88a046caa3dc687f50c3ade8fabb8d92655fb02d80791d"

RDEPENDS:rust-crossbeam-epoch+alloc-devel = " \
 cargo \
 rust-crossbeam-epoch-devel \
 "
RDEPENDS:rust-crossbeam-epoch+default-devel = " \
 cargo \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-epoch-devel \
 "
RDEPENDS:rust-crossbeam-epoch+nightly-devel = " \
 cargo \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils+nightly-devel \
 "
RDEPENDS:rust-crossbeam-epoch+std-devel = " \
 cargo \
 rust-crossbeam-epoch+alloc-devel \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-epoch-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
