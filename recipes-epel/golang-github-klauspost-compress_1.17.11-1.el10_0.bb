# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-klauspost-compress"
PV = "1.17.11"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-klauspost-compress-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-klauspost-compress-1.17.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "945b7c1d2922cfdbd9585d885e51442ac4aee2604a71d3017dda0a0ba891e037"

URI_x86_64_v2_golang-github-klauspost-compress-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-klauspost-compress-devel-1.17.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-klauspost-compress-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-klauspost-compress-devel}"
SRC_URI[x86_64_v2_golang-github-klauspost-compress-devel.sha256sum] = "ea1298ea023787c4a61e9188ea58b729b2a1dd0564312b92ee8cd2d588c3ad93"

URI_aarch64_golang-github-klauspost-compress-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-klauspost-compress-devel-1.17.11-1.el10_0.noarch.rpm;name=aarch64_golang-github-klauspost-compress-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-klauspost-compress-devel}"
SRC_URI[aarch64_golang-github-klauspost-compress-devel.sha256sum] = "0056738a060c53c4f3b0e29f32ea562facaf9acf860c4676cc23a68fd7eed0d5"

RDEPENDS:golang-github-klauspost-compress-devel = " \
 go-filesystem \
 "
