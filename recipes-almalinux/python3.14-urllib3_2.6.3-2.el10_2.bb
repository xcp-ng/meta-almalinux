# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-urllib3"
PV = "2.6.3"
PR = "2.el10_2"
PACKAGES = " \
 python3.14-urllib3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-urllib3-2.6.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aeb619ee9bd0f0c45d9d25b6b4b0172962e089f8062696d222f5d4239cd0f721"

URI_x86_64_v2_python3.14-urllib3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-urllib3-2.6.3-2.el10_2.noarch.rpm;name=x86_64_v2_python3.14-urllib3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-urllib3}"
SRC_URI[x86_64_v2_python3.14-urllib3.sha256sum] = "57130c6cb8bb3cf561d8de37fc42674c447fb5b7868aa36aa521c9f85eb9cdd9"

URI_aarch64_python3.14-urllib3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-urllib3-2.6.3-2.el10_2.noarch.rpm;name=aarch64_python3.14-urllib3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-urllib3}"
SRC_URI[aarch64_python3.14-urllib3.sha256sum] = "57130c6cb8bb3cf561d8de37fc42674c447fb5b7868aa36aa521c9f85eb9cdd9"

RDEPENDS:python3.14-urllib3 = " \
 ca-certificates \
 python3.14 \
 python3.14-idna \
 "
