# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-unliftio-core"
PV = "0.2.1.0"
PR = "6.el10_0"
PACKAGES = " \
 ghc-unliftio-core \
 ghc-unliftio-core-devel \
 ghc-unliftio-core-doc \
 ghc-unliftio-core-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-unliftio-core-0.2.1.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d141dfda48b1f327ba007683721db74d8277d250d215ffa15f4281ccf0fe4153"

URI_x86_64_v2_ghc-unliftio-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unliftio-core-0.2.1.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unliftio-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unliftio-core}"
SRC_URI[x86_64_v2_ghc-unliftio-core.sha256sum] = "8fdb31c62104de0f57eb1044b5c4648bb9a738f86561b8307b45992548d84a16"

URI_x86_64_v2_ghc-unliftio-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unliftio-core-devel-0.2.1.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unliftio-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unliftio-core-devel}"
SRC_URI[x86_64_v2_ghc-unliftio-core-devel.sha256sum] = "a4aa33368d03366ba094e7f57226b6262e56b6a746d7c7e05d10e2f9f0fa6cc3"

URI_x86_64_v2_ghc-unliftio-core-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unliftio-core-doc-0.2.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-unliftio-core-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unliftio-core-doc}"
SRC_URI[x86_64_v2_ghc-unliftio-core-doc.sha256sum] = "3fd7f6eb6617addad8006b7bc182140cc5aba7bedb015c8fe42600a1a75294e7"

URI_x86_64_v2_ghc-unliftio-core-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unliftio-core-prof-0.2.1.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unliftio-core-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unliftio-core-prof}"
SRC_URI[x86_64_v2_ghc-unliftio-core-prof.sha256sum] = "68054f5a69a4f9796f809daddd26c05cebbe2ee107c438c01c8abfc6f5231cb8"

URI_aarch64_ghc-unliftio-core = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unliftio-core-0.2.1.0-6.el10_0.aarch64.rpm;name=aarch64_ghc-unliftio-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unliftio-core}"
SRC_URI[aarch64_ghc-unliftio-core.sha256sum] = "0e011c28bde0d560f6bc9341a9cd735f77adea4ca6efc8cfecf088bd6e120559"

URI_aarch64_ghc-unliftio-core-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unliftio-core-devel-0.2.1.0-6.el10_0.aarch64.rpm;name=aarch64_ghc-unliftio-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unliftio-core-devel}"
SRC_URI[aarch64_ghc-unliftio-core-devel.sha256sum] = "bd2a637cc13d345bd478760ead3863d10e0b2da51a3aa73bc45e2d05467444d4"

URI_aarch64_ghc-unliftio-core-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unliftio-core-doc-0.2.1.0-6.el10_0.noarch.rpm;name=aarch64_ghc-unliftio-core-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unliftio-core-doc}"
SRC_URI[aarch64_ghc-unliftio-core-doc.sha256sum] = "f41c92f7dda06dced8ea7e7506f00f987526768cf68fcb1e69be875e78b00de5"

URI_aarch64_ghc-unliftio-core-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unliftio-core-prof-0.2.1.0-6.el10_0.aarch64.rpm;name=aarch64_ghc-unliftio-core-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unliftio-core-prof}"
SRC_URI[aarch64_ghc-unliftio-core-prof.sha256sum] = "c2dc8597a54aa9fdfb194eb6bf1a4f19ddc783305325734fc8b72cc6f79964e2"

RDEPENDS:ghc-unliftio-core = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-unliftio-core-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-transformers-devel \
 ghc-unliftio-core \
 "
RDEPENDS:ghc-unliftio-core-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-unliftio-core-prof = " \
 ghc-base-prof \
 ghc-transformers-prof \
 ghc-unliftio-core-devel \
 "
