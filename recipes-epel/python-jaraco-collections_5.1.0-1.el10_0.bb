# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jaraco-collections"
PV = "5.1.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-jaraco-collections \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jaraco-collections-5.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c162af5e944a552e4558d51d1d58024cb209e91b60b921b8449d7f9d1b2ddbcf"

URI_x86_64_v2_python3-jaraco-collections = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jaraco-collections-5.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jaraco-collections;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jaraco-collections}"
SRC_URI[x86_64_v2_python3-jaraco-collections.sha256sum] = "032a757beca3df7eb527a96bc58d14dff599efd5196df214762bcec83f30c317"

URI_aarch64_python3-jaraco-collections = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jaraco-collections-5.1.0-1.el10_0.noarch.rpm;name=aarch64_python3-jaraco-collections;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jaraco-collections}"
SRC_URI[aarch64_python3-jaraco-collections.sha256sum] = "3ef519bf4a0165fb5828e32d67002c03facc733d79af9209ca991511ccb9abd5"

RDEPENDS:python3-jaraco-collections = " \
 python3 \
 python3-jaraco-text \
 "
