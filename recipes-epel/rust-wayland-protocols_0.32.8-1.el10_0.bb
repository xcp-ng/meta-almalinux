# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-protocols"
PV = "0.32.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-wayland-protocols+client-devel \
 rust-wayland-protocols+default-devel \
 rust-wayland-protocols+server-devel \
 rust-wayland-protocols+staging-devel \
 rust-wayland-protocols+unstable-devel \
 rust-wayland-protocols+wayland-client-devel \
 rust-wayland-protocols+wayland-server-devel \
 rust-wayland-protocols-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-protocols-0.32.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "292234acc7374e253f86168e4aeb3a7ca719f3932cad9d81ca9f030e42fb5a2a"

URI_x86_64_v2_rust-wayland-protocols+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+client-devel-0.32.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+client-devel.sha256sum] = "6f445e7a8e2a908478fe4f4cb35e02f34b177c778a2b64b66b9819990cc0e44c"

URI_x86_64_v2_rust-wayland-protocols+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+default-devel-0.32.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+default-devel.sha256sum] = "333e3ee0e7d0e263e423a7ad38e7aab6245b070194b0dc3ee8db8f11d1122e12"

URI_x86_64_v2_rust-wayland-protocols+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+server-devel-0.32.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+server-devel.sha256sum] = "7d50fd2e06ad61319463618eff34dbe91215466dce488898cdd92aefc2a78314"

URI_x86_64_v2_rust-wayland-protocols+staging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+staging-devel-0.32.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+staging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+staging-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+staging-devel.sha256sum] = "0ef1796a59d26dc8f080b05de99d8a1f86644f2423c1a3d13c06f289ba5616b9"

URI_x86_64_v2_rust-wayland-protocols+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+unstable-devel-0.32.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+unstable-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+unstable-devel.sha256sum] = "50c54e377f7afafa2ead38a598aa1fc66c318565a88f28395ba90365b025551b"

URI_x86_64_v2_rust-wayland-protocols+wayland-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+wayland-client-devel-0.32.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+wayland-client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+wayland-client-devel.sha256sum] = "4a15b84e647f93e0e5f423910f4e88fe7a49d0f32aa71cd296844b11aaf94a1c"

URI_x86_64_v2_rust-wayland-protocols+wayland-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+wayland-server-devel-0.32.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+wayland-server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+wayland-server-devel.sha256sum] = "238a94f4cefbd80e5ae8d1fe4499f9a9b99ed3a7fcb181339b5a42351f0fdb1b"

URI_x86_64_v2_rust-wayland-protocols-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-devel-0.32.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-devel.sha256sum] = "c298435e74e4d739b7eac61794401dcacf018ffa888c5bd1023288cc44ca64ad"

URI_aarch64_rust-wayland-protocols+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+client-devel-0.32.8-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-protocols+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+client-devel}"
SRC_URI[aarch64_rust-wayland-protocols+client-devel.sha256sum] = "c9346eb92e5c9138a60d01c7bb10e146c71461cf15ff41bcf2d3c858c553a11c"

URI_aarch64_rust-wayland-protocols+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+default-devel-0.32.8-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-protocols+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+default-devel}"
SRC_URI[aarch64_rust-wayland-protocols+default-devel.sha256sum] = "fd2e09e456df1df70c9e9d33c3240c2ec1fc5cc03e83bd580994011bd879d1cc"

URI_aarch64_rust-wayland-protocols+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+server-devel-0.32.8-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-protocols+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+server-devel}"
SRC_URI[aarch64_rust-wayland-protocols+server-devel.sha256sum] = "437182e52f0e8cfe87c2b382407f934ec075fbb8f575acbb62a5ef50c0be0b53"

URI_aarch64_rust-wayland-protocols+staging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+staging-devel-0.32.8-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-protocols+staging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+staging-devel}"
SRC_URI[aarch64_rust-wayland-protocols+staging-devel.sha256sum] = "fa6e2250ba38d329ea18fc4e31ec9307fc10a2a9098846bde5f3ee69f9aeb025"

URI_aarch64_rust-wayland-protocols+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+unstable-devel-0.32.8-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-protocols+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+unstable-devel}"
SRC_URI[aarch64_rust-wayland-protocols+unstable-devel.sha256sum] = "8704d8bb0297135d9f4e489002150d6624cc3e3a6dc7c2bac317daee9a1872a0"

URI_aarch64_rust-wayland-protocols+wayland-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+wayland-client-devel-0.32.8-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-protocols+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+wayland-client-devel}"
SRC_URI[aarch64_rust-wayland-protocols+wayland-client-devel.sha256sum] = "6b36ec260ed0fd9ab26f00e252b47ac28d3ca3b274d8f3d335452330efeb61a6"

URI_aarch64_rust-wayland-protocols+wayland-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+wayland-server-devel-0.32.8-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-protocols+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+wayland-server-devel}"
SRC_URI[aarch64_rust-wayland-protocols+wayland-server-devel.sha256sum] = "3c6ca7e2a68f9f1d21407c93b352283826d0fc395f94fa8a32f0fbc0f7da2862"

URI_aarch64_rust-wayland-protocols-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-devel-0.32.8-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-devel}"
SRC_URI[aarch64_rust-wayland-protocols-devel.sha256sum] = "d9a7ed426fa47b923b1d31edf12ee3253a37ca32542acf953e3c403b18cac30f"

RDEPENDS:rust-wayland-protocols+client-devel = " \
 cargo \
 rust-wayland-protocols+wayland-client-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+default-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+server-devel = " \
 cargo \
 rust-wayland-protocols+wayland-server-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+staging-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+unstable-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+wayland-client-devel = " \
 cargo \
 rust-wayland-client+default-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+wayland-server-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 rust-wayland-server+default-devel \
 "
RDEPENDS:rust-wayland-protocols-devel = " \
 bash \
 cargo \
 python3 \
 rust \
 rust-bitflags+default-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
