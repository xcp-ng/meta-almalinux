# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdump-anaconda-addon"
PV = "006"
PR = "17.20220714git7ca2d3e.el10"
PACKAGES = " \
 kdump-anaconda-addon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/kdump-anaconda-addon-006-17.20220714git7ca2d3e.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b823340007d357b9d3db8db313a9c76cfc6f0883d2063a5e83d37d8be68d3211"

URI_x86_64_v2_kdump-anaconda-addon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kdump-anaconda-addon-006-17.20220714git7ca2d3e.el10.noarch.rpm;name=x86_64_v2_kdump-anaconda-addon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdump-anaconda-addon}"
SRC_URI[x86_64_v2_kdump-anaconda-addon.sha256sum] = "36fd216e3371eac3b31da723c217914fc3d5ceaaddb008cd0a9793ebae0e4586"

URI_aarch64_kdump-anaconda-addon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kdump-anaconda-addon-006-17.20220714git7ca2d3e.el10.noarch.rpm;name=aarch64_kdump-anaconda-addon;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdump-anaconda-addon}"
SRC_URI[aarch64_kdump-anaconda-addon.sha256sum] = "36fd216e3371eac3b31da723c217914fc3d5ceaaddb008cd0a9793ebae0e4586"

RDEPENDS:kdump-anaconda-addon = " \
 anaconda \
 hicolor-icon-theme \
 "
