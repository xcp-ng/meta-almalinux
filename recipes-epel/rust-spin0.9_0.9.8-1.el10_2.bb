# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-spin0.9"
PV = "0.9.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-spin0.9+barrier-devel \
 rust-spin0.9+default-devel \
 rust-spin0.9+fair_mutex-devel \
 rust-spin0.9+lazy-devel \
 rust-spin0.9+lock_api-devel \
 rust-spin0.9+lock_api_crate-devel \
 rust-spin0.9+mutex-devel \
 rust-spin0.9+once-devel \
 rust-spin0.9+portable-atomic-devel \
 rust-spin0.9+portable_atomic-devel \
 rust-spin0.9+rwlock-devel \
 rust-spin0.9+spin_mutex-devel \
 rust-spin0.9+std-devel \
 rust-spin0.9+ticket_mutex-devel \
 rust-spin0.9+use_ticket_mutex-devel \
 rust-spin0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-spin0.9-0.9.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54d07669ff61e9d191f2e742ec6b2e44cb4bb48d10ba26315e4a620a3667f121"

URI_x86_64_v2_rust-spin0.9+barrier-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+barrier-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+barrier-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+barrier-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+barrier-devel.sha256sum] = "d9b1218a4fc4c05e08f14e2506f1fbbf0201dc8837e839813ec02497e42189ae"

URI_x86_64_v2_rust-spin0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+default-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+default-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+default-devel.sha256sum] = "500f232a6be6c82b50e5c83bf6dfc5a170e9d1f4d1ee75bb418dbbd2ef4f527b"

URI_x86_64_v2_rust-spin0.9+fair_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+fair_mutex-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+fair_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+fair_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+fair_mutex-devel.sha256sum] = "c7cd9b21304468d1285c363592954698beaa1105df03aaa001a637d739bc10bc"

URI_x86_64_v2_rust-spin0.9+lazy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+lazy-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+lazy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+lazy-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+lazy-devel.sha256sum] = "715dabbc1145432eaa6a63e7b06cdc8a1cf8e2c91401362c2e619ad9c655756d"

URI_x86_64_v2_rust-spin0.9+lock_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+lock_api-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+lock_api-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+lock_api-devel.sha256sum] = "625058d12e172b95301d82c29040add0860ec96502a2c9b665823e13e69c7db6"

URI_x86_64_v2_rust-spin0.9+lock_api_crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+lock_api_crate-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+lock_api_crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+lock_api_crate-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+lock_api_crate-devel.sha256sum] = "108f06cc76852825c643340c70dfd21ae4b433420e4dd95dfaf7f4b486e0cf76"

URI_x86_64_v2_rust-spin0.9+mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+mutex-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+mutex-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+mutex-devel.sha256sum] = "83d537431c95a7ff89e4908c375a1ac8737a2582ceada1043bca286311320475"

URI_x86_64_v2_rust-spin0.9+once-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+once-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+once-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+once-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+once-devel.sha256sum] = "e1276cd14177b9ed3efb5a966a96ef88a779bfcccf5ccdcba882fd235f24ece0"

URI_x86_64_v2_rust-spin0.9+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+portable-atomic-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+portable-atomic-devel.sha256sum] = "beea8fa1043f194aa75ee74a39ade9de0878f32377fb8d2c0c9715f2e34ba507"

URI_x86_64_v2_rust-spin0.9+portable_atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+portable_atomic-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+portable_atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+portable_atomic-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+portable_atomic-devel.sha256sum] = "609f0a72ac6f6af2d7a5f33f29426c0845a711333eb755ff20e948c113e720e4"

URI_x86_64_v2_rust-spin0.9+rwlock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+rwlock-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+rwlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+rwlock-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+rwlock-devel.sha256sum] = "6953d7aa5d43ed70fcfd2eefa6f8e6df3e43b608d41622b33231343876c2df92"

URI_x86_64_v2_rust-spin0.9+spin_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+spin_mutex-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+spin_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+spin_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+spin_mutex-devel.sha256sum] = "f76da900b36f52dc7dd687977bff6d35acbb6d4213456a51aac6294eaf56b6b9"

URI_x86_64_v2_rust-spin0.9+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+std-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+std-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+std-devel.sha256sum] = "8b40db67f99776c75097cde561802e2dce8efe8cc1392277fad4a6ea2ff5eb7b"

URI_x86_64_v2_rust-spin0.9+ticket_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+ticket_mutex-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+ticket_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+ticket_mutex-devel.sha256sum] = "3224e044362f0ccc2d3bcba06a571debbadfec3fdeefc734010452b0ac1437e2"

URI_x86_64_v2_rust-spin0.9+use_ticket_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9+use_ticket_mutex-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9+use_ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9+use_ticket_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin0.9+use_ticket_mutex-devel.sha256sum] = "b8046f945b3058432d36e3d1efb89b7cf73e24b0f102dc52e0c0b84f6b2e5d56"

URI_x86_64_v2_rust-spin0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.9-devel-0.9.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.9-devel}"
SRC_URI[x86_64_v2_rust-spin0.9-devel.sha256sum] = "914a1b8786c0bc3c0b50fe4700e5aed9532645af6492cdd7705894949074eece"

URI_aarch64_rust-spin0.9+barrier-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+barrier-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+barrier-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+barrier-devel}"
SRC_URI[aarch64_rust-spin0.9+barrier-devel.sha256sum] = "fdb2d71d8204aefb43572a5f4388c80cd751a87499539b3eac3c2af113d5d618"

URI_aarch64_rust-spin0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+default-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+default-devel}"
SRC_URI[aarch64_rust-spin0.9+default-devel.sha256sum] = "23636a546fb43dfe244fbb152d0cb228c8ec04a4fa55141c6f9dc28a86c953a3"

URI_aarch64_rust-spin0.9+fair_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+fair_mutex-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+fair_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+fair_mutex-devel}"
SRC_URI[aarch64_rust-spin0.9+fair_mutex-devel.sha256sum] = "f39cfd77f86b3b3602b7b3a2a13f9a9dde2630526fd72793a53c1780d8389165"

URI_aarch64_rust-spin0.9+lazy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+lazy-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+lazy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+lazy-devel}"
SRC_URI[aarch64_rust-spin0.9+lazy-devel.sha256sum] = "1e9170c4b6879d486763dec8f0d38fcb17ce8fcc36eb2097256eae6e5bc7b55f"

URI_aarch64_rust-spin0.9+lock_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+lock_api-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+lock_api-devel}"
SRC_URI[aarch64_rust-spin0.9+lock_api-devel.sha256sum] = "6409e318d06202caa4d7f294266e543a74ecaf96cf761e4e8f9ac53a649cf8cd"

URI_aarch64_rust-spin0.9+lock_api_crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+lock_api_crate-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+lock_api_crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+lock_api_crate-devel}"
SRC_URI[aarch64_rust-spin0.9+lock_api_crate-devel.sha256sum] = "f07f3ea25d4a61c753813c9420b212b98c5e7f072ef2f334d2b44ca88945218a"

URI_aarch64_rust-spin0.9+mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+mutex-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+mutex-devel}"
SRC_URI[aarch64_rust-spin0.9+mutex-devel.sha256sum] = "41e752f31084b7d73351f83fb9aaf4ecdbde8f1b9dc51fee6596bd6ebec03d41"

URI_aarch64_rust-spin0.9+once-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+once-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+once-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+once-devel}"
SRC_URI[aarch64_rust-spin0.9+once-devel.sha256sum] = "83ad299cfbe63504ebb68959e5a365db13437cf9b8d07962eda8d0f0c95cb321"

URI_aarch64_rust-spin0.9+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+portable-atomic-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+portable-atomic-devel}"
SRC_URI[aarch64_rust-spin0.9+portable-atomic-devel.sha256sum] = "3c3d009fbc4c281ed85d1c0cbe58145f199d361ee386f7aa64b6b1a42836e3bc"

URI_aarch64_rust-spin0.9+portable_atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+portable_atomic-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+portable_atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+portable_atomic-devel}"
SRC_URI[aarch64_rust-spin0.9+portable_atomic-devel.sha256sum] = "b96d94a383e1beae70c5ad9425683d4b0bd108d959fd06e95b7b047a08cb1cdc"

URI_aarch64_rust-spin0.9+rwlock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+rwlock-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+rwlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+rwlock-devel}"
SRC_URI[aarch64_rust-spin0.9+rwlock-devel.sha256sum] = "79e4e8d4ef0c93b1f60889d7888bc6949ddada3c7b7ff4c5b997984a05563dc7"

URI_aarch64_rust-spin0.9+spin_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+spin_mutex-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+spin_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+spin_mutex-devel}"
SRC_URI[aarch64_rust-spin0.9+spin_mutex-devel.sha256sum] = "7c74fc4137c641bd993a120421234865072ee372414d9fadff3500ad6ad170d5"

URI_aarch64_rust-spin0.9+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+std-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+std-devel}"
SRC_URI[aarch64_rust-spin0.9+std-devel.sha256sum] = "bf0ed87f5d41776198bf32b4d44bcc1a1c8e45b9fae37ac5e2d503532b6610e7"

URI_aarch64_rust-spin0.9+ticket_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+ticket_mutex-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+ticket_mutex-devel}"
SRC_URI[aarch64_rust-spin0.9+ticket_mutex-devel.sha256sum] = "c939106446e597add4c49e42a4a5ddbeae7da043a565b43c3e62babf30ff2418"

URI_aarch64_rust-spin0.9+use_ticket_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9+use_ticket_mutex-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9+use_ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9+use_ticket_mutex-devel}"
SRC_URI[aarch64_rust-spin0.9+use_ticket_mutex-devel.sha256sum] = "a4fcdb519aa3b61358b83fdc26f02fee837c0ff02548d2cefbc34a3a709f9e39"

URI_aarch64_rust-spin0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.9-devel-0.9.8-1.el10_2.noarch.rpm;name=aarch64_rust-spin0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.9-devel}"
SRC_URI[aarch64_rust-spin0.9-devel.sha256sum] = "2fae4ed855db187fc0d2e89c7cc451575e4f40f94512f4c9d45066ce7a706625"

RDEPENDS:rust-spin0.9+barrier-devel = " \
 cargo \
 rust-spin0.9+mutex-devel \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9+default-devel = " \
 cargo \
 rust-spin0.9+barrier-devel \
 rust-spin0.9+lazy-devel \
 rust-spin0.9+lock_api-devel \
 rust-spin0.9+mutex-devel \
 rust-spin0.9+once-devel \
 rust-spin0.9+rwlock-devel \
 rust-spin0.9+spin_mutex-devel \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9+fair_mutex-devel = " \
 cargo \
 rust-spin0.9+mutex-devel \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9+lazy-devel = " \
 cargo \
 rust-spin0.9+once-devel \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9+lock_api-devel = " \
 cargo \
 rust-spin0.9+lock_api_crate-devel \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9+lock_api_crate-devel = " \
 cargo \
 rust-lock_api+default-devel \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9+mutex-devel = " \
 cargo \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9+once-devel = " \
 cargo \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9+portable-atomic-devel = " \
 cargo \
 rust-portable-atomic-devel \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9+portable_atomic-devel = " \
 cargo \
 rust-spin0.9+portable-atomic-devel \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9+rwlock-devel = " \
 cargo \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9+spin_mutex-devel = " \
 cargo \
 rust-spin0.9+mutex-devel \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9+std-devel = " \
 cargo \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9+ticket_mutex-devel = " \
 cargo \
 rust-spin0.9+mutex-devel \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9+use_ticket_mutex-devel = " \
 cargo \
 rust-spin0.9+mutex-devel \
 rust-spin0.9+ticket_mutex-devel \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-spin0.9-devel = " \
 cargo \
 rust \
 "
