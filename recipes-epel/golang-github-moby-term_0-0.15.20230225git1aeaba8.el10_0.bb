# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-moby-term"
PV = "0"
PR = "0.15.20230225git1aeaba8.el10_0"
PACKAGES = " \
 golang-github-moby-term-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-moby-term-0-0.15.20230225git1aeaba8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4936972140b053eb4a3e6ee874b32c77508a39679c010b02cd77a45788c13d2f"

URI_aarch64_golang-github-moby-term-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-moby-term-devel-0-0.15.20230225git1aeaba8.el10_0.noarch.rpm;name=aarch64_golang-github-moby-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-moby-term-devel}"
SRC_URI[aarch64_golang-github-moby-term-devel.sha256sum] = "63ab093099c1ce0b9b0d04c299dcd0dfdbba711e43966c7b2a1082a328b2f14d"

RDEPENDS:golang-github-moby-term-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
