# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-chai"
PV = "1.1.2"
PR = "34.el10_0"
PACKAGES = " \
 python3-chai \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-chai-1.1.2-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2809459ce5031954996dced8835c5c65fa8a3b85e5cbd15e4325d0eacf3fe49b"

URI_x86_64_v2_python3-chai = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-chai-1.1.2-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-chai;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-chai}"
SRC_URI[x86_64_v2_python3-chai.sha256sum] = "2ab2e75b87bca587953358e90d5b3d1f561fe97f41e78c248f61af0987eebf90"

URI_aarch64_python3-chai = "${EPEL_MIRROR}/aarch64/Packages/p/python3-chai-1.1.2-34.el10_0.noarch.rpm;name=aarch64_python3-chai;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-chai}"
SRC_URI[aarch64_python3-chai.sha256sum] = "7b4a138a4c2de51d8b028ab11045c1fd78323ae9a00b9afbdf73566bd035c96a"

RDEPENDS:python3-chai = " \
 python3 \
 "
