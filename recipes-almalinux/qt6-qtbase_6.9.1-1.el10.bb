# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtbase"
PV = "6.9.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtbase \
 qt6-qtbase-common \
 qt6-qtbase-devel \
 qt6-qtbase-examples \
 qt6-qtbase-gui \
 qt6-qtbase-mysql \
 qt6-qtbase-odbc \
 qt6-qtbase-postgresql \
 qt6-qtbase-private-devel \
 qt6-qtbase-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtbase-6.9.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42e27753abc2e41761a0f4e490b9aec166c97d92c709d4abe2d43f5b89d014dc"

URI_x86_64_v2_qt6-qtbase = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase}"
SRC_URI[x86_64_v2_qt6-qtbase.sha256sum] = "e55212010d96cd5c6fd801b856107ff15f3c21c6a893c58f0f38e2bac4e0ebde"

URI_x86_64_v2_qt6-qtbase-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-common-6.9.1-1.el10.noarch.rpm;name=x86_64_v2_qt6-qtbase-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-common}"
SRC_URI[x86_64_v2_qt6-qtbase-common.sha256sum] = "b648afccbe4b0e1bc92d2830c3e48c20697e9a688108c87898b1bccfe967fa49"

URI_x86_64_v2_qt6-qtbase-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-devel-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-devel}"
SRC_URI[x86_64_v2_qt6-qtbase-devel.sha256sum] = "1d3e91b1b8868cce840d380252aa26bfb1392f6204a7fd4f0c7921cea0da006f"

URI_x86_64_v2_qt6-qtbase-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtbase-examples-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-examples}"
SRC_URI[x86_64_v2_qt6-qtbase-examples.sha256sum] = "446ea54f0f6afb2ed574301ed97b9bbe36431a830991518bf42be14cf763e4b6"

URI_x86_64_v2_qt6-qtbase-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-gui-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-gui}"
SRC_URI[x86_64_v2_qt6-qtbase-gui.sha256sum] = "505ae24209256691b4fe9463acc817e31c7099c904009eb10bd40b4776ac53d3"

URI_x86_64_v2_qt6-qtbase-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-mysql-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-mysql}"
SRC_URI[x86_64_v2_qt6-qtbase-mysql.sha256sum] = "95669fc296451338fea1f3434813dc78efd71d33f4e4ad892c0885b39c79ba72"

URI_x86_64_v2_qt6-qtbase-odbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-odbc-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-odbc}"
SRC_URI[x86_64_v2_qt6-qtbase-odbc.sha256sum] = "ab388bb0bb8b7d0a05a9a76921a6a265cf0985e0d81816f4710cef0662eee05b"

URI_x86_64_v2_qt6-qtbase-postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-postgresql-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-postgresql}"
SRC_URI[x86_64_v2_qt6-qtbase-postgresql.sha256sum] = "2fbc2ac7dd19a88a25b617cccd81de2603eb32a5e0f23c174574f0340c358198"

URI_x86_64_v2_qt6-qtbase-private-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtbase-private-devel-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-private-devel}"
SRC_URI[x86_64_v2_qt6-qtbase-private-devel.sha256sum] = "1f5453ae0fcfffb933aaf5b86627f0d0986cb7ae4cd99355ea21c44d89dcb8ea"

URI_x86_64_v2_qt6-qtbase-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtbase-static-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-static}"
SRC_URI[x86_64_v2_qt6-qtbase-static.sha256sum] = "4a170a0b5a1992b6938fada02c3018d56ad0dd6c020b27a1fdadbc403f6cdc91"

URI_aarch64_qt6-qtbase = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtbase;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase}"
SRC_URI[aarch64_qt6-qtbase.sha256sum] = "8e10c09e0ada983f5c251451d97c582f919d02763bd405d8303be5681fc54e9f"

URI_aarch64_qt6-qtbase-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-common-6.9.1-1.el10.noarch.rpm;name=aarch64_qt6-qtbase-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-common}"
SRC_URI[aarch64_qt6-qtbase-common.sha256sum] = "b648afccbe4b0e1bc92d2830c3e48c20697e9a688108c87898b1bccfe967fa49"

URI_aarch64_qt6-qtbase-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-devel-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtbase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-devel}"
SRC_URI[aarch64_qt6-qtbase-devel.sha256sum] = "781ada32900eb423082f39a6d4246ada3a934f11346b425c36483ccf8939fcfd"

URI_aarch64_qt6-qtbase-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtbase-examples-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtbase-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-examples}"
SRC_URI[aarch64_qt6-qtbase-examples.sha256sum] = "e91dddb2d7c7d79353f998204a13d2fb15e82f4ad21b6c1451ed97d7af75ac4e"

URI_aarch64_qt6-qtbase-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-gui-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtbase-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-gui}"
SRC_URI[aarch64_qt6-qtbase-gui.sha256sum] = "1246c8ab0746530c304ff297e57f68d1f5039fe2a48b8ee0f089126d95125eb4"

URI_aarch64_qt6-qtbase-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-mysql-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtbase-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-mysql}"
SRC_URI[aarch64_qt6-qtbase-mysql.sha256sum] = "50e9d8a3878099cf90d808aa4bfa4c21da3ceed975160f936d64f4947f3bc5ad"

URI_aarch64_qt6-qtbase-odbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-odbc-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtbase-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-odbc}"
SRC_URI[aarch64_qt6-qtbase-odbc.sha256sum] = "0606684b910e02bedec8a891c7c267b7a8607b01689e2f4ebd1371c28b009978"

URI_aarch64_qt6-qtbase-postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-postgresql-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtbase-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-postgresql}"
SRC_URI[aarch64_qt6-qtbase-postgresql.sha256sum] = "9e1d3e0c0bff1ca59c302046875fbe3593273893c7be5de5a44ae2e70a55fcda"

URI_aarch64_qt6-qtbase-private-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtbase-private-devel-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtbase-private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-private-devel}"
SRC_URI[aarch64_qt6-qtbase-private-devel.sha256sum] = "74da21c9f60b4698fd3100c3653bc7c8fa1e45ea3fa173a42d72a0818f91cbe7"

URI_aarch64_qt6-qtbase-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtbase-static-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtbase-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-static}"
SRC_URI[aarch64_qt6-qtbase-static.sha256sum] = "62a34fcaeda87eef6626131c3087132ca0ddee3f4a6331907b93a5c8c9ed69b5"

RDEPENDS:qt6-qtbase = " \
 dbus-libs \
 glib2 \
 glibc \
 krb5-libs \
 libbrotli \
 libgcc \
 libicu \
 libproxy \
 libstdc++ \
 libzstd \
 openssl-libs \
 pcre2-utf16 \
 qt6-filesystem \
 qt6-qtbase-common \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:qt6-qtbase-common = " \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtbase-devel = " \
 bash \
 cmake-filesystem \
 glibc \
 libgcc \
 libglvnd-devel \
 libstdc++ \
 libxkbcommon-devel \
 libzstd \
 pcre2-utf16 \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qtbase-mysql \
 qt6-qtbase-odbc \
 qt6-qtbase-postgresql \
 qt6-rpm-macros \
 vulkan-loader-devel \
 "
RDEPENDS:qt6-qtbase-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:qt6-qtbase-gui:x86_64_v2 = " \
 bash \
 cups-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 glx-utils \
 harfbuzz \
 libICE \
 libSM \
 libX11 \
 libX11-xcb \
 libdrm \
 libgcc \
 libglvnd-egl \
 libglvnd-glx \
 libglvnd-opengl \
 libinput \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libxcb \
 libxkbcommon \
 libxkbcommon-x11 \
 mesa-libgbm \
 mtdev \
 qt6-qtbase \
 systemd-libs \
 xcb-util-cursor \
 xcb-util-image \
 xcb-util-keysyms \
 xcb-util-renderutil \
 xcb-util-wm \
 zlib-ng-compat \
"
RDEPENDS:qt6-qtbase-gui:aarch64 = " \
 bash \
 cups-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 glx-utils \
 harfbuzz \
 libICE \
 libSM \
 libX11 \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libglvnd-glx \
 libglvnd-opengl \
 libinput \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libxcb \
 libxkbcommon \
 libxkbcommon-x11 \
 mesa-libgbm \
 mtdev \
 qt6-qtbase \
 systemd-libs \
 xcb-util-cursor \
 xcb-util-image \
 xcb-util-keysyms \
 xcb-util-renderutil \
 xcb-util-wm \
 zlib-ng-compat \
"
RDEPENDS:qt6-qtbase-mysql = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 mariadb-connector-c \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtbase-odbc = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt6-qtbase \
 unixODBC \
 "
RDEPENDS:qt6-qtbase-postgresql = " \
 cmake-filesystem \
 glibc \
 libpq \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtbase-private-devel = " \
 cmake-filesystem \
 cups-devel \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:qt6-qtbase-static = " \
 cmake-filesystem \
 fontconfig-devel \
 glib2-devel \
 libinput-devel \
 libxkbcommon-devel \
 qt6-qtbase-devel \
 zlib-ng-compat-devel \
 "
