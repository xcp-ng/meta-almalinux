# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memsec"
PV = "0.6.3"
PR = "6.el10_2"
PACKAGES = " \
 rust-memsec+alloc-devel \
 rust-memsec+default-devel \
 rust-memsec+getrandom-devel \
 rust-memsec+libc-devel \
 rust-memsec+nightly-devel \
 rust-memsec+use_os-devel \
 rust-memsec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memsec-0.6.3-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70acd2adb859554c41bcfa9f523c6cd65416f6ee6d921e6311fcba82b29ae23b"

URI_x86_64_v2_rust-memsec+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memsec+alloc-devel-0.6.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memsec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memsec+alloc-devel}"
SRC_URI[x86_64_v2_rust-memsec+alloc-devel.sha256sum] = "fcb96798be927401b1dbaf6337f773f51cbe7e0c1bf754f4f4bb16f99a1d1033"

URI_x86_64_v2_rust-memsec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memsec+default-devel-0.6.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memsec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memsec+default-devel}"
SRC_URI[x86_64_v2_rust-memsec+default-devel.sha256sum] = "e9393d8ffa49376c58ebef7a65d8a389620078b4db96af896609b9b7ff4dbf30"

URI_x86_64_v2_rust-memsec+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memsec+getrandom-devel-0.6.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memsec+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memsec+getrandom-devel}"
SRC_URI[x86_64_v2_rust-memsec+getrandom-devel.sha256sum] = "52a178a134ce5b71a787ea4e21cc4111eebe382c39b2e2a898b01dbc7fff99d4"

URI_x86_64_v2_rust-memsec+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memsec+libc-devel-0.6.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memsec+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memsec+libc-devel}"
SRC_URI[x86_64_v2_rust-memsec+libc-devel.sha256sum] = "27d83eca97791b9e7d235a38cff0732ed8a9e5c6d9f4f5c6f9e198ff2f6c73ee"

URI_x86_64_v2_rust-memsec+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memsec+nightly-devel-0.6.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memsec+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memsec+nightly-devel}"
SRC_URI[x86_64_v2_rust-memsec+nightly-devel.sha256sum] = "009b20df6f416726925b98837dc8b2642cba9de7fdfbdf3bf1e668283c89e7b9"

URI_x86_64_v2_rust-memsec+use_os-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memsec+use_os-devel-0.6.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memsec+use_os-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memsec+use_os-devel}"
SRC_URI[x86_64_v2_rust-memsec+use_os-devel.sha256sum] = "240becf454240c865a1abe9e3b9746404de91aa5d424e147fb3ea5b8cebd8a46"

URI_x86_64_v2_rust-memsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memsec-devel-0.6.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memsec-devel}"
SRC_URI[x86_64_v2_rust-memsec-devel.sha256sum] = "c8e5bd5351a50d3909017d2e09983203ea596a91a485b784627c6c7103ebd0e8"

URI_aarch64_rust-memsec+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memsec+alloc-devel-0.6.3-6.el10_2.noarch.rpm;name=aarch64_rust-memsec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memsec+alloc-devel}"
SRC_URI[aarch64_rust-memsec+alloc-devel.sha256sum] = "157b392f73458f4799d6929b0580a1dccdad6661649c34848a3a474347f69b90"

URI_aarch64_rust-memsec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memsec+default-devel-0.6.3-6.el10_2.noarch.rpm;name=aarch64_rust-memsec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memsec+default-devel}"
SRC_URI[aarch64_rust-memsec+default-devel.sha256sum] = "69ee7cb10e625e72091460299d73a1af5f4ab08983c8b69d537c5971d3609008"

URI_aarch64_rust-memsec+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memsec+getrandom-devel-0.6.3-6.el10_2.noarch.rpm;name=aarch64_rust-memsec+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memsec+getrandom-devel}"
SRC_URI[aarch64_rust-memsec+getrandom-devel.sha256sum] = "c875f1a703a45bbf05a484975f10d124c855877de8a53854415a8c7f20038f5b"

URI_aarch64_rust-memsec+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memsec+libc-devel-0.6.3-6.el10_2.noarch.rpm;name=aarch64_rust-memsec+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memsec+libc-devel}"
SRC_URI[aarch64_rust-memsec+libc-devel.sha256sum] = "1cabc50d1a27ee090391bfea2680da71b0b5178b3d4b010b0528ed25822d264b"

URI_aarch64_rust-memsec+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memsec+nightly-devel-0.6.3-6.el10_2.noarch.rpm;name=aarch64_rust-memsec+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memsec+nightly-devel}"
SRC_URI[aarch64_rust-memsec+nightly-devel.sha256sum] = "14407b8945aa9810f045a37ae215488f5735333575757b7dcece972ccc84866a"

URI_aarch64_rust-memsec+use_os-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memsec+use_os-devel-0.6.3-6.el10_2.noarch.rpm;name=aarch64_rust-memsec+use_os-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memsec+use_os-devel}"
SRC_URI[aarch64_rust-memsec+use_os-devel.sha256sum] = "791c2abe50780331d9da2ba78d9ecac8d0594df82b17c4583a3b5a0675e616e6"

URI_aarch64_rust-memsec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memsec-devel-0.6.3-6.el10_2.noarch.rpm;name=aarch64_rust-memsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memsec-devel}"
SRC_URI[aarch64_rust-memsec-devel.sha256sum] = "524c9600340418fc47d9213a66bcf0e234c09ce6c7ff331abbaa4a8fca27c30c"

RDEPENDS:rust-memsec+alloc-devel = " \
 cargo \
 rust-memsec+getrandom-devel \
 rust-memsec+use_os-devel \
 rust-memsec-devel \
 "
RDEPENDS:rust-memsec+default-devel = " \
 cargo \
 rust-memsec+alloc-devel \
 rust-memsec+use_os-devel \
 rust-memsec-devel \
 "
RDEPENDS:rust-memsec+getrandom-devel = " \
 cargo \
 rust-getrandom0.2+default-devel \
 rust-memsec-devel \
 "
RDEPENDS:rust-memsec+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-memsec-devel \
 "
RDEPENDS:rust-memsec+nightly-devel = " \
 cargo \
 rust-memsec-devel \
 "
RDEPENDS:rust-memsec+use_os-devel = " \
 cargo \
 rust-memsec+libc-devel \
 rust-memsec-devel \
 "
RDEPENDS:rust-memsec-devel = " \
 cargo \
 "
