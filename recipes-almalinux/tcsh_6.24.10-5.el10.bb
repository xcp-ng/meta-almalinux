# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tcsh"
PV = "6.24.10"
PR = "5.el10"
PACKAGES = " \
 tcsh \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tcsh-6.24.10-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a99ccf5f6e597a80560fb97f0db4adb1302079bf9c67a9f085d663ddc4805a6"

URI_x86_64_v2_tcsh = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tcsh-6.24.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_tcsh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tcsh}"
SRC_URI[x86_64_v2_tcsh.sha256sum] = "52c5f14d3441ba2fb5660e43a79e65a898d81ba6b96ec81eced5da8278693e19"

URI_aarch64_tcsh = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tcsh-6.24.10-5.el10.aarch64.rpm;name=aarch64_tcsh;unpack=0"
SRC_URI:append = " ${URI_aarch64_tcsh}"
SRC_URI[aarch64_tcsh.sha256sum] = "ebd178adacce85816a522985b9aafd053055ebf36019d954d364e199e1fdb3aa"

RDEPENDS:tcsh = " \
 bash \
 glibc \
 grep \
 libxcrypt \
 ncurses-libs \
 sed \
 virtual/coreutils \
 "
