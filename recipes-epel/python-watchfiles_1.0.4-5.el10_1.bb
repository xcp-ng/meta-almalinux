# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-watchfiles"
PV = "1.0.4"
PR = "5.el10_1"
PACKAGES = " \
 python3-watchfiles \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-watchfiles-1.0.4-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e0c26e515f6feb5ea7d25430815a2c1eb277aec220a2e14809cc3cf5fcee5b0"

URI_x86_64_v2_python3-watchfiles = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-watchfiles-1.0.4-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-watchfiles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-watchfiles}"
SRC_URI[x86_64_v2_python3-watchfiles.sha256sum] = "7f79f121dab2b350c241c71b3821ce40907b98c103c712b2b17215b70dcc3a1e"

URI_aarch64_python3-watchfiles = "${EPEL_MIRROR}/aarch64/Packages/p/python3-watchfiles-1.0.4-5.el10_1.aarch64.rpm;name=aarch64_python3-watchfiles;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-watchfiles}"
SRC_URI[aarch64_python3-watchfiles.sha256sum] = "2f0a5dd3f20a2664278420b7f2a5de7a11797360d456f9dc193a9e4bee80ced4"

RDEPENDS:python3-watchfiles = " \
 glibc \
 libgcc \
 python3 \
 python3-anyio \
 "
