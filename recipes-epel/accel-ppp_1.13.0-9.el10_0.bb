# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "accel-ppp"
PV = "1.13.0"
PR = "9.el10_0"
PACKAGES = " \
 accel-ppp \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/accel-ppp-1.13.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "93fdbf3bc30e8628adc29844243cca63690fd49b0a57e51edcd914de81a7556e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/accel-ppp-1.13.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_accel-ppp;unpack=0"
SRC_URI[x86_64_v2_accel-ppp.sha256sum] = "3eadd0dbaa9007a376a0aa292648d55986329901f009cde9cc237bf208562788"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/accel-ppp-1.13.0-9.el10_0.aarch64.rpm;name=aarch64_accel-ppp;unpack=0"
SRC_URI[aarch64_accel-ppp.sha256sum] = "addbea163fdabd63dccc484d6f792455155c1dbc8b50d15f16634988cc234031"

RDEPENDS:accel-ppp = " \
 bash \
 glibc \
 openssl-libs \
 pcre2 \
 "
