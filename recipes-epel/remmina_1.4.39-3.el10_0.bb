# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "remmina"
PV = "1.4.39"
PR = "3.el10_0"
PACKAGES = " \
 remmina \
 remmina-devel \
 remmina-gnome-session \
 remmina-plugins-exec \
 remmina-plugins-python \
 remmina-plugins-rdp \
 remmina-plugins-secret \
 remmina-plugins-vnc \
 remmina-plugins-www \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/remmina-1.4.39-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8663e8a06aa99812320889f5e3cc6401b182c8802f1158263ee0bc1738b1b9fa"

URI_x86_64_v2_remmina = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/remmina-1.4.39-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_remmina;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_remmina}"
SRC_URI[x86_64_v2_remmina.sha256sum] = "2631d35ed0c5656bd9f611b24400f60f29e45f009774b66094e53843b807af0e"

URI_x86_64_v2_remmina-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/remmina-devel-1.4.39-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_remmina-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_remmina-devel}"
SRC_URI[x86_64_v2_remmina-devel.sha256sum] = "16c082dd2b3c43c16c34da70ff8573b1f71a301f408aeb63b4c5357131b4b6b6"

URI_x86_64_v2_remmina-gnome-session = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/remmina-gnome-session-1.4.39-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_remmina-gnome-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_remmina-gnome-session}"
SRC_URI[x86_64_v2_remmina-gnome-session.sha256sum] = "35dd3a42d1a678b4fe97b42d09a2e25135804b841ece9ba6e8a8648daca32a0c"

URI_x86_64_v2_remmina-plugins-exec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/remmina-plugins-exec-1.4.39-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_remmina-plugins-exec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_remmina-plugins-exec}"
SRC_URI[x86_64_v2_remmina-plugins-exec.sha256sum] = "db88a6262344539218cf2123bdf0895d13c86b6f71e4209ec99855facba8b209"

URI_x86_64_v2_remmina-plugins-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/remmina-plugins-python-1.4.39-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_remmina-plugins-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_remmina-plugins-python}"
SRC_URI[x86_64_v2_remmina-plugins-python.sha256sum] = "9200e39c3fcc4288ac9de1cf4b0a7e1860890d0ca00bf9f1b744172c3df62cb9"

URI_x86_64_v2_remmina-plugins-rdp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/remmina-plugins-rdp-1.4.39-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_remmina-plugins-rdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_remmina-plugins-rdp}"
SRC_URI[x86_64_v2_remmina-plugins-rdp.sha256sum] = "ff26d78ad426f09604ed8ca12cda0c814f281d107b905e6a034eaae01d52e304"

URI_x86_64_v2_remmina-plugins-secret = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/remmina-plugins-secret-1.4.39-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_remmina-plugins-secret;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_remmina-plugins-secret}"
SRC_URI[x86_64_v2_remmina-plugins-secret.sha256sum] = "a894b97ddd5303c8d0443427133e4c6c2a86c7d637012219ecef38808e57b2bc"

URI_x86_64_v2_remmina-plugins-vnc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/remmina-plugins-vnc-1.4.39-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_remmina-plugins-vnc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_remmina-plugins-vnc}"
SRC_URI[x86_64_v2_remmina-plugins-vnc.sha256sum] = "2c8e5189d5556e4b0ff4842bff779cce8e4571b32b51740d84ceb7d7bac0cc34"

URI_x86_64_v2_remmina-plugins-www = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/remmina-plugins-www-1.4.39-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_remmina-plugins-www;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_remmina-plugins-www}"
SRC_URI[x86_64_v2_remmina-plugins-www.sha256sum] = "336c5ff60e7f7f13a763bd50c7ee60c039d5ed62a534a74633ec14a51834bfd2"

URI_aarch64_remmina = "${EPEL_MIRROR}/aarch64/Packages/r/remmina-1.4.39-3.el10_0.aarch64.rpm;name=aarch64_remmina;unpack=0"
SRC_URI:append = " ${URI_aarch64_remmina}"
SRC_URI[aarch64_remmina.sha256sum] = "2ad8285d9a372d2e3b787e50c89744a9c487d5e528c6a99cf6bd8620aed8949e"

URI_aarch64_remmina-devel = "${EPEL_MIRROR}/aarch64/Packages/r/remmina-devel-1.4.39-3.el10_0.aarch64.rpm;name=aarch64_remmina-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_remmina-devel}"
SRC_URI[aarch64_remmina-devel.sha256sum] = "405a17c4a3eff8f024a669e7036ce175ea6b9b3cafdf12e7a0e649737ace7825"

URI_aarch64_remmina-gnome-session = "${EPEL_MIRROR}/aarch64/Packages/r/remmina-gnome-session-1.4.39-3.el10_0.aarch64.rpm;name=aarch64_remmina-gnome-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_remmina-gnome-session}"
SRC_URI[aarch64_remmina-gnome-session.sha256sum] = "82b347d38e9aac98c160d15b237344a1cd0bb6b5fb8e4368d5eaee7c979c1a35"

URI_aarch64_remmina-plugins-exec = "${EPEL_MIRROR}/aarch64/Packages/r/remmina-plugins-exec-1.4.39-3.el10_0.aarch64.rpm;name=aarch64_remmina-plugins-exec;unpack=0"
SRC_URI:append = " ${URI_aarch64_remmina-plugins-exec}"
SRC_URI[aarch64_remmina-plugins-exec.sha256sum] = "96a51e306fd34244b9e165adc34fc918960b5376354f578da1ccecd50a230446"

URI_aarch64_remmina-plugins-python = "${EPEL_MIRROR}/aarch64/Packages/r/remmina-plugins-python-1.4.39-3.el10_0.aarch64.rpm;name=aarch64_remmina-plugins-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_remmina-plugins-python}"
SRC_URI[aarch64_remmina-plugins-python.sha256sum] = "d09b036c6d34606ec8e32b655808d1de9f0c9d49b14c208264e9a693b9574b65"

URI_aarch64_remmina-plugins-rdp = "${EPEL_MIRROR}/aarch64/Packages/r/remmina-plugins-rdp-1.4.39-3.el10_0.aarch64.rpm;name=aarch64_remmina-plugins-rdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_remmina-plugins-rdp}"
SRC_URI[aarch64_remmina-plugins-rdp.sha256sum] = "ba44acf01770a72c13b4bfda038535f3a5206e8dbadc1e37ced31be14724e5a6"

URI_aarch64_remmina-plugins-secret = "${EPEL_MIRROR}/aarch64/Packages/r/remmina-plugins-secret-1.4.39-3.el10_0.aarch64.rpm;name=aarch64_remmina-plugins-secret;unpack=0"
SRC_URI:append = " ${URI_aarch64_remmina-plugins-secret}"
SRC_URI[aarch64_remmina-plugins-secret.sha256sum] = "c73795460a8d1715c43034b9233448ec0f9c8b51bd303d104b21b85772cd0c83"

URI_aarch64_remmina-plugins-vnc = "${EPEL_MIRROR}/aarch64/Packages/r/remmina-plugins-vnc-1.4.39-3.el10_0.aarch64.rpm;name=aarch64_remmina-plugins-vnc;unpack=0"
SRC_URI:append = " ${URI_aarch64_remmina-plugins-vnc}"
SRC_URI[aarch64_remmina-plugins-vnc.sha256sum] = "a979a675a716f65bdba7dfd8c08e292466619559ebc8193727a149ca50328863"

URI_aarch64_remmina-plugins-www = "${EPEL_MIRROR}/aarch64/Packages/r/remmina-plugins-www-1.4.39-3.el10_0.aarch64.rpm;name=aarch64_remmina-plugins-www;unpack=0"
SRC_URI:append = " ${URI_aarch64_remmina-plugins-www}"
SRC_URI[aarch64_remmina-plugins-www.sha256sum] = "5476e1940d1aca39fa7fba4a99101caa71c81dc1b0eff762508265cacd8f516a"

RDEPENDS:remmina = " \
 bash \
 cairo \
 glib2 \
 glibc \
 gtk3 \
 json-glib \
 libappindicator-gtk3 \
 libgcc \
 libgcrypt \
 libsodium \
 libssh \
 openssl-libs \
 pango \
 virtual/libcurl.so.4___64bit_ \
 vte291 \
 "
RDEPENDS:remmina-devel = " \
 pkgconf-pkg-config \
 remmina \
 "
RDEPENDS:remmina-gnome-session = " \
 bash \
 gnome-session \
 remmina \
 "
RDEPENDS:remmina-plugins-exec = " \
 glib2 \
 glibc \
 gtk3 \
 remmina \
 "
RDEPENDS:remmina-plugins-python = " \
 glib2 \
 glibc \
 gtk3 \
 python3-libs \
 remmina \
 "
RDEPENDS:remmina-plugins-rdp = " \
 cairo \
 cups-libs \
 freerdp-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libwinpr \
 remmina \
 "
RDEPENDS:remmina-plugins-secret = " \
 glib2 \
 glibc \
 libsecret \
 remmina \
 "
RDEPENDS:remmina-plugins-vnc = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libgcc \
 libvncserver \
 remmina \
 "
RDEPENDS:remmina-plugins-www = " \
 cairo \
 glib2 \
 glibc \
 gtk3 \
 remmina \
 webkit2gtk4.1 \
 "
