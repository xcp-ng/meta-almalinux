# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hidapi"
PV = "2.6.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-hidapi+default-devel \
 rust-hidapi+linux-native-devel \
 rust-hidapi+linux-shared-hidraw-devel \
 rust-hidapi+linux-shared-libusb-devel \
 rust-hidapi-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-hidapi-2.6.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "936b2a48614b501d27a66d75d7243b8589ebae063629686a306c4158ef5c2221"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hidapi+default-devel-2.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hidapi+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hidapi+default-devel.sha256sum] = "164a1284e3d06ba088d24c9e37bc0b1a6873fdced63abecb8cc933b4191da325"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hidapi+linux-native-devel-2.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hidapi+linux-native-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hidapi+linux-native-devel.sha256sum] = "98c8f5d5afb88069b429d9155106b57173cb258e94a8d12d76534fca32d99a87"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hidapi+linux-shared-hidraw-devel-2.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hidapi+linux-shared-hidraw-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hidapi+linux-shared-hidraw-devel.sha256sum] = "63714ac19a5f1b89274536b9467c35408823cbb71bfde8249be8763f253a9d8e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hidapi+linux-shared-libusb-devel-2.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hidapi+linux-shared-libusb-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hidapi+linux-shared-libusb-devel.sha256sum] = "1b7a6be34f5eb23dd441496d797fa4caaf7559c4104d0a7145680cb971d418af"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hidapi-devel-2.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hidapi-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hidapi-devel.sha256sum] = "d968ae235f3504a4f33b92dd7978dbc18df1591d197f4c089c326d47680a7ba7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hidapi+default-devel-2.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-hidapi+default-devel;unpack=0"
SRC_URI[aarch64_rust-hidapi+default-devel.sha256sum] = "0725d10846523d91ac655b4c8ae20a08d002bcacd62e9b3d55f66bbf90165075"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hidapi+linux-native-devel-2.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-hidapi+linux-native-devel;unpack=0"
SRC_URI[aarch64_rust-hidapi+linux-native-devel.sha256sum] = "6f1371e13cc0d55a73cd5ca6b8e2dd9743fb593069bf7034d88618e6cea9b64b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hidapi+linux-shared-hidraw-devel-2.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-hidapi+linux-shared-hidraw-devel;unpack=0"
SRC_URI[aarch64_rust-hidapi+linux-shared-hidraw-devel.sha256sum] = "a18fe14f63f36fb27e6ee636f94ab3995a54e30b06375005a1d5e79f57d09e71"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hidapi+linux-shared-libusb-devel-2.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-hidapi+linux-shared-libusb-devel;unpack=0"
SRC_URI[aarch64_rust-hidapi+linux-shared-libusb-devel.sha256sum] = "eeb61fd0a23eaa71e434a1e15fe688e115b28666f558a9555855e1e0801845cb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hidapi-devel-2.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-hidapi-devel;unpack=0"
SRC_URI[aarch64_rust-hidapi-devel.sha256sum] = "175aaf755b53f12b72bdb9658d0c69b7f453e8affdaccb1e0ca7c32cf99c8800"

RDEPENDS:rust-hidapi+default-devel = " \
 cargo \
 rust-hidapi+linux-shared-hidraw-devel \
 rust-hidapi-devel \
 "
RDEPENDS:rust-hidapi+linux-native-devel = " \
 cargo \
 rust-hidapi-devel \
 rust-nix0.30+default-devel \
 rust-nix0.30+fs-devel \
 rust-nix0.30+ioctl-devel \
 rust-nix0.30+poll-devel \
 rust-udev+default-devel \
 "
RDEPENDS:rust-hidapi+linux-shared-hidraw-devel = " \
 cargo \
 hidapi-devel \
 rust-hidapi-devel \
 "
RDEPENDS:rust-hidapi+linux-shared-libusb-devel = " \
 cargo \
 hidapi-devel \
 libusb1-devel \
 rust-hidapi-devel \
 "
RDEPENDS:rust-hidapi-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
