# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "age"
PV = "1.3.1"
PR = "1.el10_1"
PACKAGES = " \
 age \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/age-1.3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d071991f98b62e271d4e871ebb1e0ba5a13537795c9cfe5adf1fc8242f7f130"

URI_x86_64_v2_age = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/age-1.3.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_age;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_age}"
SRC_URI[x86_64_v2_age.sha256sum] = "48986fb95db16fb2947197f858d0b3c9f7da401cf83cce8410460e278753196d"

URI_aarch64_age = "${EPEL_MIRROR}/aarch64/Packages/a/age-1.3.1-1.el10_1.aarch64.rpm;name=aarch64_age;unpack=0"
SRC_URI:append = " ${URI_aarch64_age}"
SRC_URI[aarch64_age.sha256sum] = "e4e7953f9bd26334c70b746cfc9740f8d28a71f3ba18bb85ddc089d0b4c6b71f"

RDEPENDS:age = " \
 glibc \
 "
