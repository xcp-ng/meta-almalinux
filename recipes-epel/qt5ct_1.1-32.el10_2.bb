# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5ct"
PV = "1.1"
PR = "32.el10_2"
PACKAGES = " \
 qt5ct \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5ct-1.1-32.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04161aa9b7c34c53eff179084c9ae38f58966485ebb1d6c67d2f2d4dff50d00d"

URI_x86_64_v2_qt5ct = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5ct-1.1-32.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5ct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5ct}"
SRC_URI[x86_64_v2_qt5ct.sha256sum] = "962a0dba30555379c5838d9c84dc8c1653a7819f91b3bb45616e3d464eebd35e"

URI_aarch64_qt5ct = "${EPEL_MIRROR}/aarch64/Packages/q/qt5ct-1.1-32.el10_2.aarch64.rpm;name=aarch64_qt5ct;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5ct}"
SRC_URI[aarch64_qt5ct.sha256sum] = "27426e20b3245fd1183b2b6f79da30b7670cc28a373555b0e9fd21477bd445bf"

RDEPENDS:qt5ct = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
