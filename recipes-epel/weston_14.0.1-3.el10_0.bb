# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "weston"
PV = "14.0.1"
PR = "3.el10_0"
PACKAGES = " \
 weston \
 weston-demo \
 weston-devel \
 weston-libs \
 weston-session \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/weston-14.0.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3eb5d822f3702eda92786faed32349ccbd80de2bd7ad45a7e867d409ce607c0c"

URI_x86_64_v2_weston = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weston-14.0.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weston;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_weston}"
SRC_URI[x86_64_v2_weston.sha256sum] = "5969280def5ee7067702c6fe0167cf74ad0cf0ab58b2c3b2234dfabd77213537"
RPROVIDES:weston:append:x86_64_v2 = " virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_x86_64_v2_weston-demo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weston-demo-14.0.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weston-demo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_weston-demo}"
SRC_URI[x86_64_v2_weston-demo.sha256sum] = "a5b766c7813e76bbf9525556c3ccad56490f15277012930778f88843e35ae52e"

URI_x86_64_v2_weston-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weston-devel-14.0.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weston-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_weston-devel}"
SRC_URI[x86_64_v2_weston-devel.sha256sum] = "a3724d235fa4cc2b91388d5e3cc18f1770db9fee6c4cce09300cdf6ed7c8692e"

URI_x86_64_v2_weston-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weston-libs-14.0.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weston-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_weston-libs}"
SRC_URI[x86_64_v2_weston-libs.sha256sum] = "0ced65e9a3fc646009265badf58a241ffbc4d1eeceb5c5021b3acb11ddb764f5"

URI_x86_64_v2_weston-session = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weston-session-14.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_weston-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_weston-session}"
SRC_URI[x86_64_v2_weston-session.sha256sum] = "911d6037f8a6201317a3d78a9bb10c9a85658f64bca709bb5ee840c1c889715c"

URI_aarch64_weston = "${EPEL_MIRROR}/aarch64/Packages/w/weston-14.0.1-3.el10_0.aarch64.rpm;name=aarch64_weston;unpack=0"
SRC_URI:append = " ${URI_aarch64_weston}"
SRC_URI[aarch64_weston.sha256sum] = "a301312176e9f2e9f77718be08b1f8a7b8b223a00a589a621e0f7feae82acefd"
RPROVIDES:weston:append:aarch64 = " virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_aarch64_weston-demo = "${EPEL_MIRROR}/aarch64/Packages/w/weston-demo-14.0.1-3.el10_0.aarch64.rpm;name=aarch64_weston-demo;unpack=0"
SRC_URI:append = " ${URI_aarch64_weston-demo}"
SRC_URI[aarch64_weston-demo.sha256sum] = "54df3460ff082299f550aad42661b81a91bb331046c74c768d82fb648d2646da"

URI_aarch64_weston-devel = "${EPEL_MIRROR}/aarch64/Packages/w/weston-devel-14.0.1-3.el10_0.aarch64.rpm;name=aarch64_weston-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_weston-devel}"
SRC_URI[aarch64_weston-devel.sha256sum] = "eba1ec326c15af69c8888802e6cef7e943ae7cf027626df564190a26182afeb5"

URI_aarch64_weston-libs = "${EPEL_MIRROR}/aarch64/Packages/w/weston-libs-14.0.1-3.el10_0.aarch64.rpm;name=aarch64_weston-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_weston-libs}"
SRC_URI[aarch64_weston-libs.sha256sum] = "aeb729d67e720e48178098c343b7fcb2684f4f60492d28e0a9c2d7204991fbe2"

URI_aarch64_weston-session = "${EPEL_MIRROR}/aarch64/Packages/w/weston-session-14.0.1-3.el10_0.noarch.rpm;name=aarch64_weston-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_weston-session}"
SRC_URI[aarch64_weston-session.sha256sum] = "86852df3269a24ce7b3f65190a5254e592b535b311fdc2133f866608256a1d70"

RDEPENDS:weston = " \
 cairo \
 fontconfig \
 glib2 \
 glibc \
 libevdev \
 libinput \
 libjpeg-turbo \
 libpng \
 libwayland-client \
 libwayland-cursor \
 libwayland-server \
 libwebp \
 libxkbcommon \
 mesa-dri-drivers \
 pango \
 pixman \
 systemd-libs \
 weston-libs \
 "
RDEPENDS:weston-demo = " \
 cairo \
 fontconfig \
 glib2 \
 glibc \
 libdrm \
 libglvnd-egl \
 libglvnd-gles \
 libjpeg-turbo \
 libpng \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libwebp \
 libxkbcommon \
 mesa-libgbm \
 pango \
 pixman \
 systemd-libs \
 "
RDEPENDS:weston-devel = " \
 libxkbcommon-devel \
 pixman-devel \
 pkgconf-pkg-config \
 wayland-devel \
 weston \
 weston-devel \
 weston-libs \
 "
RDEPENDS:weston-libs = " \
 aml \
 cairo \
 fontconfig \
 freerdp-libs \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 lcms2 \
 libX11 \
 libX11-xcb \
 libXcursor \
 libdisplay-info \
 libdrm \
 libglvnd-egl \
 libglvnd-gles \
 libinput \
 libjpeg-turbo \
 libpng \
 libseat \
 libva \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libwayland-server \
 libwebp \
 libwinpr \
 libxcb \
 libxkbcommon \
 mesa-libgbm \
 neatvnc \
 pam-libs \
 pango \
 pipewire-libs \
 pixman \
 systemd-libs \
 "
RDEPENDS:weston-session = " \
 weston \
 "
