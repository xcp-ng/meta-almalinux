# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "guacamole-server"
PV = "1.6.0"
PR = "1.el10_1"
PACKAGES = " \
 guacd \
 libguac \
 libguac-client-kubernetes \
 libguac-client-rdp \
 libguac-client-ssh \
 libguac-client-telnet \
 libguac-client-vnc \
 libguac-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/guacamole-server-1.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7453338edc8e6d06ba4cbe968f38717f0909db70e49cf85e00d5961fd892c746"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - guacd: libavcodec.so.61()(64bit)
# - guacd: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - guacd: libavformat.so.61()(64bit)
# - guacd: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - guacd: libavutil.so.59()(64bit)
# - guacd: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - guacd: libswscale.so.8()(64bit)
# - guacd: libswscale.so.8(LIBSWSCALE_8)(64bit)

URI_x86_64_v2_guacd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/guacd-1.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_guacd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guacd}"
SRC_URI[x86_64_v2_guacd.sha256sum] = "a12be1048ea40aa095a33672898c540231be3d21c365cf09cec3fb3287c3c616"

URI_x86_64_v2_libguac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libguac-1.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libguac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguac}"
SRC_URI[x86_64_v2_libguac.sha256sum] = "5f33693d345c7d80e474c2d30c2b22eaf6ff0d656994417a8517816e9e7b6a25"

URI_x86_64_v2_libguac-client-kubernetes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libguac-client-kubernetes-1.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libguac-client-kubernetes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguac-client-kubernetes}"
SRC_URI[x86_64_v2_libguac-client-kubernetes.sha256sum] = "d0d9b9355047238ad8f5444dac20f59fe4bc0821a5d43edc15ecc2151c11ba66"

URI_x86_64_v2_libguac-client-rdp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libguac-client-rdp-1.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libguac-client-rdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguac-client-rdp}"
SRC_URI[x86_64_v2_libguac-client-rdp.sha256sum] = "ab4a4feac26d51a2163baf1266ea68eddea65fd732b88511141c2fd4f3057c9a"

URI_x86_64_v2_libguac-client-ssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libguac-client-ssh-1.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libguac-client-ssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguac-client-ssh}"
SRC_URI[x86_64_v2_libguac-client-ssh.sha256sum] = "b94dc82b6b6b49809c0fbced4ff23dcd526a28137121d712f16e7a19896d187c"

URI_x86_64_v2_libguac-client-telnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libguac-client-telnet-1.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libguac-client-telnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguac-client-telnet}"
SRC_URI[x86_64_v2_libguac-client-telnet.sha256sum] = "8956866c87f7a875ce268897b926bf9540311618550d1a12aa5e41a22e9053e6"

URI_x86_64_v2_libguac-client-vnc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libguac-client-vnc-1.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libguac-client-vnc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguac-client-vnc}"
SRC_URI[x86_64_v2_libguac-client-vnc.sha256sum] = "38864df1f2bdfeade28463249bebd9003832b11fe933a88d6972b11c59fc3ea5"

URI_x86_64_v2_libguac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libguac-devel-1.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libguac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguac-devel}"
SRC_URI[x86_64_v2_libguac-devel.sha256sum] = "5e9953ffd40c0d097ba2d60124e87ab63742006b016c4efb42805be1fd6eb14b"

URI_aarch64_guacd = "${EPEL_MIRROR}/aarch64/Packages/g/guacd-1.6.0-1.el10_1.aarch64.rpm;name=aarch64_guacd;unpack=0"
SRC_URI:append = " ${URI_aarch64_guacd}"
SRC_URI[aarch64_guacd.sha256sum] = "b80550a09aad7d38f67617adb566464d55eb47d6e8c73633067af77ee7e5619d"

URI_aarch64_libguac = "${EPEL_MIRROR}/aarch64/Packages/l/libguac-1.6.0-1.el10_1.aarch64.rpm;name=aarch64_libguac;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguac}"
SRC_URI[aarch64_libguac.sha256sum] = "b3f5a08aaf338f3c82fca8328859db820efbf6aeae364cf0d99455388864280c"

URI_aarch64_libguac-client-kubernetes = "${EPEL_MIRROR}/aarch64/Packages/l/libguac-client-kubernetes-1.6.0-1.el10_1.aarch64.rpm;name=aarch64_libguac-client-kubernetes;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguac-client-kubernetes}"
SRC_URI[aarch64_libguac-client-kubernetes.sha256sum] = "555f13201e6665144ed6a16a4cb24c5b987074088d19bd5c9b4f5b7e325a8fdb"

URI_aarch64_libguac-client-rdp = "${EPEL_MIRROR}/aarch64/Packages/l/libguac-client-rdp-1.6.0-1.el10_1.aarch64.rpm;name=aarch64_libguac-client-rdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguac-client-rdp}"
SRC_URI[aarch64_libguac-client-rdp.sha256sum] = "65ed81fcb6093a236911ff26a4ba4e120a8242d76b706c327f9ac5abe7ea52ff"

URI_aarch64_libguac-client-ssh = "${EPEL_MIRROR}/aarch64/Packages/l/libguac-client-ssh-1.6.0-1.el10_1.aarch64.rpm;name=aarch64_libguac-client-ssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguac-client-ssh}"
SRC_URI[aarch64_libguac-client-ssh.sha256sum] = "92df7209fb247ceba82c3f07254313eb0b9d3019588e3121505494a2a757dbe6"

URI_aarch64_libguac-client-telnet = "${EPEL_MIRROR}/aarch64/Packages/l/libguac-client-telnet-1.6.0-1.el10_1.aarch64.rpm;name=aarch64_libguac-client-telnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguac-client-telnet}"
SRC_URI[aarch64_libguac-client-telnet.sha256sum] = "a0d72e7776aae9e661026efe97506aef65bf4f6d1bba98319067836e6c4194d8"

URI_aarch64_libguac-client-vnc = "${EPEL_MIRROR}/aarch64/Packages/l/libguac-client-vnc-1.6.0-1.el10_1.aarch64.rpm;name=aarch64_libguac-client-vnc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguac-client-vnc}"
SRC_URI[aarch64_libguac-client-vnc.sha256sum] = "9480e8b70d75efb32151add3413221567e305d55fb3b844f44654b13b6f7a602"

URI_aarch64_libguac-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libguac-devel-1.6.0-1.el10_1.aarch64.rpm;name=aarch64_libguac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguac-devel}"
SRC_URI[aarch64_libguac-devel.sha256sum] = "e5ebf9037371877b320bde3d8a568b0df9c7bc230ce7ccee5b04875d07684b37"

RDEPENDS:guacd:x86_64_v2 = " \
 bash \
 cairo \
 glibc \
 libguac \
 libjpeg-turbo \
 libwebp \
 openssl-libs \
 shadow-utils \
 systemd \
"
RDEPENDS:guacd:aarch64 = " \
 bash \
 cairo \
 glibc \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libguac \
 libjpeg-turbo \
 libswscale-free \
 libwebp \
 openssl-libs \
 shadow-utils \
 systemd \
"
RDEPENDS:libguac = " \
 cairo \
 glib2 \
 glibc \
 harfbuzz \
 libjpeg-turbo \
 libogg \
 libpng \
 libvorbis \
 libwebp \
 openssl-libs \
 pango \
 uuid \
 "
RDEPENDS:libguac-client-kubernetes = " \
 cairo \
 glib2 \
 glibc \
 harfbuzz \
 libguac \
 libjpeg-turbo \
 libogg \
 libpng \
 libvorbis \
 libwebp \
 libwebsockets \
 openssl-libs \
 pango \
 uuid \
 "
RDEPENDS:libguac-client-rdp = " \
 cairo \
 freerdp2-libs \
 glibc \
 libguac \
 libjpeg-turbo \
 libogg \
 libpng \
 libssh2 \
 libvorbis \
 libwebp \
 libwinpr2 \
 openssl-libs \
 uuid \
 "
RDEPENDS:libguac-client-ssh = " \
 cairo \
 glib2 \
 glibc \
 harfbuzz \
 libguac \
 libjpeg-turbo \
 libogg \
 libpng \
 libssh2 \
 libvorbis \
 libwebp \
 openssl-libs \
 pango \
 uuid \
 "
RDEPENDS:libguac-client-telnet = " \
 cairo \
 glib2 \
 glibc \
 harfbuzz \
 libguac \
 libjpeg-turbo \
 libogg \
 libpng \
 libtelnet \
 libvorbis \
 libwebp \
 openssl-libs \
 pango \
 uuid \
 "
RDEPENDS:libguac-client-vnc = " \
 cairo \
 glibc \
 libguac \
 libjpeg-turbo \
 libogg \
 libpng \
 libssh2 \
 libvncserver \
 libvorbis \
 libwebp \
 openssl-libs \
 pulseaudio-libs \
 uuid \
 "
RDEPENDS:libguac-devel = " \
 libguac \
 "
