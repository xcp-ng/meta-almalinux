# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libecoli"
PV = "0.10.1"
PR = "1.el10_2"
PACKAGES = " \
 libecoli \
 libecoli-devel \
 libecoli-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libecoli-0.10.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bea9f2f048ab5c42e0583811c50a53e76e35f23e26b09ca9053e001f7835754b"

URI_x86_64_v2_libecoli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libecoli-0.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libecoli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libecoli}"
SRC_URI[x86_64_v2_libecoli.sha256sum] = "8d30771536a52655ffd7a79989760251fd85af66b37b9f6f3e96f39c4fe17ae6"

URI_x86_64_v2_libecoli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libecoli-devel-0.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libecoli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libecoli-devel}"
SRC_URI[x86_64_v2_libecoli-devel.sha256sum] = "c4859ff3fbb0491e538a6c9ab4c44f0c906c011428d4262c28068190cd29b824"

URI_x86_64_v2_libecoli-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libecoli-doc-0.10.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libecoli-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libecoli-doc}"
SRC_URI[x86_64_v2_libecoli-doc.sha256sum] = "545098c5a4c40effacf5588f4918424816f56b05796e4db05bf2f855ce4c27d3"

URI_aarch64_libecoli = "${EPEL_MIRROR}/aarch64/Packages/l/libecoli-0.10.1-1.el10_2.aarch64.rpm;name=aarch64_libecoli;unpack=0"
SRC_URI:append = " ${URI_aarch64_libecoli}"
SRC_URI[aarch64_libecoli.sha256sum] = "9bc5b4ca3e89d72a37dd79d6b0880228b18238d5aebde7e521e33926a06bc362"

URI_aarch64_libecoli-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libecoli-devel-0.10.1-1.el10_2.aarch64.rpm;name=aarch64_libecoli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libecoli-devel}"
SRC_URI[aarch64_libecoli-devel.sha256sum] = "6fa5e5adf11059000acc903aefadb02048c59aed2a5bf9e4174f3302d19b5535"

URI_aarch64_libecoli-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libecoli-doc-0.10.1-1.el10_2.noarch.rpm;name=aarch64_libecoli-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libecoli-doc}"
SRC_URI[aarch64_libecoli-doc.sha256sum] = "18f36566ee08903c259a239a28cf8e770da6bc9db73ae8cc7039f818b14e911c"

RDEPENDS:libecoli = " \
 glibc \
 libedit \
 "
RDEPENDS:libecoli-devel = " \
 libecoli \
 libedit-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libecoli-doc = " \
 "
