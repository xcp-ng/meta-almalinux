# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-etcetera"
PV = "0.10.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-etcetera+default-devel \
 rust-etcetera-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-etcetera-0.10.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60a4832a57abdd8267411200b0e136e7cbc8bffc1479073099261fc0d29747e1"

URI_x86_64_v2_rust-etcetera+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-etcetera+default-devel-0.10.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-etcetera+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-etcetera+default-devel}"
SRC_URI[x86_64_v2_rust-etcetera+default-devel.sha256sum] = "92ac1c29571bb39b4d00f9efe68e30bbcfefaa1310c51eded4676e622b256d86"

URI_x86_64_v2_rust-etcetera-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-etcetera-devel-0.10.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-etcetera-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-etcetera-devel}"
SRC_URI[x86_64_v2_rust-etcetera-devel.sha256sum] = "7b6ac2c5665430bbb3194d2dcee51b2c13a266a66bc764d81e2148e29706f718"

URI_aarch64_rust-etcetera+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-etcetera+default-devel-0.10.0-2.el10_1.noarch.rpm;name=aarch64_rust-etcetera+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-etcetera+default-devel}"
SRC_URI[aarch64_rust-etcetera+default-devel.sha256sum] = "831df4a73491303dfdb8829ca073fec75a3202d1e05b47d81ed76c500c7520eb"

URI_aarch64_rust-etcetera-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-etcetera-devel-0.10.0-2.el10_1.noarch.rpm;name=aarch64_rust-etcetera-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-etcetera-devel}"
SRC_URI[aarch64_rust-etcetera-devel.sha256sum] = "4772cd34eb4f8d1e32688ca7711a1a1c51a02c3af79e4934f231991813745e99"

RDEPENDS:rust-etcetera+default-devel = " \
 cargo \
 rust-etcetera-devel \
 "
RDEPENDS:rust-etcetera-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-home+default-devel \
 "
