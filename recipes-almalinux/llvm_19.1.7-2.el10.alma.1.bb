# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llvm"
PV = "19.1.7"
PR = "2.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 clang \
 clang-analyzer \
 clang-devel \
 clang-libs \
 clang-resource-filesystem \
 clang-tools-extra \
 compiler-rt \
 git-clang-format \
 libomp \
 libomp-devel \
 lld \
 lld-devel \
 lld-libs \
 lldb \
 lldb-devel \
 llvm \
 llvm-devel \
 llvm-doc \
 llvm-googletest \
 llvm-libs \
 llvm-static \
 llvm-test \
 llvm-toolset \
 python3-lldb \
"
PACKAGES:aarch64 = " \
 clang \
 clang-analyzer \
 clang-devel \
 clang-libs \
 clang-resource-filesystem \
 clang-tools-extra \
 compiler-rt \
 git-clang-format \
 libomp \
 libomp-devel \
 lld \
 lld-devel \
 lld-libs \
 lldb \
 lldb-devel \
 llvm \
 llvm-devel \
 llvm-doc \
 llvm-googletest \
 llvm-libs \
 llvm-static \
 llvm-test \
 llvm-toolset \
 python3-clang \
 python3-lit \
 python3-lldb \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/llvm-19.1.7-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d6ea03321222aeaea318b0704e0a0fbea9f3bb8e3946f68688dd70986482115"

URI_x86_64_v2_clang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang}"
SRC_URI[x86_64_v2_clang.sha256sum] = "15293a5efcf559fc17e0ec2e6bd75a390588852eee6bf3100d98c5e3560214af"

URI_x86_64_v2_clang-analyzer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-analyzer-19.1.7-2.el10.alma.1.noarch.rpm;name=x86_64_v2_clang-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-analyzer}"
SRC_URI[x86_64_v2_clang-analyzer.sha256sum] = "db59f46d86d96c37803700beed64addbdb97b7b96f09eb53feaec7ba6108c70c"

URI_x86_64_v2_clang-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-devel-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-devel}"
SRC_URI[x86_64_v2_clang-devel.sha256sum] = "da131a0b4c9e042c7d2e404c8504f13b3fa1e084d62bf785b187f1e5dfbcb0f4"

URI_x86_64_v2_clang-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-libs-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-libs}"
SRC_URI[x86_64_v2_clang-libs.sha256sum] = "fe1cbb7668291d0c9cb61dbb5d804a4d22350e8c5713da5a5e1dff73e97fe22a"

URI_x86_64_v2_clang-resource-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-resource-filesystem-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-resource-filesystem}"
SRC_URI[x86_64_v2_clang-resource-filesystem.sha256sum] = "06747f007168cd5f5a1a10c4b8865ae7c7752b3cab299ace748e75813aa2ef88"

URI_x86_64_v2_clang-tools-extra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-tools-extra-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-tools-extra}"
SRC_URI[x86_64_v2_clang-tools-extra.sha256sum] = "add16a337f27b9934cc9c24a35a50cb37358aa7b03980f080073f4d4b99d97dc"

URI_x86_64_v2_compiler-rt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/compiler-rt-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_compiler-rt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compiler-rt}"
SRC_URI[x86_64_v2_compiler-rt.sha256sum] = "56847248fc530d5ecdbd2ec6d53e54a767973741cc5cfda2d98cb1e5bddc90d7"

URI_x86_64_v2_git-clang-format = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-clang-format-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_git-clang-format;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-clang-format}"
SRC_URI[x86_64_v2_git-clang-format.sha256sum] = "09127ab4eb2e76ba8a2767bba186a449081662e9e6ebcf8ae46115028f7e8fbf"

URI_x86_64_v2_libomp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libomp-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libomp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libomp}"
SRC_URI[x86_64_v2_libomp.sha256sum] = "b7b61d2b6af86dd24163603c36a3ced8ce09c7b98bc3c153bde6b6790ac21c98"

URI_x86_64_v2_libomp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libomp-devel-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libomp-devel}"
SRC_URI[x86_64_v2_libomp-devel.sha256sum] = "441762f342e33cfa8f5f66b68b793fdb830666d0b38bb4eda84bb3ceb390dfff"

URI_x86_64_v2_lld = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld}"
SRC_URI[x86_64_v2_lld.sha256sum] = "023bbe60d31930ae3df47ff5ea2cdd4cff62ca7a60a315bcfcf00fb5c1f8eda6"

URI_x86_64_v2_lld-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-devel-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld-devel}"
SRC_URI[x86_64_v2_lld-devel.sha256sum] = "49f90d0f405bf828a0eff1ffc41031064b08b789f256ec5de1691cf81c694262"

URI_x86_64_v2_lld-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-libs-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld-libs}"
SRC_URI[x86_64_v2_lld-libs.sha256sum] = "180f7d092e110b961baf11c9845f95cdc9f06da9171ab6cb1e1cd1e6703d5f18"

URI_x86_64_v2_lldb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lldb-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldb}"
SRC_URI[x86_64_v2_lldb.sha256sum] = "a99ff863a937a5fa88d07549498ab32933bd149d264e6acab2ea4dce3891ede1"

URI_x86_64_v2_lldb-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lldb-devel-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lldb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldb-devel}"
SRC_URI[x86_64_v2_lldb-devel.sha256sum] = "4dee82a7222c147c39e0ad0644b9d73d626ec38e9fb8cd12177fe484c87ef170"

URI_x86_64_v2_llvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm}"
SRC_URI[x86_64_v2_llvm.sha256sum] = "198bedfb659bd8b2a922372eb60ff19fc54a6ecc5551755e3592f3c1937bda9a"

URI_x86_64_v2_llvm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-devel-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-devel}"
SRC_URI[x86_64_v2_llvm-devel.sha256sum] = "46a63b84e1be1f8e05eb281352c9c9a68b7bf41f3255d52d15f29e22eb6b5dbb"

URI_x86_64_v2_llvm-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-doc-19.1.7-2.el10.alma.1.noarch.rpm;name=x86_64_v2_llvm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-doc}"
SRC_URI[x86_64_v2_llvm-doc.sha256sum] = "91618b2d2711b45c5fe0540101a11bfa4b33d8f9f1ddad18e676f37664dc5ce2"

URI_x86_64_v2_llvm-googletest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-googletest-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-googletest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-googletest}"
SRC_URI[x86_64_v2_llvm-googletest.sha256sum] = "ce28f4dd78eb3fca3cbb341548c491a9c964b97057af529e8731e37f033b107b"

URI_x86_64_v2_llvm-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-libs-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-libs}"
SRC_URI[x86_64_v2_llvm-libs.sha256sum] = "8848810a7563a7eaee148775e0b8ef7a55624c7a04c26a8080579cac80934231"

URI_x86_64_v2_llvm-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-static-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-static}"
SRC_URI[x86_64_v2_llvm-static.sha256sum] = "cba096b521c97abd73456bfa8ee18c558c829745f0ef2392c27b90aaf9f0c005"

URI_x86_64_v2_llvm-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-test-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-test}"
SRC_URI[x86_64_v2_llvm-test.sha256sum] = "1553ea91d5a0cf1b1008ba5a445c80e5d067d4514f36dc852eb6d9c29be80bd8"

URI_x86_64_v2_llvm-toolset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-toolset-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-toolset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-toolset}"
SRC_URI[x86_64_v2_llvm-toolset.sha256sum] = "d767896ced3aa9f553b04556b7d7c7c4f2cf0ab31e6868fd2186e6047e1b6ce8"

URI_x86_64_v2_python3-lldb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lldb-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-lldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lldb}"
SRC_URI[x86_64_v2_python3-lldb.sha256sum] = "4b345617a85e33af3e4eec7ad465fd2ed6d41a50ee32fa8ebea7239bc224d770"

URI_aarch64_clang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang}"
SRC_URI[aarch64_clang.sha256sum] = "c0533af0f1294d06e8f053749d6a75a595aa2d499cd9f1f51cf33dc293647b7a"

URI_aarch64_clang-analyzer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-analyzer-19.1.7-2.el10.alma.1.noarch.rpm;name=aarch64_clang-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-analyzer}"
SRC_URI[aarch64_clang-analyzer.sha256sum] = "db59f46d86d96c37803700beed64addbdb97b7b96f09eb53feaec7ba6108c70c"

URI_aarch64_clang-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-devel-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_clang-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-devel}"
SRC_URI[aarch64_clang-devel.sha256sum] = "d5810fb59d866c144043095f9ce91e8bedffe04009fa943392304ef92f69f655"

URI_aarch64_clang-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-libs-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_clang-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-libs}"
SRC_URI[aarch64_clang-libs.sha256sum] = "7283ee0f04a4598d326f06224a2065f2208d94acc71299b28f908fe9b184096b"

URI_aarch64_clang-resource-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-resource-filesystem-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_clang-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-resource-filesystem}"
SRC_URI[aarch64_clang-resource-filesystem.sha256sum] = "4c62dd1e6864ce4ed95950654dd479f01474f356d8c738d2a44dc7dcc58f775d"

URI_aarch64_clang-tools-extra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-tools-extra-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_clang-tools-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-tools-extra}"
SRC_URI[aarch64_clang-tools-extra.sha256sum] = "c8b8bf9fa2468e9d3f18eb674a0c738dfe697558a091f62bc0d50204aeeee751"

URI_aarch64_compiler-rt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/compiler-rt-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_compiler-rt;unpack=0"
SRC_URI:append = " ${URI_aarch64_compiler-rt}"
SRC_URI[aarch64_compiler-rt.sha256sum] = "70f65a4bc67f8489ed719eb91a80eff7d73b544090f15c46d2900b78b516a6aa"

URI_aarch64_git-clang-format = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-clang-format-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_git-clang-format;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-clang-format}"
SRC_URI[aarch64_git-clang-format.sha256sum] = "22726a1913ce8704113bf99be9300cb4e9bc88825cf734c5932f4bd6f4411adb"

URI_aarch64_libomp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libomp-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_libomp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp}"
SRC_URI[aarch64_libomp.sha256sum] = "c9aca74cba5e1cd4aac018640ebadf403cfa975f1ff4d68c42733f4110abc080"

URI_aarch64_libomp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libomp-devel-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_libomp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp-devel}"
SRC_URI[aarch64_libomp-devel.sha256sum] = "a4f8f35eed06390bb9a86e87983ec210c6afd1b288d5e6fefb88700364485c28"

URI_aarch64_lld = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_lld;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld}"
SRC_URI[aarch64_lld.sha256sum] = "8a1f10f955e13c4bf0f60022f29e3e5b75975bc17f7c111fc9c9a0d361e44686"

URI_aarch64_lld-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-devel-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_lld-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld-devel}"
SRC_URI[aarch64_lld-devel.sha256sum] = "ccb0a3d5762678ab8e4f1ddaef74221bf72070b434f0d421fab6bc9706a02bdb"

URI_aarch64_lld-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-libs-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_lld-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld-libs}"
SRC_URI[aarch64_lld-libs.sha256sum] = "36931eaf5e7d194222e6c7150a332bcfdbf3503514634848deb09a8403f1ecca"

URI_aarch64_lldb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lldb-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_lldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb}"
SRC_URI[aarch64_lldb.sha256sum] = "e0eaab9071e883354b0637ab954d324ffd989f94b3390cd58619d36461c805f4"

URI_aarch64_lldb-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lldb-devel-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_lldb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb-devel}"
SRC_URI[aarch64_lldb-devel.sha256sum] = "cd2b7cfd969c22322137c3681f2a271aea9e8696012dfc5a36b89e450e039f58"

URI_aarch64_llvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_llvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm}"
SRC_URI[aarch64_llvm.sha256sum] = "ed2b37efdd2003cd329ead46fd54fbb14d0a9085ab254904bd18501cfa649d15"

URI_aarch64_llvm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-devel-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_llvm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-devel}"
SRC_URI[aarch64_llvm-devel.sha256sum] = "3eb410bc82fc00e73b491f26a03bdcce2c796c4f47573cbbefd543a573bf8fee"

URI_aarch64_llvm-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-doc-19.1.7-2.el10.alma.1.noarch.rpm;name=aarch64_llvm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-doc}"
SRC_URI[aarch64_llvm-doc.sha256sum] = "91618b2d2711b45c5fe0540101a11bfa4b33d8f9f1ddad18e676f37664dc5ce2"

URI_aarch64_llvm-googletest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-googletest-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_llvm-googletest;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-googletest}"
SRC_URI[aarch64_llvm-googletest.sha256sum] = "746eb8dd1d26a562bd08c448124f7dc940c74d2e80992cae75acae2e59e4b145"

URI_aarch64_llvm-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-libs-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_llvm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-libs}"
SRC_URI[aarch64_llvm-libs.sha256sum] = "64b2ece5c40a00b12f7a921a73253e72f726b7ec84d715ead0e13b1114a74a64"

URI_aarch64_llvm-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-static-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_llvm-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-static}"
SRC_URI[aarch64_llvm-static.sha256sum] = "f9e84c316127046d81c1c3d845eb6d4a857c3ddbe586cd7a2e57fe671328a340"

URI_aarch64_llvm-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-test-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_llvm-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-test}"
SRC_URI[aarch64_llvm-test.sha256sum] = "29543a23af12b824cd6eb100805d9c7fd95c411fe15599ea9140c6c48a204ec4"

URI_aarch64_llvm-toolset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-toolset-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_llvm-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-toolset}"
SRC_URI[aarch64_llvm-toolset.sha256sum] = "30233e724c5e894209cc5269e43b30fb489b9185da16434044b23725ce60bcd9"

URI_aarch64_python3-clang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-clang-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_python3-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-clang}"
SRC_URI[aarch64_python3-clang.sha256sum] = "fee6d2da0fafd9c052c7cdbe8ba4c2c0f26345ca6ba349871e2ca6b8bafee12d"

URI_aarch64_python3-lit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lit-19.1.7-2.el10.alma.1.noarch.rpm;name=aarch64_python3-lit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lit}"
SRC_URI[aarch64_python3-lit.sha256sum] = "737451bf511d12cfb254731ff7832e536608a534748c85ec14f4046b20ccd6b3"

URI_aarch64_python3-lldb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lldb-19.1.7-2.el10.alma.1.aarch64.rpm;name=aarch64_python3-lldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lldb}"
SRC_URI[aarch64_python3-lldb.sha256sum] = "3aabf55bd33b6913a4053f1ab8cd28832eba911e26df7f91c23a8f844e6062f6"

RDEPENDS:clang = " \
 clang-libs \
 gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 libstdc++-devel \
 llvm-libs \
 "
RDEPENDS:clang-analyzer = " \
 clang \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Hash-Util \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Text-ParseWords \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3 \
 "
RDEPENDS:clang-devel = " \
 clang \
 clang-libs \
 clang-tools-extra \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:clang-libs = " \
 clang-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
RDEPENDS:clang-resource-filesystem = " \
 "
RDEPENDS:clang-tools-extra = " \
 clang-libs \
 emacs-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm-libs \
 python3 \
 "
RDEPENDS:compiler-rt = " \
 clang-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:git-clang-format = " \
 clang-tools-extra \
 git \
 python3 \
 "
RDEPENDS:libomp = " \
 elfutils-libelf \
 glibc \
 libffi \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
RDEPENDS:libomp-devel = " \
 clang-resource-filesystem \
 libomp \
 "
RDEPENDS:lld = " \
 alternatives \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 lld-libs \
 llvm-libs \
 "
RDEPENDS:lld-devel = " \
 cmake-filesystem \
 lld \
 lld-libs \
 "
RDEPENDS:lld-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb = " \
 clang-libs \
 glibc \
 libedit \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm-libs \
 ncurses-libs \
 python3-libs \
 python3-lldb \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb-devel = " \
 lldb \
 "
RDEPENDS:llvm = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 python3 \
 zlib-ng-compat \
 "
RDEPENDS:llvm-devel = " \
 alternatives \
 bash \
 cmake-filesystem \
 glibc \
 libedit-devel \
 libgcc \
 libstdc++ \
 libzstd-devel \
 llvm \
 llvm-googletest \
 llvm-libs \
 llvm-static \
 llvm-test \
 "
RDEPENDS:llvm-doc = " \
 llvm \
 "
RDEPENDS:llvm-googletest = " \
 "
RDEPENDS:llvm-libs = " \
 glibc \
 libedit \
 libffi \
 libgcc \
 libstdc++ \
 libxml2 \
 libzstd \
 zlib-ng-compat \
 "
RDEPENDS:llvm-static = " \
 "
RDEPENDS:llvm-test = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm \
 llvm-libs \
 "
RDEPENDS:llvm-toolset = " \
 clang \
 lld \
 llvm \
 "
RDEPENDS:python3-lldb = " \
 lldb \
 python3 \
 "
RDEPENDS:python3-clang = " \
 clang-devel \
 python3 \
 "
RDEPENDS:python3-lit = " \
 python3 \
 python3-setuptools \
 "
