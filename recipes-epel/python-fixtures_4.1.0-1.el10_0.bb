# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fixtures"
PV = "4.1.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-fixtures \
 python3-fixtures+streams \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-fixtures-4.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "942c8e38bc3969936d46e78be8cbc15e195c9c3c809e080060c8ffe3aef4f87e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fixtures-4.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fixtures;unpack=0"
SRC_URI[x86_64_v2_python3-fixtures.sha256sum] = "11ca02effef3c9b3591834643cc1bc2af98e1677c1994384995cadfc672442c8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fixtures+streams-4.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fixtures+streams;unpack=0"
SRC_URI[x86_64_v2_python3-fixtures+streams.sha256sum] = "40c34d2a6d862561dd3f958fbd81270b40a4edbc57b87d271bc003ae9e0a8741"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-fixtures-4.1.0-1.el10_0.noarch.rpm;name=aarch64_python3-fixtures;unpack=0"
SRC_URI[aarch64_python3-fixtures.sha256sum] = "b48ecc119e04affe3f267bc5547bb8bf5710fdf76e3b620f48a894625f8a6adf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-fixtures+streams-4.1.0-1.el10_0.noarch.rpm;name=aarch64_python3-fixtures+streams;unpack=0"
SRC_URI[aarch64_python3-fixtures+streams.sha256sum] = "b2147b5d9d9fa3565f12cba318b0d63665b625951fd06c201fcbb71ac09338bc"

RDEPENDS:python3-fixtures = " \
 python3 \
 python3-pbr \
 "
RDEPENDS:python3-fixtures+streams = " \
 python3 \
 python3-fixtures \
 python3-testtools \
 "
