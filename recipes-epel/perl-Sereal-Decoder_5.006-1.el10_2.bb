# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sereal-Decoder"
PV = "5.006"
PR = "1.el10_2"
PACKAGES = " \
 perl-Sereal-Decoder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sereal-Decoder-5.006-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2046ee2c598eb763691f3f8667f8dd246e814290bd141c58035c389fc9dd96d"

URI_x86_64_v2_perl-Sereal-Decoder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sereal-Decoder-5.006-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sereal-Decoder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sereal-Decoder}"
SRC_URI[x86_64_v2_perl-Sereal-Decoder.sha256sum] = "55270a8c1018b2e0f8f1e324ebe747b4bded4aefbed681a6a5adf915d54c91db"

URI_aarch64_perl-Sereal-Decoder = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sereal-Decoder-5.006-1.el10_2.aarch64.rpm;name=aarch64_perl-Sereal-Decoder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sereal-Decoder}"
SRC_URI[aarch64_perl-Sereal-Decoder.sha256sum] = "578cb6ee2841197548da6022efa6428b8e64042feb6bf297ef7fd32c44a398f7"

RDEPENDS:perl-Sereal-Decoder = " \
 csnappy \
 glibc \
 libzstd \
 miniz \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
