# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libupnp"
PV = "1.14.19"
PR = "3.el10_0"
PACKAGES = " \
 libupnp \
 libupnp-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libupnp-1.14.19-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d39b1cf48ca2ee124c474233f7002eb725d5a855c9c9df11f2d6137d2c371c66"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libupnp-1.14.19-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libupnp;unpack=0"
SRC_URI[x86_64_v2_libupnp.sha256sum] = "653b99ee7c10eca01a9b948e75147810d60e0fe694518d15d65bc496f482b1cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libupnp-devel-1.14.19-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libupnp-devel;unpack=0"
SRC_URI[x86_64_v2_libupnp-devel.sha256sum] = "db6289be430d2960c81e5f20bc29b50a3a6b5c0803f51e198d331eab22798d1d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libupnp-1.14.19-3.el10_0.aarch64.rpm;name=aarch64_libupnp;unpack=0"
SRC_URI[aarch64_libupnp.sha256sum] = "74779b5a47fc5c43fa51ac97219350726ae877cf0b7f41d917da73aef2e6919b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libupnp-devel-1.14.19-3.el10_0.aarch64.rpm;name=aarch64_libupnp-devel;unpack=0"
SRC_URI[aarch64_libupnp-devel.sha256sum] = "63070315321b76cd7f1ac35ce810ce73f25aeef33d9346e12557272af7222004"

RDEPENDS:libupnp = " \
 glibc \
 "
RDEPENDS:libupnp-devel = " \
 libupnp \
 pkgconf-pkg-config \
 "
