# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cpp_demangle"
PV = "0.5.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-cpp_demangle+alloc-devel \
 rust-cpp_demangle+default-devel \
 rust-cpp_demangle+logging-devel \
 rust-cpp_demangle+std-devel \
 rust-cpp_demangle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cpp_demangle-0.5.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2dea5262d69aed9bf3ae39b5ec45e5e6c789772627288f5911118ba36e02b71f"

URI_x86_64_v2_rust-cpp_demangle+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle+alloc-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle+alloc-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle+alloc-devel.sha256sum] = "bd13af17b861e94f26da3396a9f059fd46402757a380965533cf0d002a57a573"

URI_x86_64_v2_rust-cpp_demangle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle+default-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle+default-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle+default-devel.sha256sum] = "b06e9814dab37cbce63ab535e8afdcb310ed2a41fa7d0d9575328fbb93dd9a76"

URI_x86_64_v2_rust-cpp_demangle+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle+logging-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle+logging-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle+logging-devel.sha256sum] = "b584edbac7c4e7eae646b8e85b78b0f611d5f24553b66fc5cb5f27f6c8ea3957"

URI_x86_64_v2_rust-cpp_demangle+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle+std-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle+std-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle+std-devel.sha256sum] = "0d7c9228b377aa3df1574d0edb08ae75ca93e176b600f347def943b831680a52"

URI_x86_64_v2_rust-cpp_demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle-devel.sha256sum] = "aff5f688381734c00f5d30949602ac3182898bf25936bab8196ed35126af77c8"

URI_aarch64_rust-cpp_demangle+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle+alloc-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-cpp_demangle+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle+alloc-devel}"
SRC_URI[aarch64_rust-cpp_demangle+alloc-devel.sha256sum] = "d64ec07e4190bf00f8125427c8035358d046dfc5ac2f91d228967a10eb8e7259"

URI_aarch64_rust-cpp_demangle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle+default-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-cpp_demangle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle+default-devel}"
SRC_URI[aarch64_rust-cpp_demangle+default-devel.sha256sum] = "65b87a918810a5131208546ac037954cf18997144e08b1e0b84681f850d6ed11"

URI_aarch64_rust-cpp_demangle+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle+logging-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-cpp_demangle+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle+logging-devel}"
SRC_URI[aarch64_rust-cpp_demangle+logging-devel.sha256sum] = "6bc94a8127c93ceed6b3c8722114c6c317a1bb2fdb8c71b30090017a2b72a5c5"

URI_aarch64_rust-cpp_demangle+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle+std-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-cpp_demangle+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle+std-devel}"
SRC_URI[aarch64_rust-cpp_demangle+std-devel.sha256sum] = "9edf0ff5c92a179961fc59e90d00eb1a6eedeb73646d0aea0296b4f5fa7c6a80"

URI_aarch64_rust-cpp_demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle-devel}"
SRC_URI[aarch64_rust-cpp_demangle-devel.sha256sum] = "2ec84d58e7f64e5c56e5e984ed8a55f9a3e8bf0ad633f70c9122f545c86aedfa"

RDEPENDS:rust-cpp_demangle+alloc-devel = " \
 cargo \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-cpp_demangle+default-devel = " \
 cargo \
 rust-cpp_demangle+std-devel \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-cpp_demangle+logging-devel = " \
 cargo \
 rust-cpp_demangle+std-devel \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-cpp_demangle+std-devel = " \
 cargo \
 rust-cpp_demangle+alloc-devel \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-cpp_demangle-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 "
