# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-edit-distance"
PV = "0.2.2.1"
PR = "39.el10_0"
PACKAGES = " \
 ghc-edit-distance \
 ghc-edit-distance-devel \
 ghc-edit-distance-doc \
 ghc-edit-distance-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-edit-distance-0.2.2.1-39.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05adc723bf33eb5fdee0f7c3b98de257e10c217c8d73768ca8aa60e018ddd358"

URI_x86_64_v2_ghc-edit-distance = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-edit-distance-0.2.2.1-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-edit-distance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-edit-distance}"
SRC_URI[x86_64_v2_ghc-edit-distance.sha256sum] = "e9ee3ede10610d429812937beaee41a57415f2a45d340b53b185d4e5757803d9"

URI_x86_64_v2_ghc-edit-distance-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-edit-distance-devel-0.2.2.1-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-edit-distance-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-edit-distance-devel}"
SRC_URI[x86_64_v2_ghc-edit-distance-devel.sha256sum] = "9917bfeb52a985ee26bf92b80dbcf175d0841672a4f3be6b217ffdb2544396fc"

URI_x86_64_v2_ghc-edit-distance-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-edit-distance-doc-0.2.2.1-39.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-edit-distance-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-edit-distance-doc}"
SRC_URI[x86_64_v2_ghc-edit-distance-doc.sha256sum] = "8737424deafb122fe5d5bb5a09ed4172961579eafb1fdf8972328dc53c172870"

URI_x86_64_v2_ghc-edit-distance-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-edit-distance-prof-0.2.2.1-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-edit-distance-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-edit-distance-prof}"
SRC_URI[x86_64_v2_ghc-edit-distance-prof.sha256sum] = "c68dbbcd10181c3632471e86a5a31fe52ca215caddbe744bd7b4103a9e658541"

URI_aarch64_ghc-edit-distance = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-edit-distance-0.2.2.1-39.el10_0.aarch64.rpm;name=aarch64_ghc-edit-distance;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-edit-distance}"
SRC_URI[aarch64_ghc-edit-distance.sha256sum] = "6d048eefcce4770199dfef02e811d2467d5b5e594a4f4202250c548352f27c71"

URI_aarch64_ghc-edit-distance-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-edit-distance-devel-0.2.2.1-39.el10_0.aarch64.rpm;name=aarch64_ghc-edit-distance-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-edit-distance-devel}"
SRC_URI[aarch64_ghc-edit-distance-devel.sha256sum] = "57e0f5429a85fc07aa30dab6063ad6f5499ddd6b4bb614813f321e722f5150e0"

URI_aarch64_ghc-edit-distance-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-edit-distance-doc-0.2.2.1-39.el10_0.noarch.rpm;name=aarch64_ghc-edit-distance-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-edit-distance-doc}"
SRC_URI[aarch64_ghc-edit-distance-doc.sha256sum] = "004daf561a21570c6252d5a296e1f7c2f29a064f9c1d141750e487c37a5244ad"

URI_aarch64_ghc-edit-distance-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-edit-distance-prof-0.2.2.1-39.el10_0.aarch64.rpm;name=aarch64_ghc-edit-distance-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-edit-distance-prof}"
SRC_URI[aarch64_ghc-edit-distance-prof.sha256sum] = "c10bd524555421441411da3a6469222380588a96f5a906e110e0777f10ad6313"

RDEPENDS:ghc-edit-distance = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-random \
 ghc-splitmix \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-edit-distance-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-edit-distance \
 ghc-random-devel \
 "
RDEPENDS:ghc-edit-distance-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-edit-distance-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-edit-distance-devel \
 ghc-random-prof \
 "
