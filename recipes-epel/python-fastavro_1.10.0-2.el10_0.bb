# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fastavro"
PV = "1.10.0"
PR = "2.el10_0"
PACKAGES = " \
 python-fastavro-doc \
 python3-fastavro \
 python3-fastavro+codecs \
 python3-fastavro+lz4 \
 python3-fastavro+snappy \
 python3-fastavro+zstandard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fastavro-1.10.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dba7477d8034b794ad5498210dbbf49a6c3d2d92167c10f9389cea811fa94a86"

URI_x86_64_v2_python-fastavro-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-fastavro-doc-1.10.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python-fastavro-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-fastavro-doc}"
SRC_URI[x86_64_v2_python-fastavro-doc.sha256sum] = "f467cc2ba1fd8c0c5ae04c7d107d2804c02f73668f2f6571556940930f782978"

URI_x86_64_v2_python3-fastavro = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro-1.10.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro}"
SRC_URI[x86_64_v2_python3-fastavro.sha256sum] = "a44413d80a6968d2c0b90777afe13cda576e3e70be6db174427176a7979eff52"

URI_x86_64_v2_python3-fastavro+codecs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro+codecs-1.10.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro+codecs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro+codecs}"
SRC_URI[x86_64_v2_python3-fastavro+codecs.sha256sum] = "25e4b9dbf429da3fe463797ca8b8bb6fb983cda0fb7f5067d326f6be98f8d228"

URI_x86_64_v2_python3-fastavro+lz4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro+lz4-1.10.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro+lz4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro+lz4}"
SRC_URI[x86_64_v2_python3-fastavro+lz4.sha256sum] = "ef9102c1cb8c0ca919e8555bba164e9c65e34946786c984a16d7b2983d3e5b56"

URI_x86_64_v2_python3-fastavro+snappy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro+snappy-1.10.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro+snappy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro+snappy}"
SRC_URI[x86_64_v2_python3-fastavro+snappy.sha256sum] = "185d7204e1791af64316b09158990708af44d63f417ba2f8ab67e699a7e3af2b"

URI_x86_64_v2_python3-fastavro+zstandard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro+zstandard-1.10.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro+zstandard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro+zstandard}"
SRC_URI[x86_64_v2_python3-fastavro+zstandard.sha256sum] = "e52d4a27b1ac1a835ba7d8b57d313bdfe6cb9af8ff916b9b4b626062c8500cf4"

URI_aarch64_python-fastavro-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-fastavro-doc-1.10.0-2.el10_0.aarch64.rpm;name=aarch64_python-fastavro-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-fastavro-doc}"
SRC_URI[aarch64_python-fastavro-doc.sha256sum] = "2c190a7d99f43567440838c6b755205ae997be40f7910ec8868aee4d7035f35e"

URI_aarch64_python3-fastavro = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro-1.10.0-2.el10_0.aarch64.rpm;name=aarch64_python3-fastavro;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro}"
SRC_URI[aarch64_python3-fastavro.sha256sum] = "21d817e59cab734569b59864d16435f5ecea7ede7e741ef7114c9345408c6c40"

URI_aarch64_python3-fastavro+codecs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro+codecs-1.10.0-2.el10_0.aarch64.rpm;name=aarch64_python3-fastavro+codecs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro+codecs}"
SRC_URI[aarch64_python3-fastavro+codecs.sha256sum] = "e7465bf1a61065bab213185d42eb115dc0aabbb985033be0aa4c5c1875906555"

URI_aarch64_python3-fastavro+lz4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro+lz4-1.10.0-2.el10_0.aarch64.rpm;name=aarch64_python3-fastavro+lz4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro+lz4}"
SRC_URI[aarch64_python3-fastavro+lz4.sha256sum] = "119183958b20d14983eecae3421224732aaafc0f8a8aa23675ba425c6ee28fe9"

URI_aarch64_python3-fastavro+snappy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro+snappy-1.10.0-2.el10_0.aarch64.rpm;name=aarch64_python3-fastavro+snappy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro+snappy}"
SRC_URI[aarch64_python3-fastavro+snappy.sha256sum] = "aaba9566e4eb7f8e4b17f6b63cccdcdf7687c97a2e9925c69cf05d9d2b58e21b"

URI_aarch64_python3-fastavro+zstandard = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro+zstandard-1.10.0-2.el10_0.aarch64.rpm;name=aarch64_python3-fastavro+zstandard;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro+zstandard}"
SRC_URI[aarch64_python3-fastavro+zstandard.sha256sum] = "1b4d4419da0056b9f5e9f20f78d3e30072a66d5805d3abe5aa416c38edf4dcfa"

RDEPENDS:python-fastavro-doc = " \
 "
RDEPENDS:python3-fastavro = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-fastavro+codecs = " \
 python3 \
 python3-cramjam \
 python3-fastavro \
 python3-lz4 \
 python3-zstandard \
 "
RDEPENDS:python3-fastavro+lz4 = " \
 python3 \
 python3-fastavro \
 python3-lz4 \
 "
RDEPENDS:python3-fastavro+snappy = " \
 python3 \
 python3-cramjam \
 python3-fastavro \
 "
RDEPENDS:python3-fastavro+zstandard = " \
 python3 \
 python3-fastavro \
 python3-zstandard \
 "
