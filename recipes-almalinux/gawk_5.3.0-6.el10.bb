# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gawk"
PV = "5.3.0"
PR = "6.el10"
PACKAGES = " \
 gawk \
 gawk-all-langpacks \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gawk-5.3.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2840ea03dd8930a0757566844c5667b7f93b55eef287e778890a8cc913b9179b"

URI_x86_64_v2_gawk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gawk-5.3.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_gawk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gawk}"
SRC_URI[x86_64_v2_gawk.sha256sum] = "0f756b200b7168070305891cfd7624cdfe965919a167bade078a28a93b64d001"

URI_x86_64_v2_gawk-all-langpacks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gawk-all-langpacks-5.3.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_gawk-all-langpacks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gawk-all-langpacks}"
SRC_URI[x86_64_v2_gawk-all-langpacks.sha256sum] = "5e28bc4be45e0454c3f34b9be37a0cae5f2457448c3421eb7e4559aa06a0df44"

URI_aarch64_gawk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gawk-5.3.0-6.el10.aarch64.rpm;name=aarch64_gawk;unpack=0"
SRC_URI:append = " ${URI_aarch64_gawk}"
SRC_URI[aarch64_gawk.sha256sum] = "eb1c5814499d11d698fdcdb309e811d332080af2c0385a52295dc90be16333dc"

URI_aarch64_gawk-all-langpacks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gawk-all-langpacks-5.3.0-6.el10.aarch64.rpm;name=aarch64_gawk-all-langpacks;unpack=0"
SRC_URI:append = " ${URI_aarch64_gawk-all-langpacks}"
SRC_URI[aarch64_gawk-all-langpacks.sha256sum] = "13b8608e2abf42a763006187832275a76507b60de20d450a083a0878a57a9c8e"

RDEPENDS:gawk = " \
 bash \
 filesystem \
 glibc \
 gmp \
 mpfr \
 readline \
 "
RDEPENDS:gawk-all-langpacks = " \
 "
