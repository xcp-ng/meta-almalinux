# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstream"
PV = "1.0.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-anstream+auto-devel \
 rust-anstream+default-devel \
 rust-anstream+test-devel \
 rust-anstream+wincon-devel \
 rust-anstream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstream-1.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcf0ec494389375974445c5d05d6f0498ecb9f976079d7690eeb29e9da97516f"

URI_x86_64_v2_rust-anstream+auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream+auto-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream+auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream+auto-devel}"
SRC_URI[x86_64_v2_rust-anstream+auto-devel.sha256sum] = "7b09a8b5820aead618a0b210deb26f4a3aef91d1ce9403c96a67295eb205ea1a"

URI_x86_64_v2_rust-anstream+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream+default-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream+default-devel}"
SRC_URI[x86_64_v2_rust-anstream+default-devel.sha256sum] = "c1521a3408067c94ae7267d644d49a4733bd736218380d6fc7cca9f2871d20a7"

URI_x86_64_v2_rust-anstream+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream+test-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream+test-devel}"
SRC_URI[x86_64_v2_rust-anstream+test-devel.sha256sum] = "d3c5cd9c89a2f47453bdaa76bb70e88083c3d0c54347af64a26f23cfc06a3090"

URI_x86_64_v2_rust-anstream+wincon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream+wincon-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream+wincon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream+wincon-devel}"
SRC_URI[x86_64_v2_rust-anstream+wincon-devel.sha256sum] = "12208aaa0fe1f9084e4d9e1e8fae68c3610b9c8fe7a9c8fd148c5ce32633b353"

URI_x86_64_v2_rust-anstream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream-devel}"
SRC_URI[x86_64_v2_rust-anstream-devel.sha256sum] = "10e1c327c18f0f5f905aaf2ec3bee6d948daf4cd615960f824e666353b39d09b"

URI_aarch64_rust-anstream+auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream+auto-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-anstream+auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream+auto-devel}"
SRC_URI[aarch64_rust-anstream+auto-devel.sha256sum] = "29a1e0393024a9970228789dc2d998847ea414e6081445652cd49c50673f42b5"

URI_aarch64_rust-anstream+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream+default-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-anstream+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream+default-devel}"
SRC_URI[aarch64_rust-anstream+default-devel.sha256sum] = "d9ec96dd39fced3d131e191f9c71dc921cf1509b131c8f94cb509f546c1ee719"

URI_aarch64_rust-anstream+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream+test-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-anstream+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream+test-devel}"
SRC_URI[aarch64_rust-anstream+test-devel.sha256sum] = "0ee90e5894b4114c2c52faaba2f64b0876c7bb64aa91e5073447ae6fd85545e8"

URI_aarch64_rust-anstream+wincon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream+wincon-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-anstream+wincon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream+wincon-devel}"
SRC_URI[aarch64_rust-anstream+wincon-devel.sha256sum] = "402635b9f68462dcb6ed772eefdfe74e01c3d389b420decd8d65ec5ceafe5211"

URI_aarch64_rust-anstream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-anstream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream-devel}"
SRC_URI[aarch64_rust-anstream-devel.sha256sum] = "fe74afb3937a62eb112c89751b72c3a4d21d84a3a4796316d7693c1b928f6fa0"

RDEPENDS:rust-anstream+auto-devel = " \
 cargo \
 rust-anstream-devel \
 rust-anstyle-query+default-devel \
 "
RDEPENDS:rust-anstream+default-devel = " \
 cargo \
 rust-anstream+auto-devel \
 rust-anstream+wincon-devel \
 rust-anstream-devel \
 "
RDEPENDS:rust-anstream+test-devel = " \
 cargo \
 rust-anstream-devel \
 "
RDEPENDS:rust-anstream+wincon-devel = " \
 cargo \
 rust-anstream-devel \
 "
RDEPENDS:rust-anstream-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-anstyle-parse+default-devel \
 rust-colorchoice+default-devel \
 rust-utf8parse+default-devel \
 "
