# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Contextual-Return"
PV = "0.004014"
PR = "20.el10_0"
PACKAGES = " \
 perl-Contextual-Return \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Contextual-Return-0.004014-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fefbbff7a6d1b80a7dd5e4f775b3c200128b893cf14a6a7ecaeecd194f4aba43"

URI_x86_64_v2_perl-Contextual-Return = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Contextual-Return-0.004014-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Contextual-Return;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Contextual-Return}"
SRC_URI[x86_64_v2_perl-Contextual-Return.sha256sum] = "5e2b4d6e2b3c804f538df8e96b11457b454a4a90a3b380bfca47a2276fe27692"

URI_aarch64_perl-Contextual-Return = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Contextual-Return-0.004014-20.el10_0.noarch.rpm;name=aarch64_perl-Contextual-Return;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Contextual-Return}"
SRC_URI[aarch64_perl-Contextual-Return.sha256sum] = "eb9f6bd345f627b5c1935e711bd7aab91c7f0df45cdc9620fdb8f9da512d9d47"

RDEPENDS:perl-Contextual-Return = " \
 perl-Carp \
 perl-Contextual-Return \
 perl-Data-Dumper \
 perl-Scalar-List-Utils \
 perl-Want \
 perl-libs \
 perl-overload \
 "
