# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmodplug"
PE = "1"
PV = "0.8.9.0"
PR = "25.el10_0"
PACKAGES = " \
 libmodplug \
 libmodplug-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmodplug-0.8.9.0-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1bf7d87481533774681c2e828390ff88de8c10be92447b26ebf0b79c9b2f51a"

URI_x86_64_v2_libmodplug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmodplug-0.8.9.0-25.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmodplug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmodplug}"
SRC_URI[x86_64_v2_libmodplug.sha256sum] = "51e909ae0b1be1da5ee3d33b396ee652f48345533af591276d6b6b3268baf865"

URI_x86_64_v2_libmodplug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmodplug-devel-0.8.9.0-25.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmodplug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmodplug-devel}"
SRC_URI[x86_64_v2_libmodplug-devel.sha256sum] = "65429a8b0994eb6463f1419e4e8989a8b5be379789b2aeef7444c5ce071e80b5"

URI_aarch64_libmodplug = "${EPEL_MIRROR}/aarch64/Packages/l/libmodplug-0.8.9.0-25.el10_0.aarch64.rpm;name=aarch64_libmodplug;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmodplug}"
SRC_URI[aarch64_libmodplug.sha256sum] = "976f5dfde0a8420fe87fe87f86a948ac0d3025dde78b066eae1a57c8b98f7f03"

URI_aarch64_libmodplug-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmodplug-devel-0.8.9.0-25.el10_0.aarch64.rpm;name=aarch64_libmodplug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmodplug-devel}"
SRC_URI[aarch64_libmodplug-devel.sha256sum] = "011e030e7b28fb4dab3f8635c4cb19e6c0f3b37c0d30f1f7a146339f56bfd1d4"

RDEPENDS:libmodplug = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libmodplug-devel = " \
 gcc-c++ \
 libmodplug \
 pkgconf-pkg-config \
 "
