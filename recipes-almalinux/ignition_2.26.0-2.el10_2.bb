# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ignition"
PV = "2.26.0"
PR = "2.el10_2"
PACKAGES = " \
 ignition \
 ignition-edge \
 ignition-grub \
 ignition-validate \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ignition-2.26.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a0eccbf3868bfa532b1e270cae5051335cdfd595052ab32e963675f085536dd"

URI_x86_64_v2_ignition = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-2.26.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_ignition;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition}"
SRC_URI[x86_64_v2_ignition.sha256sum] = "36b8859c2ad553d878e3d0a2c78eb8a596e133df27b2ea588470431167382abe"

URI_x86_64_v2_ignition-edge = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-edge-2.26.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_ignition-edge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition-edge}"
SRC_URI[x86_64_v2_ignition-edge.sha256sum] = "a58ede5ad42a3323cc3630d8fc88141fe39569c25697804c8b20cdc2ea46f0f7"

URI_x86_64_v2_ignition-grub = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-grub-2.26.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_ignition-grub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition-grub}"
SRC_URI[x86_64_v2_ignition-grub.sha256sum] = "409bb5a1b6cdf756914008a91f909ed3ef1d069b51adab37e484cf7953e254cc"

URI_x86_64_v2_ignition-validate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-validate-2.26.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_ignition-validate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition-validate}"
SRC_URI[x86_64_v2_ignition-validate.sha256sum] = "49130cc3773bd06d819cba4bdca81c9daf63d46a69b1afde635d466a5f0edb45"

URI_aarch64_ignition = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-2.26.0-2.el10_2.aarch64.rpm;name=aarch64_ignition;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition}"
SRC_URI[aarch64_ignition.sha256sum] = "eb5e082b960f11c16fa06001868fe1febdae513530b72588010b443e92e2f547"

URI_aarch64_ignition-edge = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-edge-2.26.0-2.el10_2.aarch64.rpm;name=aarch64_ignition-edge;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition-edge}"
SRC_URI[aarch64_ignition-edge.sha256sum] = "04ba097f63a337b0702cf9497a5b3be261489d6b42feb03d76dbe9c1c0be3439"

URI_aarch64_ignition-grub = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-grub-2.26.0-2.el10_2.aarch64.rpm;name=aarch64_ignition-grub;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition-grub}"
SRC_URI[aarch64_ignition-grub.sha256sum] = "84f9caed3068e0b493b107b00e2e7eab48eefc69681b399eae6b420c25f53ae7"

URI_aarch64_ignition-validate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-validate-2.26.0-2.el10_2.aarch64.rpm;name=aarch64_ignition-validate;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition-validate}"
SRC_URI[aarch64_ignition-validate.sha256sum] = "0aca9fe09d37d77a3acbcfaace1d9e55716fd2d61d561024887ccf0c78125f24"

RDEPENDS:ignition = " \
 bash \
 dosfstools \
 dracut \
 dracut-network \
 glibc \
 libblkid \
 libgcc \
 libstdc++ \
 libuuid \
 popt \
 "
RDEPENDS:ignition-edge = " \
 bash \
 "
RDEPENDS:ignition-grub = " \
 "
RDEPENDS:ignition-validate = " \
 glibc \
 "
