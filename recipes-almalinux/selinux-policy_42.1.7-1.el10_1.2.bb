# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "selinux-policy"
PV = "42.1.7"
PR = "1.el10_1.2"
PACKAGES = " \
 selinux-policy \
 selinux-policy-automotive \
 selinux-policy-devel \
 selinux-policy-doc \
 selinux-policy-extra \
 selinux-policy-mls \
 selinux-policy-mls-extra \
 selinux-policy-sandbox \
 selinux-policy-targeted \
 selinux-policy-targeted-extra \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/selinux-policy-42.1.7-1.el10_1.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1fda0b3167ddfea4ff89badaa6ffb70dacb0173469fcfb96b276d190a414e1c"

URI_x86_64_v2_selinux-policy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-42.1.7-1.el10_1.2.noarch.rpm;name=x86_64_v2_selinux-policy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy}"
SRC_URI[x86_64_v2_selinux-policy.sha256sum] = "2c33e5d6440ac60b24cfc4572695af6bad2e0b0ca9600dc457301e54eb9f9b20"

URI_x86_64_v2_selinux-policy-automotive = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/selinux-policy-automotive-42.1.7-1.el10_1.2.noarch.rpm;name=x86_64_v2_selinux-policy-automotive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-automotive}"
SRC_URI[x86_64_v2_selinux-policy-automotive.sha256sum] = "77d6683204a931c8d63f953f98a1ac5c498eac347351c562d08257dfcfa348b8"
RPROVIDES:selinux-policy-automotive:append:x86_64_v2 = " virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.7-1.el10_1.2 virtual/selinux-policy-any_ge_42.1.2 virtual/selinux-policy-any_ge_42.1.7"

URI_x86_64_v2_selinux-policy-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/selinux-policy-devel-42.1.7-1.el10_1.2.noarch.rpm;name=x86_64_v2_selinux-policy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-devel}"
SRC_URI[x86_64_v2_selinux-policy-devel.sha256sum] = "25ea667d3860cd10ad4e3ee263a7232339528df99bf83426e2b5fd32451b4719"

URI_x86_64_v2_selinux-policy-doc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-doc-42.1.7-1.el10_1.2.noarch.rpm;name=x86_64_v2_selinux-policy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-doc}"
SRC_URI[x86_64_v2_selinux-policy-doc.sha256sum] = "ea61a17bcef83fc5466ca21521f326048bde3d2cd00a77bc538f7813c294a609"

URI_x86_64_v2_selinux-policy-extra = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-extra-42.1.7-1.el10_1.2.noarch.rpm;name=x86_64_v2_selinux-policy-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-extra}"
SRC_URI[x86_64_v2_selinux-policy-extra.sha256sum] = "add324311546d19b5dd9aad879568eeab33042fda65dbc19cb0a564c3ac4a804"

URI_x86_64_v2_selinux-policy-mls = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-mls-42.1.7-1.el10_1.2.noarch.rpm;name=x86_64_v2_selinux-policy-mls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-mls}"
SRC_URI[x86_64_v2_selinux-policy-mls.sha256sum] = "e285b253f54c7adca7287092a68956b340bc880f70e98447eced229c156c956c"
RPROVIDES:selinux-policy-mls:append:x86_64_v2 = " virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.7-1.el10_1.2 virtual/selinux-policy-any_ge_42.1.2 virtual/selinux-policy-any_ge_42.1.7"

URI_x86_64_v2_selinux-policy-mls-extra = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-mls-extra-42.1.7-1.el10_1.2.noarch.rpm;name=x86_64_v2_selinux-policy-mls-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-mls-extra}"
SRC_URI[x86_64_v2_selinux-policy-mls-extra.sha256sum] = "5be9f97fb3edf03f05174d4a2c0e1ac194cb4a6630190f9d780546a408e1947a"

URI_x86_64_v2_selinux-policy-sandbox = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-sandbox-42.1.7-1.el10_1.2.noarch.rpm;name=x86_64_v2_selinux-policy-sandbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-sandbox}"
SRC_URI[x86_64_v2_selinux-policy-sandbox.sha256sum] = "047e1323fa1b0086436542979c6ee02f58865cc39ed37802f195fed0a6d3b310"

URI_x86_64_v2_selinux-policy-targeted = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-targeted-42.1.7-1.el10_1.2.noarch.rpm;name=x86_64_v2_selinux-policy-targeted;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-targeted}"
SRC_URI[x86_64_v2_selinux-policy-targeted.sha256sum] = "086dbe0dc0ecc0b1421ce7b38b77356a492d9491ddd501874116142f2ce6ad1d"
RPROVIDES:selinux-policy-targeted:append:x86_64_v2 = " virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.7-1.el10_1.2 virtual/selinux-policy-any_ge_42.1.2 virtual/selinux-policy-any_ge_42.1.7"

URI_x86_64_v2_selinux-policy-targeted-extra = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-targeted-extra-42.1.7-1.el10_1.2.noarch.rpm;name=x86_64_v2_selinux-policy-targeted-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-targeted-extra}"
SRC_URI[x86_64_v2_selinux-policy-targeted-extra.sha256sum] = "9ed496db1ee00ca13599eaad300e7b39353bb3a036acb92d6313d10f135eaac7"

URI_aarch64_selinux-policy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-42.1.7-1.el10_1.2.noarch.rpm;name=aarch64_selinux-policy;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy}"
SRC_URI[aarch64_selinux-policy.sha256sum] = "2c33e5d6440ac60b24cfc4572695af6bad2e0b0ca9600dc457301e54eb9f9b20"

URI_aarch64_selinux-policy-automotive = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/selinux-policy-automotive-42.1.7-1.el10_1.2.noarch.rpm;name=aarch64_selinux-policy-automotive;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-automotive}"
SRC_URI[aarch64_selinux-policy-automotive.sha256sum] = "77d6683204a931c8d63f953f98a1ac5c498eac347351c562d08257dfcfa348b8"
RPROVIDES:selinux-policy-automotive:append:aarch64 = " virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.7-1.el10_1.2 virtual/selinux-policy-any_ge_42.1.3 virtual/selinux-policy-any_ge_42.1.7"

URI_aarch64_selinux-policy-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/selinux-policy-devel-42.1.7-1.el10_1.2.noarch.rpm;name=aarch64_selinux-policy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-devel}"
SRC_URI[aarch64_selinux-policy-devel.sha256sum] = "25ea667d3860cd10ad4e3ee263a7232339528df99bf83426e2b5fd32451b4719"

URI_aarch64_selinux-policy-doc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-doc-42.1.7-1.el10_1.2.noarch.rpm;name=aarch64_selinux-policy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-doc}"
SRC_URI[aarch64_selinux-policy-doc.sha256sum] = "ea61a17bcef83fc5466ca21521f326048bde3d2cd00a77bc538f7813c294a609"

URI_aarch64_selinux-policy-extra = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-extra-42.1.7-1.el10_1.2.noarch.rpm;name=aarch64_selinux-policy-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-extra}"
SRC_URI[aarch64_selinux-policy-extra.sha256sum] = "add324311546d19b5dd9aad879568eeab33042fda65dbc19cb0a564c3ac4a804"

URI_aarch64_selinux-policy-mls = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-mls-42.1.7-1.el10_1.2.noarch.rpm;name=aarch64_selinux-policy-mls;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-mls}"
SRC_URI[aarch64_selinux-policy-mls.sha256sum] = "e285b253f54c7adca7287092a68956b340bc880f70e98447eced229c156c956c"
RPROVIDES:selinux-policy-mls:append:aarch64 = " virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.7-1.el10_1.2 virtual/selinux-policy-any_ge_42.1.3 virtual/selinux-policy-any_ge_42.1.7"

URI_aarch64_selinux-policy-mls-extra = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-mls-extra-42.1.7-1.el10_1.2.noarch.rpm;name=aarch64_selinux-policy-mls-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-mls-extra}"
SRC_URI[aarch64_selinux-policy-mls-extra.sha256sum] = "5be9f97fb3edf03f05174d4a2c0e1ac194cb4a6630190f9d780546a408e1947a"

URI_aarch64_selinux-policy-sandbox = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-sandbox-42.1.7-1.el10_1.2.noarch.rpm;name=aarch64_selinux-policy-sandbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-sandbox}"
SRC_URI[aarch64_selinux-policy-sandbox.sha256sum] = "047e1323fa1b0086436542979c6ee02f58865cc39ed37802f195fed0a6d3b310"

URI_aarch64_selinux-policy-targeted = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-targeted-42.1.7-1.el10_1.2.noarch.rpm;name=aarch64_selinux-policy-targeted;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-targeted}"
SRC_URI[aarch64_selinux-policy-targeted.sha256sum] = "086dbe0dc0ecc0b1421ce7b38b77356a492d9491ddd501874116142f2ce6ad1d"
RPROVIDES:selinux-policy-targeted:append:aarch64 = " virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.7-1.el10_1.2 virtual/selinux-policy-any_ge_42.1.3 virtual/selinux-policy-any_ge_42.1.7"

URI_aarch64_selinux-policy-targeted-extra = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-targeted-extra-42.1.7-1.el10_1.2.noarch.rpm;name=aarch64_selinux-policy-targeted-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-targeted-extra}"
SRC_URI[aarch64_selinux-policy-targeted-extra.sha256sum] = "9ed496db1ee00ca13599eaad300e7b39353bb3a036acb92d6313d10f135eaac7"

RDEPENDS:selinux-policy = " \
 bash \
 gawk \
 policycoreutils \
 rpm-plugin-selinux \
 virtual//usr/bin/sha512sum \
 virtual/selinux-policy-any_eq_42.1.7-1.el10_1.2 \
 "
RDEPENDS:selinux-policy-automotive = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/coreutils \
 "
RDEPENDS:selinux-policy-devel = " \
 bash \
 checkpolicy \
 m4 \
 make \
 policycoreutils-devel \
 selinux-policy \
 "
RDEPENDS:selinux-policy-doc = " \
 selinux-policy \
 "
RDEPENDS:selinux-policy-extra = " \
 selinux-policy-mls-extra \
 selinux-policy-targeted-extra \
 "
RDEPENDS:selinux-policy-mls = " \
 bash \
 mcstrans \
 policycoreutils \
 policycoreutils-newrole \
 selinux-policy \
 virtual/coreutils \
 "
RDEPENDS:selinux-policy-mls-extra = " \
 selinux-policy-mls \
 "
RDEPENDS:selinux-policy-sandbox = " \
 bash \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:selinux-policy-targeted = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/coreutils \
 "
RDEPENDS:selinux-policy-targeted-extra = " \
 selinux-policy-targeted \
 "
