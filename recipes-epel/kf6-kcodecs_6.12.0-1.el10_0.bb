# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcodecs"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kcodecs \
 kf6-kcodecs-devel \
 kf6-kcodecs-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcodecs-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6506536ad1dbf7b3d4fe35b29e44fc5428cc3063f854cd252589bd28b55617cc"

URI_x86_64_v2_kf6-kcodecs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcodecs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs}"
SRC_URI[x86_64_v2_kf6-kcodecs.sha256sum] = "38eabf41be0e5ef6fe4b8c17b9cd462627f6e32189eca2602c7244419c77d488"

URI_x86_64_v2_kf6-kcodecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcodecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs-devel}"
SRC_URI[x86_64_v2_kf6-kcodecs-devel.sha256sum] = "18f5c887e7546a72b6462ce35dd75be77140bb7e75132a9b3d11808780a2f78f"

URI_x86_64_v2_kf6-kcodecs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcodecs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs-doc}"
SRC_URI[x86_64_v2_kf6-kcodecs-doc.sha256sum] = "3e680971fffda627a0324120cf76381db87995138719c3f397a96a0d509a6f23"

URI_aarch64_kf6-kcodecs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcodecs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs}"
SRC_URI[aarch64_kf6-kcodecs.sha256sum] = "1c048f4c26667bdf2ec2acdad723c07d7577b16f9a868cfe275c4e699f78a1cc"

URI_aarch64_kf6-kcodecs-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcodecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs-devel}"
SRC_URI[aarch64_kf6-kcodecs-devel.sha256sum] = "9d3629902f0ce0a04c22cee511479e861388d977f8823363a725be326aafe021"

URI_aarch64_kf6-kcodecs-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kcodecs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs-doc}"
SRC_URI[aarch64_kf6-kcodecs-doc.sha256sum] = "27a5a3e1674786b59f7354417a88d31ef77beb4e2f83bcb401039f0216f44914"

RDEPENDS:kf6-kcodecs = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kcodecs-devel = " \
 cmake-filesystem \
 kf6-kcodecs \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcodecs-doc = " \
 "
