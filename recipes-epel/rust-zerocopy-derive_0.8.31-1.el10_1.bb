# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerocopy-derive"
PV = "0.8.31"
PR = "1.el10_1"
PACKAGES = " \
 rust-zerocopy-derive+default-devel \
 rust-zerocopy-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerocopy-derive-0.8.31-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5850cd4549a3b98d2445ec25eb2ed04025fc1cc1c4a14ccf3aac0a4ce3504de5"

URI_x86_64_v2_rust-zerocopy-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-derive+default-devel-0.8.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy-derive+default-devel}"
SRC_URI[x86_64_v2_rust-zerocopy-derive+default-devel.sha256sum] = "ff02a008464e434eb8c194f2d57c4825ab7ecb7891108b3f924f1ccab4d1a23e"

URI_x86_64_v2_rust-zerocopy-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-derive-devel-0.8.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy-derive-devel}"
SRC_URI[x86_64_v2_rust-zerocopy-derive-devel.sha256sum] = "2fdf66f99fd46aa738f59b4f1448cbadb2fcb5ba0946a75d0694ca62f4a3871c"

URI_aarch64_rust-zerocopy-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-derive+default-devel-0.8.31-1.el10_1.noarch.rpm;name=aarch64_rust-zerocopy-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy-derive+default-devel}"
SRC_URI[aarch64_rust-zerocopy-derive+default-devel.sha256sum] = "a29e276cc956f44be09add2b008f1bb1366e07618c614c6cff01b940ae9c8661"

URI_aarch64_rust-zerocopy-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-derive-devel-0.8.31-1.el10_1.noarch.rpm;name=aarch64_rust-zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy-derive-devel}"
SRC_URI[aarch64_rust-zerocopy-derive-devel.sha256sum] = "81f64d377c1ab1b06422fde4b2937043c7ee8bb781e1a5f1d318b4f102e42e5b"

RDEPENDS:rust-zerocopy-derive+default-devel = " \
 cargo \
 rust-zerocopy-derive-devel \
 "
RDEPENDS:rust-zerocopy-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
