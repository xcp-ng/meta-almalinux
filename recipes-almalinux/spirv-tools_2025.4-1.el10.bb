# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spirv-tools"
PV = "2025.4"
PR = "1.el10"
PACKAGES = " \
 spirv-tools \
 spirv-tools-devel \
 spirv-tools-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/spirv-tools-2025.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2baae4f8f8623dc3c9a2206e5bdfe44d7aa51dd94b63c6897289ba36a300278"

URI_x86_64_v2_spirv-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/spirv-tools-2025.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_spirv-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spirv-tools}"
SRC_URI[x86_64_v2_spirv-tools.sha256sum] = "ee175cdab63cc5efb40167717d043587088046ff9f8fa19e2cf8176994aa4fb0"

URI_x86_64_v2_spirv-tools-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/spirv-tools-devel-2025.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_spirv-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spirv-tools-devel}"
SRC_URI[x86_64_v2_spirv-tools-devel.sha256sum] = "02dc8a3bf36b1601691c366092ba6d2086f0d1aed7115f7b2933c68c4972be7f"

URI_x86_64_v2_spirv-tools-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/spirv-tools-libs-2025.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_spirv-tools-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spirv-tools-libs}"
SRC_URI[x86_64_v2_spirv-tools-libs.sha256sum] = "76c6cb0fd55f77a5eafd0f37c7630e2a3a103c8b087a768e7cd397806044b5c5"

URI_aarch64_spirv-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/spirv-tools-2025.4-1.el10.aarch64.rpm;name=aarch64_spirv-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_spirv-tools}"
SRC_URI[aarch64_spirv-tools.sha256sum] = "95eb7e609cece02c3064c0fc26673ed32d03ebddc12e11e6d0b1e91b649cdc4e"

URI_aarch64_spirv-tools-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/spirv-tools-devel-2025.4-1.el10.aarch64.rpm;name=aarch64_spirv-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_spirv-tools-devel}"
SRC_URI[aarch64_spirv-tools-devel.sha256sum] = "7563b88ec740cc8121d2a8c0566d090860192f7749c0740535ec640bc3047d47"

URI_aarch64_spirv-tools-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/spirv-tools-libs-2025.4-1.el10.aarch64.rpm;name=aarch64_spirv-tools-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_spirv-tools-libs}"
SRC_URI[aarch64_spirv-tools-libs.sha256sum] = "887c14176d23e760823322825e01d3449e4c2ef98f58dc6e3d441974bf7a2e61"

RDEPENDS:spirv-tools = " \
 bash \
 glibc \
 libstdc++ \
 spirv-tools-libs \
 "
RDEPENDS:spirv-tools-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 spirv-tools \
 spirv-tools-libs \
 "
RDEPENDS:spirv-tools-libs = " \
 glibc \
 libstdc++ \
 "
