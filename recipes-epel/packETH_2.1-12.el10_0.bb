# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "packETH"
PV = "2.1"
PR = "12.el10_0"
PACKAGES = " \
 packETH \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/packETH-2.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1054e3c13215caffc0f76312e47a3124ed4c064b85b7ad5533d85b30d16cb914"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/packETH-2.1-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_packETH;unpack=0"
SRC_URI[x86_64_v2_packETH.sha256sum] = "928c3918f12796b52c50201c0d014328c3361ce274d0586230d13b5a3b042804"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/packETH-2.1-12.el10_0.aarch64.rpm;name=aarch64_packETH;unpack=0"
SRC_URI[aarch64_packETH.sha256sum] = "17945e4c849eba8c2dd7054ab488eb3ed12c5c574245b9a38a62600088c53874"

RDEPENDS:packETH = " \
 glib2 \
 glibc \
 gtk2 \
 "
