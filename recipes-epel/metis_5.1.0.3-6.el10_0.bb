# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "metis"
PV = "5.1.0.3"
PR = "6.el10_0"
PACKAGES = " \
 metis \
 metis-devel \
 metis64 \
 metis64-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/metis-5.1.0.3-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f25229d37feabc8fc4535938343b788b4ba951770dcfab737a8cca1b6e48eda3"

URI_x86_64_v2_metis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/metis-5.1.0.3-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_metis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_metis}"
SRC_URI[x86_64_v2_metis.sha256sum] = "b72844a275359d9d2527dba800abd9f2ec9d008f666fd1fbad9e04ed0e995089"

URI_x86_64_v2_metis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/metis-devel-5.1.0.3-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_metis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_metis-devel}"
SRC_URI[x86_64_v2_metis-devel.sha256sum] = "e121bae818c10ec2a204bc8d2de050c1732ae75b9f5b70730527d6cd35b6ea42"

URI_x86_64_v2_metis64 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/metis64-5.1.0.3-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_metis64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_metis64}"
SRC_URI[x86_64_v2_metis64.sha256sum] = "05e51829041f3cec732a1f6db20bc3466675bde24f149a6263aa8b721da0709a"

URI_x86_64_v2_metis64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/metis64-devel-5.1.0.3-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_metis64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_metis64-devel}"
SRC_URI[x86_64_v2_metis64-devel.sha256sum] = "3012060a55e5e432a551024add79b21df9ab940734b64cc6d32bef9c5726866b"

URI_aarch64_metis = "${EPEL_MIRROR}/aarch64/Packages/m/metis-5.1.0.3-6.el10_0.aarch64.rpm;name=aarch64_metis;unpack=0"
SRC_URI:append = " ${URI_aarch64_metis}"
SRC_URI[aarch64_metis.sha256sum] = "36abccbab1aba58713ee4e33bbaa3619376c797d046e5f527fb38066c9bbb082"

URI_aarch64_metis-devel = "${EPEL_MIRROR}/aarch64/Packages/m/metis-devel-5.1.0.3-6.el10_0.aarch64.rpm;name=aarch64_metis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_metis-devel}"
SRC_URI[aarch64_metis-devel.sha256sum] = "d92be5c15ca777b6be09f1282a0d1dd061145bcb8a0263b4dd4a07189dcde764"

URI_aarch64_metis64 = "${EPEL_MIRROR}/aarch64/Packages/m/metis64-5.1.0.3-6.el10_0.aarch64.rpm;name=aarch64_metis64;unpack=0"
SRC_URI:append = " ${URI_aarch64_metis64}"
SRC_URI[aarch64_metis64.sha256sum] = "7ef5306139378bf54bd5e1911e3ca079df1d7b265d7700baf4dbb68916bcf793"

URI_aarch64_metis64-devel = "${EPEL_MIRROR}/aarch64/Packages/m/metis64-devel-5.1.0.3-6.el10_0.aarch64.rpm;name=aarch64_metis64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_metis64-devel}"
SRC_URI[aarch64_metis64-devel.sha256sum] = "9ff47b9361ad2f90c4c082e0bb0efb47a444591bd610fcedf57d3bfa29067ae6"

RDEPENDS:metis = " \
 glibc \
 libgcc \
 libgomp \
 pcre2 \
 "
RDEPENDS:metis-devel = " \
 metis \
 "
RDEPENDS:metis64 = " \
 glibc \
 libgcc \
 libgomp \
 pcre2 \
 "
RDEPENDS:metis64-devel = " \
 metis64 \
 "
