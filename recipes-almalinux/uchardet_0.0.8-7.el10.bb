# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uchardet"
PV = "0.0.8"
PR = "7.el10"
PACKAGES = " \
 uchardet \
 uchardet-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/uchardet-0.0.8-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0d17b111a08714e557bf857021af1ac9cbcb25ff5980c31918c0f5e5adf68da"

URI_x86_64_v2_uchardet = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/uchardet-0.0.8-7.el10.x86_64_v2.rpm;name=x86_64_v2_uchardet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uchardet}"
SRC_URI[x86_64_v2_uchardet.sha256sum] = "877ff6ef7ee620a238717775823d18ffc9599df551d6ac3baf2a179f94067480"

URI_x86_64_v2_uchardet-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/uchardet-devel-0.0.8-7.el10.x86_64_v2.rpm;name=x86_64_v2_uchardet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uchardet-devel}"
SRC_URI[x86_64_v2_uchardet-devel.sha256sum] = "794c744210779d7cb642482427afbb7b2ce5c4d31187d6ff83a00724d5fbfbfc"

URI_aarch64_uchardet = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/uchardet-0.0.8-7.el10.aarch64.rpm;name=aarch64_uchardet;unpack=0"
SRC_URI:append = " ${URI_aarch64_uchardet}"
SRC_URI[aarch64_uchardet.sha256sum] = "b7baa7551ea5f5ae50ccd8672a918d09f777821142f774db1572a585bf20fd0e"

URI_aarch64_uchardet-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/uchardet-devel-0.0.8-7.el10.aarch64.rpm;name=aarch64_uchardet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_uchardet-devel}"
SRC_URI[aarch64_uchardet-devel.sha256sum] = "4634484cecb16b261943ca7b21c16e46790a06881eb9021f61e103504da22759"

RDEPENDS:uchardet = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:uchardet-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 uchardet \
 "
