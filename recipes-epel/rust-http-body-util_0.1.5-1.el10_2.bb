# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-body-util"
PV = "0.1.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-http-body-util+channel-devel \
 rust-http-body-util+default-devel \
 rust-http-body-util+full-devel \
 rust-http-body-util-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-http-body-util-0.1.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "86c57e994c2f65299d4385076e7de83d7e468070aea6a12467f04edebda8805f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+channel-devel-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+channel-devel;unpack=0"
SRC_URI[x86_64_v2_rust-http-body-util+channel-devel.sha256sum] = "a31c288b39f4cca22d8ea47cf79131486107aaf85c6c9081eb103654fd25a380"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+default-devel-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-http-body-util+default-devel.sha256sum] = "ce4f7b729c37c4eea4a0ab0f7ae6f0bd4b1b0a4ba64cd509a03ac09f09116612"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+full-devel-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+full-devel;unpack=0"
SRC_URI[x86_64_v2_rust-http-body-util+full-devel.sha256sum] = "ddb73c87045181eb8f88ada5dd1ad83f00491625f5ed0c4adca5301b294ba335"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util-devel-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-http-body-util-devel.sha256sum] = "b7e41b5e60016816940365eb12d753253e116556bfcd8067fccd982a5e329f70"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+channel-devel-0.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-http-body-util+channel-devel;unpack=0"
SRC_URI[aarch64_rust-http-body-util+channel-devel.sha256sum] = "8bb7a214800cee46ac60b4984a7585789a16f7d8905c26a83c70237bc8de056b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+default-devel-0.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-http-body-util+default-devel;unpack=0"
SRC_URI[aarch64_rust-http-body-util+default-devel.sha256sum] = "9194f8646e696e62dab441da942a03e585cb328ba1bf419cf94fe49ba9ae0d17"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+full-devel-0.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-http-body-util+full-devel;unpack=0"
SRC_URI[aarch64_rust-http-body-util+full-devel.sha256sum] = "8f92405a44fab58d1f21355deab18c27df119609418e6939cee1f4a2c78be241"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util-devel-0.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-http-body-util-devel;unpack=0"
SRC_URI[aarch64_rust-http-body-util-devel.sha256sum] = "161da3582375d81e78574b91708767db75a8610d4a9d309aa78a5925349ae4ec"

RDEPENDS:rust-http-body-util+channel-devel = " \
 cargo \
 rust-http-body-util-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
RDEPENDS:rust-http-body-util+default-devel = " \
 cargo \
 rust-http-body-util-devel \
 "
RDEPENDS:rust-http-body-util+full-devel = " \
 cargo \
 rust-http-body-util+channel-devel \
 rust-http-body-util-devel \
 "
RDEPENDS:rust-http-body-util-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-futures-core-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-pin-project-lite+default-devel \
 "
