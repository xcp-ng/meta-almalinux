# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs24"
PE = "1"
PV = "24.18.0"
PR = "1.el10"
PACKAGES = " \
 nodejs24 \
 nodejs24-devel \
 nodejs24-docs \
 nodejs24-full-i18n \
 nodejs24-libs \
 nodejs24-npm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs24-24.18.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbcf54cd3b39a1e2c0ec4e9f03fe03b5a0002e9a29c2e63c14a107a045b47e3c"

URI_x86_64_v2_nodejs24 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-24.18.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs24;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24}"
SRC_URI[x86_64_v2_nodejs24.sha256sum] = "ea0dede8a9424444dc2e7ea86ab65b21b8f9d7fe68070814f0d5a1d5828b0980"
RPROVIDES:nodejs24:x86_64_v2 = "virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

URI_x86_64_v2_nodejs24-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-devel-24.18.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs24-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-devel}"
SRC_URI[x86_64_v2_nodejs24-devel.sha256sum] = "024e542abfab17b24304b13fd2bba349d0dadb6ba563141558a04f7f6fa9bcb5"

URI_x86_64_v2_nodejs24-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-docs-24.18.0-1.el10.noarch.rpm;name=x86_64_v2_nodejs24-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-docs}"
SRC_URI[x86_64_v2_nodejs24-docs.sha256sum] = "7065de193fe05d074fa833079c71c02dfb7f09468aa82fe8fe23b65cb64014bb"

URI_x86_64_v2_nodejs24-full-i18n = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-full-i18n-24.18.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs24-full-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-full-i18n}"
SRC_URI[x86_64_v2_nodejs24-full-i18n.sha256sum] = "0eec7d937cc4afa600ff9e973405b7148e9e33c70f59475c6a9907758f056409"

URI_x86_64_v2_nodejs24-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-libs-24.18.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs24-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-libs}"
SRC_URI[x86_64_v2_nodejs24-libs.sha256sum] = "039be6ad24d9a5083abfff38cbb03d042689dc108dab90f482a1065a2a0be28b"

URI_x86_64_v2_nodejs24-npm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-npm-11.16.0-1.24.18.0.1.el10.noarch.rpm;name=x86_64_v2_nodejs24-npm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-npm}"
SRC_URI[x86_64_v2_nodejs24-npm.sha256sum] = "1ba431f8ddbb38106d1fd6307a916ebda5ab9b22554bfbb06ceccca5b59e2502"

URI_aarch64_nodejs24 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-24.18.0-1.el10.aarch64.rpm;name=aarch64_nodejs24;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24}"
SRC_URI[aarch64_nodejs24.sha256sum] = "77eab3ead2bb64e2d162ea69c480e8d2a2df3affaecf9d9858c6cbc03cf6fb9f"
RPROVIDES:nodejs24:aarch64 = "virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

URI_aarch64_nodejs24-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-devel-24.18.0-1.el10.aarch64.rpm;name=aarch64_nodejs24-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-devel}"
SRC_URI[aarch64_nodejs24-devel.sha256sum] = "f6d4a8779aadf7eb546ba52a8bc182184c3bf94a6adbedf8eea6928d6b5de07a"

URI_aarch64_nodejs24-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-docs-24.18.0-1.el10.noarch.rpm;name=aarch64_nodejs24-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-docs}"
SRC_URI[aarch64_nodejs24-docs.sha256sum] = "7065de193fe05d074fa833079c71c02dfb7f09468aa82fe8fe23b65cb64014bb"

URI_aarch64_nodejs24-full-i18n = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-full-i18n-24.18.0-1.el10.aarch64.rpm;name=aarch64_nodejs24-full-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-full-i18n}"
SRC_URI[aarch64_nodejs24-full-i18n.sha256sum] = "0cd3299bb252175b971a3dafee4370f5f97e0a58f03c7ffb6fe8bae9c0abd0c4"

URI_aarch64_nodejs24-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-libs-24.18.0-1.el10.aarch64.rpm;name=aarch64_nodejs24-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-libs}"
SRC_URI[aarch64_nodejs24-libs.sha256sum] = "2a4a416f042d051cb888282ccc68a8d096ee8f9443ea43e2ccbe3ea706ac3b66"

URI_aarch64_nodejs24-npm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-npm-11.16.0-1.24.18.0.1.el10.noarch.rpm;name=aarch64_nodejs24-npm;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-npm}"
SRC_URI[aarch64_nodejs24-npm.sha256sum] = "1ba431f8ddbb38106d1fd6307a916ebda5ab9b22554bfbb06ceccca5b59e2502"

RDEPENDS:nodejs24 = " \
 ca-certificates \
 glibc \
 nodejs24-libs \
 "
RDEPENDS:nodejs24-devel = " \
 brotli-devel \
 libuv-devel \
 nodejs-packaging \
 nodejs24 \
 nodejs24-libs \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:nodejs24-docs = " \
 nodejs24 \
 "
RDEPENDS:nodejs24-full-i18n = " \
 nodejs24 \
 "
RDEPENDS:nodejs24-libs = " \
 c-ares \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 libuv \
 openssl-libs \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:nodejs24-npm = " \
 bash \
 nodejs24 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/nodejs_engine_ rpm/virtual/nodejs_engine__ge_0.8.0"

PROVIDES:append:aarch64 = " rpm/virtual/nodejs_engine_ rpm/virtual/nodejs_engine__ge_0.8.0"
