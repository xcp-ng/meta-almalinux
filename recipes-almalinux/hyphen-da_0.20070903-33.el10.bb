# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-da"
PV = "0.20070903"
PR = "33.el10"
PACKAGES = " \
 hyphen-da \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-da-0.20070903-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c482cd9cade3f7cae5948acc795be91ac20561c6f479a58c034d54a8aae5e3f"

URI_x86_64_v2_hyphen-da = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-da-0.20070903-33.el10.noarch.rpm;name=x86_64_v2_hyphen-da;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-da}"
SRC_URI[x86_64_v2_hyphen-da.sha256sum] = "385b8f7f57270d1053c1a2c03176ac4a0dc46393329bfb23116fbbfa1c305e07"

URI_aarch64_hyphen-da = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-da-0.20070903-33.el10.noarch.rpm;name=aarch64_hyphen-da;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-da}"
SRC_URI[aarch64_hyphen-da.sha256sum] = "385b8f7f57270d1053c1a2c03176ac4a0dc46393329bfb23116fbbfa1c305e07"

RDEPENDS:hyphen-da = " \
 hyphen \
 "
