# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "speech-dispatcher"
PV = "0.11.5"
PR = "8.el10"
PACKAGES = " \
 python3-speechd \
 speech-dispatcher \
 speech-dispatcher-devel \
 speech-dispatcher-doc \
 speech-dispatcher-espeak-ng \
 speech-dispatcher-libs \
 speech-dispatcher-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/speech-dispatcher-0.11.5-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f40d8ae697f33f8e0dc70c4c8d1e96c8877e5831fda3d7ae850d5b988b26a7d"

URI_x86_64_v2_python3-speechd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-speechd-0.11.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_python3-speechd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-speechd}"
SRC_URI[x86_64_v2_python3-speechd.sha256sum] = "815ae2f4be1906a13210ad42a8f377fe7b7d434e270fac7dba818d0ef358730d"

URI_x86_64_v2_speech-dispatcher = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/speech-dispatcher-0.11.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_speech-dispatcher;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_speech-dispatcher}"
SRC_URI[x86_64_v2_speech-dispatcher.sha256sum] = "fd67de939425a662b281ca6f7adf6df3da45e5c7102fdd53013784986c21bcf5"

URI_x86_64_v2_speech-dispatcher-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/speech-dispatcher-devel-0.11.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_speech-dispatcher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_speech-dispatcher-devel}"
SRC_URI[x86_64_v2_speech-dispatcher-devel.sha256sum] = "4fc4ba028095bc3737e6bcce5cd951428ab50c41b1f9a026561eb0c8544a18e9"

URI_x86_64_v2_speech-dispatcher-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/speech-dispatcher-doc-0.11.5-8.el10.noarch.rpm;name=x86_64_v2_speech-dispatcher-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_speech-dispatcher-doc}"
SRC_URI[x86_64_v2_speech-dispatcher-doc.sha256sum] = "5a9fc92d9d28eb666a66cfb6c385d3a5c9ed44e32e8e0bac4e525c978b7d002c"

URI_x86_64_v2_speech-dispatcher-espeak-ng = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/speech-dispatcher-espeak-ng-0.11.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_speech-dispatcher-espeak-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_speech-dispatcher-espeak-ng}"
SRC_URI[x86_64_v2_speech-dispatcher-espeak-ng.sha256sum] = "5e819f00bedd3e25402a55a51b022b325ce3ce19b9fe52f07f57d619458afaa2"

URI_x86_64_v2_speech-dispatcher-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/speech-dispatcher-libs-0.11.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_speech-dispatcher-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_speech-dispatcher-libs}"
SRC_URI[x86_64_v2_speech-dispatcher-libs.sha256sum] = "6869e345daeff6257f1fea350605b31a9ab7fdb830f716d58972bddf2142512e"

URI_x86_64_v2_speech-dispatcher-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/speech-dispatcher-utils-0.11.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_speech-dispatcher-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_speech-dispatcher-utils}"
SRC_URI[x86_64_v2_speech-dispatcher-utils.sha256sum] = "210c134927af73d21f43dcc5d3de403a56435c198087c435a42cce49792e911c"

URI_aarch64_python3-speechd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-speechd-0.11.5-8.el10.aarch64.rpm;name=aarch64_python3-speechd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-speechd}"
SRC_URI[aarch64_python3-speechd.sha256sum] = "75cf0bf4982b6c98fa76d9fe251fcca52127386ac3378e81222a96441925d5e3"

URI_aarch64_speech-dispatcher = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/speech-dispatcher-0.11.5-8.el10.aarch64.rpm;name=aarch64_speech-dispatcher;unpack=0"
SRC_URI:append = " ${URI_aarch64_speech-dispatcher}"
SRC_URI[aarch64_speech-dispatcher.sha256sum] = "c8059bc89b049aa16b7c2a56f8fef6992dd0eb5bd0a851f4cd970f8e2437c7ca"

URI_aarch64_speech-dispatcher-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/speech-dispatcher-devel-0.11.5-8.el10.aarch64.rpm;name=aarch64_speech-dispatcher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_speech-dispatcher-devel}"
SRC_URI[aarch64_speech-dispatcher-devel.sha256sum] = "9d61e218035bc831b69444bdeee9a4b553fa0b6533907f13158dfd232cfac160"

URI_aarch64_speech-dispatcher-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/speech-dispatcher-doc-0.11.5-8.el10.noarch.rpm;name=aarch64_speech-dispatcher-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_speech-dispatcher-doc}"
SRC_URI[aarch64_speech-dispatcher-doc.sha256sum] = "5a9fc92d9d28eb666a66cfb6c385d3a5c9ed44e32e8e0bac4e525c978b7d002c"

URI_aarch64_speech-dispatcher-espeak-ng = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/speech-dispatcher-espeak-ng-0.11.5-8.el10.aarch64.rpm;name=aarch64_speech-dispatcher-espeak-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_speech-dispatcher-espeak-ng}"
SRC_URI[aarch64_speech-dispatcher-espeak-ng.sha256sum] = "a3a5e538fc9f30e8cd3904871c9a252965467e51a05618dcf78e4eab005a326d"

URI_aarch64_speech-dispatcher-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/speech-dispatcher-libs-0.11.5-8.el10.aarch64.rpm;name=aarch64_speech-dispatcher-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_speech-dispatcher-libs}"
SRC_URI[aarch64_speech-dispatcher-libs.sha256sum] = "cac9052ea47087d2cf15c69efb685bed6eea1cb33f73063f03271c62df42a9d1"

URI_aarch64_speech-dispatcher-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/speech-dispatcher-utils-0.11.5-8.el10.aarch64.rpm;name=aarch64_speech-dispatcher-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_speech-dispatcher-utils}"
SRC_URI[aarch64_speech-dispatcher-utils.sha256sum] = "92d641dc234821eea2604107c6a6cc9089925aba6a94a24677e48bbacebca0f6"

RDEPENDS:python3-speechd = " \
 python3 \
 "
RDEPENDS:speech-dispatcher = " \
 alsa-lib \
 bash \
 dotconf \
 glib2 \
 glibc \
 libao \
 libsndfile \
 libtool-ltdl \
 pulseaudio-libs \
 speech-dispatcher-espeak-ng \
 systemd \
 "
RDEPENDS:speech-dispatcher-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 speech-dispatcher-libs \
 "
RDEPENDS:speech-dispatcher-doc = " \
 speech-dispatcher \
 "
RDEPENDS:speech-dispatcher-espeak-ng = " \
 dotconf \
 espeak-ng \
 glib2 \
 glibc \
 libtool-ltdl \
 speech-dispatcher \
 "
RDEPENDS:speech-dispatcher-libs = " \
 glib2 \
 glibc \
 libgcc \
 libtool-ltdl \
 "
RDEPENDS:speech-dispatcher-utils = " \
 glibc \
 pulseaudio-utils \
 python3 \
 python3-speechd \
 speech-dispatcher-libs \
 "
