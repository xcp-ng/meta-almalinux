# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rancor"
PV = "0.1.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-rancor+alloc-devel \
 rust-rancor+default-devel \
 rust-rancor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rancor-0.1.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8679ebaff3c7a8a3a523d79419b44b4c622598cf60dfeb0da7d158dd23a4769"

URI_x86_64_v2_rust-rancor+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rancor+alloc-devel-0.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rancor+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rancor+alloc-devel}"
SRC_URI[x86_64_v2_rust-rancor+alloc-devel.sha256sum] = "0981a19e1c9b5c8cbd5b0c56ec235bccd5aa17b85a9b72f7547c952c2d04dfc6"

URI_x86_64_v2_rust-rancor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rancor+default-devel-0.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rancor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rancor+default-devel}"
SRC_URI[x86_64_v2_rust-rancor+default-devel.sha256sum] = "87a29972f9e4fc6a8fc6a1a10e724d8a9d62402339d9aecc12a50a35096f3eaa"

URI_x86_64_v2_rust-rancor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rancor-devel-0.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rancor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rancor-devel}"
SRC_URI[x86_64_v2_rust-rancor-devel.sha256sum] = "5157a190c39179f72263f46b03254ff895b8a287e39be79f5c3d578be2c93ca1"

URI_aarch64_rust-rancor+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rancor+alloc-devel-0.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-rancor+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rancor+alloc-devel}"
SRC_URI[aarch64_rust-rancor+alloc-devel.sha256sum] = "8ea9fa3b72e4753395a4f3756cc51caf3e13b4a0c0340f698e3d1f406fdfab6a"

URI_aarch64_rust-rancor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rancor+default-devel-0.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-rancor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rancor+default-devel}"
SRC_URI[aarch64_rust-rancor+default-devel.sha256sum] = "c5872c6ff5dcc72d19a2b004583ffd9478a0d3986d99f5e9cd2666fb64b790f2"

URI_aarch64_rust-rancor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rancor-devel-0.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-rancor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rancor-devel}"
SRC_URI[aarch64_rust-rancor-devel.sha256sum] = "19028869068b78ff2e5a874807d54283cef791f8dda51b72448343aa616fe7ad"

RDEPENDS:rust-rancor+alloc-devel = " \
 cargo \
 rust-rancor-devel \
 "
RDEPENDS:rust-rancor+default-devel = " \
 cargo \
 rust-rancor+alloc-devel \
 rust-rancor-devel \
 "
RDEPENDS:rust-rancor-devel = " \
 cargo \
 rust \
 rust-ptr_meta+derive-devel \
 rust-ptr_meta-devel \
 "
