# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-qmk-via-api"
PV = "0.8.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-qmk-via-api+default-devel \
 rust-qmk-via-api-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-qmk-via-api-0.8.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae952920608c786172de7caf0beb5d6307206c176a3f17d5d18e2bf302f4a69e"

URI_x86_64_v2_rust-qmk-via-api+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-qmk-via-api+default-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-qmk-via-api+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-qmk-via-api+default-devel}"
SRC_URI[x86_64_v2_rust-qmk-via-api+default-devel.sha256sum] = "3c80cf20fe824a43c3ed3c8e1bbb76b4866ddd9a9949fa29aa37c326fd3dcee2"

URI_x86_64_v2_rust-qmk-via-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-qmk-via-api-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-qmk-via-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-qmk-via-api-devel}"
SRC_URI[x86_64_v2_rust-qmk-via-api-devel.sha256sum] = "4a54fa61357985a51b432f742be298df5a9ce581dd9304003017a58315af3258"

URI_aarch64_rust-qmk-via-api+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-qmk-via-api+default-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-qmk-via-api+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-qmk-via-api+default-devel}"
SRC_URI[aarch64_rust-qmk-via-api+default-devel.sha256sum] = "df7c1b69c0b074852fdaa57042c5bed9f6e618381cb0846f24613b3a8f0fae44"

URI_aarch64_rust-qmk-via-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-qmk-via-api-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-qmk-via-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-qmk-via-api-devel}"
SRC_URI[aarch64_rust-qmk-via-api-devel.sha256sum] = "7af748f937422dc2004a104a9fd2ff3d297d6e4c86ab91cce6b91cb57ffa32f2"

RDEPENDS:rust-qmk-via-api+default-devel = " \
 cargo \
 rust-qmk-via-api-devel \
 "
RDEPENDS:rust-qmk-via-api-devel = " \
 cargo \
 rust-hidapi+default-devel \
 rust-itertools0.14+default-devel \
 rust-num_enum+default-devel \
 rust-strum+default-devel \
 rust-strum_macros+default-devel \
 "
