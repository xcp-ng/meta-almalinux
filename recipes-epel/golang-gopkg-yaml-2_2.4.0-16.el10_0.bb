# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-yaml-2"
PV = "2.4.0"
PR = "16.el10_0"
PACKAGES = " \
 compat-golang-gopkg-2-yaml-devel \
 golang-gopkg-yaml-2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-yaml-2-2.4.0-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98397eb115d31e447edb1e52bdfeaa0d73d1475ae93ae126b037cbd979c342c9"

URI_x86_64_v2_compat-golang-gopkg-2-yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-gopkg-2-yaml-devel-2.4.0-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-gopkg-2-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-gopkg-2-yaml-devel}"
SRC_URI[x86_64_v2_compat-golang-gopkg-2-yaml-devel.sha256sum] = "8411a415d66bcf4d5a3ec12a2d5546dc8b73e051f2ba7176e68e91b723e38c0b"

URI_x86_64_v2_golang-gopkg-yaml-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-yaml-2-devel-2.4.0-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-yaml-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gopkg-yaml-2-devel}"
SRC_URI[x86_64_v2_golang-gopkg-yaml-2-devel.sha256sum] = "f3c862060adee4b0ec56fec4a8b3c769d9cc64f8c566ce3b5d2358275fa61889"

URI_aarch64_compat-golang-gopkg-2-yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-gopkg-2-yaml-devel-2.4.0-16.el10_0.noarch.rpm;name=aarch64_compat-golang-gopkg-2-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-gopkg-2-yaml-devel}"
SRC_URI[aarch64_compat-golang-gopkg-2-yaml-devel.sha256sum] = "4a6e237044a3d37dea625cf8d30cbf3b188420d6bca5a94c933d006c15e5d45c"

URI_aarch64_golang-gopkg-yaml-2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-yaml-2-devel-2.4.0-16.el10_0.noarch.rpm;name=aarch64_golang-gopkg-yaml-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-yaml-2-devel}"
SRC_URI[aarch64_golang-gopkg-yaml-2-devel.sha256sum] = "bab465399e85d55fb1529fbb5253744c3f1d786d99cc2615553ce04371e8aaef"

RDEPENDS:compat-golang-gopkg-2-yaml-devel = " \
 go-filesystem \
 golang-gopkg-yaml-2-devel \
 "
RDEPENDS:golang-gopkg-yaml-2-devel = " \
 go-filesystem \
 "
