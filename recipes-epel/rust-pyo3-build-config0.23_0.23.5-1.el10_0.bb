# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-build-config0.23"
PV = "0.23.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyo3-build-config0.23+abi3-devel \
 rust-pyo3-build-config0.23+abi3-py310-devel \
 rust-pyo3-build-config0.23+abi3-py311-devel \
 rust-pyo3-build-config0.23+abi3-py312-devel \
 rust-pyo3-build-config0.23+abi3-py37-devel \
 rust-pyo3-build-config0.23+abi3-py38-devel \
 rust-pyo3-build-config0.23+abi3-py39-devel \
 rust-pyo3-build-config0.23+default-devel \
 rust-pyo3-build-config0.23+extension-module-devel \
 rust-pyo3-build-config0.23+resolve-config-devel \
 rust-pyo3-build-config0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-build-config0.23-0.23.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "972257bd9a6105880e64bc9a5764edaa9e8d6bb181ea5dfbc0d4aecb5972e582"

URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+abi3-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+abi3-devel.sha256sum] = "5702954714ad6d0746ef31ee3e2afc23057b1eaffe084de8682c3c1e7f2a6fe4"

URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+abi3-py310-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+abi3-py310-devel.sha256sum] = "11b6c519af60c46d401eed7a2ca765b4ee86c68a5f00223894bb9c76f5456b78"

URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+abi3-py311-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+abi3-py311-devel.sha256sum] = "676f17fe156bbfb87d3e065fc26db449238503293c33e0c466f75ad54d6a8931"

URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+abi3-py312-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+abi3-py312-devel.sha256sum] = "1f9d462634a535ad92215da5321fae279a071e258955f77a01d2473d1f4585da"

URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+abi3-py37-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+abi3-py37-devel.sha256sum] = "3144287e2e1be79cada4dea6254491855c07a289a0f74f7247ef2dc40912676c"

URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+abi3-py38-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+abi3-py38-devel.sha256sum] = "21f64e3b17403ba57abf67e52fc61e8b11ad688ac4157a263afa8d4c71777a52"

URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+abi3-py39-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+abi3-py39-devel.sha256sum] = "1d8f86fb970e385204109f90ad2658734fddde63fc5d8e6faffd0339bd652de7"

URI_x86_64_v2_rust-pyo3-build-config0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+default-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+default-devel.sha256sum] = "046b50c861241e487996b8b7687035dfd8125a9dfe64680af43c80f4fa5da6f8"

URI_x86_64_v2_rust-pyo3-build-config0.23+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+extension-module-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+extension-module-devel.sha256sum] = "779a8d38dc3480182896a06bc348ec15fd9d142f891cbdf21241235acc156d2f"

URI_x86_64_v2_rust-pyo3-build-config0.23+resolve-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+resolve-config-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+resolve-config-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+resolve-config-devel.sha256sum] = "a0faf04f3f6daface30ae62f92baa406773c6398c1c6f9b791e2d396fdf09737"

URI_x86_64_v2_rust-pyo3-build-config0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23-devel.sha256sum] = "5590788016370ffea61b24849ad7e8867370c85622e6fd47f2410ace87e5325c"

URI_aarch64_rust-pyo3-build-config0.23+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+abi3-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+abi3-devel.sha256sum] = "1d843f5ea6a95937adf472183ebec7a4e84d0456d07dcd4099562ca71c2dc55e"

URI_aarch64_rust-pyo3-build-config0.23+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+abi3-py310-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+abi3-py310-devel.sha256sum] = "1113ec0aee51b72dcfa6bd89462266ac24f658cb5f0406622cc5a0c62ebd74be"

URI_aarch64_rust-pyo3-build-config0.23+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+abi3-py311-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+abi3-py311-devel.sha256sum] = "97f4fd6ad422f3ed1fc38a5a8b590bb88d1857adaebb3a473d8290861f2a09e5"

URI_aarch64_rust-pyo3-build-config0.23+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+abi3-py312-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+abi3-py312-devel.sha256sum] = "6d8655d3aa7adac83121050fbef48d6c87d98edc4e019cfd23fc46f1c954e5cb"

URI_aarch64_rust-pyo3-build-config0.23+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+abi3-py37-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+abi3-py37-devel.sha256sum] = "77e3d4abcb09f4f9a4c370c8139f1497b12bfea767300e9b6e63813a5d8298c7"

URI_aarch64_rust-pyo3-build-config0.23+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+abi3-py38-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+abi3-py38-devel.sha256sum] = "8ef4e7311f079dc09823ced5cb859e7a34e6d45ca87583ce32653d09ae991fab"

URI_aarch64_rust-pyo3-build-config0.23+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+abi3-py39-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+abi3-py39-devel.sha256sum] = "4b6b631dc06feb1e009b3339a0869d84c8bd6103421481e3269280792425f479"

URI_aarch64_rust-pyo3-build-config0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+default-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+default-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+default-devel.sha256sum] = "8b82c0120070661c23b7ec342520bddd6afe194059ab4e19aec2ba4c0038b9c1"

URI_aarch64_rust-pyo3-build-config0.23+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+extension-module-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+extension-module-devel.sha256sum] = "00dc80916dbe72a34e97b9f4a28f4b25d148a253134f506ebda22c046abe1716"

URI_aarch64_rust-pyo3-build-config0.23+resolve-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+resolve-config-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+resolve-config-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+resolve-config-devel.sha256sum] = "3110d42035b71d91b39fda6b3cc64d484c6751bc4f41284eae6af1546b2538ee"

URI_aarch64_rust-pyo3-build-config0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23-devel.sha256sum] = "c8e6615949709c8463be1f211d4ee8c24d25898c63bedffd72368a9e1814ab96"

RDEPENDS:rust-pyo3-build-config0.23+abi3-devel = " \
 cargo \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+abi3-py310-devel = " \
 cargo \
 rust-pyo3-build-config0.23+abi3-py311-devel \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+abi3-py311-devel = " \
 cargo \
 rust-pyo3-build-config0.23+abi3-py312-devel \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+abi3-py312-devel = " \
 cargo \
 rust-pyo3-build-config0.23+abi3-devel \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+abi3-py37-devel = " \
 cargo \
 rust-pyo3-build-config0.23+abi3-py38-devel \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+abi3-py38-devel = " \
 cargo \
 rust-pyo3-build-config0.23+abi3-py39-devel \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+abi3-py39-devel = " \
 cargo \
 rust-pyo3-build-config0.23+abi3-py310-devel \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+default-devel = " \
 cargo \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+extension-module-devel = " \
 cargo \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+resolve-config-devel = " \
 cargo \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23-devel = " \
 cargo \
 python3 \
 rust \
 rust-once_cell+default-devel \
 rust-target-lexicon0.12+default-devel \
 "
