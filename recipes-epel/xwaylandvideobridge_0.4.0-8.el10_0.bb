# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xwaylandvideobridge"
PV = "0.4.0"
PR = "8.el10_0"
PACKAGES = " \
 xwaylandvideobridge \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xwaylandvideobridge-0.4.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8efe56a417eb3d3556036892be240949d604b0299855cdb4f4b1de39b7def43"

URI_x86_64_v2_xwaylandvideobridge = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xwaylandvideobridge-0.4.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xwaylandvideobridge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xwaylandvideobridge}"
SRC_URI[x86_64_v2_xwaylandvideobridge.sha256sum] = "143c662470af8e2ceca523a6b02684bce74f76913231eced416ab4da931ce395"

URI_aarch64_xwaylandvideobridge = "${EPEL_MIRROR}/aarch64/Packages/x/xwaylandvideobridge-0.4.0-8.el10_0.aarch64.rpm;name=aarch64_xwaylandvideobridge;unpack=0"
SRC_URI:append = " ${URI_aarch64_xwaylandvideobridge}"
SRC_URI[aarch64_xwaylandvideobridge.sha256sum] = "2248deff2992e9f74ac05fa0241532a268dc451c9a14436e5ea12a969fd99c22"

RDEPENDS:xwaylandvideobridge = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kpipewire \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
