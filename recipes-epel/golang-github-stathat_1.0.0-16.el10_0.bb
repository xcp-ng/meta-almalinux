# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-stathat"
PV = "1.0.0"
PR = "16.el10_0"
PACKAGES = " \
 golang-github-stathat-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-stathat-1.0.0-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf986917c574f2f472a6ad6368dd38c22b8c2d232653686455d0b2cdf67b9bfd"

URI_x86_64_v2_golang-github-stathat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-stathat-devel-1.0.0-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-stathat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-stathat-devel}"
SRC_URI[x86_64_v2_golang-github-stathat-devel.sha256sum] = "8a89eec9c2bacacd1e6a251621422653371b0c86d4b768abe9d4911955f03abc"

URI_aarch64_golang-github-stathat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-stathat-devel-1.0.0-16.el10_0.noarch.rpm;name=aarch64_golang-github-stathat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-stathat-devel}"
SRC_URI[aarch64_golang-github-stathat-devel.sha256sum] = "187cf2fdf5b33c35b8739f8517e80fa94a5c4100dee63a199e2593a8dc8e6958"

RDEPENDS:golang-github-stathat-devel = " \
 go-filesystem \
 "
