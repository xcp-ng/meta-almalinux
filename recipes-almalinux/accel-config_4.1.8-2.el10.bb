# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "accel-config"
PV = "4.1.8"
PR = "2.el10"
PACKAGES:x86_64_v2 = " \
 accel-config \
 accel-config-devel \
 accel-config-libs \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/accel-config-4.1.8-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "745c4158503d2d08e304e7f501fd5506151eab8100cc034a7ffb40ad7dfa892b"

URI_x86_64_v2_accel-config = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/accel-config-4.1.8-2.el10.x86_64_v2.rpm;name=x86_64_v2_accel-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accel-config}"
SRC_URI[x86_64_v2_accel-config.sha256sum] = "5dc64d4e0e91a26e6313328a1e6a686e58abb9727099fc32615453e969b2d7d1"

URI_x86_64_v2_accel-config-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/accel-config-devel-4.1.8-2.el10.x86_64_v2.rpm;name=x86_64_v2_accel-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accel-config-devel}"
SRC_URI[x86_64_v2_accel-config-devel.sha256sum] = "c1ad48cf4aab9468234161e493d5c701d5210fb4c9e15307a38a5745f3d136af"

URI_x86_64_v2_accel-config-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/accel-config-libs-4.1.8-2.el10.x86_64_v2.rpm;name=x86_64_v2_accel-config-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accel-config-libs}"
SRC_URI[x86_64_v2_accel-config-libs.sha256sum] = "6e1fed5da3d63c8bdfb235146c8954e569866aa8f623ab4db542bc6378c17f24"

RDEPENDS:accel-config = " \
 accel-config-libs \
 glibc \
 json-c \
 "
RDEPENDS:accel-config-devel = " \
 accel-config-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:accel-config-libs = " \
 accel-config \
 glibc \
 libuuid \
 "
