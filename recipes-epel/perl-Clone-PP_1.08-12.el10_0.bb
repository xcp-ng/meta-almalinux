# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Clone-PP"
PV = "1.08"
PR = "12.el10_0"
PACKAGES = " \
 perl-Clone-PP \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Clone-PP-1.08-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6120e1f883a608109e4af7579bfe331ef9b339fd8177aaafdfd40215fe4ea38"

URI_x86_64_v2_perl-Clone-PP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Clone-PP-1.08-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Clone-PP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Clone-PP}"
SRC_URI[x86_64_v2_perl-Clone-PP.sha256sum] = "034c2888ea6c298ed56bb612b17ef7c7c708839d111eff71049b9e07f7810605"

URI_aarch64_perl-Clone-PP = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Clone-PP-1.08-12.el10_0.noarch.rpm;name=aarch64_perl-Clone-PP;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Clone-PP}"
SRC_URI[aarch64_perl-Clone-PP.sha256sum] = "8bae2d599ea155fcdbcd1a784589b52d93bba1539054e5fc69bf9b7e7bd840fc"

RDEPENDS:perl-Clone-PP = " \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
