# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpm"
PV = "1.20.7"
PR = "48.el10_1"
PACKAGES = " \
 gpm \
 gpm-devel \
 gpm-libs \
 gpm-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gpm-1.20.7-48.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0180cf50b4eb50695ae6a84dd89dc8db2d5b24a20498dc8ef0359a49d9c97171"

URI_x86_64_v2_gpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpm-1.20.7-48.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpm}"
SRC_URI[x86_64_v2_gpm.sha256sum] = "358d7efe5c6305e7d7c1b589942ba362a881754131762d90ecb4729eb8f8fec9"

URI_x86_64_v2_gpm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpm-devel-1.20.7-48.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpm-devel}"
SRC_URI[x86_64_v2_gpm-devel.sha256sum] = "75dd4ebb5e157db76e3c2bc3977920970355d467f45c9dc48af9fbc19b1c43b2"

URI_x86_64_v2_gpm-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpm-libs-1.20.7-48.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpm-libs}"
SRC_URI[x86_64_v2_gpm-libs.sha256sum] = "97443f8172e50a75aa138875615b0504e9b8b88359f1c64d5d21f6430d562f52"

URI_x86_64_v2_gpm-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpm-static-1.20.7-48.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpm-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpm-static}"
SRC_URI[x86_64_v2_gpm-static.sha256sum] = "3b213f80d95d5ae3d980735b8cbf3efd7e4d2a3d3f4d54fe55549edfa7d4e1b3"

URI_aarch64_gpm = "${EPEL_MIRROR}/aarch64/Packages/g/gpm-1.20.7-48.el10_1.aarch64.rpm;name=aarch64_gpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpm}"
SRC_URI[aarch64_gpm.sha256sum] = "041ccf5edf2ff00063386fa675911623402493f5d68638dc890b357dc0550210"

URI_aarch64_gpm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gpm-devel-1.20.7-48.el10_1.aarch64.rpm;name=aarch64_gpm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpm-devel}"
SRC_URI[aarch64_gpm-devel.sha256sum] = "1a2c377c287895795267ebf587ac860bf7bb5522401c8966bb5c137833e61a35"

URI_aarch64_gpm-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gpm-libs-1.20.7-48.el10_1.aarch64.rpm;name=aarch64_gpm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpm-libs}"
SRC_URI[aarch64_gpm-libs.sha256sum] = "1a6f172bcb957ba38d5901e2413d9f4590a2c31d5a2592b87e4d3af2371220b4"

URI_aarch64_gpm-static = "${EPEL_MIRROR}/aarch64/Packages/g/gpm-static-1.20.7-48.el10_1.aarch64.rpm;name=aarch64_gpm-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpm-static}"
SRC_URI[aarch64_gpm-static.sha256sum] = "da087ebf191f4e86472aabb904b41be40b18c418361feaa14f40f3ecfb554cfa"

RDEPENDS:gpm = " \
 bash \
 glibc \
 gpm-libs \
 info \
 linuxconsoletools \
 "
RDEPENDS:gpm-devel = " \
 gpm \
 gpm-libs \
 "
RDEPENDS:gpm-libs = " \
 glibc \
 "
RDEPENDS:gpm-static = " \
 gpm \
 "
