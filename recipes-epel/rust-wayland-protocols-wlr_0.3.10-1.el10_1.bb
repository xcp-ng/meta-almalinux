# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-protocols-wlr"
PV = "0.3.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-wayland-protocols-wlr+client-devel \
 rust-wayland-protocols-wlr+default-devel \
 rust-wayland-protocols-wlr+server-devel \
 rust-wayland-protocols-wlr+wayland-client-devel \
 rust-wayland-protocols-wlr+wayland-server-devel \
 rust-wayland-protocols-wlr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-protocols-wlr-0.3.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0c5b766198b74abe0ae41a46cd435588016d52532637af6841efb50746dfc84"

URI_x86_64_v2_rust-wayland-protocols-wlr+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+client-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+client-devel.sha256sum] = "bd3ac2408bf2bf33bc47ae186fccdaab64261fd5990abd776eee53b65275380a"

URI_x86_64_v2_rust-wayland-protocols-wlr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+default-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+default-devel.sha256sum] = "5565ec29e3f9575059450a30ff845e84514cb07fb9ae1228130286194c7ef49b"

URI_x86_64_v2_rust-wayland-protocols-wlr+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+server-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+server-devel.sha256sum] = "382bbb28bde187b59a99db9aefddea988907cc62500d162bcc668d4075046815"

URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+wayland-client-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel.sha256sum] = "a3545fd338f17d6f70a8846edd8043cf92a091bda30da1465d448fe5b07ffeda"

URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+wayland-server-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel.sha256sum] = "ec8b4663fd2f2e73d224c7fab1d08732eead610f514a523d0b4ac85069583626"

URI_x86_64_v2_rust-wayland-protocols-wlr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr-devel.sha256sum] = "6dc14565e956219542ac62f2f90c0c14bf9aa78d7b90d3867d2ad75f6a629889"

URI_aarch64_rust-wayland-protocols-wlr+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+client-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+client-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+client-devel.sha256sum] = "8d9fc42283861ada12020d180511b554bd11f44e047a33d23480fc382af72f0e"

URI_aarch64_rust-wayland-protocols-wlr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+default-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+default-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+default-devel.sha256sum] = "de9261eef557d4f721204943bda2ec4f390c4e86428602922665197887470d58"

URI_aarch64_rust-wayland-protocols-wlr+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+server-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+server-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+server-devel.sha256sum] = "7e837a5b1d96fbcaa406a777bab144df02f6b95747f2f773e1fcb75015bdd822"

URI_aarch64_rust-wayland-protocols-wlr+wayland-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+wayland-client-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+wayland-client-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+wayland-client-devel.sha256sum] = "5e0666da436fb011c35d21aa1cff00e17530e934e5bf311ac3faa8ec8abfd964"

URI_aarch64_rust-wayland-protocols-wlr+wayland-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+wayland-server-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+wayland-server-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+wayland-server-devel.sha256sum] = "f4f973324c869a9f5e3c0e0ca739f14ddc07e0a182bb629d305d6e63abb6ed24"

URI_aarch64_rust-wayland-protocols-wlr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr-devel.sha256sum] = "41981ecebd6a99251ae169f3b07140dcb4fef768a363014c0c6e6ceee5602d32"

RDEPENDS:rust-wayland-protocols-wlr+client-devel = " \
 cargo \
 rust-wayland-protocols+client-devel \
 rust-wayland-protocols-wlr+wayland-client-devel \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+default-devel = " \
 cargo \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+server-devel = " \
 cargo \
 rust-wayland-protocols+server-devel \
 rust-wayland-protocols-wlr+wayland-server-devel \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+wayland-client-devel = " \
 cargo \
 rust-wayland-client+default-devel \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+wayland-server-devel = " \
 cargo \
 rust-wayland-protocols-wlr-devel \
 rust-wayland-server+default-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-protocols+default-devel \
 rust-wayland-scanner+default-devel \
 "
