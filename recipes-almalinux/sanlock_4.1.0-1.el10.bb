# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sanlock"
PV = "4.1.0"
PR = "1.el10"
PACKAGES = " \
 sanlock \
 sanlock-devel \
 sanlock-lib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sanlock-4.1.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f403fe4ef52ad3b164e58d8998f65b097c422de9334512e75a9b636bc102a2fe"

URI_x86_64_v2_sanlock = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sanlock-4.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sanlock}"
SRC_URI[x86_64_v2_sanlock.sha256sum] = "1535cd2f235eb970d3362c4e82504b75c467520a49e4ffa5d3d736ca37fb3244"

URI_x86_64_v2_sanlock-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sanlock-devel-4.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sanlock-devel}"
SRC_URI[x86_64_v2_sanlock-devel.sha256sum] = "3e7c0851f23ee75331b25e852826ea67c4de0ec2d87cfef21a604691c285b276"

URI_x86_64_v2_sanlock-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sanlock-lib-4.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sanlock-lib}"
SRC_URI[x86_64_v2_sanlock-lib.sha256sum] = "1a4dae5b3b2307ba289f9869726ee866aab345b11c37e7a8b5abd0cc8700d0e5"

URI_aarch64_sanlock = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sanlock-4.1.0-1.el10.aarch64.rpm;name=aarch64_sanlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_sanlock}"
SRC_URI[aarch64_sanlock.sha256sum] = "281922fa944768a1efa7a9c86bbe5d19e8e43728ec69c62856db3ede64efb5df"

URI_aarch64_sanlock-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sanlock-devel-4.1.0-1.el10.aarch64.rpm;name=aarch64_sanlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sanlock-devel}"
SRC_URI[aarch64_sanlock-devel.sha256sum] = "36b8959f53bcabcf2c3f031124e8234a002d9aa00f7001f73a9b4381aab91b1c"

URI_aarch64_sanlock-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sanlock-lib-4.1.0-1.el10.aarch64.rpm;name=aarch64_sanlock-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_sanlock-lib}"
SRC_URI[aarch64_sanlock-lib.sha256sum] = "793dc0f43615dc2b7b443086e9103b44853f1a081b57cdf2bbc8b531ba19fa9e"

RDEPENDS:sanlock = " \
 bash \
 glibc \
 libaio \
 libblkid \
 libuuid \
 sanlock-lib \
 systemd \
 "
RDEPENDS:sanlock-devel = " \
 pkgconf-pkg-config \
 sanlock-lib \
 "
RDEPENDS:sanlock-lib = " \
 glibc \
 libaio \
 libblkid \
 "
