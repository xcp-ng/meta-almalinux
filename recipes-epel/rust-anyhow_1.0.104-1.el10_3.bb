# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anyhow"
PV = "1.0.104"
PR = "1.el10_3"
PACKAGES = " \
 rust-anyhow+backtrace-devel \
 rust-anyhow+default-devel \
 rust-anyhow+std-devel \
 rust-anyhow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anyhow-1.0.104-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b581bda3e616f1e742b8396e6402a976d91ef2ea50777b8e463e9ba58cc760f7"

URI_x86_64_v2_rust-anyhow+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow+backtrace-devel-1.0.104-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow+backtrace-devel}"
SRC_URI[x86_64_v2_rust-anyhow+backtrace-devel.sha256sum] = "91bc97b5988a09f9a6c617edec622ac995113cdbc40a092e3d9eec5967f35878"

URI_x86_64_v2_rust-anyhow+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow+default-devel-1.0.104-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow+default-devel}"
SRC_URI[x86_64_v2_rust-anyhow+default-devel.sha256sum] = "117ad3a43fe8e080f4e2aa00244e83a85bcd772fd17193b0c5ab0e33bcabdd51"

URI_x86_64_v2_rust-anyhow+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow+std-devel-1.0.104-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow+std-devel}"
SRC_URI[x86_64_v2_rust-anyhow+std-devel.sha256sum] = "9e959c589bf43e317b3d624837df627c2c188f17c601c560a658ba0bd16eb124"

URI_x86_64_v2_rust-anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow-devel-1.0.104-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow-devel}"
SRC_URI[x86_64_v2_rust-anyhow-devel.sha256sum] = "dbee62453f05d6457ea0ac3946f4510b48fcc4b78472c2a80a87ee698db0071d"

URI_aarch64_rust-anyhow+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow+backtrace-devel-1.0.104-1.el10_3.noarch.rpm;name=aarch64_rust-anyhow+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow+backtrace-devel}"
SRC_URI[aarch64_rust-anyhow+backtrace-devel.sha256sum] = "66885f9a9be0d71adf9a579c3c0baf4e06e5c1d04b5cfb9ebd269dc290e85993"

URI_aarch64_rust-anyhow+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow+default-devel-1.0.104-1.el10_3.noarch.rpm;name=aarch64_rust-anyhow+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow+default-devel}"
SRC_URI[aarch64_rust-anyhow+default-devel.sha256sum] = "a46fcf34694f756155468535ac3de297e1d1cecb0d71a4810d199c8cf22d4a0a"

URI_aarch64_rust-anyhow+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow+std-devel-1.0.104-1.el10_3.noarch.rpm;name=aarch64_rust-anyhow+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow+std-devel}"
SRC_URI[aarch64_rust-anyhow+std-devel.sha256sum] = "2bcc73fa3f9269a0252ad8d22b442a3ee0bdf91a20737ae29adfa02a058b32fe"

URI_aarch64_rust-anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow-devel-1.0.104-1.el10_3.noarch.rpm;name=aarch64_rust-anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow-devel}"
SRC_URI[aarch64_rust-anyhow-devel.sha256sum] = "927849325494ecc599a78ee8afa2e8285398c9dff23a21bcbaba83b8ee27d2b6"

RDEPENDS:rust-anyhow+backtrace-devel = " \
 cargo \
 rust-anyhow-devel \
 "
RDEPENDS:rust-anyhow+default-devel = " \
 cargo \
 rust-anyhow+std-devel \
 rust-anyhow-devel \
 "
RDEPENDS:rust-anyhow+std-devel = " \
 cargo \
 rust-anyhow-devel \
 "
RDEPENDS:rust-anyhow-devel = " \
 cargo \
 rust \
 "
