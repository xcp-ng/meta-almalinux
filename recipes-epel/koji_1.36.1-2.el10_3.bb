# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "koji"
PV = "1.36.1"
PR = "2.el10_3"
PACKAGES = " \
 koji \
 koji-builder \
 koji-builder-plugins \
 koji-hub \
 koji-hub-plugins \
 koji-utils \
 koji-vm \
 koji-web \
 python3-koji \
 python3-koji-cli-plugins \
 python3-koji-hub \
 python3-koji-hub-plugins \
 python3-koji-web \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/koji-1.36.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d26b7f0f48d94b17d6d7d8e47040b4d8cd3f495bef0df59dda25e89361fbf8c"

URI_x86_64_v2_koji = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-1.36.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_koji;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji}"
SRC_URI[x86_64_v2_koji.sha256sum] = "ac1652bd51c29d8cacfde2b007ca14d2e6cf30d412c5c5f40e271f1221f47338"

URI_x86_64_v2_koji-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-builder-1.36.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_koji-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-builder}"
SRC_URI[x86_64_v2_koji-builder.sha256sum] = "55e01e1bff2d961bc81fc993c8d53b6eabb4114f996ce69f812223a86746ab64"

URI_x86_64_v2_koji-builder-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-builder-plugins-1.36.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_koji-builder-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-builder-plugins}"
SRC_URI[x86_64_v2_koji-builder-plugins.sha256sum] = "20f9fed75f2361b0ba5392aa20a6646b4eae238fce6b8667471f1a02abfe038d"

URI_x86_64_v2_koji-hub = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-hub-1.36.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_koji-hub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-hub}"
SRC_URI[x86_64_v2_koji-hub.sha256sum] = "c53c51ac534e4509e90ad6c697c8f969e4e0d5e64d334c91c5b1b69039ceccef"

URI_x86_64_v2_koji-hub-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-hub-plugins-1.36.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-hub-plugins}"
SRC_URI[x86_64_v2_koji-hub-plugins.sha256sum] = "a2f18533b3eca92b9288aeb581098c4f94fd4db1bfbbc2d3afe74ec89a57e95d"

URI_x86_64_v2_koji-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-utils-1.36.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_koji-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-utils}"
SRC_URI[x86_64_v2_koji-utils.sha256sum] = "80c82633414741dd6c40b7ad3af294b3966981fc349ab92fc23eb492267788ef"

URI_x86_64_v2_koji-vm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-vm-1.36.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_koji-vm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-vm}"
SRC_URI[x86_64_v2_koji-vm.sha256sum] = "57b290fdea8d7e97517c8c6baf67c7eb68d2869546f8327c1c19cffa418a76aa"

URI_x86_64_v2_koji-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-web-1.36.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_koji-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-web}"
SRC_URI[x86_64_v2_koji-web.sha256sum] = "58ea90c25f6f38919f59b0f0c4d6a071042ebc29df174a6cc49cc1d045e3d9f4"

URI_x86_64_v2_python3-koji = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-1.36.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji}"
SRC_URI[x86_64_v2_python3-koji.sha256sum] = "f57ccdb9ab5f59929e4d5851df0a023609bfb43a9fb48eba03cd188c8044327a"

URI_x86_64_v2_python3-koji-cli-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-cli-plugins-1.36.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-cli-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-cli-plugins}"
SRC_URI[x86_64_v2_python3-koji-cli-plugins.sha256sum] = "317d101e20c784cdd30488a19a927123c949066a069dbfd97b3c63d9a39efe64"

URI_x86_64_v2_python3-koji-hub = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-hub-1.36.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-hub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-hub}"
SRC_URI[x86_64_v2_python3-koji-hub.sha256sum] = "38006ab62f1f97cc6b353520ff986977d3b0231dcc3c7016cc8a2ccf0ca86fd7"

URI_x86_64_v2_python3-koji-hub-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-hub-plugins-1.36.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-hub-plugins}"
SRC_URI[x86_64_v2_python3-koji-hub-plugins.sha256sum] = "7033f8436d01922b2edd43a06e78b147de8b031351bb3f8ac1b549c16273442f"

URI_x86_64_v2_python3-koji-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-web-1.36.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-web}"
SRC_URI[x86_64_v2_python3-koji-web.sha256sum] = "22f605070252e8b99c30fa27d5dca267bd7c5d7987db3017de54425bd4813817"

URI_aarch64_koji = "${EPEL_MIRROR}/aarch64/Packages/k/koji-1.36.1-2.el10_3.noarch.rpm;name=aarch64_koji;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji}"
SRC_URI[aarch64_koji.sha256sum] = "3564a1e8a7d02b593e949071d8cd1290fd7b8039d83732be0fb741ec242a64f2"

URI_aarch64_koji-builder = "${EPEL_MIRROR}/aarch64/Packages/k/koji-builder-1.36.1-2.el10_3.noarch.rpm;name=aarch64_koji-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-builder}"
SRC_URI[aarch64_koji-builder.sha256sum] = "ce32f15b1a2ad27c8d819524b235bae720ba4377d1f09950be619ac5496baaaf"

URI_aarch64_koji-builder-plugins = "${EPEL_MIRROR}/aarch64/Packages/k/koji-builder-plugins-1.36.1-2.el10_3.noarch.rpm;name=aarch64_koji-builder-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-builder-plugins}"
SRC_URI[aarch64_koji-builder-plugins.sha256sum] = "03fdf2f231511b8e83fd5226a3ec43ca3818fc0f200af1fcd6f8c46d19589a4a"

URI_aarch64_koji-hub = "${EPEL_MIRROR}/aarch64/Packages/k/koji-hub-1.36.1-2.el10_3.noarch.rpm;name=aarch64_koji-hub;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-hub}"
SRC_URI[aarch64_koji-hub.sha256sum] = "69d3bb7566c3e2cb9144a21a921666879bacedc5a5ba790148ede22520dce238"

URI_aarch64_koji-hub-plugins = "${EPEL_MIRROR}/aarch64/Packages/k/koji-hub-plugins-1.36.1-2.el10_3.noarch.rpm;name=aarch64_koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-hub-plugins}"
SRC_URI[aarch64_koji-hub-plugins.sha256sum] = "820de1fe9964abb7d06b379b70903a7bc7d0c1d2476fad5156b658374f32a4a3"

URI_aarch64_koji-utils = "${EPEL_MIRROR}/aarch64/Packages/k/koji-utils-1.36.1-2.el10_3.noarch.rpm;name=aarch64_koji-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-utils}"
SRC_URI[aarch64_koji-utils.sha256sum] = "168c029b7b5512532ba2990a20686bf5315f4ceda33613604e34cd9554099339"

URI_aarch64_koji-vm = "${EPEL_MIRROR}/aarch64/Packages/k/koji-vm-1.36.1-2.el10_3.noarch.rpm;name=aarch64_koji-vm;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-vm}"
SRC_URI[aarch64_koji-vm.sha256sum] = "1705f2bdfb46a81ef613bb4e145bb5f9b43eaaa51db65ffe36bc82232f325d08"

URI_aarch64_koji-web = "${EPEL_MIRROR}/aarch64/Packages/k/koji-web-1.36.1-2.el10_3.noarch.rpm;name=aarch64_koji-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-web}"
SRC_URI[aarch64_koji-web.sha256sum] = "f58b12b0b25893adb3bded2e0f86ee54794ed97597b2c067b93d7f2fa7676ee0"

URI_aarch64_python3-koji = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-1.36.1-2.el10_3.noarch.rpm;name=aarch64_python3-koji;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji}"
SRC_URI[aarch64_python3-koji.sha256sum] = "38d7f1342151d9363edc7b507991e27bd29653a71734d8bff39c7dfad96dbcc3"

URI_aarch64_python3-koji-cli-plugins = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-cli-plugins-1.36.1-2.el10_3.noarch.rpm;name=aarch64_python3-koji-cli-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-cli-plugins}"
SRC_URI[aarch64_python3-koji-cli-plugins.sha256sum] = "675689aedce12ada5d637fd36287081c17c9c6d6c79a81558d837715cf92ea9f"

URI_aarch64_python3-koji-hub = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-hub-1.36.1-2.el10_3.noarch.rpm;name=aarch64_python3-koji-hub;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-hub}"
SRC_URI[aarch64_python3-koji-hub.sha256sum] = "1f754b77e0e9594a179ae2d8777f8e9abe115d70427e5ded4a5d5e92fa8f9671"

URI_aarch64_python3-koji-hub-plugins = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-hub-plugins-1.36.1-2.el10_3.noarch.rpm;name=aarch64_python3-koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-hub-plugins}"
SRC_URI[aarch64_python3-koji-hub-plugins.sha256sum] = "67c98ef2094bb035417dc25eee91b22578a01b154e9c755880af4ec74c255ce1"

URI_aarch64_python3-koji-web = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-web-1.36.1-2.el10_3.noarch.rpm;name=aarch64_python3-koji-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-web}"
SRC_URI[aarch64_python3-koji-web.sha256sum] = "bba8d8e4a1da9bc60e9eb27f230694dcdc81a3c3e97047e7ead34f42c6ef294d"

RDEPENDS:koji = " \
 python3 \
 python3-koji \
 python3-libcomps \
 "
RDEPENDS:koji-builder = " \
 bash \
 createrepo_c \
 git-core \
 mock \
 python3 \
 python3-cheetah \
 python3-koji \
 python3-librepo \
 python3-multilib \
 python3-pycdio \
 squashfs-tools \
 subversion \
 systemd \
 "
RDEPENDS:koji-builder-plugins = " \
 koji \
 koji-builder \
 "
RDEPENDS:koji-hub = " \
 koji \
 python3 \
 python3-koji-hub \
 "
RDEPENDS:koji-hub-plugins = " \
 python3-koji-hub-plugins \
 "
RDEPENDS:koji-utils = " \
 bash \
 koji \
 python3 \
 python3-psycopg2 \
 systemd \
 "
RDEPENDS:koji-vm = " \
 bash \
 koji \
 python3 \
 python3-libvirt \
 python3-libxml2 \
 qemu-img \
 systemd \
 virt-install \
 "
RDEPENDS:koji-web = " \
 koji \
 python3-koji-web \
 "
RDEPENDS:python3-koji = " \
 python3 \
 python3-dateutil \
 python3-defusedxml \
 python3-requests \
 python3-requests-gssapi \
 python3-rpm \
 python3-six \
 "
RDEPENDS:python3-koji-cli-plugins = " \
 python3 \
 python3-koji \
 "
RDEPENDS:python3-koji-hub = " \
 httpd \
 mod_auth_gssapi \
 python3 \
 python3-koji \
 python3-mod_wsgi \
 python3-psycopg2 \
 "
RDEPENDS:python3-koji-hub-plugins = " \
 cpio \
 python3-koji-hub \
 python3-qpid-proton \
 "
RDEPENDS:python3-koji-web = " \
 httpd \
 mod_auth_gssapi \
 python3-cheetah \
 python3-koji \
 python3-mod_wsgi \
 python3-psycopg2 \
 "
