# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libraqm"
PV = "0.10.1"
PR = "1.el10_0"
PACKAGES = " \
 libraqm \
 libraqm-devel \
 libraqm-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libraqm-0.10.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6882fa431f77093bdf213a7943820dd7ff96daaf4441631604efa04a3e151f68"

URI_x86_64_v2_libraqm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libraqm-0.10.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libraqm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libraqm}"
SRC_URI[x86_64_v2_libraqm.sha256sum] = "9086294111123e028dc481cc887eaa4188a34aa9f985e615588f0241183171d4"

URI_x86_64_v2_libraqm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libraqm-devel-0.10.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libraqm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libraqm-devel}"
SRC_URI[x86_64_v2_libraqm-devel.sha256sum] = "d7f307a9b929d22b4c935d65256c2a4505c0cc514460adbd7901457b754805e0"

URI_x86_64_v2_libraqm-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libraqm-docs-0.10.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libraqm-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libraqm-docs}"
SRC_URI[x86_64_v2_libraqm-docs.sha256sum] = "1c5952f8eeaf80b38c1921336db8ad1f2f556a75498ae25cba70c4a12cf53934"

URI_aarch64_libraqm = "${EPEL_MIRROR}/aarch64/Packages/l/libraqm-0.10.1-1.el10_0.aarch64.rpm;name=aarch64_libraqm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libraqm}"
SRC_URI[aarch64_libraqm.sha256sum] = "6c773868a45487932470d48ff21d616bfb87ed537c4fe649275c4a557a8e8879"

URI_aarch64_libraqm-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libraqm-devel-0.10.1-1.el10_0.aarch64.rpm;name=aarch64_libraqm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libraqm-devel}"
SRC_URI[aarch64_libraqm-devel.sha256sum] = "51eb4225814b6e3b04a7bd3d3e1a99873c890f10aa3f9644c207779cac848520"

URI_aarch64_libraqm-docs = "${EPEL_MIRROR}/aarch64/Packages/l/libraqm-docs-0.10.1-1.el10_0.noarch.rpm;name=aarch64_libraqm-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libraqm-docs}"
SRC_URI[aarch64_libraqm-docs.sha256sum] = "baa4e200b61128482260d0719782c93a69484e3166bd502779b0e0490df48a00"

RDEPENDS:libraqm = " \
 freetype \
 fribidi \
 glibc \
 harfbuzz \
 "
RDEPENDS:libraqm-devel = " \
 freetype-devel \
 fribidi-devel \
 harfbuzz-devel \
 libraqm \
 pkgconf-pkg-config \
 "
RDEPENDS:libraqm-docs = " \
 "
