# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-thunderbolt"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 plasma-thunderbolt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-thunderbolt-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9dde3cf4b6bd49071063fe78e1cc7e5dedfa1d4e0433891331c77e0f90bac503"

URI_x86_64_v2_plasma-thunderbolt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-thunderbolt-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-thunderbolt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-thunderbolt}"
SRC_URI[x86_64_v2_plasma-thunderbolt.sha256sum] = "30b99b38252c15c0f776ac36f5aac722db2ef9992a82c6d0c118205a5e421f61"

URI_aarch64_plasma-thunderbolt = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-thunderbolt-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-thunderbolt;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-thunderbolt}"
SRC_URI[aarch64_plasma-thunderbolt.sha256sum] = "1c596c2437cdc2ff9d78d7468b4302af8d955ed3ddabc92325df7678bafe7f6b"

RDEPENDS:plasma-thunderbolt = " \
 bolt \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knotifications \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
