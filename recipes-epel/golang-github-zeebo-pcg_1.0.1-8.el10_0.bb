# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-zeebo-pcg"
PV = "1.0.1"
PR = "8.el10_0"
PACKAGES = " \
 golang-github-zeebo-pcg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-zeebo-pcg-1.0.1-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a95c693c7e9b520c5b527b69ba547cbe9130dc183b0a1e69e44d1f0d958a28b9"

URI_x86_64_v2_golang-github-zeebo-pcg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-zeebo-pcg-devel-1.0.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-zeebo-pcg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-zeebo-pcg-devel}"
SRC_URI[x86_64_v2_golang-github-zeebo-pcg-devel.sha256sum] = "ff73fd09d95de7dc5eb4079ff0206f4891ec80ff4906b015f5f532b6feb0ff8e"

URI_aarch64_golang-github-zeebo-pcg-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-zeebo-pcg-devel-1.0.1-8.el10_0.noarch.rpm;name=aarch64_golang-github-zeebo-pcg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-zeebo-pcg-devel}"
SRC_URI[aarch64_golang-github-zeebo-pcg-devel.sha256sum] = "62fee44d3d07f867624b47b3ea4dba30105dba2d5f3ddf09ae4968be7158dd99"

RDEPENDS:golang-github-zeebo-pcg-devel = " \
 go-filesystem \
 "
