# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Email-MIME"
PV = "1.954"
PR = "1.el10_0"
PACKAGES = " \
 perl-Email-MIME \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Email-MIME-1.954-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e661911bfbc0557ceb7c78f52d8b1d3e477a2e69f9bdb31008ff4dd9b1a78d1"

URI_x86_64_v2_perl-Email-MIME = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Email-MIME-1.954-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Email-MIME;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Email-MIME}"
SRC_URI[x86_64_v2_perl-Email-MIME.sha256sum] = "ff4ae21689cc2dc5d9a885d9d6056437bddf209de06f3f74e71c851a083e55fb"

URI_aarch64_perl-Email-MIME = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Email-MIME-1.954-1.el10_0.noarch.rpm;name=aarch64_perl-Email-MIME;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Email-MIME}"
SRC_URI[aarch64_perl-Email-MIME.sha256sum] = "292a12495c9a172bdcbd6cfa39c716aa1b601c0f945f70f26cabcccd9ab1b230"

RDEPENDS:perl-Email-MIME = " \
 perl-Carp \
 perl-Email-Address-XS \
 perl-Email-MIME \
 perl-Email-MIME-ContentType \
 perl-Email-MIME-Encodings \
 perl-Email-MessageID \
 perl-Email-Simple \
 perl-Encode \
 perl-MIME-Base64 \
 perl-MIME-Types \
 perl-Module-Runtime \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-parent \
 "
