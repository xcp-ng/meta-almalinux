# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-render"
PV = "0.9.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-below-render+default-devel \
 rust-below-render-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-render-0.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5dd97074a3bb6480015ed9d12ac0bffae275f42f9a548ad9606686d07c05ba83"

URI_x86_64_v2_rust-below-render+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-render+default-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-render+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-render+default-devel}"
SRC_URI[x86_64_v2_rust-below-render+default-devel.sha256sum] = "963b21133efa236283e05301cae09937e0003f19cf3e40c38c7d16d575fe67b4"

URI_x86_64_v2_rust-below-render-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-render-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-render-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-render-devel}"
SRC_URI[x86_64_v2_rust-below-render-devel.sha256sum] = "0b75dc756ab958dfd4f0dad085031f8828792512fe62da4b45290ef95f7feb21"

URI_aarch64_rust-below-render+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-render+default-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below-render+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-render+default-devel}"
SRC_URI[aarch64_rust-below-render+default-devel.sha256sum] = "391be83b02d40d08ffd662e587639e8352c239c6143ea2563c7d7d0440c969f5"

URI_aarch64_rust-below-render-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-render-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below-render-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-render-devel}"
SRC_URI[aarch64_rust-below-render-devel.sha256sum] = "fefa0d0e21bafc011f27ed78a357c1e6e148f1e76c0f65780b448830091acdf7"

RDEPENDS:rust-below-render+default-devel = " \
 cargo \
 rust-below-render-devel \
 "
RDEPENDS:rust-below-render-devel = " \
 cargo \
 rust-below-common+default-devel \
 rust-below-model+default-devel \
 "
