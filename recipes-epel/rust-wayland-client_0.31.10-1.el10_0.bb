# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-client"
PV = "0.31.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-wayland-client+default-devel \
 rust-wayland-client+log-devel \
 rust-wayland-client-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-client-0.31.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01f7b693a7dee861a9900d8b1429452d580478968ea6129ee32ccb09bd5d7699"

URI_x86_64_v2_rust-wayland-client+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+default-devel-0.31.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-client+default-devel.sha256sum] = "480ac1080b35df34f75a3fb9127357ebb0cd54b4a599c143e3983c9e0889a3fb"

URI_x86_64_v2_rust-wayland-client+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+log-devel-0.31.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client+log-devel}"
SRC_URI[x86_64_v2_rust-wayland-client+log-devel.sha256sum] = "0b93afba7974fa6e0eaf469f3fc0029ddd169fe4b0c2b6b541a85ae22c679ce0"

URI_x86_64_v2_rust-wayland-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client-devel-0.31.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client-devel}"
SRC_URI[x86_64_v2_rust-wayland-client-devel.sha256sum] = "0e4d58a4400a9f32983b69e35da723abc8ae94261102cf06eeb379a527fc5d17"

URI_aarch64_rust-wayland-client+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+default-devel-0.31.10-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-client+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client+default-devel}"
SRC_URI[aarch64_rust-wayland-client+default-devel.sha256sum] = "bceb1b7e640fdcc18e44a930def119e815f89924b20b3d3e953993259005e8dd"

URI_aarch64_rust-wayland-client+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+log-devel-0.31.10-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-client+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client+log-devel}"
SRC_URI[aarch64_rust-wayland-client+log-devel.sha256sum] = "2bf9067dfa251d6fddccc7bb109104081363412d39539da663aac916589cd1e5"

URI_aarch64_rust-wayland-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client-devel-0.31.10-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client-devel}"
SRC_URI[aarch64_rust-wayland-client-devel.sha256sum] = "d3c327f909d9e7257bb847c0b5ba97519326ed9a63636cc213359a6683aac330"

RDEPENDS:rust-wayland-client+default-devel = " \
 cargo \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
