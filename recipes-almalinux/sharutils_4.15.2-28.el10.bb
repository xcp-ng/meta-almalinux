# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sharutils"
PV = "4.15.2"
PR = "28.el10"
PACKAGES = " \
 sharutils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/sharutils-4.15.2-28.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "632808084d78412b6e39cc5bc3e485d6eb016a22c7518d6eb8195f5e98172f45"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sharutils-4.15.2-28.el10.x86_64_v2.rpm;name=x86_64_v2_sharutils;unpack=0"
SRC_URI[x86_64_v2_sharutils.sha256sum] = "7f77022575897a2b7ab27bfc96358cfc2e646187cf641321fcddeca2b5f4170d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sharutils-4.15.2-28.el10.aarch64.rpm;name=aarch64_sharutils;unpack=0"
SRC_URI[aarch64_sharutils.sha256sum] = "ae053a251209f99ac1a4a0b59a6b4efc11d42c22b50dd6c2de85186e1c0aaab5"

RDEPENDS:sharutils = " \
 glibc \
 "
