# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "otf2"
PV = "3.1.1"
PR = "1.el10_1"
PACKAGES = " \
 otf2 \
 otf2-devel \
 otf2-doc \
 python3-otf2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/otf2-3.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9d8987a30510a06352f4e0aa0880c4897e548e056494d500136e99a04d9f048"

URI_x86_64_v2_otf2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/otf2-3.1.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_otf2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_otf2}"
SRC_URI[x86_64_v2_otf2.sha256sum] = "ddff1de1dedc32022ebeebcc80c5f55e480d47318e1217179f4e255bac36b377"

URI_x86_64_v2_otf2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/otf2-devel-3.1.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_otf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_otf2-devel}"
SRC_URI[x86_64_v2_otf2-devel.sha256sum] = "9d3171ed29cdc4e8a00e9a8b1381bcc29e55192be6697b00e682f7f8a32b0b5f"

URI_x86_64_v2_otf2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/otf2-doc-3.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_otf2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_otf2-doc}"
SRC_URI[x86_64_v2_otf2-doc.sha256sum] = "5364ee5e0dec38ed51d2f9384f6d2307bbe7d27e2555173433503ab5f326f1cd"

URI_x86_64_v2_python3-otf2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-otf2-3.1.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-otf2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-otf2}"
SRC_URI[x86_64_v2_python3-otf2.sha256sum] = "611dd3a454be13ed6acc566fbdd94642755394d1f482e90295797a3a737e3515"

URI_aarch64_otf2 = "${EPEL_MIRROR}/aarch64/Packages/o/otf2-3.1.1-1.el10_1.aarch64.rpm;name=aarch64_otf2;unpack=0"
SRC_URI:append = " ${URI_aarch64_otf2}"
SRC_URI[aarch64_otf2.sha256sum] = "08d2974ca3ad37cabfc4b5d5c825853c0d83f97b10082aece48356c6cf2f8f17"

URI_aarch64_otf2-devel = "${EPEL_MIRROR}/aarch64/Packages/o/otf2-devel-3.1.1-1.el10_1.aarch64.rpm;name=aarch64_otf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_otf2-devel}"
SRC_URI[aarch64_otf2-devel.sha256sum] = "a0ce2b9bb5fa1ef74997d98e00d10bfb2af264cc5ca813dad7986de2a9b9df95"

URI_aarch64_otf2-doc = "${EPEL_MIRROR}/aarch64/Packages/o/otf2-doc-3.1.1-1.el10_1.noarch.rpm;name=aarch64_otf2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_otf2-doc}"
SRC_URI[aarch64_otf2-doc.sha256sum] = "ed9b5a67f46f645d5f4929ffc663383b50f4d0210892e4bdc95179045fe83efa"

URI_aarch64_python3-otf2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-otf2-3.1.1-1.el10_1.aarch64.rpm;name=aarch64_python3-otf2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-otf2}"
SRC_URI[aarch64_python3-otf2.sha256sum] = "e70377d59652b10925cd4826a93ac465cb1a9ae077dddde85beef2fb15bf970c"

RDEPENDS:otf2 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:otf2-devel = " \
 glibc \
 libgcc \
 libstdc++ \
 otf2 \
 pkgconf-pkg-config \
 "
RDEPENDS:otf2-doc = " \
 "
RDEPENDS:python3-otf2 = " \
 glibc \
 otf2 \
 python3 \
 python3-jinja2 \
 python3-six \
 "
