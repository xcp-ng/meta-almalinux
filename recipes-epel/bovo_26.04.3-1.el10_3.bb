# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bovo"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 bovo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bovo-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55f167fefe909693415b5f7e3d30e4adc0acf875185c2ea09e77b6e9e2ac2485"

URI_x86_64_v2_bovo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bovo-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bovo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bovo}"
SRC_URI[x86_64_v2_bovo.sha256sum] = "384e6fa00e3be96dc9ce391103b43b070834e8106d1079faf36be1acce98470e"

URI_aarch64_bovo = "${EPEL_MIRROR}/aarch64/Packages/b/bovo-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_bovo;unpack=0"
SRC_URI:append = " ${URI_aarch64_bovo}"
SRC_URI[aarch64_bovo.sha256sum] = "b32af52a8637661dcbf4b7685fa4ff936c7b15ea30d0b737ef8862f9229e261d"

RDEPENDS:bovo = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
