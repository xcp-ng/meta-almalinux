# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-kiosk"
PV = "49.0"
PR = "1.el10"
PACKAGES = " \
 gnome-kiosk \
 gnome-kiosk-script-session \
 gnome-kiosk-search-appliance \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-kiosk-49.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77091eacf19863308e9017dbd727ac7b6c29081932725242cb45f9d8d3147f5d"

URI_x86_64_v2_gnome-kiosk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-kiosk-49.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-kiosk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-kiosk}"
SRC_URI[x86_64_v2_gnome-kiosk.sha256sum] = "fbfd58536f60a16a1e81b9e3e183f33956d66594e5d147d8629eecd8509f0094"
RPROVIDES:gnome-kiosk:x86_64_v2 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_x86_64_v2_gnome-kiosk-script-session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-kiosk-script-session-49.0-1.el10.noarch.rpm;name=x86_64_v2_gnome-kiosk-script-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-kiosk-script-session}"
SRC_URI[x86_64_v2_gnome-kiosk-script-session.sha256sum] = "fce44d0f2e5120c739615b82cb0f5560f9f0a303dda40dbf5ebce9e164ce78ee"

URI_x86_64_v2_gnome-kiosk-search-appliance = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-kiosk-search-appliance-49.0-1.el10.noarch.rpm;name=x86_64_v2_gnome-kiosk-search-appliance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-kiosk-search-appliance}"
SRC_URI[x86_64_v2_gnome-kiosk-search-appliance.sha256sum] = "09de55fd7d2f2e7a66ffcc13bc3daa06b5547dc3c59d5ecab2d7a81ea87c6dd7"

URI_aarch64_gnome-kiosk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-kiosk-49.0-1.el10.aarch64.rpm;name=aarch64_gnome-kiosk;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-kiosk}"
SRC_URI[aarch64_gnome-kiosk.sha256sum] = "158f6832811ca101e5baee91fa8071256a01bf6c2a139e68ef8cfad67f5de8bb"
RPROVIDES:gnome-kiosk:aarch64 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_aarch64_gnome-kiosk-script-session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-kiosk-script-session-49.0-1.el10.noarch.rpm;name=aarch64_gnome-kiosk-script-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-kiosk-script-session}"
SRC_URI[aarch64_gnome-kiosk-script-session.sha256sum] = "fce44d0f2e5120c739615b82cb0f5560f9f0a303dda40dbf5ebce9e164ce78ee"

URI_aarch64_gnome-kiosk-search-appliance = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-kiosk-search-appliance-49.0-1.el10.noarch.rpm;name=aarch64_gnome-kiosk-search-appliance;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-kiosk-search-appliance}"
SRC_URI[aarch64_gnome-kiosk-search-appliance.sha256sum] = "09de55fd7d2f2e7a66ffcc13bc3daa06b5547dc3c59d5ecab2d7a81ea87c6dd7"

RDEPENDS:gnome-kiosk = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-desktop4 \
 gnome-settings-daemon \
 gsettings-desktop-schemas \
 ibus-libs \
 libX11 \
 libgcc \
 libglvnd-gles \
 mutter \
 systemd-libs \
 "
RDEPENDS:gnome-kiosk-script-session = " \
 bash \
 gnome-kiosk \
 gnome-session \
 "
RDEPENDS:gnome-kiosk-search-appliance = " \
 flatpak \
 gnome-kiosk \
 gnome-session \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

PROVIDES:append:aarch64 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"
