# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fs4"
PV = "0.13.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-fs4+async-std-devel \
 rust-fs4+default-devel \
 rust-fs4+fs-err2-devel \
 rust-fs4+fs-err2-tokio-devel \
 rust-fs4+fs-err3-devel \
 rust-fs4+fs-err3-tokio-devel \
 rust-fs4+sync-devel \
 rust-fs4+tokio-devel \
 rust-fs4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fs4-0.13.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0472ab912a73b2d22b8ba15404d746faa039cef3304e2c12bc016e785cf827c"

URI_x86_64_v2_rust-fs4+async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs4+async-std-devel-0.13.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs4+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs4+async-std-devel}"
SRC_URI[x86_64_v2_rust-fs4+async-std-devel.sha256sum] = "055ca07d61f85f71f529b4a4348bfc65743baeeb17c99418a73f059bb2bebcf8"

URI_x86_64_v2_rust-fs4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs4+default-devel-0.13.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs4+default-devel}"
SRC_URI[x86_64_v2_rust-fs4+default-devel.sha256sum] = "935d5aba04a63ef26262ff5066aafdae1d175c685b999f46bc2e33e41a9adf52"

URI_x86_64_v2_rust-fs4+fs-err2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs4+fs-err2-devel-0.13.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs4+fs-err2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs4+fs-err2-devel}"
SRC_URI[x86_64_v2_rust-fs4+fs-err2-devel.sha256sum] = "b8651fd60c4f9f975ea10bef68bfe0db2f544ad213e262f850a0b502d992dcd5"

URI_x86_64_v2_rust-fs4+fs-err2-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs4+fs-err2-tokio-devel-0.13.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs4+fs-err2-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs4+fs-err2-tokio-devel}"
SRC_URI[x86_64_v2_rust-fs4+fs-err2-tokio-devel.sha256sum] = "ba541cb69c0a1606a182735b1be2215395890de79c7c6ac6c22e7edd0bf7153e"

URI_x86_64_v2_rust-fs4+fs-err3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs4+fs-err3-devel-0.13.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs4+fs-err3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs4+fs-err3-devel}"
SRC_URI[x86_64_v2_rust-fs4+fs-err3-devel.sha256sum] = "f485c3b2080b69f9eedf9c370b58e429482cf5a33d5c8c9e2996558b051c3238"

URI_x86_64_v2_rust-fs4+fs-err3-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs4+fs-err3-tokio-devel-0.13.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs4+fs-err3-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs4+fs-err3-tokio-devel}"
SRC_URI[x86_64_v2_rust-fs4+fs-err3-tokio-devel.sha256sum] = "181313f79f9f06574722e9257613c4c8109fafe94dbe2c99844ac9f98fca4984"

URI_x86_64_v2_rust-fs4+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs4+sync-devel-0.13.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs4+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs4+sync-devel}"
SRC_URI[x86_64_v2_rust-fs4+sync-devel.sha256sum] = "152d67ef8d6828e53d469ae02deb914012b140fb63605e3b43e085946be9654c"

URI_x86_64_v2_rust-fs4+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs4+tokio-devel-0.13.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs4+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs4+tokio-devel}"
SRC_URI[x86_64_v2_rust-fs4+tokio-devel.sha256sum] = "f2e41f1d95dfbae340287a6953e292bddbb7d16469f891ccc69d84693459edd4"

URI_x86_64_v2_rust-fs4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs4-devel-0.13.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs4-devel}"
SRC_URI[x86_64_v2_rust-fs4-devel.sha256sum] = "7a119591720d95c95c865ecd9ee6d3cd582c1cb385cf2f513f089781b5b2b4d3"

URI_aarch64_rust-fs4+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs4+async-std-devel-0.13.1-2.el10_2.noarch.rpm;name=aarch64_rust-fs4+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs4+async-std-devel}"
SRC_URI[aarch64_rust-fs4+async-std-devel.sha256sum] = "fb05d489e3f340f1ad93223fa2fda61580d923dc71cc4ddb86686f932ac752b4"

URI_aarch64_rust-fs4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs4+default-devel-0.13.1-2.el10_2.noarch.rpm;name=aarch64_rust-fs4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs4+default-devel}"
SRC_URI[aarch64_rust-fs4+default-devel.sha256sum] = "5e07b77e1089d6eb32dcb961bf292810f51f349673c68d875b8927716fa8af2f"

URI_aarch64_rust-fs4+fs-err2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs4+fs-err2-devel-0.13.1-2.el10_2.noarch.rpm;name=aarch64_rust-fs4+fs-err2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs4+fs-err2-devel}"
SRC_URI[aarch64_rust-fs4+fs-err2-devel.sha256sum] = "d8ec4b74c99ab043481f11f4010f440d00bcf95ea2a530bba01b0bc8cafc8f25"

URI_aarch64_rust-fs4+fs-err2-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs4+fs-err2-tokio-devel-0.13.1-2.el10_2.noarch.rpm;name=aarch64_rust-fs4+fs-err2-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs4+fs-err2-tokio-devel}"
SRC_URI[aarch64_rust-fs4+fs-err2-tokio-devel.sha256sum] = "b67615dbd97d75250c2a73fdb0063c1315954863513dcb1f41f16d0a232afe18"

URI_aarch64_rust-fs4+fs-err3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs4+fs-err3-devel-0.13.1-2.el10_2.noarch.rpm;name=aarch64_rust-fs4+fs-err3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs4+fs-err3-devel}"
SRC_URI[aarch64_rust-fs4+fs-err3-devel.sha256sum] = "b261647b6d6b3d18e047fbe0d534ff2f8cec475a87a30a5b9890b1d48dc290a7"

URI_aarch64_rust-fs4+fs-err3-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs4+fs-err3-tokio-devel-0.13.1-2.el10_2.noarch.rpm;name=aarch64_rust-fs4+fs-err3-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs4+fs-err3-tokio-devel}"
SRC_URI[aarch64_rust-fs4+fs-err3-tokio-devel.sha256sum] = "fdea8a7f8027dad62e0493a5a5a883a26cb4feacbd138469a6c94ac0b6b222e4"

URI_aarch64_rust-fs4+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs4+sync-devel-0.13.1-2.el10_2.noarch.rpm;name=aarch64_rust-fs4+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs4+sync-devel}"
SRC_URI[aarch64_rust-fs4+sync-devel.sha256sum] = "78ac512d8ac567196af39f3c5273ff55786bb3b0be16468df50b14839ec8a417"

URI_aarch64_rust-fs4+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs4+tokio-devel-0.13.1-2.el10_2.noarch.rpm;name=aarch64_rust-fs4+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs4+tokio-devel}"
SRC_URI[aarch64_rust-fs4+tokio-devel.sha256sum] = "fbe32246442d642fa7d58bf1a39e5a626d375badcfef05dce2bbf5dbb3cb16a5"

URI_aarch64_rust-fs4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs4-devel-0.13.1-2.el10_2.noarch.rpm;name=aarch64_rust-fs4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs4-devel}"
SRC_URI[aarch64_rust-fs4-devel.sha256sum] = "7888fdf02d5c04527339db574ed7cdffa294608de17c22765612cd22d188de9d"

RDEPENDS:rust-fs4+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-fs4-devel \
 "
RDEPENDS:rust-fs4+default-devel = " \
 cargo \
 rust-fs4+sync-devel \
 rust-fs4-devel \
 "
RDEPENDS:rust-fs4+fs-err2-devel = " \
 cargo \
 rust-fs-err2+default-devel \
 rust-fs-err2+io_safety-devel \
 rust-fs4-devel \
 "
RDEPENDS:rust-fs4+fs-err2-tokio-devel = " \
 cargo \
 rust-fs-err2+default-devel \
 rust-fs-err2+tokio-devel \
 rust-fs4+fs-err2-devel \
 rust-fs4-devel \
 "
RDEPENDS:rust-fs4+fs-err3-devel = " \
 cargo \
 rust-fs-err+default-devel \
 rust-fs4-devel \
 "
RDEPENDS:rust-fs4+fs-err3-tokio-devel = " \
 cargo \
 rust-fs-err+default-devel \
 rust-fs-err+tokio-devel \
 rust-fs4+fs-err3-devel \
 rust-fs4-devel \
 "
RDEPENDS:rust-fs4+sync-devel = " \
 cargo \
 rust-fs4-devel \
 "
RDEPENDS:rust-fs4+tokio-devel = " \
 cargo \
 rust-fs4-devel \
 rust-tokio+fs-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-fs4-devel = " \
 cargo \
 rust \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 "
