# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linux-firmware"
PV = "20260624"
PR = "24.el10"
PACKAGES = " \
 amd-gpu-firmware \
 amd-ucode-firmware \
 atheros-firmware \
 brcmfmac-firmware \
 cirrus-audio-firmware \
 dvb-firmware \
 intel-audio-firmware \
 intel-gpu-firmware \
 intel-vsc-firmware \
 iwlegacy-firmware \
 iwlwifi-dvm-firmware \
 iwlwifi-mvm-firmware \
 libertas-firmware \
 linux-firmware \
 linux-firmware-whence \
 mlxsw_spectrum-firmware \
 mrvlprestera-firmware \
 mt7xxx-firmware \
 netronome-firmware \
 nvidia-gpu-firmware \
 nxpwireless-firmware \
 qcom-firmware \
 realtek-firmware \
 tiwilink-firmware \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/linux-firmware-20260624-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6cc70a95477fc1f7d9ada95cd826d1119e7951e1eaf86b7bf65709cfecba5a1d"

URI_x86_64_v2_amd-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/amd-gpu-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_amd-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amd-gpu-firmware}"
SRC_URI[x86_64_v2_amd-gpu-firmware.sha256sum] = "a797c854d4f303dcf76c9f7ecc7bb7c4e60b4d46b15361fbb7b3940c7c58a500"

URI_x86_64_v2_amd-ucode-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/amd-ucode-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_amd-ucode-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amd-ucode-firmware}"
SRC_URI[x86_64_v2_amd-ucode-firmware.sha256sum] = "a0be374b21ad50cfa0115ed4fbb3ebe01738166b250f40d86f459dd749e9afed"

URI_x86_64_v2_atheros-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/atheros-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_atheros-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atheros-firmware}"
SRC_URI[x86_64_v2_atheros-firmware.sha256sum] = "f2afc4d28d06d3af647ad8e4375df9ddaac89b73fc2bd011c780049b26cfffe9"

URI_x86_64_v2_brcmfmac-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/brcmfmac-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_brcmfmac-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brcmfmac-firmware}"
SRC_URI[x86_64_v2_brcmfmac-firmware.sha256sum] = "14c6468d5f8eaf292e739391c61a4a4fdbf83b5952e3c9ea8c8670394241a401"

URI_x86_64_v2_cirrus-audio-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cirrus-audio-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_cirrus-audio-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cirrus-audio-firmware}"
SRC_URI[x86_64_v2_cirrus-audio-firmware.sha256sum] = "93cf12ca484ff71a2ffb3e253e36cef3745f24ffcaee80adf80cc0f617f7c9e8"

URI_x86_64_v2_dvb-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dvb-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_dvb-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dvb-firmware}"
SRC_URI[x86_64_v2_dvb-firmware.sha256sum] = "a2192386c645f26717c80acf5bcce4d41ecb84a43f4408b8b5baa32816fd31fc"

URI_x86_64_v2_intel-audio-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-audio-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_intel-audio-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-audio-firmware}"
SRC_URI[x86_64_v2_intel-audio-firmware.sha256sum] = "039a5e534c421c697faf37a4283f560704e49634e351b89ce3ede6c74b1051ac"

URI_x86_64_v2_intel-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/intel-gpu-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_intel-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-gpu-firmware}"
SRC_URI[x86_64_v2_intel-gpu-firmware.sha256sum] = "b50a5cb2a9cee2897711226818b8b9ad5c9503263b6616fe84be2f579967aea0"

URI_x86_64_v2_intel-vsc-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-vsc-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_intel-vsc-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-vsc-firmware}"
SRC_URI[x86_64_v2_intel-vsc-firmware.sha256sum] = "ede5d8f787bb7be0bfe939a1b7391dd655cb8b6efa4bd6a92d537a137d4a5170"

URI_x86_64_v2_iwlegacy-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlegacy-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_iwlegacy-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iwlegacy-firmware}"
SRC_URI[x86_64_v2_iwlegacy-firmware.sha256sum] = "073f0211851467cb4525bd02bee86bb756ba11b9a9baac6602e2424eab21ee9b"

URI_x86_64_v2_iwlwifi-dvm-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlwifi-dvm-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_iwlwifi-dvm-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iwlwifi-dvm-firmware}"
SRC_URI[x86_64_v2_iwlwifi-dvm-firmware.sha256sum] = "32f20f0f1270ce630f1b57b64e3a01661e6d62e270f7ded9999c0796ea4cd152"

URI_x86_64_v2_iwlwifi-mvm-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlwifi-mvm-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_iwlwifi-mvm-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iwlwifi-mvm-firmware}"
SRC_URI[x86_64_v2_iwlwifi-mvm-firmware.sha256sum] = "7c10ca450663bb168e957883ef7c43327671eddf8d3ec6c56341f9c6f6c5d2a5"

URI_x86_64_v2_libertas-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libertas-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_libertas-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libertas-firmware}"
SRC_URI[x86_64_v2_libertas-firmware.sha256sum] = "3ee314e1ae053f86ce6d075b3ef9de4abda6bc60f9ea91a79e34dfab1e248c97"

URI_x86_64_v2_linux-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/linux-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_linux-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linux-firmware}"
SRC_URI[x86_64_v2_linux-firmware.sha256sum] = "b758c56ef05f8c00a954845c2be58f2349aef7f3990a4de92c2f67ab71dc03ae"

URI_x86_64_v2_linux-firmware-whence = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/linux-firmware-whence-20260624-24.el10.noarch.rpm;name=x86_64_v2_linux-firmware-whence;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linux-firmware-whence}"
SRC_URI[x86_64_v2_linux-firmware-whence.sha256sum] = "5541453270c600ddf5ed614fe06762b3e8a58c1706a7c734df8a627364205e7a"

URI_x86_64_v2_mlxsw_spectrum-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mlxsw_spectrum-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_mlxsw_spectrum-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mlxsw_spectrum-firmware}"
SRC_URI[x86_64_v2_mlxsw_spectrum-firmware.sha256sum] = "8953130317a3d6a971ba67a935a68260187578fdd28fadd6a3bdcd7abc608515"

URI_x86_64_v2_mrvlprestera-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mrvlprestera-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_mrvlprestera-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrvlprestera-firmware}"
SRC_URI[x86_64_v2_mrvlprestera-firmware.sha256sum] = "241f5a7cfbde41addd2064e73ebbc644bacd83608369ad40d59b4f20e11ea0a7"

URI_x86_64_v2_mt7xxx-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mt7xxx-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_mt7xxx-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mt7xxx-firmware}"
SRC_URI[x86_64_v2_mt7xxx-firmware.sha256sum] = "855205c69d9908d91ec9074044da23ea2123ebec8240a983d6b5306749bb08d0"

URI_x86_64_v2_netronome-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/netronome-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_netronome-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netronome-firmware}"
SRC_URI[x86_64_v2_netronome-firmware.sha256sum] = "d81d8a61a24559ae9cdd7c1bdfbbd87bd73cb940415b977054c882ef41aec60f"

URI_x86_64_v2_nvidia-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nvidia-gpu-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_nvidia-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nvidia-gpu-firmware}"
SRC_URI[x86_64_v2_nvidia-gpu-firmware.sha256sum] = "2c890f1f07edf02d12c0aba40eed2fefaa18cfa5633fd70f114f2f9548a1983d"

URI_x86_64_v2_nxpwireless-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nxpwireless-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_nxpwireless-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nxpwireless-firmware}"
SRC_URI[x86_64_v2_nxpwireless-firmware.sha256sum] = "0ec9c4e3fd634c68052e78c0a651ea37bd0e396ae937fd98e602254576e3b2f4"

URI_x86_64_v2_qcom-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/qcom-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_qcom-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcom-firmware}"
SRC_URI[x86_64_v2_qcom-firmware.sha256sum] = "6a11098174757bc7391887eb800f17f2296d29ae7814646f3e02d2fce4e14207"

URI_x86_64_v2_realtek-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/realtek-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_realtek-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_realtek-firmware}"
SRC_URI[x86_64_v2_realtek-firmware.sha256sum] = "45fdee9d1830d73438980a11ca4a3df2d505d029dffb3793890126e0703595bc"

URI_x86_64_v2_tiwilink-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tiwilink-firmware-20260624-24.el10.noarch.rpm;name=x86_64_v2_tiwilink-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tiwilink-firmware}"
SRC_URI[x86_64_v2_tiwilink-firmware.sha256sum] = "bc378f917dedcd512e5926579eef9961c4870561c3737d1925fafe10538e681e"

URI_aarch64_amd-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/amd-gpu-firmware-20260624-24.el10.noarch.rpm;name=aarch64_amd-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_amd-gpu-firmware}"
SRC_URI[aarch64_amd-gpu-firmware.sha256sum] = "a797c854d4f303dcf76c9f7ecc7bb7c4e60b4d46b15361fbb7b3940c7c58a500"

URI_aarch64_amd-ucode-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/amd-ucode-firmware-20260624-24.el10.noarch.rpm;name=aarch64_amd-ucode-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_amd-ucode-firmware}"
SRC_URI[aarch64_amd-ucode-firmware.sha256sum] = "a0be374b21ad50cfa0115ed4fbb3ebe01738166b250f40d86f459dd749e9afed"

URI_aarch64_atheros-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/atheros-firmware-20260624-24.el10.noarch.rpm;name=aarch64_atheros-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_atheros-firmware}"
SRC_URI[aarch64_atheros-firmware.sha256sum] = "f2afc4d28d06d3af647ad8e4375df9ddaac89b73fc2bd011c780049b26cfffe9"

URI_aarch64_brcmfmac-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/brcmfmac-firmware-20260624-24.el10.noarch.rpm;name=aarch64_brcmfmac-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_brcmfmac-firmware}"
SRC_URI[aarch64_brcmfmac-firmware.sha256sum] = "14c6468d5f8eaf292e739391c61a4a4fdbf83b5952e3c9ea8c8670394241a401"

URI_aarch64_cirrus-audio-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cirrus-audio-firmware-20260624-24.el10.noarch.rpm;name=aarch64_cirrus-audio-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_cirrus-audio-firmware}"
SRC_URI[aarch64_cirrus-audio-firmware.sha256sum] = "93cf12ca484ff71a2ffb3e253e36cef3745f24ffcaee80adf80cc0f617f7c9e8"

URI_aarch64_dvb-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dvb-firmware-20260624-24.el10.noarch.rpm;name=aarch64_dvb-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_dvb-firmware}"
SRC_URI[aarch64_dvb-firmware.sha256sum] = "a2192386c645f26717c80acf5bcce4d41ecb84a43f4408b8b5baa32816fd31fc"

URI_aarch64_intel-audio-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/intel-audio-firmware-20260624-24.el10.noarch.rpm;name=aarch64_intel-audio-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-audio-firmware}"
SRC_URI[aarch64_intel-audio-firmware.sha256sum] = "039a5e534c421c697faf37a4283f560704e49634e351b89ce3ede6c74b1051ac"

URI_aarch64_intel-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/intel-gpu-firmware-20260624-24.el10.noarch.rpm;name=aarch64_intel-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-gpu-firmware}"
SRC_URI[aarch64_intel-gpu-firmware.sha256sum] = "b50a5cb2a9cee2897711226818b8b9ad5c9503263b6616fe84be2f579967aea0"

URI_aarch64_intel-vsc-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/intel-vsc-firmware-20260624-24.el10.noarch.rpm;name=aarch64_intel-vsc-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-vsc-firmware}"
SRC_URI[aarch64_intel-vsc-firmware.sha256sum] = "ede5d8f787bb7be0bfe939a1b7391dd655cb8b6efa4bd6a92d537a137d4a5170"

URI_aarch64_iwlegacy-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlegacy-firmware-20260624-24.el10.noarch.rpm;name=aarch64_iwlegacy-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_iwlegacy-firmware}"
SRC_URI[aarch64_iwlegacy-firmware.sha256sum] = "073f0211851467cb4525bd02bee86bb756ba11b9a9baac6602e2424eab21ee9b"

URI_aarch64_iwlwifi-dvm-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlwifi-dvm-firmware-20260624-24.el10.noarch.rpm;name=aarch64_iwlwifi-dvm-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_iwlwifi-dvm-firmware}"
SRC_URI[aarch64_iwlwifi-dvm-firmware.sha256sum] = "32f20f0f1270ce630f1b57b64e3a01661e6d62e270f7ded9999c0796ea4cd152"

URI_aarch64_iwlwifi-mvm-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlwifi-mvm-firmware-20260624-24.el10.noarch.rpm;name=aarch64_iwlwifi-mvm-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_iwlwifi-mvm-firmware}"
SRC_URI[aarch64_iwlwifi-mvm-firmware.sha256sum] = "7c10ca450663bb168e957883ef7c43327671eddf8d3ec6c56341f9c6f6c5d2a5"

URI_aarch64_libertas-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libertas-firmware-20260624-24.el10.noarch.rpm;name=aarch64_libertas-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_libertas-firmware}"
SRC_URI[aarch64_libertas-firmware.sha256sum] = "3ee314e1ae053f86ce6d075b3ef9de4abda6bc60f9ea91a79e34dfab1e248c97"

URI_aarch64_linux-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/linux-firmware-20260624-24.el10.noarch.rpm;name=aarch64_linux-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_linux-firmware}"
SRC_URI[aarch64_linux-firmware.sha256sum] = "b758c56ef05f8c00a954845c2be58f2349aef7f3990a4de92c2f67ab71dc03ae"

URI_aarch64_linux-firmware-whence = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/linux-firmware-whence-20260624-24.el10.noarch.rpm;name=aarch64_linux-firmware-whence;unpack=0"
SRC_URI:append = " ${URI_aarch64_linux-firmware-whence}"
SRC_URI[aarch64_linux-firmware-whence.sha256sum] = "5541453270c600ddf5ed614fe06762b3e8a58c1706a7c734df8a627364205e7a"

URI_aarch64_mlxsw_spectrum-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mlxsw_spectrum-firmware-20260624-24.el10.noarch.rpm;name=aarch64_mlxsw_spectrum-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_mlxsw_spectrum-firmware}"
SRC_URI[aarch64_mlxsw_spectrum-firmware.sha256sum] = "8953130317a3d6a971ba67a935a68260187578fdd28fadd6a3bdcd7abc608515"

URI_aarch64_mrvlprestera-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mrvlprestera-firmware-20260624-24.el10.noarch.rpm;name=aarch64_mrvlprestera-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrvlprestera-firmware}"
SRC_URI[aarch64_mrvlprestera-firmware.sha256sum] = "241f5a7cfbde41addd2064e73ebbc644bacd83608369ad40d59b4f20e11ea0a7"

URI_aarch64_mt7xxx-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mt7xxx-firmware-20260624-24.el10.noarch.rpm;name=aarch64_mt7xxx-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_mt7xxx-firmware}"
SRC_URI[aarch64_mt7xxx-firmware.sha256sum] = "855205c69d9908d91ec9074044da23ea2123ebec8240a983d6b5306749bb08d0"

URI_aarch64_netronome-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/netronome-firmware-20260624-24.el10.noarch.rpm;name=aarch64_netronome-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_netronome-firmware}"
SRC_URI[aarch64_netronome-firmware.sha256sum] = "d81d8a61a24559ae9cdd7c1bdfbbd87bd73cb940415b977054c882ef41aec60f"

URI_aarch64_nvidia-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nvidia-gpu-firmware-20260624-24.el10.noarch.rpm;name=aarch64_nvidia-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_nvidia-gpu-firmware}"
SRC_URI[aarch64_nvidia-gpu-firmware.sha256sum] = "2c890f1f07edf02d12c0aba40eed2fefaa18cfa5633fd70f114f2f9548a1983d"

URI_aarch64_nxpwireless-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nxpwireless-firmware-20260624-24.el10.noarch.rpm;name=aarch64_nxpwireless-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_nxpwireless-firmware}"
SRC_URI[aarch64_nxpwireless-firmware.sha256sum] = "0ec9c4e3fd634c68052e78c0a651ea37bd0e396ae937fd98e602254576e3b2f4"

URI_aarch64_qcom-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/qcom-firmware-20260624-24.el10.noarch.rpm;name=aarch64_qcom-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcom-firmware}"
SRC_URI[aarch64_qcom-firmware.sha256sum] = "6a11098174757bc7391887eb800f17f2296d29ae7814646f3e02d2fce4e14207"

URI_aarch64_realtek-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/realtek-firmware-20260624-24.el10.noarch.rpm;name=aarch64_realtek-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_realtek-firmware}"
SRC_URI[aarch64_realtek-firmware.sha256sum] = "45fdee9d1830d73438980a11ca4a3df2d505d029dffb3793890126e0703595bc"

URI_aarch64_tiwilink-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tiwilink-firmware-20260624-24.el10.noarch.rpm;name=aarch64_tiwilink-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_tiwilink-firmware}"
SRC_URI[aarch64_tiwilink-firmware.sha256sum] = "bc378f917dedcd512e5926579eef9961c4870561c3737d1925fafe10538e681e"

RDEPENDS:amd-gpu-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:amd-ucode-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:atheros-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:brcmfmac-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:cirrus-audio-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:dvb-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-audio-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-gpu-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-vsc-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlegacy-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlwifi-dvm-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlwifi-mvm-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:libertas-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:linux-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:linux-firmware-whence = " \
 "
RDEPENDS:mlxsw_spectrum-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:mrvlprestera-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:mt7xxx-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:netronome-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:nvidia-gpu-firmware = " \
 linux-firmware \
 linux-firmware-whence \
 "
RDEPENDS:nxpwireless-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:qcom-firmware = " \
 atheros-firmware \
 linux-firmware-whence \
 "
RDEPENDS:realtek-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:tiwilink-firmware = " \
 linux-firmware-whence \
 "
