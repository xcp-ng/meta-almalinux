# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-azure-storage"
PV = "2.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-reqsign-azure-storage+default-devel \
 rust-reqsign-azure-storage-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-azure-storage-2.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "174d2f025ce8f4528335244fb64b21b1362d3a3b5767a07e437ece0c1fe4bce7"

URI_x86_64_v2_rust-reqsign-azure-storage+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-azure-storage+default-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-azure-storage+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-azure-storage+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-azure-storage+default-devel.sha256sum] = "be51fc867ca474c1428cc041fb14aab46ee150c56e4e35ecd8de166a3707073a"

URI_x86_64_v2_rust-reqsign-azure-storage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-azure-storage-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-azure-storage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-azure-storage-devel}"
SRC_URI[x86_64_v2_rust-reqsign-azure-storage-devel.sha256sum] = "2d2b674375ff40110b1826303e94cb6e37f8939c531e02ed1cdb4a386179e365"

URI_aarch64_rust-reqsign-azure-storage+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-azure-storage+default-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-azure-storage+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-azure-storage+default-devel}"
SRC_URI[aarch64_rust-reqsign-azure-storage+default-devel.sha256sum] = "551b55057bb612b8696bab82cfdc15d6c291e990cac93b629b60c4c327516ea1"

URI_aarch64_rust-reqsign-azure-storage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-azure-storage-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-azure-storage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-azure-storage-devel}"
SRC_URI[aarch64_rust-reqsign-azure-storage-devel.sha256sum] = "b08576a8775588b0eda9df4adcee55ac0d8f5db779c5561f737473d1116569ab"

RDEPENDS:rust-reqsign-azure-storage+default-devel = " \
 cargo \
 rust-reqsign-azure-storage-devel \
 "
RDEPENDS:rust-reqsign-azure-storage-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-base64+default-devel \
 rust-bytes+default-devel \
 rust-form_urlencoded+default-devel \
 rust-http+default-devel \
 rust-jsonwebtoken+default-devel \
 rust-log+default-devel \
 rust-pem+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-sha1+default-devel \
 "
