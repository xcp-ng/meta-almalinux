# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snapd"
PV = "2.67"
PR = "0.el10_0"
PACKAGES = " \
 snap-confine \
 snapd \
 snapd-devel \
 snapd-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/snapd-2.67-0.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d943a5c979402d2cd3fffef572d0afe70b67cfe5762f6415f53ce90ebef6591"

URI_x86_64_v2_snap-confine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snap-confine-2.67-0.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snap-confine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snap-confine}"
SRC_URI[x86_64_v2_snap-confine.sha256sum] = "9cc5c1dea927e60a6fbe68257c14a5e048efc62c4f87c20f50146190316007b8"

URI_x86_64_v2_snapd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-2.67-0.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd}"
SRC_URI[x86_64_v2_snapd.sha256sum] = "2ff80ac7fcb5f540d2e73866fc78b202c90e3cbcfaec2e3dda3f683b79f722b0"

URI_x86_64_v2_snapd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-devel-2.67-0.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_snapd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-devel}"
SRC_URI[x86_64_v2_snapd-devel.sha256sum] = "e3c1e86e2c03095ac175f58b0858565109dd1a3d1eda922f79dca9423bc863e0"

URI_x86_64_v2_snapd-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-selinux-2.67-0.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_snapd-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-selinux}"
SRC_URI[x86_64_v2_snapd-selinux.sha256sum] = "b89c80df7e3a529cbe6ffc12e5991027cd57baf33b13a86059f48aaf8548eda1"

URI_aarch64_snap-confine = "${EPEL_MIRROR}/aarch64/Packages/s/snap-confine-2.67-0.el10_0.aarch64.rpm;name=aarch64_snap-confine;unpack=0"
SRC_URI:append = " ${URI_aarch64_snap-confine}"
SRC_URI[aarch64_snap-confine.sha256sum] = "dcc2afcdcbd2e46dc3348ab4d793e21a25f1369855f214fb5f452bbc62a992ee"

URI_aarch64_snapd = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-2.67-0.el10_0.aarch64.rpm;name=aarch64_snapd;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd}"
SRC_URI[aarch64_snapd.sha256sum] = "665a94919de7ca4780e798eb3e8d90a33aa59a449629d8ab91116b1cb2bb8ae2"

URI_aarch64_snapd-devel = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-devel-2.67-0.el10_0.noarch.rpm;name=aarch64_snapd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-devel}"
SRC_URI[aarch64_snapd-devel.sha256sum] = "7b858ba5324b2e2a0f4c5a257545d444d38372a68ccca45763f28b209eb33c73"

URI_aarch64_snapd-selinux = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-selinux-2.67-0.el10_0.noarch.rpm;name=aarch64_snapd-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-selinux}"
SRC_URI[aarch64_snapd-selinux.sha256sum] = "6b310f28b188452e1019e1a4fcf018aea16bbaf644bfe9022c3ba61defa10dc1"

RDEPENDS:snap-confine = " \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 systemd-libs \
 "
RDEPENDS:snapd = " \
 bash \
 bash-completion \
 glibc \
 snap-confine \
 snapd-selinux \
 squashfs-tools \
 systemd \
 virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_ \
 xdelta \
 "
RDEPENDS:snapd-devel = " \
 "
RDEPENDS:snapd-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
