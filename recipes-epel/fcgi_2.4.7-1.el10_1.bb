# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fcgi"
PV = "2.4.7"
PR = "1.el10_1"
PACKAGES = " \
 fcgi \
 fcgi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fcgi-2.4.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c883699d334b680529eeb02b22ab3c2e9eac10717220ca65fd3ee1fd27109c6"

URI_x86_64_v2_fcgi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fcgi-2.4.7-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fcgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fcgi}"
SRC_URI[x86_64_v2_fcgi.sha256sum] = "bd9c81b8483cb76ada339c8ecc419894c654ceadb4ff5687bdd03ff946d954a8"

URI_x86_64_v2_fcgi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fcgi-devel-2.4.7-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fcgi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fcgi-devel}"
SRC_URI[x86_64_v2_fcgi-devel.sha256sum] = "c78209b8ed15fbf2d88d8e5a64e6f5117eefd1c1824978c3bbe27ee7b3f91cca"

URI_aarch64_fcgi = "${EPEL_MIRROR}/aarch64/Packages/f/fcgi-2.4.7-1.el10_1.aarch64.rpm;name=aarch64_fcgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_fcgi}"
SRC_URI[aarch64_fcgi.sha256sum] = "71bcbd3dbb7663b5bf3e697a741b705dc5a59c2d56bc3246ea89258888ddde8b"

URI_aarch64_fcgi-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fcgi-devel-2.4.7-1.el10_1.aarch64.rpm;name=aarch64_fcgi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fcgi-devel}"
SRC_URI[aarch64_fcgi-devel.sha256sum] = "c5444f082fbf09c3169ad2abd33865fa82ff9716d1093dd238a1a8cbe081653b"

RDEPENDS:fcgi = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:fcgi-devel = " \
 fcgi \
 pkgconf-pkg-config \
 "
