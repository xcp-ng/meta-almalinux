# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "psacct"
PV = "6.6.4"
PR = "24.el10"
PACKAGES = " \
 psacct \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/psacct-6.6.4-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c7a67a7ab8fb77888de9f30d8086f665cead1561f0565a897c776ac0d0f1426"

URI_x86_64_v2_psacct = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/psacct-6.6.4-24.el10.x86_64_v2.rpm;name=x86_64_v2_psacct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_psacct}"
SRC_URI[x86_64_v2_psacct.sha256sum] = "e98392d64f774a54cec03b0ef0138e0791c4a3914618e3727b766d78edccb11d"

URI_aarch64_psacct = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/psacct-6.6.4-24.el10.aarch64.rpm;name=aarch64_psacct;unpack=0"
SRC_URI:append = " ${URI_aarch64_psacct}"
SRC_URI[aarch64_psacct.sha256sum] = "855ece82dba01f693095c6d55c5f379e366d062e6c0cd37a4b08df9264c955fa"

RDEPENDS:psacct = " \
 bash \
 glibc \
 systemd \
 virtual/coreutils \
 "
