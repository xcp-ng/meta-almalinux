# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwidgetsaddons"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kwidgetsaddons \
 kf6-kwidgetsaddons-devel \
 kf6-kwidgetsaddons-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kwidgetsaddons-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b04ef2a12ac62ca2d68aa53c846ab290f4c9429a7930a22c676aa271f06dade5"

URI_x86_64_v2_kf6-kwidgetsaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwidgetsaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons.sha256sum] = "858f4c4e03969b9121769b7f61e6f02f50092b5fb8e0a6b74a5732fda566552d"

URI_x86_64_v2_kf6-kwidgetsaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwidgetsaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons-devel}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons-devel.sha256sum] = "c48443daf456a8ec67003821c08f7c76b15126f77128091f8f6c70a4d91112f7"

URI_x86_64_v2_kf6-kwidgetsaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwidgetsaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons-doc}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons-doc.sha256sum] = "ccc3d4b6a7ac4c2e370b4ec1c10037558b3f65907f935b707f40a794fdb269fc"

URI_aarch64_kf6-kwidgetsaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kwidgetsaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons}"
SRC_URI[aarch64_kf6-kwidgetsaddons.sha256sum] = "d1b5a8596d7a113e1be840c06460cc7aaeb4eb3a8c40b11087f80806b59cc1ca"

URI_aarch64_kf6-kwidgetsaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kwidgetsaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons-devel}"
SRC_URI[aarch64_kf6-kwidgetsaddons-devel.sha256sum] = "6059539a60ab3444ebcf29c35e66cb6caecf0a275cd727c0afdb95d8eaeb4088"

URI_aarch64_kf6-kwidgetsaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kwidgetsaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons-doc}"
SRC_URI[aarch64_kf6-kwidgetsaddons-doc.sha256sum] = "6182cfa1b380537c17e61dfe0666fe60cbda37d6a0eca3866b724b4183859633"

RDEPENDS:kf6-kwidgetsaddons = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwidgetsaddons-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwidgetsaddons-doc = " \
 "
