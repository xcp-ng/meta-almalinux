# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kaddressbook"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kaddressbook \
 kaddressbook-devel \
 kaddressbook-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kaddressbook-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d236867c6e70f06964f7e16be0687b033d6dbab91f78caa0fcd8ff5355cc5b2c"

URI_x86_64_v2_kaddressbook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaddressbook}"
SRC_URI[x86_64_v2_kaddressbook.sha256sum] = "06d3f02924066b46c8f7e634492907d53c6ddab0ec1b09275c293fa6cd2ef72e"

URI_x86_64_v2_kaddressbook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaddressbook-devel}"
SRC_URI[x86_64_v2_kaddressbook-devel.sha256sum] = "aee902be7ec2650852abc354870162591a7e2ce2901659d7102466d2060f2edb"

URI_x86_64_v2_kaddressbook-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-libs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaddressbook-libs}"
SRC_URI[x86_64_v2_kaddressbook-libs.sha256sum] = "ba4610593a938b8451fa300741488664ed0bb31c5f4a3b60f7b9a05e2b89af9e"

URI_aarch64_kaddressbook = "${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kaddressbook;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaddressbook}"
SRC_URI[aarch64_kaddressbook.sha256sum] = "8dad9b6115682a11e89996e08e0dd6a5feb9de71da2a2cb4786eec974a421793"

URI_aarch64_kaddressbook-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kaddressbook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaddressbook-devel}"
SRC_URI[aarch64_kaddressbook-devel.sha256sum] = "86a478edf935a62290237a7d04a7a5e4665bbb8c7a4f95e763147b514381ef09"

URI_aarch64_kaddressbook-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-libs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kaddressbook-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaddressbook-libs}"
SRC_URI[aarch64_kaddressbook-libs.sha256sum] = "f51a08038d55a58e2aa714e05923aade3f5aacaee40d4bc0438df1e3dded4419"

RDEPENDS:kaddressbook = " \
 glibc \
 kaddressbook-libs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kontactinterface \
 libgcc \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kaddressbook-devel = " \
 cmake-filesystem \
 kaddressbook \
 kaddressbook-libs \
 "
RDEPENDS:kaddressbook-libs = " \
 akonadi-contacts \
 akonadi-search \
 akonadi-server \
 glibc \
 grantleetheme \
 kaddressbook \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kparts \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kldap \
 kontactinterface \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
