# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-posener-complete"
PV = "1.2.3"
PR = "16.el10_0"
PACKAGES = " \
 golang-github-posener-complete \
 golang-github-posener-complete-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-posener-complete-1.2.3-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5df9d6a31d8590c5ad4fed8ce318a549948a558619fd33bdcad186c83a4fc9f7"

URI_x86_64_v2_golang-github-posener-complete = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-posener-complete-1.2.3-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-posener-complete;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-posener-complete}"
SRC_URI[x86_64_v2_golang-github-posener-complete.sha256sum] = "b834ece5990416ff0b0c826419daceeae84864640e6948f5c25560c5af6f5038"

URI_x86_64_v2_golang-github-posener-complete-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-posener-complete-devel-1.2.3-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-posener-complete-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-posener-complete-devel}"
SRC_URI[x86_64_v2_golang-github-posener-complete-devel.sha256sum] = "2c490c3d89387117538956f0d460efdb51d6cd56dce56218741429b5e2c555bc"

URI_aarch64_golang-github-posener-complete = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-posener-complete-1.2.3-16.el10_0.aarch64.rpm;name=aarch64_golang-github-posener-complete;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-posener-complete}"
SRC_URI[aarch64_golang-github-posener-complete.sha256sum] = "f759276981659b7a95c6d0c4910c030470d02dc864a098e5638419662de5f689"

URI_aarch64_golang-github-posener-complete-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-posener-complete-devel-1.2.3-16.el10_0.noarch.rpm;name=aarch64_golang-github-posener-complete-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-posener-complete-devel}"
SRC_URI[aarch64_golang-github-posener-complete-devel.sha256sum] = "84f9932f29e8827b525bbb5033fe0f51fa5ab3da380a5a6eb8f7685c54aed2a2"

RDEPENDS:golang-github-posener-complete = " \
 glibc \
 "
RDEPENDS:golang-github-posener-complete-devel = " \
 go-filesystem \
 golang-github-hashicorp-multierror-devel \
 "
