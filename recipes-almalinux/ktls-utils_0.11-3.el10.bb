# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktls-utils"
PV = "0.11"
PR = "3.el10"
PACKAGES = " \
 ktls-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ktls-utils-0.11-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7de8dfaf92a20022bd19e234ec794f86b8d7be12e248eec8d2172de8599ac113"

URI_x86_64_v2_ktls-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ktls-utils-0.11-3.el10.x86_64_v2.rpm;name=x86_64_v2_ktls-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktls-utils}"
SRC_URI[x86_64_v2_ktls-utils.sha256sum] = "cf5ab9bf92d8ce9f90057ae693e103c428f28405c23b57fce766ec84e2f53041"

URI_aarch64_ktls-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ktls-utils-0.11-3.el10.aarch64.rpm;name=aarch64_ktls-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktls-utils}"
SRC_URI[aarch64_ktls-utils.sha256sum] = "e333428ca4af297aa73cfbd2e9d074779ffce5745d3a3ba31a3cd50c371b653d"

RDEPENDS:ktls-utils = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 keyutils-libs \
 libnl3 \
 "
