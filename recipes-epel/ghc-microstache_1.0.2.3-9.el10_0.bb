# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-microstache"
PV = "1.0.2.3"
PR = "9.el10_0"
PACKAGES = " \
 ghc-microstache \
 ghc-microstache-devel \
 ghc-microstache-doc \
 ghc-microstache-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-microstache-1.0.2.3-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70e2f65a76617241dd155a1165fd959c961db26413682b822fc3c195dcd31777"

URI_x86_64_v2_ghc-microstache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microstache-1.0.2.3-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microstache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microstache}"
SRC_URI[x86_64_v2_ghc-microstache.sha256sum] = "451c3f340efa201208d95cf45d2953e95738faacd58cce3dbab9c0e031cede38"

URI_x86_64_v2_ghc-microstache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microstache-devel-1.0.2.3-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microstache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microstache-devel}"
SRC_URI[x86_64_v2_ghc-microstache-devel.sha256sum] = "b62ee9d04c531907219a4aa1dcafca040d96f527d46cf80d8a75beda2f6685b7"

URI_x86_64_v2_ghc-microstache-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microstache-doc-1.0.2.3-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-microstache-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microstache-doc}"
SRC_URI[x86_64_v2_ghc-microstache-doc.sha256sum] = "c4e3783d0874772dab1bc5a768b4781c5f4ef541ff36128a7691e5bb6fd7aaf2"

URI_x86_64_v2_ghc-microstache-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microstache-prof-1.0.2.3-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microstache-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microstache-prof}"
SRC_URI[x86_64_v2_ghc-microstache-prof.sha256sum] = "5e8c6d2046057c9379a4335b2ef782129d9635f76bab633a58faa9753ac0877d"

URI_aarch64_ghc-microstache = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microstache-1.0.2.3-9.el10_0.aarch64.rpm;name=aarch64_ghc-microstache;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microstache}"
SRC_URI[aarch64_ghc-microstache.sha256sum] = "9b7ae99b734545d7a142178cd9275ab3dd533e517564bbb725e2a75f35d2eb30"

URI_aarch64_ghc-microstache-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microstache-devel-1.0.2.3-9.el10_0.aarch64.rpm;name=aarch64_ghc-microstache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microstache-devel}"
SRC_URI[aarch64_ghc-microstache-devel.sha256sum] = "6ef8f0ac5763512b28c3af99e013c80b2dc16b61310e7ae04daa2f3c441cd6e1"

URI_aarch64_ghc-microstache-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microstache-doc-1.0.2.3-9.el10_0.noarch.rpm;name=aarch64_ghc-microstache-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microstache-doc}"
SRC_URI[aarch64_ghc-microstache-doc.sha256sum] = "1783b288feacece15c0012cace5b1380fa55ba7113900e6880d84d957d80c341"

URI_aarch64_ghc-microstache-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microstache-prof-1.0.2.3-9.el10_0.aarch64.rpm;name=aarch64_ghc-microstache-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microstache-prof}"
SRC_URI[aarch64_ghc-microstache-prof.sha256sum] = "12bf34c7f86cd9d27da32ee28a22b618ba023e17b772db7dccc67c7fba277b04"

RDEPENDS:ghc-microstache = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-microstache-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-microstache \
 ghc-parsec-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-microstache-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-microstache-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-microstache-devel \
 ghc-parsec-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
