# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-event-stream"
PV = "0.5.4"
PR = "2.el10_0"
PACKAGES = " \
 aws-c-event-stream \
 aws-c-event-stream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-event-stream-0.5.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "838024339084dc255440c53aea69b5f5c59ab533fe09d09198d6f67f413664cd"

URI_x86_64_v2_aws-c-event-stream = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-event-stream-0.5.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-event-stream;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-event-stream}"
SRC_URI[x86_64_v2_aws-c-event-stream.sha256sum] = "b374f22914531acce7b8ddecda15bbb17339a81f0664910e8e6112f9d9e8cde4"

URI_x86_64_v2_aws-c-event-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-event-stream-devel-0.5.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-event-stream-devel}"
SRC_URI[x86_64_v2_aws-c-event-stream-devel.sha256sum] = "fa3476aaee61bc9cc3989895783f5868c01115e8dd2d8fc8e29ce53a9a8f3fb0"

URI_aarch64_aws-c-event-stream = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-event-stream-0.5.4-2.el10_0.aarch64.rpm;name=aarch64_aws-c-event-stream;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-event-stream}"
SRC_URI[aarch64_aws-c-event-stream.sha256sum] = "f7c354750b3fbb48d33d3783bcb8c23fa21dbc2af5bdf781debd10eb57bdb1c1"

URI_aarch64_aws-c-event-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-event-stream-devel-0.5.4-2.el10_0.aarch64.rpm;name=aarch64_aws-c-event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-event-stream-devel}"
SRC_URI[aarch64_aws-c-event-stream-devel.sha256sum] = "b878a4192b18d2a2c19730e95d25da475ed8d8c231b8db7b67261ba6d255b95a"

RDEPENDS:aws-c-event-stream = " \
 aws-c-common-libs \
 aws-c-io \
 aws-checksums-libs \
 glibc \
 "
RDEPENDS:aws-c-event-stream-devel = " \
 aws-c-common-devel \
 aws-c-event-stream \
 aws-c-io-devel \
 aws-checksums-devel \
 cmake-filesystem \
 openssl-devel \
 "
