# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prosody"
PV = "13.0.6"
PR = "1.el10_2"
PACKAGES = " \
 prosody \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/prosody-13.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cff241a1cdb3a581abe5899c58419ccb864f2a7c2ca4c47f9b265082fe89426d"

URI_x86_64_v2_prosody = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/prosody-13.0.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_prosody;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_prosody}"
SRC_URI[x86_64_v2_prosody.sha256sum] = "4fdbff0f28b7aeffe3d344b95ee72f306da1ced654570c656b3f6fd21842ae98"

URI_aarch64_prosody = "${EPEL_MIRROR}/aarch64/Packages/p/prosody-13.0.6-1.el10_2.aarch64.rpm;name=aarch64_prosody;unpack=0"
SRC_URI:append = " ${URI_aarch64_prosody}"
SRC_URI[aarch64_prosody.sha256sum] = "3874e9a9c770a25404eeb4b694b7d025ec01ad229c70388fcb406b2ff45dadae"

RDEPENDS:prosody = " \
 bash \
 glibc \
 libicu \
 lua \
 lua-expat \
 lua-filesystem \
 lua-libs \
 lua-sec \
 lua-socket \
 openssl \
 openssl-libs \
 shadow-utils \
 systemd \
 "
