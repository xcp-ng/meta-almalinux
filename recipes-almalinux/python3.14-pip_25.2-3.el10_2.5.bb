# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-pip"
PV = "25.2"
PR = "3.el10_2.5"
PACKAGES = " \
 python3.14-pip \
 python3.14-pip-wheel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-pip-25.2-3.el10_2.5.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc0df7c65e3594f8b71467a1cd4d15781a71286c1445306f109d532cc47112f9"

URI_x86_64_v2_python3.14-pip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-pip-25.2-3.el10_2.5.noarch.rpm;name=x86_64_v2_python3.14-pip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-pip}"
SRC_URI[x86_64_v2_python3.14-pip.sha256sum] = "927cdfb0565ce93516e52106bc6c1092e3eb33f3170f0a74c8dfae46233929be"

URI_x86_64_v2_python3.14-pip-wheel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-pip-wheel-25.2-3.el10_2.5.noarch.rpm;name=x86_64_v2_python3.14-pip-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-pip-wheel}"
SRC_URI[x86_64_v2_python3.14-pip-wheel.sha256sum] = "80456c6bf4f96a398309a5858cf83bf96d5c0f655b8b581a95e3ff83b8664e80"

URI_aarch64_python3.14-pip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-pip-25.2-3.el10_2.5.noarch.rpm;name=aarch64_python3.14-pip;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-pip}"
SRC_URI[aarch64_python3.14-pip.sha256sum] = "927cdfb0565ce93516e52106bc6c1092e3eb33f3170f0a74c8dfae46233929be"

URI_aarch64_python3.14-pip-wheel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-pip-wheel-25.2-3.el10_2.5.noarch.rpm;name=aarch64_python3.14-pip-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-pip-wheel}"
SRC_URI[aarch64_python3.14-pip-wheel.sha256sum] = "80456c6bf4f96a398309a5858cf83bf96d5c0f655b8b581a95e3ff83b8664e80"

RDEPENDS:python3.14-pip = " \
 ca-certificates \
 python3.14 \
 "
RDEPENDS:python3.14-pip-wheel = " \
 ca-certificates \
 "
