# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Params-SomeUtil"
PV = "1.11"
PR = "1.el10_3"
PACKAGES = " \
 perl-Params-SomeUtil \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Params-SomeUtil-1.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a610f466eb1d2704261c3cd4a8620a43057c96cfd3a0e405b7a80a9ca9d9ab1e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Params-SomeUtil-1.11-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Params-SomeUtil;unpack=0"
SRC_URI[x86_64_v2_perl-Params-SomeUtil.sha256sum] = "0e2e9266fc537d3abe68b469c00ee1b6b472c7e707836386762b7223a4de1408"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Params-SomeUtil-1.11-1.el10_3.aarch64.rpm;name=aarch64_perl-Params-SomeUtil;unpack=0"
SRC_URI[aarch64_perl-Params-SomeUtil.sha256sum] = "2813eee434e349d5b103a6ca73b4e1663a2af7996214895a4cdc41563b3613c9"

RDEPENDS:perl-Params-SomeUtil = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 perl-vars \
 "
