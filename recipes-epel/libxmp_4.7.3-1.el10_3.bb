# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxmp"
PV = "4.7.3"
PR = "1.el10_3"
PACKAGES = " \
 libxmp \
 libxmp-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libxmp-4.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "379aac7d6b1b81e8f93d190f86ffbe18d71161ebb38ca2fa885e7cce4fde181d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxmp-4.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxmp;unpack=0"
SRC_URI[x86_64_v2_libxmp.sha256sum] = "9fa4c20e261492902ddd7d44a3cd0e14013ac676ab5bf4040df7e3fde640e5a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxmp-devel-4.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxmp-devel;unpack=0"
SRC_URI[x86_64_v2_libxmp-devel.sha256sum] = "ff962df2affc92c2154c532ae11d93626c580ba0e11ecd50225a306a1c114410"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libxmp-4.7.3-1.el10_3.aarch64.rpm;name=aarch64_libxmp;unpack=0"
SRC_URI[aarch64_libxmp.sha256sum] = "43a2388b48626dd47d5fdbc767131146d9925f93f5e19cac8d245bd29f29be16"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libxmp-devel-4.7.3-1.el10_3.aarch64.rpm;name=aarch64_libxmp-devel;unpack=0"
SRC_URI[aarch64_libxmp-devel.sha256sum] = "aff7ccc7d2a633dbf8260baf3e16f28c72c14e06ec9aa7fcdfccfe6065814d6b"

RDEPENDS:libxmp = " \
 glibc \
 "
RDEPENDS:libxmp-devel = " \
 cmake-filesystem \
 libxmp \
 pkgconf-pkg-config \
 "
