# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hashicorp-immutable-radix"
PV = "1.3.1"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-hashicorp-immutable-radix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-hashicorp-immutable-radix-1.3.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b586a717a47cef8bd5b80c77bb29eef5f3e0c427810e0bedebfda3274c954dfe"

URI_x86_64_v2_golang-github-hashicorp-immutable-radix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hashicorp-immutable-radix-devel-1.3.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hashicorp-immutable-radix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hashicorp-immutable-radix-devel}"
SRC_URI[x86_64_v2_golang-github-hashicorp-immutable-radix-devel.sha256sum] = "243df7153c29f5104cedc4a55893fcd6e82fbf12c9284be51a4a2987e5dbfdce"

URI_aarch64_golang-github-hashicorp-immutable-radix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hashicorp-immutable-radix-devel-1.3.1-6.el10_0.noarch.rpm;name=aarch64_golang-github-hashicorp-immutable-radix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hashicorp-immutable-radix-devel}"
SRC_URI[aarch64_golang-github-hashicorp-immutable-radix-devel.sha256sum] = "0938c708d978bcc5b14300f78294ab14d069df7ee098cdbff9029306003a30fb"

RDEPENDS:golang-github-hashicorp-immutable-radix-devel = " \
 go-filesystem \
 golang-github-hashicorp-lru-devel \
 "
