# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "eventviews"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 eventviews \
 eventviews-devel \
 eventviews-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/eventviews-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "372c13c64ab6ab50fb739175b039c766ba47edbfacf8cdb12408d0afed0a065c"

URI_x86_64_v2_eventviews = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eventviews;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eventviews}"
SRC_URI[x86_64_v2_eventviews.sha256sum] = "6fd5ad87c8d4017d89ce1a85b677bace821057cea056f82bbd95a4e1fd382856"

URI_x86_64_v2_eventviews-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eventviews-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eventviews-devel}"
SRC_URI[x86_64_v2_eventviews-devel.sha256sum] = "3eda988fe926b26c39a0903a2ba7fa956264f53ae964232b029fbbd9f1473cf6"

URI_x86_64_v2_eventviews-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_eventviews-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eventviews-doc}"
SRC_URI[x86_64_v2_eventviews-doc.sha256sum] = "e4ef322a7c0ca03ff8a097d00331a2dab2b35e1af615fdf1cd3a11642fa0c765"

URI_aarch64_eventviews = "${EPEL_MIRROR}/aarch64/Packages/e/eventviews-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_eventviews;unpack=0"
SRC_URI:append = " ${URI_aarch64_eventviews}"
SRC_URI[aarch64_eventviews.sha256sum] = "2af6040c6a577c5e82abc5e85a7aff1aa79dbbce91e6a4037032b1bd4ae01497"

URI_aarch64_eventviews-devel = "${EPEL_MIRROR}/aarch64/Packages/e/eventviews-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_eventviews-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_eventviews-devel}"
SRC_URI[aarch64_eventviews-devel.sha256sum] = "859fef5acd3d5ca04fdefa8e58e744f4fd6be2a8db348dbc96119363157faed1"

URI_aarch64_eventviews-doc = "${EPEL_MIRROR}/aarch64/Packages/e/eventviews-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_eventviews-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_eventviews-doc}"
SRC_URI[aarch64_eventviews-doc.sha256sum] = "81c2745c15c21cd591a07f0d8ee55f50684cf507613f2decf7e2528d6bc2b9f0"

RDEPENDS:eventviews = " \
 akonadi-calendar \
 akonadi-server \
 calendarsupport \
 glibc \
 kcalutils \
 kdiagram \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 libgcc \
 libkdepim \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:eventviews-devel = " \
 akonadi-calendar-devel \
 akonadi-server-devel \
 calendarsupport-devel \
 cmake-filesystem \
 eventviews \
 kcalutils-devel \
 kf6-kcalendarcore-devel \
 "
RDEPENDS:eventviews-doc = " \
 "
