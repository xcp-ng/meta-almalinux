# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Config-General"
PV = "2.65"
PR = "6.el10_0"
PACKAGES = " \
 perl-Config-General \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Config-General-2.65-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53e39f3ecbd6ba9f47bba50fee995c78047615cdc1a381de4660547071dd4ecd"

URI_x86_64_v2_perl-Config-General = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Config-General-2.65-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Config-General;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Config-General}"
SRC_URI[x86_64_v2_perl-Config-General.sha256sum] = "443c3bce96b15acc6b064e9b594c28c5a5bb3bd2388629f766b41a6be708cc46"

URI_aarch64_perl-Config-General = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Config-General-2.65-6.el10_0.noarch.rpm;name=aarch64_perl-Config-General;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Config-General}"
SRC_URI[aarch64_perl-Config-General.sha256sum] = "4879ef5e9a43fb9fc8f5b83afaf0dc61e34c7224f683da2f55433d17f57f9fa1"

RDEPENDS:perl-Config-General = " \
 perl-Carp \
 perl-Config-General \
 perl-English \
 perl-Exporter \
 perl-FileHandle \
 perl-IO \
 perl-PathTools \
 perl-base \
 perl-constant \
 perl-libs \
 perl-vars \
 "
