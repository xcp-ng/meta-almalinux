# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dkms"
PV = "3.4.2"
PR = "1.el10_3"
PACKAGES = " \
 dkms \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dkms-3.4.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "890b4b76614fd9c58f5320b356c51d413b7860cd36759f2fefde1d00e466df5d"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - dkms: (kernel-64k-devel-matched if kernel-64k-core)
# - dkms: (kernel-rt-debug-devel if kernel-rt-debug-core)
# - dkms: (kernel-rt-devel if kernel-rt-core)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - dkms: (kernel-rt-debug-devel if kernel-rt-debug-core)
# - dkms: (kernel-rt-devel if kernel-rt-core)

URI_x86_64_v2_dkms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dkms-3.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dkms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dkms}"
SRC_URI[x86_64_v2_dkms.sha256sum] = "b49b409b9727c19058ba37739f70eb124046c9cd1ae9f802266ec45a30919ea7"

URI_aarch64_dkms = "${EPEL_MIRROR}/aarch64/Packages/d/dkms-3.4.2-1.el10_3.noarch.rpm;name=aarch64_dkms;unpack=0"
SRC_URI:append = " ${URI_aarch64_dkms}"
SRC_URI[aarch64_dkms.sha256sum] = "fe121a66912b17a2ae0b7431d7d1bf1241675d19e7961cabc41d2a7b4cf4fc81"

RDEPENDS:dkms:x86_64_v2 = " \
 bash \
 cpio \
 elfutils-libelf-devel \
 file \
 findutils \
 gawk \
 gcc \
 grep \
 gzip \
 kernel-debug-devel-matched \
 kernel-devel-matched \
 kmod \
 make \
 patch \
 sed \
 tar \
 virtual/coreutils \
 which \
"
RDEPENDS:dkms:aarch64 = " \
 bash \
 cpio \
 elfutils-libelf-devel \
 file \
 findutils \
 gawk \
 gcc \
 grep \
 gzip \
 kernel-64k-devel-matched \
 kernel-debug-devel-matched \
 kernel-devel-matched \
 kmod \
 make \
 patch \
 sed \
 tar \
 virtual/coreutils \
 which \
"
