# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nfs4-acl-tools"
PV = "0.4.2"
PR = "7.el10"
PACKAGES = " \
 nfs4-acl-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nfs4-acl-tools-0.4.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d4c2e3884b38d76ecc3284aa8716c4e1c0ad21f7436bc7db631a7f79de9c192"

URI_x86_64_v2_nfs4-acl-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nfs4-acl-tools-0.4.2-7.el10.x86_64_v2.rpm;name=x86_64_v2_nfs4-acl-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfs4-acl-tools}"
SRC_URI[x86_64_v2_nfs4-acl-tools.sha256sum] = "664082d35e05ebd81905cb0cca8c12d1676ea76727951ab696737e54371cfd18"

URI_aarch64_nfs4-acl-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nfs4-acl-tools-0.4.2-7.el10.aarch64.rpm;name=aarch64_nfs4-acl-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfs4-acl-tools}"
SRC_URI[aarch64_nfs4-acl-tools.sha256sum] = "6b2e8f73ebd90ae010b090729bddf68d6b307614adf48ece9689f232efa876fc"

RDEPENDS:nfs4-acl-tools = " \
 glibc \
 "
