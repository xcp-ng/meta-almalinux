# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oqsprovider"
PV = "0.8.0"
PR = "5.el10"
PACKAGES = " \
 oqsprovider \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/oqsprovider-0.8.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e0298d0067e0e1b994190c441da43d8c82656c9b9fff00234f26b5132d9e1bb"

URI_x86_64_v2_oqsprovider = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/oqsprovider-0.8.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_oqsprovider;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oqsprovider}"
SRC_URI[x86_64_v2_oqsprovider.sha256sum] = "74391a9187cca4565f52260f3b7eea20a0e00bd22c9dab8382959c9004f9d0ee"

URI_aarch64_oqsprovider = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/oqsprovider-0.8.0-5.el10.aarch64.rpm;name=aarch64_oqsprovider;unpack=0"
SRC_URI:append = " ${URI_aarch64_oqsprovider}"
SRC_URI[aarch64_oqsprovider.sha256sum] = "d266dcf748c0036f1c7ab089a8b33d904c81850f2295d9896f30ccd67146e562"

RDEPENDS:oqsprovider = " \
 glibc \
 liboqs \
 openssl \
 openssl-libs \
 "
