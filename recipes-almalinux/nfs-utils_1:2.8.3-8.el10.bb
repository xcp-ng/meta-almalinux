# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nfs-utils"
PE = "1"
PV = "2.8.3"
PR = "8.el10"
PACKAGES = " \
 libnfsidmap \
 libnfsidmap-devel \
 nfs-utils \
 nfs-utils-coreos \
 nfsv4-client-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nfs-utils-2.8.3-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e66abfc751955b597da69558fee9393ccf35e511c9d624f0dcd545071368aa42"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - nfs-utils-coreos: libcap.so.2()(64bit)
# - nfs-utils: libcap
# - nfs-utils: libcap.so.2()(64bit)

URI_x86_64_v2_libnfsidmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnfsidmap-2.8.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_libnfsidmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfsidmap}"
SRC_URI[x86_64_v2_libnfsidmap.sha256sum] = "b36628802a76f875477bc6706da77cd7377d5797fe2771599d5aac37143830f3"

URI_x86_64_v2_libnfsidmap-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnfsidmap-devel-2.8.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_libnfsidmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfsidmap-devel}"
SRC_URI[x86_64_v2_libnfsidmap-devel.sha256sum] = "73aeb70d64558b51434bcb6822ed6c332bbcd9eef8af8b733d14a351e620a4f7"

URI_x86_64_v2_nfs-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nfs-utils-2.8.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_nfs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfs-utils}"
SRC_URI[x86_64_v2_nfs-utils.sha256sum] = "64bbbeb9961b57774f25585e96e0682ae4c11e04676593958921c361b33fe026"
RPROVIDES:nfs-utils:x86_64_v2 = "virtual/nfs-utils_or_nfsv4-client-utils"

URI_x86_64_v2_nfs-utils-coreos = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nfs-utils-coreos-2.8.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_nfs-utils-coreos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfs-utils-coreos}"
SRC_URI[x86_64_v2_nfs-utils-coreos.sha256sum] = "c4901fb7b12791f23d68cb98368dbbe11a342c15445c1460f4d1f8df8c19f5b6"

URI_x86_64_v2_nfsv4-client-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nfsv4-client-utils-2.8.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_nfsv4-client-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfsv4-client-utils}"
SRC_URI[x86_64_v2_nfsv4-client-utils.sha256sum] = "04c69abbb41c92dc7b291855654400c54c6f553801fa77928e9a4ec817b245d5"
RPROVIDES:nfsv4-client-utils:x86_64_v2 = "virtual/nfs-utils_or_nfsv4-client-utils"

URI_aarch64_libnfsidmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnfsidmap-2.8.3-8.el10.aarch64.rpm;name=aarch64_libnfsidmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfsidmap}"
SRC_URI[aarch64_libnfsidmap.sha256sum] = "966384d9ccde5b439e054973c87783c6d953f17b0a4f1e8cad2a10bb036ce780"

URI_aarch64_libnfsidmap-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnfsidmap-devel-2.8.3-8.el10.aarch64.rpm;name=aarch64_libnfsidmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfsidmap-devel}"
SRC_URI[aarch64_libnfsidmap-devel.sha256sum] = "6766d3deacdb7890b357364864cd596fb69973c2b8375d25ac2619f0414c2a89"

URI_aarch64_nfs-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nfs-utils-2.8.3-8.el10.aarch64.rpm;name=aarch64_nfs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfs-utils}"
SRC_URI[aarch64_nfs-utils.sha256sum] = "26614589e3d49fc4257e73ee6c60cb24283047e46eb1b5fcb002674e82fcd001"
RPROVIDES:nfs-utils:aarch64 = "virtual/nfs-utils_or_nfsv4-client-utils"

URI_aarch64_nfs-utils-coreos = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nfs-utils-coreos-2.8.3-8.el10.aarch64.rpm;name=aarch64_nfs-utils-coreos;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfs-utils-coreos}"
SRC_URI[aarch64_nfs-utils-coreos.sha256sum] = "eb9b1e1d29bf2a3038aaac0fa155ecab8fcdb8fb0b7cc615e89c0b8f8d9cd72b"

URI_aarch64_nfsv4-client-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nfsv4-client-utils-2.8.3-8.el10.aarch64.rpm;name=aarch64_nfsv4-client-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfsv4-client-utils}"
SRC_URI[aarch64_nfsv4-client-utils.sha256sum] = "b7b42d00741f399f4beb925d6d7838a7086afd2e904a53a2c275bb89cd2b6933"
RPROVIDES:nfsv4-client-utils:aarch64 = "virtual/nfs-utils_or_nfsv4-client-utils"

RDEPENDS:libnfsidmap = " \
 glibc \
 krb5-libs \
 openldap \
 "
RDEPENDS:libnfsidmap-devel = " \
 libnfsidmap \
 pkgconf-pkg-config \
 "
RDEPENDS:nfs-utils:x86_64_v2 = " \
 bash \
 device-mapper-libs \
 gawk \
 glibc \
 grep \
 gssproxy \
 keyutils \
 keyutils-libs \
 kmod \
 krb5-libs \
 libblkid \
 libcap \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libnl3 \
 libtirpc \
 libuuid \
 libxml2 \
 python3 \
 quota \
 readline \
 rpcbind \
 sed \
 selinux-policy \
 shadow-utils \
 sqlite-libs \
 systemd \
 util-linux \
 virtual/coreutils \
"
RDEPENDS:nfs-utils:aarch64 = " \
 bash \
 device-mapper-libs \
 gawk \
 glibc \
 grep \
 gssproxy \
 keyutils \
 keyutils-libs \
 kmod \
 krb5-libs \
 libblkid \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libnl3 \
 libtirpc \
 libuuid \
 libxml2 \
 python3 \
 quota \
 readline \
 rpcbind \
 sed \
 selinux-policy \
 shadow-utils \
 sqlite-libs \
 systemd \
 util-linux \
 virtual/coreutils \
"
RDEPENDS:nfs-utils-coreos:x86_64_v2 = " \
 bash \
 glibc \
 keyutils-libs \
 krb5-libs \
 libcap \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libtirpc \
 rpcbind \
 systemd \
"
RDEPENDS:nfs-utils-coreos:aarch64 = " \
 bash \
 glibc \
 keyutils-libs \
 krb5-libs \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libtirpc \
 rpcbind \
 systemd \
"
RDEPENDS:nfsv4-client-utils = " \
 glibc \
 gssproxy \
 keyutils-libs \
 krb5-libs \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libtirpc \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/nfs-utils_or_nfsv4-client-utils"

PROVIDES:append:aarch64 = " rpm/virtual/nfs-utils_or_nfsv4-client-utils"
