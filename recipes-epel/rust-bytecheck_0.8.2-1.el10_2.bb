# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytecheck"
PV = "0.8.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-bytecheck+default-devel \
 rust-bytecheck+simdutf8-devel \
 rust-bytecheck+uuid-1-devel \
 rust-bytecheck-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytecheck-0.8.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0793914b31532698007c61870ee65ed8772e1a56f843118abc3171645e1eaa6"

URI_x86_64_v2_rust-bytecheck+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck+default-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck+default-devel}"
SRC_URI[x86_64_v2_rust-bytecheck+default-devel.sha256sum] = "23bacdc83377fd31570c679ad5edfea9dec1fc0d49a3b1712dc119bb3ad62a79"

URI_x86_64_v2_rust-bytecheck+simdutf8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck+simdutf8-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck+simdutf8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck+simdutf8-devel}"
SRC_URI[x86_64_v2_rust-bytecheck+simdutf8-devel.sha256sum] = "8863078dcbc4c09c2ce10311da53ceb4650a139443c28f6d9f5039d1ccd79fcd"

URI_x86_64_v2_rust-bytecheck+uuid-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck+uuid-1-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck+uuid-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck+uuid-1-devel}"
SRC_URI[x86_64_v2_rust-bytecheck+uuid-1-devel.sha256sum] = "7aadf3b792e11ddb0df9552486e5d0de588eec5d5c745c5c570b9005bf9ee2d2"

URI_x86_64_v2_rust-bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck-devel}"
SRC_URI[x86_64_v2_rust-bytecheck-devel.sha256sum] = "341f27f5dd50f4b4f96486a7b8747dc36ca74ea759130a91a615f7882b316537"

URI_aarch64_rust-bytecheck+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck+default-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytecheck+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck+default-devel}"
SRC_URI[aarch64_rust-bytecheck+default-devel.sha256sum] = "a224cea731f602d4c099cae58cc77d6c00be6009baeb3e842f43732009abcab0"

URI_aarch64_rust-bytecheck+simdutf8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck+simdutf8-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytecheck+simdutf8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck+simdutf8-devel}"
SRC_URI[aarch64_rust-bytecheck+simdutf8-devel.sha256sum] = "150f61139f776097317e53fa1f1adb3cfcf82343d8fbaa0936255c182d111013"

URI_aarch64_rust-bytecheck+uuid-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck+uuid-1-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytecheck+uuid-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck+uuid-1-devel}"
SRC_URI[aarch64_rust-bytecheck+uuid-1-devel.sha256sum] = "a2fbca373588d30a97a1d5b33e7e3dca486c7ce95ae22d17f0aa9a8e2ec2593e"

URI_aarch64_rust-bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck-devel}"
SRC_URI[aarch64_rust-bytecheck-devel.sha256sum] = "cd7042cfe7c258f0633790d5a27729019c221a01f3942ce8e961e5ce45061560"

RDEPENDS:rust-bytecheck+default-devel = " \
 cargo \
 rust-bytecheck+simdutf8-devel \
 rust-bytecheck-devel \
 "
RDEPENDS:rust-bytecheck+simdutf8-devel = " \
 cargo \
 rust-bytecheck-devel \
 rust-simdutf8-devel \
 "
RDEPENDS:rust-bytecheck+uuid-1-devel = " \
 cargo \
 rust-bytecheck-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-bytecheck-devel = " \
 cargo \
 rust \
 rust-bytecheck_derive-devel \
 rust-ptr_meta-devel \
 rust-rancor-devel \
 "
