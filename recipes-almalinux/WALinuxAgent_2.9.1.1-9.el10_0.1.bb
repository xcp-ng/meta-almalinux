# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "WALinuxAgent"
PV = "2.9.1.1"
PR = "9.el10_0.1"
PACKAGES = " \
 WALinuxAgent \
 WALinuxAgent-udev \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/WALinuxAgent-2.9.1.1-9.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f138dfd001519bdd2a138cf3e2c668c9048895c5ffb860d89dddb2694b6b119b"

URI_x86_64_v2_WALinuxAgent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/WALinuxAgent-2.9.1.1-9.el10_0.1.noarch.rpm;name=x86_64_v2_WALinuxAgent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_WALinuxAgent}"
SRC_URI[x86_64_v2_WALinuxAgent.sha256sum] = "54edb682e405ded2648cfc208124e16c24debddea2a22f24a34eb970186a2651"

URI_x86_64_v2_WALinuxAgent-udev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/WALinuxAgent-udev-2.9.1.1-9.el10_0.1.noarch.rpm;name=x86_64_v2_WALinuxAgent-udev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_WALinuxAgent-udev}"
SRC_URI[x86_64_v2_WALinuxAgent-udev.sha256sum] = "c9ebf630b30cec85de58a49798c5b83fd01b5840fb0a698589e3ae067b80b355"

URI_aarch64_WALinuxAgent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/WALinuxAgent-2.9.1.1-9.el10_0.1.noarch.rpm;name=aarch64_WALinuxAgent;unpack=0"
SRC_URI:append = " ${URI_aarch64_WALinuxAgent}"
SRC_URI[aarch64_WALinuxAgent.sha256sum] = "54edb682e405ded2648cfc208124e16c24debddea2a22f24a34eb970186a2651"

URI_aarch64_WALinuxAgent-udev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/WALinuxAgent-udev-2.9.1.1-9.el10_0.1.noarch.rpm;name=aarch64_WALinuxAgent-udev;unpack=0"
SRC_URI:append = " ${URI_aarch64_WALinuxAgent-udev}"
SRC_URI[aarch64_WALinuxAgent-udev.sha256sum] = "c9ebf630b30cec85de58a49798c5b83fd01b5840fb0a698589e3ae067b80b355"

RDEPENDS:WALinuxAgent = " \
 WALinuxAgent-udev \
 bash \
 iptables-nft \
 openssh \
 openssh-server \
 openssl \
 parted \
 python3 \
 python3-pyasn1 \
 systemd \
 "
RDEPENDS:WALinuxAgent-udev = " \
 bash \
 "
