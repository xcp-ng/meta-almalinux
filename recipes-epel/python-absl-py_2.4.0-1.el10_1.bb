# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-absl-py"
PV = "2.4.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-absl-py \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-absl-py-2.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "894b279fc750d04164f955fa3614cf4a736f34336486456ccd71a019c9807f94"

URI_x86_64_v2_python3-absl-py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-absl-py-2.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-absl-py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-absl-py}"
SRC_URI[x86_64_v2_python3-absl-py.sha256sum] = "19722ef288b02dc86d9b1312e3ab62868eba0091b171674825d386413360e738"

URI_aarch64_python3-absl-py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-absl-py-2.4.0-1.el10_1.noarch.rpm;name=aarch64_python3-absl-py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-absl-py}"
SRC_URI[aarch64_python3-absl-py.sha256sum] = "1c5535006611e9e98a55c5038063df1b69440a1fe28da8f22e37c31ac78e88de"

RDEPENDS:python3-absl-py = " \
 python3 \
 "
