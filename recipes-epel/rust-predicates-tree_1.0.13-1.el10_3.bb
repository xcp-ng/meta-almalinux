# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-predicates-tree"
PV = "1.0.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-predicates-tree+default-devel \
 rust-predicates-tree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-predicates-tree-1.0.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e83afdfa152359e7bb281e6ca89529172ccb6bdf42632704102d70f8b9114da"

URI_x86_64_v2_rust-predicates-tree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-tree+default-devel-1.0.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-tree+default-devel}"
SRC_URI[x86_64_v2_rust-predicates-tree+default-devel.sha256sum] = "2b597c0dc41bfb102fc94f36ec9f72600e0509a4d2b685c13c3dea696d0a8b9c"

URI_x86_64_v2_rust-predicates-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-tree-devel-1.0.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-tree-devel}"
SRC_URI[x86_64_v2_rust-predicates-tree-devel.sha256sum] = "c252eb1c30af792a70ea06665ed2c3ae9ff93493dd73d63e374e466a2ec3ef29"

URI_aarch64_rust-predicates-tree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-tree+default-devel-1.0.13-1.el10_3.noarch.rpm;name=aarch64_rust-predicates-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-tree+default-devel}"
SRC_URI[aarch64_rust-predicates-tree+default-devel.sha256sum] = "eb02d96443510da016cafe09b3c07bd6f1836c3bb65f9b125ffec0bfef5e1d3d"

URI_aarch64_rust-predicates-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-tree-devel-1.0.13-1.el10_3.noarch.rpm;name=aarch64_rust-predicates-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-tree-devel}"
SRC_URI[aarch64_rust-predicates-tree-devel.sha256sum] = "b7a585ed7d3f132e54412d0a44c054920d522d6312e4d94f9beca3f55f469537"

RDEPENDS:rust-predicates-tree+default-devel = " \
 cargo \
 rust-predicates-tree-devel \
 "
RDEPENDS:rust-predicates-tree-devel = " \
 cargo \
 rust \
 rust-predicates-core+default-devel \
 rust-termtree0.5+default-devel \
 "
