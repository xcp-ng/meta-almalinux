# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gsoap"
PV = "2.8.135"
PR = "1.el10_0"
PACKAGES = " \
 gsoap \
 gsoap-devel \
 gsoap-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gsoap-2.8.135-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3ebe9ba5142577ce29e31690766824f0c8a04f5e4cac77814f569e58cb9ed0a6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsoap-2.8.135-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsoap;unpack=0"
SRC_URI[x86_64_v2_gsoap.sha256sum] = "e635f13404273460d424c9a23472d2e8c1a6c61d60810fa58c19046bd933b4db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsoap-devel-2.8.135-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsoap-devel;unpack=0"
SRC_URI[x86_64_v2_gsoap-devel.sha256sum] = "1f065432b04dc080166958e684f71bddfe8cfb1d57b28796c850ec8a79450c1e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsoap-doc-2.8.135-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gsoap-doc;unpack=0"
SRC_URI[x86_64_v2_gsoap-doc.sha256sum] = "585d85d7bb943d941a645e929d9f81109d1a9e2e79de2888b36abd2aa5a89b6a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gsoap-2.8.135-1.el10_0.aarch64.rpm;name=aarch64_gsoap;unpack=0"
SRC_URI[aarch64_gsoap.sha256sum] = "0a2a135bd02046cbb24645e3e7a718967117f44a26a15f0f275d6fec6c03bfbc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gsoap-devel-2.8.135-1.el10_0.aarch64.rpm;name=aarch64_gsoap-devel;unpack=0"
SRC_URI[aarch64_gsoap-devel.sha256sum] = "00966b0968022d1b530f06c4a80d84bb22c19a9dd83bd01fd3c1d87f94954939"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gsoap-doc-2.8.135-1.el10_0.noarch.rpm;name=aarch64_gsoap-doc;unpack=0"
SRC_URI[aarch64_gsoap-doc.sha256sum] = "bc3ccaa84d0d234d9771b3a5732d0187967f10e88d910ce7e07da459ac73d654"

RDEPENDS:gsoap = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:gsoap-devel = " \
 glibc \
 gsoap \
 libgcc \
 libstdc++ \
 openssl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:gsoap-doc = " \
 "
