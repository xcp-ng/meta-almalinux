# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtwebsockets"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtwebsockets \
 qt5-qtwebsockets-devel \
 qt5-qtwebsockets-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtwebsockets-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00ce71d5edb16a9668aed115ad208cf79da40ceafb3652faf0c13b606aef882c"

URI_x86_64_v2_qt5-qtwebsockets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebsockets-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebsockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebsockets}"
SRC_URI[x86_64_v2_qt5-qtwebsockets.sha256sum] = "85c20320b3efcdd0b56b1b519b495a4e68f85c4e2eca609e6116cde5627208fe"

URI_x86_64_v2_qt5-qtwebsockets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebsockets-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebsockets-devel}"
SRC_URI[x86_64_v2_qt5-qtwebsockets-devel.sha256sum] = "3436941bfcadde188b4307b9861b60aacb9f45fe200aea111fac7f051e5aec04"

URI_x86_64_v2_qt5-qtwebsockets-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebsockets-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebsockets-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebsockets-examples}"
SRC_URI[x86_64_v2_qt5-qtwebsockets-examples.sha256sum] = "2a9cc5be20cf724f10ec8cafa347fc550b6aa126db7e5d360555208751f7995a"

URI_aarch64_qt5-qtwebsockets = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebsockets-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtwebsockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebsockets}"
SRC_URI[aarch64_qt5-qtwebsockets.sha256sum] = "7ef9ad09957efaeacfd20bf2fa2258513d11c155c29ba3fdd2036e2624c85be9"

URI_aarch64_qt5-qtwebsockets-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebsockets-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebsockets-devel}"
SRC_URI[aarch64_qt5-qtwebsockets-devel.sha256sum] = "3aa9234434f41fab6df005649824142dd3d0780e34190a981761e7d5c8ed575e"

URI_aarch64_qt5-qtwebsockets-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebsockets-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtwebsockets-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebsockets-examples}"
SRC_URI[aarch64_qt5-qtwebsockets-examples.sha256sum] = "856fbad1b0f0e9a5650239959fa8ea965c3a08d7cbcc0f65ecab44ddff436fbb"

RDEPENDS:qt5-qtwebsockets = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtwebsockets-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtdeclarative \
 qt5-qtwebsockets \
 "
RDEPENDS:qt5-qtwebsockets-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtwebsockets \
 "
