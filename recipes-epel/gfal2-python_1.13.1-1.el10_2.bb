# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gfal2-python"
PV = "1.13.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-gfal2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gfal2-python-1.13.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbcc82eb712c1e9f6053d8b196424c7d7ee5db44fa995c9cf40c67147e8ac6c5"

URI_x86_64_v2_python3-gfal2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gfal2-1.13.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-gfal2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gfal2}"
SRC_URI[x86_64_v2_python3-gfal2.sha256sum] = "d0a48dc9aa9c5d8c11f1bcd585d41d03bb25d1d12d036c1bf78d939a4b7cf133"

URI_aarch64_python3-gfal2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gfal2-1.13.1-1.el10_2.aarch64.rpm;name=aarch64_python3-gfal2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gfal2}"
SRC_URI[aarch64_python3-gfal2.sha256sum] = "52f8a3dc8749eaf1c22259a47dd7be2d944d27b77a530aeef2fd1e1d0dd9bd09"

RDEPENDS:python3-gfal2 = " \
 boost-python3 \
 gfal2 \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
