# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nfdump"
PV = "1.7.8"
PR = "1.el10_3"
PACKAGES = " \
 nfdump \
 nfdump-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nfdump-1.7.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36e966c3b3eef25ea0b4119b4ce6452ee0aefa6947f63e327a6139ba8e90c202"

URI_x86_64_v2_nfdump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nfdump-1.7.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nfdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfdump}"
SRC_URI[x86_64_v2_nfdump.sha256sum] = "b9b7433e4295ffa8acc0ae65040332065c406a7c69c78451078fb949de7196e2"

URI_x86_64_v2_nfdump-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nfdump-libs-1.7.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nfdump-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfdump-libs}"
SRC_URI[x86_64_v2_nfdump-libs.sha256sum] = "eb482c6928c67e862d47db6b5f39e55d235b109841424c44094ca56fa7cc3ca0"

URI_aarch64_nfdump = "${EPEL_MIRROR}/aarch64/Packages/n/nfdump-1.7.8-1.el10_3.aarch64.rpm;name=aarch64_nfdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfdump}"
SRC_URI[aarch64_nfdump.sha256sum] = "ccf7d955e8f17cd95ebbf604693c5dbfaa158350091e9210260d992a9567d36b"

URI_aarch64_nfdump-libs = "${EPEL_MIRROR}/aarch64/Packages/n/nfdump-libs-1.7.8-1.el10_3.aarch64.rpm;name=aarch64_nfdump-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfdump-libs}"
SRC_URI[aarch64_nfdump-libs.sha256sum] = "d966896d5d0731f17aee70ec73b9012c73fece048f740d824d868710282f1eab"

RDEPENDS:nfdump = " \
 bash \
 glibc \
 libpcap \
 nfdump-libs \
 rrdtool \
 "
RDEPENDS:nfdump-libs = " \
 bzip2-libs \
 glibc \
 libzstd \
 "
