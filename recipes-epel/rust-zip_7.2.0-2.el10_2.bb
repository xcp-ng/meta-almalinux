# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zip"
PV = "7.2.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-zip+_all-features-devel \
 rust-zip+_arbitrary-devel \
 rust-zip+_bzip2_any-devel \
 rust-zip+_deflate-any-devel \
 rust-zip+aes-crypto-devel \
 rust-zip+bitstream-io-devel \
 rust-zip+bzip2-devel \
 rust-zip+bzip2-rs-devel \
 rust-zip+chrono-devel \
 rust-zip+default-devel \
 rust-zip+deflate-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip+deflate-flate2-zlib-devel \
 rust-zip+deflate-flate2-zlib-ng-devel \
 rust-zip+deflate-flate2-zlib-rs-devel \
 rust-zip+deflate-zopfli-devel \
 rust-zip+deflate64-devel \
 rust-zip+getrandom-devel \
 rust-zip+jiff-02-devel \
 rust-zip+legacy-zip-devel \
 rust-zip+lzma-devel \
 rust-zip+ppmd-devel \
 rust-zip+time-devel \
 rust-zip+unreserved-devel \
 rust-zip+xz-devel \
 rust-zip+zstd-devel \
 rust-zip-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zip-7.2.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f72e119b6093f12d94eb36261082d0cdf60b0cd4130efdda900c19c025265ff"

URI_x86_64_v2_rust-zip+_all-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+_all-features-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+_all-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+_all-features-devel}"
SRC_URI[x86_64_v2_rust-zip+_all-features-devel.sha256sum] = "81e375c1eef0fe23b1741c8f2594d671cd542245bd4226f48430ad7f1774e465"

URI_x86_64_v2_rust-zip+_arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+_arbitrary-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+_arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+_arbitrary-devel}"
SRC_URI[x86_64_v2_rust-zip+_arbitrary-devel.sha256sum] = "a8cf9e92f2387af226d92e1379863ad529a9f42f88764aeb97361d49aa64e97a"

URI_x86_64_v2_rust-zip+_bzip2_any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+_bzip2_any-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+_bzip2_any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+_bzip2_any-devel}"
SRC_URI[x86_64_v2_rust-zip+_bzip2_any-devel.sha256sum] = "6228654c143f9e97cf6996fca26006ca8fc72132eea5a8f08410d7c81b6a8adf"

URI_x86_64_v2_rust-zip+_deflate-any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+_deflate-any-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+_deflate-any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+_deflate-any-devel}"
SRC_URI[x86_64_v2_rust-zip+_deflate-any-devel.sha256sum] = "64d95c6ec28d4425ab1e7bcc83548c948cdd1e9cd9917674b59c85fb617c42a0"

URI_x86_64_v2_rust-zip+aes-crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+aes-crypto-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+aes-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+aes-crypto-devel}"
SRC_URI[x86_64_v2_rust-zip+aes-crypto-devel.sha256sum] = "72630a44b51aeabeeb4826396fb4096dfb8ac5d436ddc88770b4e2ad546e43ec"

URI_x86_64_v2_rust-zip+bitstream-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+bitstream-io-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+bitstream-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+bitstream-io-devel}"
SRC_URI[x86_64_v2_rust-zip+bitstream-io-devel.sha256sum] = "1084504393a01d8e8f8aa83d2feb42498e8a945d686a39b3146fb352cd47212c"

URI_x86_64_v2_rust-zip+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+bzip2-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+bzip2-devel}"
SRC_URI[x86_64_v2_rust-zip+bzip2-devel.sha256sum] = "844dd404c0c3618d446e59ac2ce90c0a0f0b7fee7e1ddf588866284ba6763405"
RPROVIDES:rust-zip+bzip2-devel:x86_64_v2 = "virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_8.0.0~"

URI_x86_64_v2_rust-zip+bzip2-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+bzip2-rs-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+bzip2-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+bzip2-rs-devel}"
SRC_URI[x86_64_v2_rust-zip+bzip2-rs-devel.sha256sum] = "7c5d9d9e716139ec2fccb539bc1c973f5d03053b8777ada22ae6cb508db544a9"

URI_x86_64_v2_rust-zip+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+chrono-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+chrono-devel}"
SRC_URI[x86_64_v2_rust-zip+chrono-devel.sha256sum] = "d2e1f85bc7d935508ef264fa6ca4902f70a51521f38f8ffacc14092ac5db2d0a"

URI_x86_64_v2_rust-zip+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+default-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+default-devel}"
SRC_URI[x86_64_v2_rust-zip+default-devel.sha256sum] = "fadeacd97ba45efd8d83c1a6827305d97d2fbf6a358313984a256c8d9125e06c"

URI_x86_64_v2_rust-zip+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-devel.sha256sum] = "c34779240a0311639ebe61f697d0593f42481571643e9b5582e9cbc5bf9208bc"
RPROVIDES:rust-zip+deflate-devel:x86_64_v2 = "virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_8.0.0~"

URI_x86_64_v2_rust-zip+deflate-flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-flate2-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-flate2-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-flate2-devel.sha256sum] = "db745aae55572215bb96719392bcdb4ad1a2918e2701ac9f4a19faed16042538"

URI_x86_64_v2_rust-zip+deflate-flate2-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-flate2-zlib-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-flate2-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-flate2-zlib-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-flate2-zlib-devel.sha256sum] = "523acb9a66eea593e432c55b76f10d7aabed08b971f701297853202cd82ca299"

URI_x86_64_v2_rust-zip+deflate-flate2-zlib-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-flate2-zlib-ng-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-flate2-zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-flate2-zlib-ng-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-flate2-zlib-ng-devel.sha256sum] = "ca8d601a0ee2f8fd33a6ed8d05cacde9f761634cf932a71373cfab97cb36ec4f"

URI_x86_64_v2_rust-zip+deflate-flate2-zlib-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-flate2-zlib-rs-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-flate2-zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-flate2-zlib-rs-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-flate2-zlib-rs-devel.sha256sum] = "17007f82a5c484a2b4a5a2836771c86624de7f46032805bf555e0cf6eb01e3ad"

URI_x86_64_v2_rust-zip+deflate-zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-zopfli-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-zopfli-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-zopfli-devel.sha256sum] = "e0a072132472be62bc0346098d3deb690b1ddefa3e68e32ed3b192430d006c46"

URI_x86_64_v2_rust-zip+deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate64-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate64-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate64-devel.sha256sum] = "4182fb45a33ae041e7a7ba9970650c83979ec236ac29f5d65218f85c087055f2"

URI_x86_64_v2_rust-zip+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+getrandom-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+getrandom-devel}"
SRC_URI[x86_64_v2_rust-zip+getrandom-devel.sha256sum] = "3663c27095e52c87db9720b12ace0315e1771dde005dca1fc66b15c8b7dbaead"

URI_x86_64_v2_rust-zip+jiff-02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+jiff-02-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+jiff-02-devel}"
SRC_URI[x86_64_v2_rust-zip+jiff-02-devel.sha256sum] = "894e44c1abc9667c877606f4bc7b2459adc5e541a2d74b346fefd27ecc7c17fe"

URI_x86_64_v2_rust-zip+legacy-zip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+legacy-zip-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+legacy-zip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+legacy-zip-devel}"
SRC_URI[x86_64_v2_rust-zip+legacy-zip-devel.sha256sum] = "12bc6d5247fe42dcda856ad5eaeafe68937035d85a2a86c1bcd618fb16b61074"

URI_x86_64_v2_rust-zip+lzma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+lzma-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+lzma-devel}"
SRC_URI[x86_64_v2_rust-zip+lzma-devel.sha256sum] = "d80b3e6446554281760f50cb1c786c91ddc77198d5e3dd51f230531517cd317d"

URI_x86_64_v2_rust-zip+ppmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+ppmd-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+ppmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+ppmd-devel}"
SRC_URI[x86_64_v2_rust-zip+ppmd-devel.sha256sum] = "0a16bc950a421faa110656b9e2fe24e6d368a6690dfa516dc86f01bbb82505a7"

URI_x86_64_v2_rust-zip+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+time-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+time-devel}"
SRC_URI[x86_64_v2_rust-zip+time-devel.sha256sum] = "7eb8c62472b1f8619dff9666b37e42501c629e6bfe1c0f658147d38184f0f2e4"

URI_x86_64_v2_rust-zip+unreserved-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+unreserved-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+unreserved-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+unreserved-devel}"
SRC_URI[x86_64_v2_rust-zip+unreserved-devel.sha256sum] = "fb58b8b6d24f95be661e58452a1231419143e59de1b77f440d8bcf5b3d88a095"

URI_x86_64_v2_rust-zip+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+xz-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+xz-devel}"
SRC_URI[x86_64_v2_rust-zip+xz-devel.sha256sum] = "3ec4f905568701875afcfc46608e7ce58b0572eabfd0b81a2888cb7618f8df5c"

URI_x86_64_v2_rust-zip+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+zstd-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+zstd-devel}"
SRC_URI[x86_64_v2_rust-zip+zstd-devel.sha256sum] = "a3e2bd7e54b4e3bcfba875f99e38e43a8eec11e9f7893fecd3298970b63d463b"

URI_x86_64_v2_rust-zip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip-devel-7.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip-devel}"
SRC_URI[x86_64_v2_rust-zip-devel.sha256sum] = "a6fab081bb6a458a9e97b2533009a72038c9b371643888e918db3f3693d62408"
RPROVIDES:rust-zip-devel:x86_64_v2 = "virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_8.0.0~"

URI_aarch64_rust-zip+_all-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+_all-features-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+_all-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+_all-features-devel}"
SRC_URI[aarch64_rust-zip+_all-features-devel.sha256sum] = "eba1da90ce576aba0c27b469e61cf12abf3503dfcb84b5e9e6a313d46b785575"

URI_aarch64_rust-zip+_arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+_arbitrary-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+_arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+_arbitrary-devel}"
SRC_URI[aarch64_rust-zip+_arbitrary-devel.sha256sum] = "10e38d8b0edd691640ee343422110609824a53e2bcdae5e04d557eecb2117c0e"

URI_aarch64_rust-zip+_bzip2_any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+_bzip2_any-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+_bzip2_any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+_bzip2_any-devel}"
SRC_URI[aarch64_rust-zip+_bzip2_any-devel.sha256sum] = "88a9b82ace5e90baa37a56472b9eab73242045ee4bf91bfefddea6f9197cd4ea"

URI_aarch64_rust-zip+_deflate-any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+_deflate-any-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+_deflate-any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+_deflate-any-devel}"
SRC_URI[aarch64_rust-zip+_deflate-any-devel.sha256sum] = "76c6d6c12f5f55d377f7de4a4680e6010005afce15ea7faa097a3e1026a8bc5d"

URI_aarch64_rust-zip+aes-crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+aes-crypto-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+aes-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+aes-crypto-devel}"
SRC_URI[aarch64_rust-zip+aes-crypto-devel.sha256sum] = "07971f3be776eaf17efa27ba65c6597a63c09385b96f6c40ef7e91b2c730d131"

URI_aarch64_rust-zip+bitstream-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+bitstream-io-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+bitstream-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+bitstream-io-devel}"
SRC_URI[aarch64_rust-zip+bitstream-io-devel.sha256sum] = "a73d4e99dbaf31e1d7338c6d57c456eb97ee9d7421eac8be12227edbef4c034d"

URI_aarch64_rust-zip+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+bzip2-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+bzip2-devel}"
SRC_URI[aarch64_rust-zip+bzip2-devel.sha256sum] = "b557aea0474b9d886a6ec6d1412c741ee2d746dd304bceeb30e14346048a0e78"
RPROVIDES:rust-zip+bzip2-devel:aarch64 = "virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_8.0.0~"

URI_aarch64_rust-zip+bzip2-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+bzip2-rs-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+bzip2-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+bzip2-rs-devel}"
SRC_URI[aarch64_rust-zip+bzip2-rs-devel.sha256sum] = "1a37bec3ad80ac8af3ea814128270ad785bfeb6e392674167d9f618ed0102b32"

URI_aarch64_rust-zip+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+chrono-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+chrono-devel}"
SRC_URI[aarch64_rust-zip+chrono-devel.sha256sum] = "6992b1ee1035f9ff7f3dbcd2930e8db1bb8e90414dd2154e9c05238b87adc9fb"

URI_aarch64_rust-zip+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+default-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+default-devel}"
SRC_URI[aarch64_rust-zip+default-devel.sha256sum] = "097b11bf42fb2d1c7951eb6182221bbd0ed4bd0f459e94bb15f911878e4e92dc"

URI_aarch64_rust-zip+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-devel}"
SRC_URI[aarch64_rust-zip+deflate-devel.sha256sum] = "2571ed1e58db96d69099b2c0f4a2f5d745d969d0d2ae61b0b7652a67ee4d7bed"
RPROVIDES:rust-zip+deflate-devel:aarch64 = "virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_8.0.0~"

URI_aarch64_rust-zip+deflate-flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-flate2-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+deflate-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-flate2-devel}"
SRC_URI[aarch64_rust-zip+deflate-flate2-devel.sha256sum] = "f2efaf608f1adc70d65c28b75ba73c4a28dfb31759f0887638c569f8596bb445"

URI_aarch64_rust-zip+deflate-flate2-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-flate2-zlib-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+deflate-flate2-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-flate2-zlib-devel}"
SRC_URI[aarch64_rust-zip+deflate-flate2-zlib-devel.sha256sum] = "1a9016f230d1deacf603f5e130ae45f8c7063259309abbd3d9a90b7106c6a833"

URI_aarch64_rust-zip+deflate-flate2-zlib-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-flate2-zlib-ng-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+deflate-flate2-zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-flate2-zlib-ng-devel}"
SRC_URI[aarch64_rust-zip+deflate-flate2-zlib-ng-devel.sha256sum] = "f76f7c234a79881bd78fc0b92a9c702764b0b0c288b673d0c1add8bf36829170"

URI_aarch64_rust-zip+deflate-flate2-zlib-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-flate2-zlib-rs-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+deflate-flate2-zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-flate2-zlib-rs-devel}"
SRC_URI[aarch64_rust-zip+deflate-flate2-zlib-rs-devel.sha256sum] = "5dc18856970ba1d602026a9357f81a528878c1ab2bde45c8f7766e8741e00b87"

URI_aarch64_rust-zip+deflate-zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-zopfli-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+deflate-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-zopfli-devel}"
SRC_URI[aarch64_rust-zip+deflate-zopfli-devel.sha256sum] = "65b5312c69d7aa7e60384741a347efe455a05aec361f2a938298a3ad5ab707bb"

URI_aarch64_rust-zip+deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate64-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate64-devel}"
SRC_URI[aarch64_rust-zip+deflate64-devel.sha256sum] = "8ec8f826b2dd06ee3517f27df7c960effbf48586034dea05b6c95c1a054a913b"

URI_aarch64_rust-zip+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+getrandom-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+getrandom-devel}"
SRC_URI[aarch64_rust-zip+getrandom-devel.sha256sum] = "c76381f1a124fbefd4d03ae46befd8e823e91ce4b6d0f28e64df6c285e253c2d"

URI_aarch64_rust-zip+jiff-02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+jiff-02-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+jiff-02-devel}"
SRC_URI[aarch64_rust-zip+jiff-02-devel.sha256sum] = "4ec370a503cc0bd231d3ff361365c02a9e0ff1e27a7d3b2626b75598f8e416c9"

URI_aarch64_rust-zip+legacy-zip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+legacy-zip-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+legacy-zip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+legacy-zip-devel}"
SRC_URI[aarch64_rust-zip+legacy-zip-devel.sha256sum] = "c99f77a0692d0809783b1725c29ad71013fb916c8a2173538d2ff8656cd6cfaf"

URI_aarch64_rust-zip+lzma-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+lzma-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+lzma-devel}"
SRC_URI[aarch64_rust-zip+lzma-devel.sha256sum] = "d41b477e270ce5d46287e9e79cd2767043f45bf1e60041c5625ea24e68a4b581"

URI_aarch64_rust-zip+ppmd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+ppmd-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+ppmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+ppmd-devel}"
SRC_URI[aarch64_rust-zip+ppmd-devel.sha256sum] = "3db29c6cc83af772affebcc88b52a381df94d1ec8136905b55dab2f54002029f"

URI_aarch64_rust-zip+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+time-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+time-devel}"
SRC_URI[aarch64_rust-zip+time-devel.sha256sum] = "13cb7018dc971defa974dc3bc4632d3008d92b504f9cf58ff58e9309e3d83ff8"

URI_aarch64_rust-zip+unreserved-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+unreserved-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+unreserved-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+unreserved-devel}"
SRC_URI[aarch64_rust-zip+unreserved-devel.sha256sum] = "055f242cf33e00810d14eef90269ee443d6db60bc08b73567b7ad20dc9799d44"

URI_aarch64_rust-zip+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+xz-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+xz-devel}"
SRC_URI[aarch64_rust-zip+xz-devel.sha256sum] = "f1c0a594ad9081e58998a731af33739e7a2677cf43a9fb670bc0c2a0123c3962"

URI_aarch64_rust-zip+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+zstd-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+zstd-devel}"
SRC_URI[aarch64_rust-zip+zstd-devel.sha256sum] = "4fd61b5ffec1d8acbfa5b15b35075b65f7aa695298b2fe032a24422159a80b95"

URI_aarch64_rust-zip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip-devel-7.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-zip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip-devel}"
SRC_URI[aarch64_rust-zip-devel.sha256sum] = "66d347014c3f5aee05b8aaa4ac180c3c26725b9304c5ec6fb04446b50670dfa9"
RPROVIDES:rust-zip-devel:aarch64 = "virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_8.0.0~"

RDEPENDS:rust-zip+_all-features-devel = " \
 cargo \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+_arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+_bzip2_any-devel = " \
 cargo \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+_deflate-any-devel = " \
 cargo \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+aes-crypto-devel = " \
 cargo \
 rust-aes+default-devel \
 rust-constant_time_eq+default-devel \
 rust-generic-array+default-devel \
 rust-getrandom0.3+std-devel \
 rust-getrandom0.3-devel \
 rust-hmac+default-devel \
 rust-hmac+reset-devel \
 rust-pbkdf2+default-devel \
 rust-sha1+default-devel \
 rust-zeroize+default-devel \
 rust-zeroize+zeroize_derive-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+bitstream-io-devel = " \
 cargo \
 rust-bitstream-io+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-bzip2-devel \
 rust-zip+_bzip2_any-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+bzip2-rs-devel = " \
 cargo \
 rust-bzip2+bzip2-sys-devel \
 rust-bzip2-devel \
 rust-zip+_bzip2_any-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+chrono-devel = " \
 cargo \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+default-devel = " \
 cargo \
 rust-zip+aes-crypto-devel \
 rust-zip+bzip2-devel \
 rust-zip+deflate-devel \
 rust-zip+deflate64-devel \
 rust-zip+lzma-devel \
 rust-zip+ppmd-devel \
 rust-zip+time-devel \
 rust-zip+xz-devel \
 rust-zip+zstd-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-devel = " \
 cargo \
 rust-zip+deflate-flate2-zlib-rs-devel \
 rust-zip+deflate-zopfli-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-flate2-devel = " \
 cargo \
 rust-flate2-devel \
 rust-zip+_deflate-any-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-flate2-zlib-devel = " \
 cargo \
 rust-flate2+zlib-devel \
 rust-flate2-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-flate2-zlib-ng-devel = " \
 cargo \
 rust-flate2+zlib-ng-devel \
 rust-flate2-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-flate2-zlib-rs-devel = " \
 cargo \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-zopfli-devel = " \
 cargo \
 rust-zip+_deflate-any-devel \
 rust-zip-devel \
 rust-zopfli+default-devel \
 "
RDEPENDS:rust-zip+deflate64-devel = " \
 cargo \
 rust-deflate64+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+getrandom-devel = " \
 cargo \
 rust-getrandom0.3-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+jiff-02-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+legacy-zip-devel = " \
 cargo \
 rust-zip+bitstream-io-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+lzma-devel = " \
 cargo \
 rust-lzma-rust2+encoder-devel \
 rust-lzma-rust2+optimization-devel \
 rust-lzma-rust2+std-devel \
 rust-lzma-rust2+xz-devel \
 rust-lzma-rust2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+ppmd-devel = " \
 cargo \
 rust-ppmd-rust+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+time-devel = " \
 cargo \
 rust-time-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+unreserved-devel = " \
 cargo \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+xz-devel = " \
 cargo \
 rust-lzma-rust2+encoder-devel \
 rust-lzma-rust2+optimization-devel \
 rust-lzma-rust2+std-devel \
 rust-lzma-rust2+xz-devel \
 rust-lzma-rust2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+zstd-devel = " \
 cargo \
 rust-zip-devel \
 rust-zstd-devel \
 "
RDEPENDS:rust-zip-devel = " \
 cargo \
 rust \
 rust-crc32fast+default-devel \
 rust-indexmap+default-devel \
 rust-memchr+default-devel \
 rust-typed-path+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_8.0.0~ rpm/virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_8.0.0~ rpm/virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_8.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_8.0.0~ rpm/virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_8.0.0~ rpm/virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_8.0.0~"
