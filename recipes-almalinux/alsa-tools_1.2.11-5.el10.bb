# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alsa-tools"
PV = "1.2.11"
PR = "5.el10"
PACKAGES = " \
 alsa-tools-firmware \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/alsa-tools-1.2.11-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90c83d06fc72cb422ef51acfa0645c6eecd253a65a2e1c2c2915430f77b72d94"

URI_x86_64_v2_alsa-tools-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-tools-firmware-1.2.11-5.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-tools-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alsa-tools-firmware}"
SRC_URI[x86_64_v2_alsa-tools-firmware.sha256sum] = "4df151e5b1c1bd0918c3e72ecf4ec865d52c53135298d3521620337b98df68bf"

URI_aarch64_alsa-tools-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-tools-firmware-1.2.11-5.el10.aarch64.rpm;name=aarch64_alsa-tools-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_alsa-tools-firmware}"
SRC_URI[aarch64_alsa-tools-firmware.sha256sum] = "22a3eed62cc655105cdecdabece4415bb1ed90503dad37e32d4bfb33d5bc5d34"

RDEPENDS:alsa-tools-firmware = " \
 alsa-firmware \
 alsa-lib \
 bash \
 fxload \
 glibc \
 systemd-udev \
 "
