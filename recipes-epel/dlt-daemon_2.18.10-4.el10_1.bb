# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dlt-daemon"
PV = "2.18.10"
PR = "4.el10_1"
PACKAGES = " \
 dlt-daemon \
 dlt-examples \
 dlt-libs \
 dlt-libs-devel \
 dlt-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dlt-daemon-2.18.10-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f557f1b35249ffcf3614c12a688a792f2fa177331e34920a4225cf41e626906d"

URI_x86_64_v2_dlt-daemon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dlt-daemon-2.18.10-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dlt-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dlt-daemon}"
SRC_URI[x86_64_v2_dlt-daemon.sha256sum] = "173a3171c07d32928d8319be1ac6ec2dd8f457d8a586aeec33e2e2f1abd5855f"

URI_x86_64_v2_dlt-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dlt-examples-2.18.10-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dlt-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dlt-examples}"
SRC_URI[x86_64_v2_dlt-examples.sha256sum] = "a74d5a8cefb04ea55a494e6b16b1d11f2e1eceb8d2e3e7711ec883073fa9823d"

URI_x86_64_v2_dlt-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dlt-libs-2.18.10-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dlt-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dlt-libs}"
SRC_URI[x86_64_v2_dlt-libs.sha256sum] = "7394dbdfb4d394c185fed54651ae6d82ec3428da2ea68e88081a53c52d374249"

URI_x86_64_v2_dlt-libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dlt-libs-devel-2.18.10-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dlt-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dlt-libs-devel}"
SRC_URI[x86_64_v2_dlt-libs-devel.sha256sum] = "c068f9b5a74e30a08555d8bd4cd27bf426464484ef607eb8a8180fe7350c6bca"

URI_x86_64_v2_dlt-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dlt-tools-2.18.10-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dlt-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dlt-tools}"
SRC_URI[x86_64_v2_dlt-tools.sha256sum] = "e2dd15ed06229a10eb026ab63da45868e28acf11bb90e1a7ba9133035c062372"

URI_aarch64_dlt-daemon = "${EPEL_MIRROR}/aarch64/Packages/d/dlt-daemon-2.18.10-4.el10_1.aarch64.rpm;name=aarch64_dlt-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_dlt-daemon}"
SRC_URI[aarch64_dlt-daemon.sha256sum] = "477d98cdb03ed27dc4ea6f690ea055ceff2738a110f9badfe4ce7cd61c6a287c"

URI_aarch64_dlt-examples = "${EPEL_MIRROR}/aarch64/Packages/d/dlt-examples-2.18.10-4.el10_1.aarch64.rpm;name=aarch64_dlt-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_dlt-examples}"
SRC_URI[aarch64_dlt-examples.sha256sum] = "f8ded80a2c72e9c0ef84571b3edff3dc97bac71b8305a04404e560d9bcb90508"

URI_aarch64_dlt-libs = "${EPEL_MIRROR}/aarch64/Packages/d/dlt-libs-2.18.10-4.el10_1.aarch64.rpm;name=aarch64_dlt-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_dlt-libs}"
SRC_URI[aarch64_dlt-libs.sha256sum] = "af34b1a4461827ac07ba2fd33f415b477f0f8b39d59a7210d9fbe6b2f98563ac"

URI_aarch64_dlt-libs-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dlt-libs-devel-2.18.10-4.el10_1.aarch64.rpm;name=aarch64_dlt-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dlt-libs-devel}"
SRC_URI[aarch64_dlt-libs-devel.sha256sum] = "95d8a247b86279e57960db50bf7166e3a82efa2ed560b10fc720c267ff7f5771"

URI_aarch64_dlt-tools = "${EPEL_MIRROR}/aarch64/Packages/d/dlt-tools-2.18.10-4.el10_1.aarch64.rpm;name=aarch64_dlt-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_dlt-tools}"
SRC_URI[aarch64_dlt-tools.sha256sum] = "d16a4b8cc0f3dac4f3d65699cfb26c67ea6a072410303ba3affec32c337aeff4"

RDEPENDS:dlt-daemon = " \
 glibc \
 shadow-utils \
 "
RDEPENDS:dlt-examples = " \
 dlt-daemon \
 dlt-libs \
 glibc \
 "
RDEPENDS:dlt-libs = " \
 glibc \
 libgcc \
 "
RDEPENDS:dlt-libs-devel = " \
 cmake-filesystem \
 dlt-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:dlt-tools = " \
 dlt-libs \
 glibc \
 systemd-libs \
 "
