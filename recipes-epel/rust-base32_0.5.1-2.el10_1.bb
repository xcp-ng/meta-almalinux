# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-base32"
PV = "0.5.1"
PR = "2.el10_1"
PACKAGES = " \
 rust-base32+default-devel \
 rust-base32-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-base32-0.5.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0ba623d3dfdfc736b3ffb37d0ced036031631d96c0cdf4f86b25a8e1106acd1"

URI_x86_64_v2_rust-base32+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base32+default-devel-0.5.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base32+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base32+default-devel}"
SRC_URI[x86_64_v2_rust-base32+default-devel.sha256sum] = "cd50b6a1f6cb53db97f3797861b3b4e786c30298ea5b326dab7640c488cb32e6"

URI_x86_64_v2_rust-base32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base32-devel-0.5.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base32-devel}"
SRC_URI[x86_64_v2_rust-base32-devel.sha256sum] = "d84e63184a4f4df68b41f7746d91d3321f01a9b2665e960d41a2d56e78c6608f"

URI_aarch64_rust-base32+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base32+default-devel-0.5.1-2.el10_1.noarch.rpm;name=aarch64_rust-base32+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base32+default-devel}"
SRC_URI[aarch64_rust-base32+default-devel.sha256sum] = "f093e6f431a8057ad32f87ba89bd731a9b51f1b0b468a5ebe9c5fd15a0b21ba4"

URI_aarch64_rust-base32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base32-devel-0.5.1-2.el10_1.noarch.rpm;name=aarch64_rust-base32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base32-devel}"
SRC_URI[aarch64_rust-base32-devel.sha256sum] = "5c31c0a970f3aeaa15aaa8b9b349577c97eb2b030ab8c092dc840c805cd780b2"

RDEPENDS:rust-base32+default-devel = " \
 cargo \
 rust-base32-devel \
 "
RDEPENDS:rust-base32-devel = " \
 cargo \
 "
