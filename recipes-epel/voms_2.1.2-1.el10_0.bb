# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "voms"
PV = "2.1.2"
PR = "1.el10_0"
PACKAGES = " \
 voms \
 voms-clients-cpp \
 voms-devel \
 voms-doc \
 voms-server \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/voms-2.1.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f27af29717d7b3bc2eaa7ff1a701632e13f01e744346f1e2e29013184a437846"

URI_x86_64_v2_voms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-2.1.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_voms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms}"
SRC_URI[x86_64_v2_voms.sha256sum] = "b300d4bb0e5f0045cecc2bf32d7543006a218eb28885738ee82c357ee4292fb6"

URI_x86_64_v2_voms-clients-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-clients-cpp-2.1.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_voms-clients-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-clients-cpp}"
SRC_URI[x86_64_v2_voms-clients-cpp.sha256sum] = "aff2f2a3cce9afbb65dd4e10ba20c74f428983a5808b590ff31d02bcd9fe0930"
RPROVIDES:voms-clients-cpp:x86_64_v2 = "virtual/voms-clients"

URI_x86_64_v2_voms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-devel-2.1.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_voms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-devel}"
SRC_URI[x86_64_v2_voms-devel.sha256sum] = "79ae499e8d835b65236d4560dbb95457012c5bbe88cdcd723da62f2087f3c60a"

URI_x86_64_v2_voms-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-doc-2.1.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_voms-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-doc}"
SRC_URI[x86_64_v2_voms-doc.sha256sum] = "1f8b610c5b7405ddb10e6f2d243f9cdde9e9587955e0d22d576febe0a67c743c"

URI_x86_64_v2_voms-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-server-2.1.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_voms-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-server}"
SRC_URI[x86_64_v2_voms-server.sha256sum] = "7d3de2c4707519de07c9257410f43ae37ea6be503b12b6f885ee00c7375b2a8b"

URI_aarch64_voms = "${EPEL_MIRROR}/aarch64/Packages/v/voms-2.1.2-1.el10_0.aarch64.rpm;name=aarch64_voms;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms}"
SRC_URI[aarch64_voms.sha256sum] = "817bd4a6173396378bd71d20d4a2ddf3cb411a1c0fcf5747b311d92b4b384dd1"

URI_aarch64_voms-clients-cpp = "${EPEL_MIRROR}/aarch64/Packages/v/voms-clients-cpp-2.1.2-1.el10_0.aarch64.rpm;name=aarch64_voms-clients-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-clients-cpp}"
SRC_URI[aarch64_voms-clients-cpp.sha256sum] = "9022fb1317dfb4c23ccb1b995245b8f6b204b4d32be645c2da04b765216f09e4"
RPROVIDES:voms-clients-cpp:aarch64 = "virtual/voms-clients"

URI_aarch64_voms-devel = "${EPEL_MIRROR}/aarch64/Packages/v/voms-devel-2.1.2-1.el10_0.aarch64.rpm;name=aarch64_voms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-devel}"
SRC_URI[aarch64_voms-devel.sha256sum] = "93ecae744ff11c881255ec802d7f30b0e7144d0db0aa64b470b4176b8db8e582"

URI_aarch64_voms-doc = "${EPEL_MIRROR}/aarch64/Packages/v/voms-doc-2.1.2-1.el10_0.noarch.rpm;name=aarch64_voms-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-doc}"
SRC_URI[aarch64_voms-doc.sha256sum] = "2da57f1d9bb2d8a4a1aad7b4a79f05be132f51fab3d3055e10c88469e91589a0"

URI_aarch64_voms-server = "${EPEL_MIRROR}/aarch64/Packages/v/voms-server-2.1.2-1.el10_0.aarch64.rpm;name=aarch64_voms-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-server}"
SRC_URI[aarch64_voms-server.sha256sum] = "0f5992ed7756d8d1209ff914e527bd7ecf5f0804174389a1ebe5be350bf52361"

RDEPENDS:voms = " \
 bash \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 "
RDEPENDS:voms-clients-cpp = " \
 alternatives \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 voms \
 "
RDEPENDS:voms-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 voms \
 "
RDEPENDS:voms-doc = " \
 "
RDEPENDS:voms-server = " \
 bash \
 expat \
 glibc \
 gsoap \
 libgcc \
 libstdc++ \
 openssl-libs \
 shadow-utils \
 systemd \
 voms \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/voms-clients"

PROVIDES:append:aarch64 = " rpm/virtual/voms-clients"
