# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-human_format"
PV = "1.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-human_format+default-devel \
 rust-human_format+panic_parse-devel \
 rust-human_format-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-human_format-1.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6e38b22a7714f056fe88d51a99f498ded2e9c576f82cb858e91bb2941e03835"

URI_x86_64_v2_rust-human_format+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human_format+default-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human_format+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human_format+default-devel}"
SRC_URI[x86_64_v2_rust-human_format+default-devel.sha256sum] = "3986c48224dace32cceee66219e6f0571c8e8a2e981578599c6781f0ceffcf7c"

URI_x86_64_v2_rust-human_format+panic_parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human_format+panic_parse-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human_format+panic_parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human_format+panic_parse-devel}"
SRC_URI[x86_64_v2_rust-human_format+panic_parse-devel.sha256sum] = "a43e0f7fe3c01beca4aa7f408279a83fd4aaf8bffec0bfbe622a91726f96e69a"

URI_x86_64_v2_rust-human_format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human_format-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human_format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human_format-devel}"
SRC_URI[x86_64_v2_rust-human_format-devel.sha256sum] = "a7b55f7664fa1a541a6aa0d18265838c8ce24ebd77659019082afa1798d1e579"

URI_aarch64_rust-human_format+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human_format+default-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-human_format+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human_format+default-devel}"
SRC_URI[aarch64_rust-human_format+default-devel.sha256sum] = "beb99ae1e2fac88582f31847f8b78ebad29c88a289247d627ed94c63ff9977ad"

URI_aarch64_rust-human_format+panic_parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human_format+panic_parse-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-human_format+panic_parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human_format+panic_parse-devel}"
SRC_URI[aarch64_rust-human_format+panic_parse-devel.sha256sum] = "cd849451c7276413b84a019df4f22d50940fcc078cda3743f8707561d5c8b4ef"

URI_aarch64_rust-human_format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human_format-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-human_format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human_format-devel}"
SRC_URI[aarch64_rust-human_format-devel.sha256sum] = "ea0d49e6ef5daedfd23f6976f395a2c626181fd02d0b05ec145c268afa8db84b"

RDEPENDS:rust-human_format+default-devel = " \
 cargo \
 rust-human_format-devel \
 "
RDEPENDS:rust-human_format+panic_parse-devel = " \
 cargo \
 rust-human_format-devel \
 "
RDEPENDS:rust-human_format-devel = " \
 cargo \
 "
