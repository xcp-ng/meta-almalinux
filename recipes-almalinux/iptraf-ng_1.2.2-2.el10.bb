# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iptraf-ng"
PV = "1.2.2"
PR = "2.el10"
PACKAGES = " \
 iptraf-ng \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iptraf-ng-1.2.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52b483524fef7f445bd5a95c7574105d6c18c38da52acfb46581702a0c2ee8fe"

URI_x86_64_v2_iptraf-ng = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iptraf-ng-1.2.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_iptraf-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptraf-ng}"
SRC_URI[x86_64_v2_iptraf-ng.sha256sum] = "fca61a8fb695ec6581b338fa8e9e33d75836ccece48ed282eaebd660ef49d909"

URI_aarch64_iptraf-ng = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iptraf-ng-1.2.2-2.el10.aarch64.rpm;name=aarch64_iptraf-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptraf-ng}"
SRC_URI[aarch64_iptraf-ng.sha256sum] = "8a711e6f25bf0ac19f866b4b0849be66a430bc6420a944dd57485866d90e889a"

RDEPENDS:iptraf-ng = " \
 glibc \
 logrotate \
 ncurses-libs \
 "
