# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Tie-Hash-Method"
PV = "0.02"
PR = "32.el10_3"
PACKAGES = " \
 perl-Tie-Hash-Method \
 perl-Tie-Hash-Method-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Tie-Hash-Method-0.02-32.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ec0ecd6a8d39d221313105c9f64136fdc997530d120493899b32df523db4144"

URI_x86_64_v2_perl-Tie-Hash-Method = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tie-Hash-Method-0.02-32.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tie-Hash-Method;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-Hash-Method}"
SRC_URI[x86_64_v2_perl-Tie-Hash-Method.sha256sum] = "b8f2021051020b3ed1be0050672df2aee9db32781b50b2dbb86398fa016ec34b"

URI_x86_64_v2_perl-Tie-Hash-Method-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tie-Hash-Method-tests-0.02-32.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tie-Hash-Method-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-Hash-Method-tests}"
SRC_URI[x86_64_v2_perl-Tie-Hash-Method-tests.sha256sum] = "bff67f7ccf85ca3aeb1ec384b0aeee38c5ad608d65233c6052902eea72bf5976"

URI_aarch64_perl-Tie-Hash-Method = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tie-Hash-Method-0.02-32.el10_3.noarch.rpm;name=aarch64_perl-Tie-Hash-Method;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-Hash-Method}"
SRC_URI[aarch64_perl-Tie-Hash-Method.sha256sum] = "50c74eb8dc9587d289c5035b3539947170a56047bb12259c883b9aae7ea771f8"

URI_aarch64_perl-Tie-Hash-Method-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tie-Hash-Method-tests-0.02-32.el10_3.noarch.rpm;name=aarch64_perl-Tie-Hash-Method-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-Hash-Method-tests}"
SRC_URI[aarch64_perl-Tie-Hash-Method-tests.sha256sum] = "47916067d822fe2f8c427dfa65931e245093d1e329c302e5ba93bee90a66b9dd"

RDEPENDS:perl-Tie-Hash-Method = " \
 perl-Data-Dumper \
 perl-Exporter \
 perl-base \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Tie-Hash-Method-tests = " \
 bash \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Tie-Hash-Method \
 "
