# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Set-Scalar"
PV = "1.29"
PR = "29.el10_0"
PACKAGES = " \
 perl-Set-Scalar \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Set-Scalar-1.29-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d4432413a5a8c5d085aea4c6b74bc7784d50854e72619997967cb15d5a22262"

URI_x86_64_v2_perl-Set-Scalar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Set-Scalar-1.29-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Set-Scalar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Set-Scalar}"
SRC_URI[x86_64_v2_perl-Set-Scalar.sha256sum] = "d7e0cc783c5f00459b21da607a2990912871338748cd00adc2c7fd9369027c71"

URI_aarch64_perl-Set-Scalar = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Set-Scalar-1.29-29.el10_0.noarch.rpm;name=aarch64_perl-Set-Scalar;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Set-Scalar}"
SRC_URI[aarch64_perl-Set-Scalar.sha256sum] = "e52e83612880d920e07e56754bd31b472eacd0828c98a0b1ee70102509d485fc"

RDEPENDS:perl-Set-Scalar = " \
 perl-Exporter \
 perl-Set-Scalar \
 perl-constant \
 perl-libs \
 perl-overload \
 perl-vars \
 "
