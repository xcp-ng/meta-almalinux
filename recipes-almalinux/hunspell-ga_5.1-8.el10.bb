# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ga"
PV = "5.1"
PR = "8.el10"
PACKAGES = " \
 hunspell-ga \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ga-5.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ab7421a80e33239c3071fed78ed2c3cde6d35353292478b488dc3a9446c7b0c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ga-5.1-8.el10.noarch.rpm;name=x86_64_v2_hunspell-ga;unpack=0"
SRC_URI[x86_64_v2_hunspell-ga.sha256sum] = "2f70c9e2c76c191523600991e81f84394a301a29f1a396c5e4971f3084d58033"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ga-5.1-8.el10.noarch.rpm;name=aarch64_hunspell-ga;unpack=0"
SRC_URI[aarch64_hunspell-ga.sha256sum] = "2f70c9e2c76c191523600991e81f84394a301a29f1a396c5e4971f3084d58033"

RDEPENDS:hunspell-ga = " \
 hunspell-filesystem \
 "
