# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "makedumpfile"
PV = "1.7.7"
PR = "2.el10"
PACKAGES = " \
 makedumpfile \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/makedumpfile-1.7.7-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a20b41756c9261072f93b77dcb721c36e01a9d4df1bde6c9fdbc8d79bb8007e4"

URI_x86_64_v2_makedumpfile = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/makedumpfile-1.7.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_makedumpfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_makedumpfile}"
SRC_URI[x86_64_v2_makedumpfile.sha256sum] = "55f5e41d30eff0dfe8e9121a57d1cd2c64e36a72bbfa362b9942c674cc3e3a2c"

URI_aarch64_makedumpfile = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/makedumpfile-1.7.7-2.el10.aarch64.rpm;name=aarch64_makedumpfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_makedumpfile}"
SRC_URI[aarch64_makedumpfile.sha256sum] = "0d12e1646f42f213c42e7699afd081c292a6933a5fa2f0beda7133977ddec05b"

RDEPENDS:makedumpfile = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libgcc \
 libzstd \
 lzo \
 ncurses-libs \
 snappy \
 zlib-ng-compat \
 "
