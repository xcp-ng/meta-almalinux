# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustc-hash"
PV = "2.1.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustc-hash+default-devel \
 rust-rustc-hash+rand-devel \
 rust-rustc-hash+std-devel \
 rust-rustc-hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustc-hash-2.1.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a65b0b0c973c22319e7752225eb983bfc04b8562e8a9593f0bc6fbcc4fd5d56"

URI_x86_64_v2_rust-rustc-hash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-hash+default-devel-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-hash+default-devel}"
SRC_URI[x86_64_v2_rust-rustc-hash+default-devel.sha256sum] = "8b71712f9ac126ddbf91afac58de3ab2ba8a4612185bf33dca6ae8136d0ab743"

URI_x86_64_v2_rust-rustc-hash+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-hash+rand-devel-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-hash+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-hash+rand-devel}"
SRC_URI[x86_64_v2_rust-rustc-hash+rand-devel.sha256sum] = "4aa39db14297dfaa7173e135b80f68f83bf35ac530d6736a988363e706cc24f7"

URI_x86_64_v2_rust-rustc-hash+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-hash+std-devel-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-hash+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-hash+std-devel}"
SRC_URI[x86_64_v2_rust-rustc-hash+std-devel.sha256sum] = "6e603087090729f77d0aff1fef18cf485fe7aa694604e6ea247239c1dff1983a"

URI_x86_64_v2_rust-rustc-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-hash-devel-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-hash-devel}"
SRC_URI[x86_64_v2_rust-rustc-hash-devel.sha256sum] = "3f7a37968fbc476ead826254ce60372da6b25c5d804a329e38762ab4fb0eb820"

URI_aarch64_rust-rustc-hash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-hash+default-devel-2.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-rustc-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-hash+default-devel}"
SRC_URI[aarch64_rust-rustc-hash+default-devel.sha256sum] = "7db1f5d0fc7d7a09859a1ae9af2633828170d8ad80b4235dbd965fa08ecbf484"

URI_aarch64_rust-rustc-hash+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-hash+rand-devel-2.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-rustc-hash+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-hash+rand-devel}"
SRC_URI[aarch64_rust-rustc-hash+rand-devel.sha256sum] = "65c88f35fab094fdbd73f072a100377d1fd1e03a22056d62a3e6288727ce585e"

URI_aarch64_rust-rustc-hash+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-hash+std-devel-2.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-rustc-hash+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-hash+std-devel}"
SRC_URI[aarch64_rust-rustc-hash+std-devel.sha256sum] = "81b688b99240dd6d8a2ab686b83d848a7480484308691e70eb44237ee45994e8"

URI_aarch64_rust-rustc-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-hash-devel-2.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-rustc-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-hash-devel}"
SRC_URI[aarch64_rust-rustc-hash-devel.sha256sum] = "33754a8c6fb5b272ac8238431f892c12854000c3495b9420b982218bf760f340"

RDEPENDS:rust-rustc-hash+default-devel = " \
 cargo \
 rust-rustc-hash+std-devel \
 rust-rustc-hash-devel \
 "
RDEPENDS:rust-rustc-hash+rand-devel = " \
 cargo \
 rust-rand0.9+default-devel \
 rust-rustc-hash+std-devel \
 rust-rustc-hash-devel \
 "
RDEPENDS:rust-rustc-hash+std-devel = " \
 cargo \
 rust-rustc-hash-devel \
 "
RDEPENDS:rust-rustc-hash-devel = " \
 cargo \
 rust \
 "
