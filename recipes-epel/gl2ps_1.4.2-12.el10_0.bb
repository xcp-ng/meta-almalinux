# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gl2ps"
PV = "1.4.2"
PR = "12.el10_0"
PACKAGES = " \
 gl2ps \
 gl2ps-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gl2ps-1.4.2-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ac5d0fc0e06ac8f748dfcda69d1957e03797a52fb60a04da57743ae65ecafaa4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gl2ps-1.4.2-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gl2ps;unpack=0"
SRC_URI[x86_64_v2_gl2ps.sha256sum] = "6ef9afabcf6286e996309483e782f9a04a5b387bb3817aaa03db08240472abd5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gl2ps-devel-1.4.2-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gl2ps-devel;unpack=0"
SRC_URI[x86_64_v2_gl2ps-devel.sha256sum] = "64281b97cd109f818eccdd61ef22c8b08037b8a4b1558ff9d2303bd610a04410"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gl2ps-1.4.2-12.el10_0.aarch64.rpm;name=aarch64_gl2ps;unpack=0"
SRC_URI[aarch64_gl2ps.sha256sum] = "8cbf12763434e44570a5b538a429d59ecf92ac1a5e79be7fedede9201e7ffccc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gl2ps-devel-1.4.2-12.el10_0.aarch64.rpm;name=aarch64_gl2ps-devel;unpack=0"
SRC_URI[aarch64_gl2ps-devel.sha256sum] = "e2eee7fa09d2ee09933cf0bc9ade226b5dbe1217fca27df29c34409947796deb"

RDEPENDS:gl2ps = " \
 glibc \
 libglvnd-glx \
 libpng \
 zlib-ng-compat \
 "
RDEPENDS:gl2ps-devel = " \
 gl2ps \
 mesa-libGL-devel \
 "
