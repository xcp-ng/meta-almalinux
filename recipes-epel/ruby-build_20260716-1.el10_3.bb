# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby-build"
PV = "20260716"
PR = "1.el10_3"
PACKAGES = " \
 ruby-build \
 ruby-build-all \
 ruby-build-core \
 ruby-build-jruby \
 ruby-build-mruby \
 ruby-build-others \
 ruby-build-picoruby \
 ruby-build-rbenv \
 ruby-build-ruby \
 ruby-build-truffleruby \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/ruby-build-20260716-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4551b71e6e0af19f1e37b2abd6e60dda20bec33cb633fbf74647a5c7c893a5b8"

URI_x86_64_v2_ruby-build = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-20260716-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build}"
SRC_URI[x86_64_v2_ruby-build.sha256sum] = "e541ddcee62645721d4a9098e6a43ab5c20914fb12dc86c6d926f8763f90ad11"

URI_x86_64_v2_ruby-build-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-all-20260716-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-all}"
SRC_URI[x86_64_v2_ruby-build-all.sha256sum] = "5373a53c3c59d145677a33acf19c9c5697b100aa21acfa877156b7b3c4029ae5"

URI_x86_64_v2_ruby-build-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-core-20260716-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-core}"
SRC_URI[x86_64_v2_ruby-build-core.sha256sum] = "38e5726cda6418b4363a06ac9bb25daab494482423ddf83ba2528d8ead07fbcf"

URI_x86_64_v2_ruby-build-jruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-jruby-20260716-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-jruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-jruby}"
SRC_URI[x86_64_v2_ruby-build-jruby.sha256sum] = "3cb67113f322992bf3806ecef00f44c61c823860c08b3b82ea25688e68e19015"

URI_x86_64_v2_ruby-build-mruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-mruby-20260716-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-mruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-mruby}"
SRC_URI[x86_64_v2_ruby-build-mruby.sha256sum] = "f783119e510cdbfad3a876ea93645cdc592b75beb7105c28b4fa4e5a682c6c8f"

URI_x86_64_v2_ruby-build-others = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-others-20260716-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-others;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-others}"
SRC_URI[x86_64_v2_ruby-build-others.sha256sum] = "881c168f9b74865aaae802aaa929fb14542593e8399129e09d6b09908efba2c6"

URI_x86_64_v2_ruby-build-picoruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-picoruby-20260716-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-picoruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-picoruby}"
SRC_URI[x86_64_v2_ruby-build-picoruby.sha256sum] = "bf92d559689ba5416f45dc2b7a476cded8b26013ed3cb3660eda2a4f4ff2e80d"

URI_x86_64_v2_ruby-build-rbenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-rbenv-20260716-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-rbenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-rbenv}"
SRC_URI[x86_64_v2_ruby-build-rbenv.sha256sum] = "d27ed9a52d200c91a778968daf63acd6d0da032f2ee1577cf5a7cc9c5d3ac983"

URI_x86_64_v2_ruby-build-ruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-ruby-20260716-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-ruby}"
SRC_URI[x86_64_v2_ruby-build-ruby.sha256sum] = "eed0e7c86e835a822884b71fc92be9318434a8c4d166817f03f92d1adf10679f"

URI_x86_64_v2_ruby-build-truffleruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-truffleruby-20260716-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-truffleruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-truffleruby}"
SRC_URI[x86_64_v2_ruby-build-truffleruby.sha256sum] = "9a228681b1f635a577c5f4d63b07a3a8bdaa12d527d8638f587db18aba6d0ea1"

URI_aarch64_ruby-build = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-20260716-1.el10_3.noarch.rpm;name=aarch64_ruby-build;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build}"
SRC_URI[aarch64_ruby-build.sha256sum] = "b9e0560c773bccd47ea79b98c5ab0f5637a4fc32f081d8c43c53c4d1b572ab2d"

URI_aarch64_ruby-build-all = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-all-20260716-1.el10_3.noarch.rpm;name=aarch64_ruby-build-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-all}"
SRC_URI[aarch64_ruby-build-all.sha256sum] = "6317c177a6d37ecf22a4bd1614a9c65dd6ec786d5eba2523333032e0bebc928f"

URI_aarch64_ruby-build-core = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-core-20260716-1.el10_3.noarch.rpm;name=aarch64_ruby-build-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-core}"
SRC_URI[aarch64_ruby-build-core.sha256sum] = "7f65bd20cbf644fdeceddfdbf0e397148e9790352ca61caa93be4151a24724e9"

URI_aarch64_ruby-build-jruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-jruby-20260716-1.el10_3.noarch.rpm;name=aarch64_ruby-build-jruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-jruby}"
SRC_URI[aarch64_ruby-build-jruby.sha256sum] = "32d70696b8c40b34d04654e82eaa174b6b5af67833cb0164ae0b584d94e98a39"

URI_aarch64_ruby-build-mruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-mruby-20260716-1.el10_3.noarch.rpm;name=aarch64_ruby-build-mruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-mruby}"
SRC_URI[aarch64_ruby-build-mruby.sha256sum] = "4ad9822a49b40b4b7ac9a57946d7e13168810800dea230a437f5cd27a01e064e"

URI_aarch64_ruby-build-others = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-others-20260716-1.el10_3.noarch.rpm;name=aarch64_ruby-build-others;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-others}"
SRC_URI[aarch64_ruby-build-others.sha256sum] = "e27147da41d6a049e08427b400b7cd0702278396a0efe882cf5fbb0a331839ce"

URI_aarch64_ruby-build-picoruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-picoruby-20260716-1.el10_3.noarch.rpm;name=aarch64_ruby-build-picoruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-picoruby}"
SRC_URI[aarch64_ruby-build-picoruby.sha256sum] = "f4078eaf9fd7a2c9e24aac631c909645f3680b75894fd69330e99c4bf353a35a"

URI_aarch64_ruby-build-rbenv = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-rbenv-20260716-1.el10_3.noarch.rpm;name=aarch64_ruby-build-rbenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-rbenv}"
SRC_URI[aarch64_ruby-build-rbenv.sha256sum] = "8e7751e2b542f2394d56fb487372e22a7e41240183de00cf828c8475e9a3817a"

URI_aarch64_ruby-build-ruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-ruby-20260716-1.el10_3.noarch.rpm;name=aarch64_ruby-build-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-ruby}"
SRC_URI[aarch64_ruby-build-ruby.sha256sum] = "1ad98781c60b7411b20c9a1adb648c62f8e0b4967da8148165b105275b04969b"

URI_aarch64_ruby-build-truffleruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-truffleruby-20260716-1.el10_3.noarch.rpm;name=aarch64_ruby-build-truffleruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-truffleruby}"
SRC_URI[aarch64_ruby-build-truffleruby.sha256sum] = "4201e28e417518cb1175061cf237848e07470511bf9da439d102d0dca2d5ad26"

RDEPENDS:ruby-build = " \
 ruby-build-core \
 "
RDEPENDS:ruby-build-all = " \
 ruby-build \
 ruby-build-core \
 ruby-build-jruby \
 ruby-build-mruby \
 ruby-build-others \
 ruby-build-picoruby \
 ruby-build-ruby \
 ruby-build-truffleruby \
 "
RDEPENDS:ruby-build-core = " \
 bash \
 "
RDEPENDS:ruby-build-jruby = " \
 gcc-c++ \
 java-latest-openjdk-headless \
 make \
 ruby-build-core \
 "
RDEPENDS:ruby-build-mruby = " \
 ruby \
 ruby-build-core \
 rubygem-rake \
 "
RDEPENDS:ruby-build-others = " \
 ruby-build-core \
 "
RDEPENDS:ruby-build-picoruby = " \
 gcc \
 git-core \
 ruby \
 ruby-build-core \
 rubygem-rake \
 "
RDEPENDS:ruby-build-rbenv = " \
 bash \
 rbenv \
 ruby-build \
 "
RDEPENDS:ruby-build-ruby = " \
 gcc \
 libffi-devel \
 libyaml-devel \
 perl-File-Compare \
 perl-File-Copy \
 perl-FindBin \
 perl-IPC-Cmd \
 perl-Time-Piece \
 perl-interpreter \
 perl-lib \
 ruby-build-core \
 zlib-ng-compat-devel \
 "
RDEPENDS:ruby-build-truffleruby = " \
 gcc \
 libyaml-devel \
 ruby-build-core \
 "
