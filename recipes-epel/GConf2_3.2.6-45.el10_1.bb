# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "GConf2"
PV = "3.2.6"
PR = "45.el10_1"
PACKAGES = " \
 GConf2 \
 GConf2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/GConf2-3.2.6-45.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1b35f95bf5acabaaaccd3be336fe71b309bd50e378f13663bdf754b7a239d2c"

URI_x86_64_v2_GConf2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/GConf2-3.2.6-45.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_GConf2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_GConf2}"
SRC_URI[x86_64_v2_GConf2.sha256sum] = "88436cf9451f37cc63be569120f524b4e35c10a1deff63fcf16b8bdb493cb96d"

URI_x86_64_v2_GConf2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/GConf2-devel-3.2.6-45.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_GConf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_GConf2-devel}"
SRC_URI[x86_64_v2_GConf2-devel.sha256sum] = "17810fc6dd8a533b83367b22c61336127eed207813849d9a4e5ff1108d7c8ad8"

URI_aarch64_GConf2 = "${EPEL_MIRROR}/aarch64/Packages/g/GConf2-3.2.6-45.el10_1.aarch64.rpm;name=aarch64_GConf2;unpack=0"
SRC_URI:append = " ${URI_aarch64_GConf2}"
SRC_URI[aarch64_GConf2.sha256sum] = "fd33504f9cd014ec3f5329e435f7189c480d40cfd0d99249e3ab2f274fbf9598"

URI_aarch64_GConf2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/GConf2-devel-3.2.6-45.el10_1.aarch64.rpm;name=aarch64_GConf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_GConf2-devel}"
SRC_URI[aarch64_GConf2-devel.sha256sum] = "30637256f4c12ef00a2daa9f50730dd48c3f21323cd915e894defe05818d523e"

RDEPENDS:GConf2 = " \
 bash \
 dbus \
 dbus-glib \
 dbus-libs \
 glib2 \
 glibc \
 libxml2 \
 polkit-libs \
 procps-ng \
 "
RDEPENDS:GConf2-devel = " \
 GConf2 \
 dbus-devel \
 glib2-devel \
 pkgconf-pkg-config \
 "
