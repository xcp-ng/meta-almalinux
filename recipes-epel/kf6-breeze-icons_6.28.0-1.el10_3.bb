# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-breeze-icons"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 breeze-icon-theme \
 breeze-icon-theme-rcc \
 kf6-breeze-icons \
 kf6-breeze-icons-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-breeze-icons-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6baa25853330aeb6d964f42e03dab032ddda587ac4962b8a73c582bc65d8c3a"

URI_x86_64_v2_breeze-icon-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-icon-theme-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-icon-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-icon-theme}"
SRC_URI[x86_64_v2_breeze-icon-theme.sha256sum] = "a88d64bec7f524b3290d58ee27776983c21499f38d1203cc72d6833ee3f1a06f"

URI_x86_64_v2_breeze-icon-theme-rcc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-icon-theme-rcc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-icon-theme-rcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-icon-theme-rcc}"
SRC_URI[x86_64_v2_breeze-icon-theme-rcc.sha256sum] = "4003086add6363a46b1987b7cc6d9f2fef4dc8a6b416c28b937aeee6ff22d557"

URI_x86_64_v2_kf6-breeze-icons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-breeze-icons-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-breeze-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-breeze-icons}"
SRC_URI[x86_64_v2_kf6-breeze-icons.sha256sum] = "b9164da7c17de19529b8d5118d412880d690681dd2345978649ac66b1be4a1a2"

URI_x86_64_v2_kf6-breeze-icons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-breeze-icons-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-breeze-icons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-breeze-icons-devel}"
SRC_URI[x86_64_v2_kf6-breeze-icons-devel.sha256sum] = "6131c72bba785731a5edfa4d0e8e69d8065ffad9c072e9c305e1cf9b294687f4"

URI_aarch64_breeze-icon-theme = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-icon-theme-6.28.0-1.el10_3.noarch.rpm;name=aarch64_breeze-icon-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-icon-theme}"
SRC_URI[aarch64_breeze-icon-theme.sha256sum] = "d1a65dd35c861fe4a7d99b581d3519e37c1cf1fcec07cfc791e690acdb08c3a4"

URI_aarch64_breeze-icon-theme-rcc = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-icon-theme-rcc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_breeze-icon-theme-rcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-icon-theme-rcc}"
SRC_URI[aarch64_breeze-icon-theme-rcc.sha256sum] = "b1f5ed0fc01846aad73c02a12ec03ce1872217850ec76bfadc4632299d052ff1"

URI_aarch64_kf6-breeze-icons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-breeze-icons-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-breeze-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-breeze-icons}"
SRC_URI[aarch64_kf6-breeze-icons.sha256sum] = "8277d462866e844c32d8619f7003d10013e40fa5d59d673ae2485be01a5ea409"

URI_aarch64_kf6-breeze-icons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-breeze-icons-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-breeze-icons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-breeze-icons-devel}"
SRC_URI[aarch64_kf6-breeze-icons-devel.sha256sum] = "b2b9af3893bc2b402887f2bab6b3cf414955e796619dc344a6f26e93bfd596f2"

RDEPENDS:breeze-icon-theme = " \
 almalinux-logos \
 bash \
 hicolor-icon-theme \
 "
RDEPENDS:breeze-icon-theme-rcc = " \
 "
RDEPENDS:kf6-breeze-icons = " \
 breeze-icon-theme \
 glibc \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-breeze-icons-devel = " \
 cmake-filesystem \
 kf6-breeze-icons \
 "
