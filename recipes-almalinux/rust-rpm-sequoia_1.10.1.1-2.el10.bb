# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rpm-sequoia"
PV = "1.10.1.1"
PR = "2.el10"
PACKAGES = " \
 rpm-sequoia \
 rpm-sequoia-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rust-rpm-sequoia-1.10.1.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e20732fb3fc19c988b15a58ade3810467de958146167ffe815b8b19d1b6cf943"

URI_x86_64_v2_rpm-sequoia = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-sequoia-1.10.1.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_rpm-sequoia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-sequoia}"
SRC_URI[x86_64_v2_rpm-sequoia.sha256sum] = "da71847e3dab6d2f4c76a1ccb884e82f10414d5f31ddbeb6847c32955f6a1305"

URI_x86_64_v2_rpm-sequoia-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rpm-sequoia-devel-1.10.1.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_rpm-sequoia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-sequoia-devel}"
SRC_URI[x86_64_v2_rpm-sequoia-devel.sha256sum] = "664467e9750cd71fa21bd2bc40e3289407f2992beab2339763d00c9d09fe0471"

URI_aarch64_rpm-sequoia = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-sequoia-1.10.1.1-2.el10.aarch64.rpm;name=aarch64_rpm-sequoia;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-sequoia}"
SRC_URI[aarch64_rpm-sequoia.sha256sum] = "ba5b9a0cff530dbf916e4f5d53c0ab9e3ff6919d63abd2249cefbc5ecc19c4ad"

URI_aarch64_rpm-sequoia-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rpm-sequoia-devel-1.10.1.1-2.el10.aarch64.rpm;name=aarch64_rpm-sequoia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-sequoia-devel}"
SRC_URI[aarch64_rpm-sequoia-devel.sha256sum] = "73490207273b584f08bbd1f3c0adb338f3695ddb2ec895c5bd60804eaace6b1c"

RDEPENDS:rpm-sequoia = " \
 glibc \
 libgcc \
 openssl-libs \
 "
RDEPENDS:rpm-sequoia-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 rpm-sequoia \
 "
