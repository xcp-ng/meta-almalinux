# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-mongodb"
PV = "1.21.9"
PR = "1.el10_2"
PACKAGES = " \
 php-pecl-mongodb \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-pecl-mongodb-1.21.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d8003fcf11d37e76e1745ef42f87ce82b5d2c92d128833cbb22a6e4d74ce0827"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-mongodb-1.21.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-mongodb;unpack=0"
SRC_URI[x86_64_v2_php-pecl-mongodb.sha256sum] = "0a7d0f067fd5c8139f8b6028c89c749171de208db3b13aa2b4e9ff3a25f4bfa7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-mongodb-1.21.9-1.el10_2.aarch64.rpm;name=aarch64_php-pecl-mongodb;unpack=0"
SRC_URI[aarch64_php-pecl-mongodb.sha256sum] = "5e423b99ac775a4f7ad09c4cef6257de6385451fd8ecd57f059442e6eca16a4a"

RDEPENDS:php-pecl-mongodb:x86_64_v2 = " \
 glibc \
 libbson \
 libmongocrypt \
 mongo-c-driver-libs \
 php-common \
 virtual/php-json_x86-64_ \
"
RDEPENDS:php-pecl-mongodb:aarch64 = " \
 glibc \
 libbson \
 libmongocrypt \
 mongo-c-driver-libs \
 php-common \
 virtual/php-json_aarch-64_ \
"
