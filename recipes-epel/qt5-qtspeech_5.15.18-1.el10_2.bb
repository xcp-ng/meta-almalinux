# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtspeech"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtspeech \
 qt5-qtspeech-devel \
 qt5-qtspeech-examples \
 qt5-qtspeech-speechd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtspeech-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e80d15bc1af0f345c811a9e008dd7a8f6b6d62543e1135e9505507f59353c3ac"

URI_x86_64_v2_qt5-qtspeech = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtspeech-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtspeech;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtspeech}"
SRC_URI[x86_64_v2_qt5-qtspeech.sha256sum] = "0552e46f39b5b8f93a07e5655df50a50a87c58c2984ca495f4b83e8bcddaadc1"

URI_x86_64_v2_qt5-qtspeech-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtspeech-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtspeech-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtspeech-devel}"
SRC_URI[x86_64_v2_qt5-qtspeech-devel.sha256sum] = "23bcdd8ff3e2df4c400e1eca18790dcd9aecbb89cb8e3c19abccdb6a059f6180"

URI_x86_64_v2_qt5-qtspeech-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtspeech-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtspeech-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtspeech-examples}"
SRC_URI[x86_64_v2_qt5-qtspeech-examples.sha256sum] = "617e4349f09cbe523d15ba790fe97ae644f783c24925ff00821d9841d78beaab"

URI_x86_64_v2_qt5-qtspeech-speechd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtspeech-speechd-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtspeech-speechd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtspeech-speechd}"
SRC_URI[x86_64_v2_qt5-qtspeech-speechd.sha256sum] = "823c23478fe667e0443cacb4900b56f9c5fc446e32689e5df88dd5f74cd775bb"

URI_aarch64_qt5-qtspeech = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtspeech-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtspeech;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtspeech}"
SRC_URI[aarch64_qt5-qtspeech.sha256sum] = "a7ed2d03c62543e0c17d0aa3d7670da297ab433d138c04c80599b1cc74b6ea5c"

URI_aarch64_qt5-qtspeech-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtspeech-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtspeech-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtspeech-devel}"
SRC_URI[aarch64_qt5-qtspeech-devel.sha256sum] = "7108a2529e534da3b4dd0e94bf3016de2fa7ee821e28f565010d9123fcc6c605"

URI_aarch64_qt5-qtspeech-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtspeech-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtspeech-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtspeech-examples}"
SRC_URI[aarch64_qt5-qtspeech-examples.sha256sum] = "1061c055bbc0834fd2e766fcee8fa09a593b8b831b89f2747596c32689c4ad79"

URI_aarch64_qt5-qtspeech-speechd = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtspeech-speechd-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtspeech-speechd;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtspeech-speechd}"
SRC_URI[aarch64_qt5-qtspeech-speechd.sha256sum] = "fde2a1c843e4f77182354d41ed38defb0ecfb3c8de361d5fe520c5fb14cf5b18"

RDEPENDS:qt5-qtspeech = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtspeech-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtspeech \
 "
RDEPENDS:qt5-qtspeech-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtspeech \
 "
RDEPENDS:qt5-qtspeech-speechd = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtspeech \
 speech-dispatcher-libs \
 "
