# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_paste"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_paste+default-devel \
 rust-uu_paste-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_paste-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "852b4d1f7e9c3d082c3b55517a9d7cbd0b454593efb75fe1f229e4f6391fd99d"

URI_x86_64_v2_rust-uu_paste+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_paste+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_paste+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_paste+default-devel}"
SRC_URI[x86_64_v2_rust-uu_paste+default-devel.sha256sum] = "3ca9fcf40521d295e2721bc60029cd4540ab4aa79b8ea0a7a04ec376235f3aec"

URI_x86_64_v2_rust-uu_paste-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_paste-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_paste-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_paste-devel}"
SRC_URI[x86_64_v2_rust-uu_paste-devel.sha256sum] = "c97febf86f86336c050079b59dfa3d6d27a263b4ee916c8e54d06b386077c485"

URI_aarch64_rust-uu_paste+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_paste+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_paste+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_paste+default-devel}"
SRC_URI[aarch64_rust-uu_paste+default-devel.sha256sum] = "2a0c17753af5e457810b9c021e6aab19ca3c3d6f3d7eb19aed28beb4ee6244d9"

URI_aarch64_rust-uu_paste-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_paste-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_paste-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_paste-devel}"
SRC_URI[aarch64_rust-uu_paste-devel.sha256sum] = "b5f968089b83f794fb99705343c9fe4165290d917ec36b730eb62a71e3d7ce4a"

RDEPENDS:rust-uu_paste+default-devel = " \
 cargo \
 rust-uu_paste-devel \
 "
RDEPENDS:rust-uu_paste-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+i18n-charmap-devel \
 "
