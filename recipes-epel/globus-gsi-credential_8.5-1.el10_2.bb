# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gsi-credential"
PV = "8.5"
PR = "1.el10_2"
PACKAGES = " \
 globus-gsi-credential \
 globus-gsi-credential-devel \
 globus-gsi-credential-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gsi-credential-8.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8051b7d0e07a27b3d071ef9d7e10e5400e48847bc99657fedec5af78e4f9f63"

URI_x86_64_v2_globus-gsi-credential = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-credential-8.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-credential;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-credential}"
SRC_URI[x86_64_v2_globus-gsi-credential.sha256sum] = "81bd019259394b5d054543caa51d15a131168d26569fc13264e189e7a8e3793b"

URI_x86_64_v2_globus-gsi-credential-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-credential-devel-8.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-credential-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-credential-devel}"
SRC_URI[x86_64_v2_globus-gsi-credential-devel.sha256sum] = "138e133f5465452cd06758cd986303efa3ad08d439a14e48b7e03467cbd4a675"

URI_x86_64_v2_globus-gsi-credential-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-credential-doc-8.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gsi-credential-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-credential-doc}"
SRC_URI[x86_64_v2_globus-gsi-credential-doc.sha256sum] = "6eb9d0b9a08e90f26d59d5ba35b711560991033be54e5a5fa53be76d1e647cc9"

URI_aarch64_globus-gsi-credential = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-credential-8.5-1.el10_2.aarch64.rpm;name=aarch64_globus-gsi-credential;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-credential}"
SRC_URI[aarch64_globus-gsi-credential.sha256sum] = "52ac77377150638a9eb923f2e4d3b760a350e75b15221f6126100635a4d78330"

URI_aarch64_globus-gsi-credential-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-credential-devel-8.5-1.el10_2.aarch64.rpm;name=aarch64_globus-gsi-credential-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-credential-devel}"
SRC_URI[aarch64_globus-gsi-credential-devel.sha256sum] = "22a453a2ff6f0caeb9ad7d3fdd6abdeb9fc4e572cf395983d931cb505d0231dc"

URI_aarch64_globus-gsi-credential-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-credential-doc-8.5-1.el10_2.noarch.rpm;name=aarch64_globus-gsi-credential-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-credential-doc}"
SRC_URI[aarch64_globus-gsi-credential-doc.sha256sum] = "ddddd667948f9973d7e8c57a5a710d05682bbfa28453066642c1ef672603f695"

RDEPENDS:globus-gsi-credential = " \
 glibc \
 globus-common \
 globus-gsi-callback \
 globus-gsi-cert-utils \
 globus-gsi-openssl-error \
 globus-gsi-sysconfig \
 openssl-libs \
 "
RDEPENDS:globus-gsi-credential-devel = " \
 globus-common-devel \
 globus-gsi-callback-devel \
 globus-gsi-cert-utils-devel \
 globus-gsi-credential \
 globus-gsi-openssl-error-devel \
 globus-gsi-sysconfig-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gsi-credential-doc = " \
 "
