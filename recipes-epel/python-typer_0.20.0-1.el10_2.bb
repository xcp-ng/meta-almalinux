# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-typer"
PV = "0.20.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-typer \
 python3-typer-cli \
 python3-typer-slim \
 python3-typer-slim+standard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-typer-0.20.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fae6a2b31ddbb420d02146b2bc230eb0675b09d4f856b6df64b5d847c1416bc0"

URI_x86_64_v2_python3-typer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-typer-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-typer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-typer}"
SRC_URI[x86_64_v2_python3-typer.sha256sum] = "a6b846067822ad509d8b5076f6a8262570f13c58eeb307fbfb110acdd2570705"

URI_x86_64_v2_python3-typer-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-typer-cli-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-typer-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-typer-cli}"
SRC_URI[x86_64_v2_python3-typer-cli.sha256sum] = "3a5693d43a4ea97b60d512bef98a562f91d986d985f02c615a79ee735f96d6e7"

URI_x86_64_v2_python3-typer-slim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-typer-slim-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-typer-slim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-typer-slim}"
SRC_URI[x86_64_v2_python3-typer-slim.sha256sum] = "23ecf995a7215f8406f01dba2cfdb7fc150e3410f1ad9fc840351bb374a1755b"

URI_x86_64_v2_python3-typer-slim+standard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-typer-slim+standard-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-typer-slim+standard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-typer-slim+standard}"
SRC_URI[x86_64_v2_python3-typer-slim+standard.sha256sum] = "5290ec29cee2a303c05ec0b5d1eb336aa29c4c079f1c75b5188916af6fc016a2"

URI_aarch64_python3-typer = "${EPEL_MIRROR}/aarch64/Packages/p/python3-typer-0.20.0-1.el10_2.noarch.rpm;name=aarch64_python3-typer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-typer}"
SRC_URI[aarch64_python3-typer.sha256sum] = "00f2796bfcfa14b2dd0ec34ca1d5f442ad612dc4f4d3eb9a2cf407e7df284474"

URI_aarch64_python3-typer-cli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-typer-cli-0.20.0-1.el10_2.noarch.rpm;name=aarch64_python3-typer-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-typer-cli}"
SRC_URI[aarch64_python3-typer-cli.sha256sum] = "f995a1f88d5e727bdb8476598f1d436836d89f7027c634a31eca833d725d8bd6"

URI_aarch64_python3-typer-slim = "${EPEL_MIRROR}/aarch64/Packages/p/python3-typer-slim-0.20.0-1.el10_2.noarch.rpm;name=aarch64_python3-typer-slim;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-typer-slim}"
SRC_URI[aarch64_python3-typer-slim.sha256sum] = "b83ba51a42d03711f0b8d5cdf7972f6959513b4c83fb89dceae81c36f25192b4"

URI_aarch64_python3-typer-slim+standard = "${EPEL_MIRROR}/aarch64/Packages/p/python3-typer-slim+standard-0.20.0-1.el10_2.noarch.rpm;name=aarch64_python3-typer-slim+standard;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-typer-slim+standard}"
SRC_URI[aarch64_python3-typer-slim+standard.sha256sum] = "29df307b14359a4a36ae96d4887b37008b0801e054dfbcfe7c1213fbe70c4332"

RDEPENDS:python3-typer = " \
 python3 \
 python3-click \
 python3-rich \
 python3-shellingham \
 python3-typer-cli \
 python3-typer-slim \
 python3-typing-extensions \
 "
RDEPENDS:python3-typer-cli = " \
 python3 \
 python3-typer \
 python3-typer-slim \
 "
RDEPENDS:python3-typer-slim = " \
 python3 \
 python3-click \
 python3-typing-extensions \
 "
RDEPENDS:python3-typer-slim+standard = " \
 python3 \
 python3-rich \
 python3-shellingham \
 python3-typer-slim \
 "
