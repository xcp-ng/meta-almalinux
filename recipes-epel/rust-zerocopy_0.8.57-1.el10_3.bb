# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerocopy"
PV = "0.8.57"
PR = "1.el10_3"
PACKAGES = " \
 rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel \
 rust-zerocopy+alloc-devel \
 rust-zerocopy+default-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+float-nightly-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy+simd-nightly-devel \
 rust-zerocopy+std-devel \
 rust-zerocopy+zerocopy-derive-devel \
 rust-zerocopy-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-zerocopy-0.8.57-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "622faddcb70e6c19ab0ffe3958c82a8b5097b98bef17d75cfeeba0007218b577"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel-0.8.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel.sha256sum] = "7d514431d66af84f990237646a8c05d5a0baed2cbd67f5a150829daa75e0e831"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+alloc-devel-0.8.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+alloc-devel.sha256sum] = "58bf4afde8c2a5889edb68a8f356496f5a741e60949864bba3a503c3f2aaca23"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+default-devel-0.8.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+default-devel.sha256sum] = "9c68b24a5a15ef70f569e120dc14d3b7c677601f3acc62ab27975f364b856a56"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+derive-devel-0.8.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+derive-devel.sha256sum] = "9e712d359ec913690dda9531293097bbae57cf5647aef6963dbd8bd1e1eae4e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+float-nightly-devel-0.8.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+float-nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+float-nightly-devel.sha256sum] = "b95c5f3a08ff6d82acecab0cc3d138cb847811f3e60863d81b97c6fb725607a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+simd-devel-0.8.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+simd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+simd-devel.sha256sum] = "e4bb359bd27a67ec0b9218adcedf1f29b0afa3772135b5d89f98d30736309cf0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+simd-nightly-devel-0.8.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+simd-nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+simd-nightly-devel.sha256sum] = "7f50d616fbb412407e10f01b987cae1b098a94bc8ba4c14663dd3303c9d24d95"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+std-devel-0.8.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+std-devel.sha256sum] = "0601460cbbf992565e7989a69e601b16c17054bfe35914f8b05ede756350f560"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+zerocopy-derive-devel-0.8.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+zerocopy-derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+zerocopy-derive-devel.sha256sum] = "6dcecc6ad4dae924f771c40a3708c9f681b75e691cb2aedce420e5317ec61c7a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-devel-0.8.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy-devel.sha256sum] = "368fae944f213081fb74e3f2fa6b1d9cbb86416d204126deb4b3f54e7cd87161"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel-0.8.57-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel.sha256sum] = "89aa210a8ffb1de62b0a5a6a3ec89fdbea665c57fa20b8394836f2ab8f7281d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+alloc-devel-0.8.57-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+alloc-devel.sha256sum] = "ffd5be9793dd5b75634ff407997291f33faeba58d511abf8c2ef451b78d707d4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+default-devel-0.8.57-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+default-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+default-devel.sha256sum] = "4bb050063c9d1c8c054855c37f6159da671e4be645b61d2255bd7f435c242989"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+derive-devel-0.8.57-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+derive-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+derive-devel.sha256sum] = "5ca4684bb8c61f5872d1126554ec8623861ff64ca18ccc9ccd45812783881011"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+float-nightly-devel-0.8.57-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+float-nightly-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+float-nightly-devel.sha256sum] = "da63496fed63d10a0c16436f1e07fe6b3bc54f035ec28f7646220c9808d86b8c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+simd-devel-0.8.57-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+simd-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+simd-devel.sha256sum] = "662cba1d0a245a8ecc932b3090772367df4b511e135e54c6e306d8ea160da79e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+simd-nightly-devel-0.8.57-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+simd-nightly-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+simd-nightly-devel.sha256sum] = "8941424ff603d18948d97df5bb899de1cfc378c297fe20990b624bf4df52790d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+std-devel-0.8.57-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+std-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+std-devel.sha256sum] = "07c3f5e3c2e01e4e561b49ffac1db55e3b65f86e389104afd8cd594073739132"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+zerocopy-derive-devel-0.8.57-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+zerocopy-derive-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+zerocopy-derive-devel.sha256sum] = "edd6ab512d27a40b05018dab90e92c320454badc7dc46bbae0c75f8f2c18b90f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-devel-0.8.57-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy-devel.sha256sum] = "a8e5e56456eaab20da719f8a4e7ef56011808e9e278348b198344354bcee9dff"

RDEPENDS:rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel = " \
 cargo \
 rust-zerocopy+alloc-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy+std-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+alloc-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+default-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+derive-devel = " \
 cargo \
 rust-zerocopy+zerocopy-derive-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+float-nightly-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+simd-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+simd-nightly-devel = " \
 cargo \
 rust-zerocopy+simd-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+std-devel = " \
 cargo \
 rust-zerocopy+alloc-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+zerocopy-derive-devel = " \
 cargo \
 rust-zerocopy-derive+default-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy-devel = " \
 cargo \
 rust \
 rust-zerocopy-derive+default-devel \
 "
