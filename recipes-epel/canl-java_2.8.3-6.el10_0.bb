# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "canl-java"
PV = "2.8.3"
PR = "6.el10_0"
PACKAGES = " \
 canl-java \
 canl-java-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/canl-java-2.8.3-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96d92881157ea59006f9804cc2310f160bcb8987f164e9384db414b391fef15d"

URI_x86_64_v2_canl-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/canl-java-2.8.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_canl-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_canl-java}"
SRC_URI[x86_64_v2_canl-java.sha256sum] = "90bd353ab8098e4b34e349511b4f6206be7c0a3369663e3801c0d24f1bde0949"

URI_x86_64_v2_canl-java-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/canl-java-javadoc-2.8.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_canl-java-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_canl-java-javadoc}"
SRC_URI[x86_64_v2_canl-java-javadoc.sha256sum] = "cb0c2e7e8de6dfd04a36fa608211c28f371fee89d26785cca9f63a8b2d7a279d"

URI_aarch64_canl-java = "${EPEL_MIRROR}/aarch64/Packages/c/canl-java-2.8.3-6.el10_0.noarch.rpm;name=aarch64_canl-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_canl-java}"
SRC_URI[aarch64_canl-java.sha256sum] = "13f6ceaaf76eef18e04f8225a5a9a9ad1ff2588e1dfb05a1b5f40b24719116f4"

URI_aarch64_canl-java-javadoc = "${EPEL_MIRROR}/aarch64/Packages/c/canl-java-javadoc-2.8.3-6.el10_0.noarch.rpm;name=aarch64_canl-java-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_canl-java-javadoc}"
SRC_URI[aarch64_canl-java-javadoc.sha256sum] = "f012ae89ffdc074e8dc412f341b29314e5fbb823c6de87bcd5241823e7d74f33"

RDEPENDS:canl-java = " \
 apache-commons-io \
 bouncycastle \
 bouncycastle-pkix \
 javapackages-filesystem \
 "
RDEPENDS:canl-java-javadoc = " \
 javapackages-filesystem \
 "
