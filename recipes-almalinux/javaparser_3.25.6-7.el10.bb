# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "javaparser"
PV = "3.25.6"
PR = "7.el10"
PACKAGES = " \
 javaparser \
 javaparser-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/javaparser-3.25.6-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0a26c7c535103ae7476f8be1e960bfc803a551d5f56e32c22e45303e409dfa7"

URI_x86_64_v2_javaparser = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/javaparser-3.25.6-7.el10.noarch.rpm;name=x86_64_v2_javaparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javaparser}"
SRC_URI[x86_64_v2_javaparser.sha256sum] = "e30f682e59f77ebda88a6d38ee2a131118f48a917f64a037e8571f2e6699d302"

URI_x86_64_v2_javaparser-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/javaparser-javadoc-3.25.6-7.el10.noarch.rpm;name=x86_64_v2_javaparser-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javaparser-javadoc}"
SRC_URI[x86_64_v2_javaparser-javadoc.sha256sum] = "da39a509701c86911f6d730b0bb43de2e6181eaaba819f4ed717631529111834"

URI_aarch64_javaparser = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/javaparser-3.25.6-7.el10.noarch.rpm;name=aarch64_javaparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_javaparser}"
SRC_URI[aarch64_javaparser.sha256sum] = "e30f682e59f77ebda88a6d38ee2a131118f48a917f64a037e8571f2e6699d302"

URI_aarch64_javaparser-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/javaparser-javadoc-3.25.6-7.el10.noarch.rpm;name=aarch64_javaparser-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_javaparser-javadoc}"
SRC_URI[aarch64_javaparser-javadoc.sha256sum] = "da39a509701c86911f6d730b0bb43de2e6181eaaba819f4ed717631529111834"

RDEPENDS:javaparser = " \
 javapackages-filesystem \
 "
RDEPENDS:javaparser-javadoc = " \
 javapackages-filesystem \
 "
