# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-yaml"
PV = "2.3.0"
PR = "1.el10_2"
PACKAGES = " \
 php-pecl-yaml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-yaml-2.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91815f46badbd97765ac540758b96c4c96f3fe3b00a057e3323b7fb827105497"

URI_x86_64_v2_php-pecl-yaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-yaml-2.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-yaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-yaml}"
SRC_URI[x86_64_v2_php-pecl-yaml.sha256sum] = "eb1a8f439cbce1e203e79e32cabfce63593c3f2f7ad06aeae11bc76157d62a70"

URI_aarch64_php-pecl-yaml = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-yaml-2.3.0-1.el10_2.aarch64.rpm;name=aarch64_php-pecl-yaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-yaml}"
SRC_URI[aarch64_php-pecl-yaml.sha256sum] = "bf64ac8c91e859fe32f17ade7fc8ac4f9df64f7c4eafcb3d11738901882c8eb8"

RDEPENDS:php-pecl-yaml = " \
 glibc \
 libyaml \
 php-common \
 "
