# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-term_size"
PV = "0.3.2"
PR = "15.el10_0"
PACKAGES = " \
 rust-term_size+debug-devel \
 rust-term_size+default-devel \
 rust-term_size+nightly-devel \
 rust-term_size+travis-devel \
 rust-term_size+unstable-devel \
 rust-term_size-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-term_size-0.3.2-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07398b98e05de9b19baf5929fb53985fbf02eb27230cca72f54725efada3180d"

URI_x86_64_v2_rust-term_size+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-term_size+debug-devel-0.3.2-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-term_size+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-term_size+debug-devel}"
SRC_URI[x86_64_v2_rust-term_size+debug-devel.sha256sum] = "96a9727e04918bf097fc0e73ec4bda8ee13f4a4cc5f5e9f71eb65a75fdcd6359"

URI_x86_64_v2_rust-term_size+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-term_size+default-devel-0.3.2-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-term_size+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-term_size+default-devel}"
SRC_URI[x86_64_v2_rust-term_size+default-devel.sha256sum] = "1305210a986145ec3158b6a26de68cacdf9490c721f5e7d15792802734068906"

URI_x86_64_v2_rust-term_size+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-term_size+nightly-devel-0.3.2-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-term_size+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-term_size+nightly-devel}"
SRC_URI[x86_64_v2_rust-term_size+nightly-devel.sha256sum] = "56d00fbd73ea47ad0a911f41eb8d003a0bcf712b046f8cfa7d3406732c28f304"

URI_x86_64_v2_rust-term_size+travis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-term_size+travis-devel-0.3.2-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-term_size+travis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-term_size+travis-devel}"
SRC_URI[x86_64_v2_rust-term_size+travis-devel.sha256sum] = "36155ab4e612416be7c102a98db6ae64e99a7ce2bc8157ae0f22396745cc3f49"

URI_x86_64_v2_rust-term_size+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-term_size+unstable-devel-0.3.2-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-term_size+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-term_size+unstable-devel}"
SRC_URI[x86_64_v2_rust-term_size+unstable-devel.sha256sum] = "04ca081ba7d8169dfd8d387fcc8b349fc037f23293866a20ca63ffe0dbd78c6f"

URI_x86_64_v2_rust-term_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-term_size-devel-0.3.2-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-term_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-term_size-devel}"
SRC_URI[x86_64_v2_rust-term_size-devel.sha256sum] = "822b52b833b4d9fe4ad25fd452a984091d544da8cbe3d701623d368c92253922"

URI_aarch64_rust-term_size+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-term_size+debug-devel-0.3.2-15.el10_0.noarch.rpm;name=aarch64_rust-term_size+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-term_size+debug-devel}"
SRC_URI[aarch64_rust-term_size+debug-devel.sha256sum] = "039e3e1c3b40eee35ec7ed8c5fb589ab71f62a7598fea5ab919570142520309c"

URI_aarch64_rust-term_size+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-term_size+default-devel-0.3.2-15.el10_0.noarch.rpm;name=aarch64_rust-term_size+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-term_size+default-devel}"
SRC_URI[aarch64_rust-term_size+default-devel.sha256sum] = "31ce12fd7b6b1eaa1e9d1fe498fd58c55a87d38d20ff72c8c5d87b6011542e1e"

URI_aarch64_rust-term_size+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-term_size+nightly-devel-0.3.2-15.el10_0.noarch.rpm;name=aarch64_rust-term_size+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-term_size+nightly-devel}"
SRC_URI[aarch64_rust-term_size+nightly-devel.sha256sum] = "df199ba1a8a68c975c5c9cfd3473b809823f64b9c7e68224b2b593cc40356e78"

URI_aarch64_rust-term_size+travis-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-term_size+travis-devel-0.3.2-15.el10_0.noarch.rpm;name=aarch64_rust-term_size+travis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-term_size+travis-devel}"
SRC_URI[aarch64_rust-term_size+travis-devel.sha256sum] = "7652261135f7a376509cbe2fa71ce0009254c93cbe2b3c395015f56a1d5b1a91"

URI_aarch64_rust-term_size+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-term_size+unstable-devel-0.3.2-15.el10_0.noarch.rpm;name=aarch64_rust-term_size+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-term_size+unstable-devel}"
SRC_URI[aarch64_rust-term_size+unstable-devel.sha256sum] = "98fa09d91b2e967a21641b8861b42c4d686e429e67d68e165e85745c33f5b720"

URI_aarch64_rust-term_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-term_size-devel-0.3.2-15.el10_0.noarch.rpm;name=aarch64_rust-term_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-term_size-devel}"
SRC_URI[aarch64_rust-term_size-devel.sha256sum] = "46275f9a670518f9ebf8f4aee044ad34d7f848dd43a872f2493f3cba279203a4"

RDEPENDS:rust-term_size+debug-devel = " \
 cargo \
 rust-term_size-devel \
 "
RDEPENDS:rust-term_size+default-devel = " \
 cargo \
 rust-term_size-devel \
 "
RDEPENDS:rust-term_size+nightly-devel = " \
 cargo \
 rust-term_size-devel \
 "
RDEPENDS:rust-term_size+travis-devel = " \
 cargo \
 rust-term_size+nightly-devel \
 rust-term_size-devel \
 "
RDEPENDS:rust-term_size+unstable-devel = " \
 cargo \
 rust-term_size-devel \
 "
RDEPENDS:rust-term_size-devel = " \
 cargo \
 rust-libc+default-devel \
 "
