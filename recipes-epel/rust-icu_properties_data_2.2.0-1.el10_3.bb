# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_properties_data"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_properties_data+default-devel \
 rust-icu_properties_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_properties_data-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87c36d9c25f24c007f81e2b98e22d0fc44a34e8f1083cf8bcdb66421d9849175"

URI_x86_64_v2_rust-icu_properties_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties_data+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_properties_data+default-devel.sha256sum] = "a10eaec5ff90877826053a3cba87159756b6d20d5544c830c15135d2fc737b80"

URI_x86_64_v2_rust-icu_properties_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties_data-devel}"
SRC_URI[x86_64_v2_rust-icu_properties_data-devel.sha256sum] = "c32277ac2d080ee8d1d89fdab0c85b8aa0f540701dd9386c32da3d30ebeda753"

URI_aarch64_rust-icu_properties_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties_data+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_properties_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties_data+default-devel}"
SRC_URI[aarch64_rust-icu_properties_data+default-devel.sha256sum] = "509276e4dd367cd2fc1bb60e5304adb4a3e4c00a733bfb9e0478a3d7bec73405"

URI_aarch64_rust-icu_properties_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_properties_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties_data-devel}"
SRC_URI[aarch64_rust-icu_properties_data-devel.sha256sum] = "5198f1b9d0187db802a9f4b04931c711c887c4a9accf15cfd9d89b3cb3c720e2"

RDEPENDS:rust-icu_properties_data+default-devel = " \
 cargo \
 rust-icu_properties_data-devel \
 "
RDEPENDS:rust-icu_properties_data-devel = " \
 cargo \
 rust \
 "
