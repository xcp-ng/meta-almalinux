# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgit2"
PV = "1.7.2"
PR = "4.el10_0"
PACKAGES = " \
 libgit2 \
 libgit2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgit2-1.7.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d37e78a1ef22f151dee45b687b83644fb272ce93d5504aefc654956ec899ca9b"

URI_x86_64_v2_libgit2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgit2-1.7.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgit2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgit2}"
SRC_URI[x86_64_v2_libgit2.sha256sum] = "1e34beeb8ec10438372c334672f8ac62e423ff42582c31ae2fbd19dd015c296b"

URI_x86_64_v2_libgit2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgit2-devel-1.7.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgit2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgit2-devel}"
SRC_URI[x86_64_v2_libgit2-devel.sha256sum] = "b9b01ba82c00167c252c307b55a9ecfe7f18c2d0bf87cea4502eb5dd4e22930a"

URI_aarch64_libgit2 = "${EPEL_MIRROR}/aarch64/Packages/l/libgit2-1.7.2-4.el10_0.aarch64.rpm;name=aarch64_libgit2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgit2}"
SRC_URI[aarch64_libgit2.sha256sum] = "0e1a8e015556088ec03139c4a9b4e2cbfc67719ae0397e47ae1b2ee5469721bf"

URI_aarch64_libgit2-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgit2-devel-1.7.2-4.el10_0.aarch64.rpm;name=aarch64_libgit2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgit2-devel}"
SRC_URI[aarch64_libgit2-devel.sha256sum] = "09aa896516e9468354cd81f42abb431b7234484e39bd10bd0c3f8e7bde9d3747"
RPROVIDES:libgit2-devel:aarch64 = "virtual/pkgconfig_libgit2_"

RDEPENDS:libgit2 = " \
 glibc \
 libgcc \
 llhttp \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:libgit2-devel = " \
 libgit2 \
 openssl-devel \
 pcre2-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "

PROVIDES:append:aarch64 = " rpm/virtual/pkgconfig_libgit2_"
