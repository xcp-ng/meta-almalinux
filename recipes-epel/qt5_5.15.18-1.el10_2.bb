# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5 \
 qt5-devel \
 qt5-filesystem \
 qt5-rpm-macros \
 qt5-srpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1a407616e47f21ae525ad27ee6fb594a62b0726c707c5f7e8a153d4e7276802"

URI_x86_64_v2_qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5}"
SRC_URI[x86_64_v2_qt5.sha256sum] = "f8124621e125636d93b29dcb9896aa88d67cb10d8ab1803353fd9e10383827aa"

URI_x86_64_v2_qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-devel}"
SRC_URI[x86_64_v2_qt5-devel.sha256sum] = "12b206697dbdd8195e96601651700829450ff8e3fabd8e800c32dd1f75a7bdbd"

URI_x86_64_v2_qt5-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-filesystem-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-filesystem}"
SRC_URI[x86_64_v2_qt5-filesystem.sha256sum] = "01040f555dbfe857109d1a5de0e9b7dd0d23b937e05bbddf90ff6bd9cd195fe4"

URI_x86_64_v2_qt5-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-rpm-macros-5.15.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-rpm-macros}"
SRC_URI[x86_64_v2_qt5-rpm-macros.sha256sum] = "6ed330751454afd900c97626dd0e8bfcaa666b545415857b3fdff9d3c7cb60ba"

URI_x86_64_v2_qt5-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-srpm-macros-5.15.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-srpm-macros}"
SRC_URI[x86_64_v2_qt5-srpm-macros.sha256sum] = "1038b32161ad11598f66db0ea57ee499790fa13a4cea99b0e1ede21abcb0a212"

URI_aarch64_qt5 = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5}"
SRC_URI[aarch64_qt5.sha256sum] = "5061d9cbce7b7a1c4f4644ec8272efd651f065262c89af63c5c965b5a4c131c4"

URI_aarch64_qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-devel}"
SRC_URI[aarch64_qt5-devel.sha256sum] = "51e10cb3ec9ec8f8be1f02447e22db2d5d234709d635a5ea51bd19f5607fc340"

URI_aarch64_qt5-filesystem = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-filesystem-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-filesystem}"
SRC_URI[aarch64_qt5-filesystem.sha256sum] = "c714aae62f7e04a06e9b998f2594060da17245456e392fc8bd4b7c4795f981a7"

URI_aarch64_qt5-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-rpm-macros-5.15.18-1.el10_2.noarch.rpm;name=aarch64_qt5-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-rpm-macros}"
SRC_URI[aarch64_qt5-rpm-macros.sha256sum] = "3904e2a9c036c7a58ea79487c106dad38b3d892c29e0c0ca19b5552c63620db4"

URI_aarch64_qt5-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-srpm-macros-5.15.18-1.el10_2.noarch.rpm;name=aarch64_qt5-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-srpm-macros}"
SRC_URI[aarch64_qt5-srpm-macros.sha256sum] = "ea192810d32fed49dede46dbafebf55e4ef1bd542dfe8b0dfe27274eae1e3da2"

RDEPENDS:qt5 = " \
 qt5-qdbusviewer \
 qt5-qt3d \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtbase-mysql \
 qt5-qtbase-postgresql \
 qt5-qtconnectivity \
 qt5-qtdeclarative \
 qt5-qtdoc \
 qt5-qtgraphicaleffects \
 qt5-qtimageformats \
 qt5-qtlocation \
 qt5-qtmultimedia \
 qt5-qtquickcontrols \
 qt5-qtquickcontrols2 \
 qt5-qtscript \
 qt5-qtsensors \
 qt5-qtserialport \
 qt5-qtsvg \
 qt5-qttools \
 qt5-qtwayland \
 qt5-qtwebchannel \
 qt5-qtwebsockets \
 qt5-qtx11extras \
 qt5-qtxmlpatterns \
 "
RDEPENDS:qt5-devel = " \
 qt5-designer \
 qt5-doctools \
 qt5-linguist \
 qt5-qt3d-devel \
 qt5-qtbase-devel \
 qt5-qtbase-static \
 qt5-qtconnectivity-devel \
 qt5-qtdeclarative-devel \
 qt5-qtdeclarative-static \
 qt5-qtlocation-devel \
 qt5-qtmultimedia-devel \
 qt5-qtscript-devel \
 qt5-qtsensors-devel \
 qt5-qtserialport-devel \
 qt5-qtsvg-devel \
 qt5-qttools-devel \
 qt5-qttools-static \
 qt5-qtwayland-devel \
 qt5-qtwebchannel-devel \
 qt5-qtwebsockets-devel \
 qt5-qtx11extras-devel \
 qt5-qtxmlpatterns-devel \
 qt5-rpm-macros \
 "
RDEPENDS:qt5-filesystem = " \
 "
RDEPENDS:qt5-rpm-macros = " \
 bash \
 cmake \
 gcc-c++ \
 "
RDEPENDS:qt5-srpm-macros = " \
 "
