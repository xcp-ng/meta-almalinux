# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grubby"
PV = "8.40"
PR = "83.el10.alma.1"
PACKAGES = " \
 grubby \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/grubby-8.40-83.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5cdb66663dc2eb9959614756883c2d5616fca7f490777d7b3fdce38154703e3"

URI_x86_64_v2_grubby = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grubby-8.40-83.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grubby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grubby}"
SRC_URI[x86_64_v2_grubby.sha256sum] = "93b3b09095b6ff97a58201296c2ba50704c62a0bffcf8f00167b0706157f44b4"

URI_aarch64_grubby = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grubby-8.40-83.el10.alma.1.aarch64.rpm;name=aarch64_grubby;unpack=0"
SRC_URI:append = " ${URI_aarch64_grubby}"
SRC_URI[aarch64_grubby.sha256sum] = "d91653c52ca6b0c9fca7935789d3034a1a48670c8f73e9208edbfeaf0f759b8e"

RDEPENDS:grubby = " \
 bash \
 findutils \
 grub2-tools \
 grub2-tools-minimal \
 util-linux \
 "
