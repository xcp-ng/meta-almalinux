# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdnf"
PV = "0.73.1"
PR = "12.el10_1.1.alma.1"
PACKAGES = " \
 libdnf \
 libdnf-devel \
 python3-hawkey \
 python3-libdnf \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libdnf-0.73.1-12.el10_1.1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1543c2885b839aca9e66eb4ec868e789d17a90e1a21713048975bc23a1af0ed3"

URI_x86_64_v2_libdnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libdnf-0.73.1-12.el10_1.1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libdnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdnf}"
SRC_URI[x86_64_v2_libdnf.sha256sum] = "f008b02d3a12198f9ed2cc4fa65ef3b76239ca634469e010c89d087e8bd795ed"

URI_x86_64_v2_libdnf-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdnf-devel-0.73.1-12.el10_1.1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libdnf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdnf-devel}"
SRC_URI[x86_64_v2_libdnf-devel.sha256sum] = "19b3d1b5dde28c0dffd323e697bc99bf89fecac85608267d54fb12b4a6ae7dce"

URI_x86_64_v2_python3-hawkey = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-hawkey-0.73.1-12.el10_1.1.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-hawkey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hawkey}"
SRC_URI[x86_64_v2_python3-hawkey.sha256sum] = "2a727203b63de6598d1f2c6908e836bcf14bc346797b004da80d9d55a31653c5"

URI_x86_64_v2_python3-libdnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libdnf-0.73.1-12.el10_1.1.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-libdnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libdnf}"
SRC_URI[x86_64_v2_python3-libdnf.sha256sum] = "df07a66544384d4086d1ce061d731803a459d8ce26b043206e01ee7b41ba5596"

URI_aarch64_libdnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libdnf-0.73.1-12.el10_1.1.alma.1.aarch64.rpm;name=aarch64_libdnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdnf}"
SRC_URI[aarch64_libdnf.sha256sum] = "7d5a852983f194dbf4f8e4fa3eb9eb148383d42946c8af3b1844b2d4151d550e"

URI_aarch64_libdnf-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdnf-devel-0.73.1-12.el10_1.1.alma.1.aarch64.rpm;name=aarch64_libdnf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdnf-devel}"
SRC_URI[aarch64_libdnf-devel.sha256sum] = "bcb6a4b9d59ef49bfafb3e337c67804f119c3b8b18c363d2d559db352691d35f"

URI_aarch64_python3-hawkey = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-hawkey-0.73.1-12.el10_1.1.alma.1.aarch64.rpm;name=aarch64_python3-hawkey;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hawkey}"
SRC_URI[aarch64_python3-hawkey.sha256sum] = "3e048c7039720e29cb1c88af92a83747b915dd7d17e1514174e89ced2d304d01"

URI_aarch64_python3-libdnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libdnf-0.73.1-12.el10_1.1.alma.1.aarch64.rpm;name=aarch64_python3-libdnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libdnf}"
SRC_URI[aarch64_python3-libdnf.sha256sum] = "d7dd3b0cd6eab6e6ecd48d63507de9e213423478960917886d8e1d17898526d7"

RDEPENDS:libdnf = " \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libmodulemd \
 librepo \
 libsmartcols \
 libsolv \
 libstdc++ \
 rpm-libs \
 sqlite-libs \
 "
RDEPENDS:libdnf-devel = " \
 glib2-devel \
 libdnf \
 librepo-devel \
 libsolv-devel \
 pkgconf-pkg-config \
 rpm-devel \
 sqlite-devel \
 "
RDEPENDS:python3-hawkey = " \
 glib2 \
 glibc \
 libdnf \
 libgcc \
 libsolv \
 libstdc++ \
 python3 \
 python3-libdnf \
 python3-libs \
 "
RDEPENDS:python3-libdnf = " \
 glibc \
 libdnf \
 libgcc \
 libsmartcols \
 libstdc++ \
 python3 \
 python3-libs \
 "
