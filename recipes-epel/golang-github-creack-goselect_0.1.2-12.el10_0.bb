# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-creack-goselect"
PV = "0.1.2"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-creack-goselect-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-creack-goselect-0.1.2-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "314ec470a9d3ac59f0a8df54345bca82845fbabfd2facf7f0e4bb9b03a5a92c3"

URI_x86_64_v2_golang-github-creack-goselect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-creack-goselect-devel-0.1.2-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-creack-goselect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-creack-goselect-devel}"
SRC_URI[x86_64_v2_golang-github-creack-goselect-devel.sha256sum] = "a6c0b537fae1d5fc4a619a9415784a646de4d0d9da9e3c4f9eb5014c932eeacc"

URI_aarch64_golang-github-creack-goselect-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-creack-goselect-devel-0.1.2-12.el10_0.noarch.rpm;name=aarch64_golang-github-creack-goselect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-creack-goselect-devel}"
SRC_URI[aarch64_golang-github-creack-goselect-devel.sha256sum] = "0a77139d982cb9df02fb56633694a603732c1f6e6f46f4d2cdb20357e86135e8"

RDEPENDS:golang-github-creack-goselect-devel = " \
 go-filesystem \
 "
