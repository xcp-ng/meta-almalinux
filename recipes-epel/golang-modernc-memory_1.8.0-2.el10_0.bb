# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-modernc-memory"
PV = "1.8.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-modernc-memory-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-modernc-memory-1.8.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "eb3ae16a2c6cf25103e67d8acb2ca3cbc1402293e8a1ae7efd18070c1f84a6f5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-modernc-memory-devel-1.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-modernc-memory-devel;unpack=0"
SRC_URI[x86_64_v2_golang-modernc-memory-devel.sha256sum] = "db72670e6046f7600a011c63fd3f66aaf49bf3f10098eff2827eb179459ffa0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-modernc-memory-devel-1.8.0-2.el10_0.noarch.rpm;name=aarch64_golang-modernc-memory-devel;unpack=0"
SRC_URI[aarch64_golang-modernc-memory-devel.sha256sum] = "31b8004e22f6dc40f47f8635482aa3323ceb879fd317a20fe0a026d99b225021"

RDEPENDS:golang-modernc-memory-devel = " \
 go-filesystem \
 "
