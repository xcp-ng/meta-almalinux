# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rich"
PV = "14.3.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-rich \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rich-14.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3dfcc6a4b45ead30260d0542097d183a9ca393242becdf41e5a0cf623587ccdd"

URI_x86_64_v2_python3-rich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rich-14.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rich}"
SRC_URI[x86_64_v2_python3-rich.sha256sum] = "9fcd7ecf10dbeae759d62fe3bbd8e65bb99f526fc32a8f4be73362d0c9e69c7c"

URI_aarch64_python3-rich = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rich-14.3.0-1.el10_3.noarch.rpm;name=aarch64_python3-rich;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rich}"
SRC_URI[aarch64_python3-rich.sha256sum] = "3df28a7b986be0610c51216a839f840fcf82189d8e386b4611397d5022782315"

RDEPENDS:python3-rich = " \
 python3 \
 python3-markdown-it-py \
 python3-pygments \
 "
