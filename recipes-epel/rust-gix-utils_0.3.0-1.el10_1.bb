# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-utils"
PV = "0.3.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-utils+bstr-devel \
 rust-gix-utils+default-devel \
 rust-gix-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-utils-0.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c120154ab38a08b78dd3b2c59f75207203b3f87f615883622389146deb37893"

URI_x86_64_v2_rust-gix-utils+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-utils+bstr-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-utils+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-utils+bstr-devel}"
SRC_URI[x86_64_v2_rust-gix-utils+bstr-devel.sha256sum] = "610ea79614b3631b934819ca8bd5ef9d5c6a8d781b15646e1d7bcec0c188934e"

URI_x86_64_v2_rust-gix-utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-utils+default-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-utils+default-devel}"
SRC_URI[x86_64_v2_rust-gix-utils+default-devel.sha256sum] = "915ce3d63d20500ac25933ef6368131fd404f01b5f0d4fcb24816da511e4055d"

URI_x86_64_v2_rust-gix-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-utils-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-utils-devel}"
SRC_URI[x86_64_v2_rust-gix-utils-devel.sha256sum] = "25311b326ef9417f7e220c8217bbb9eb1fb365ac2e583690b38cf595da27ec47"

URI_aarch64_rust-gix-utils+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-utils+bstr-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-utils+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-utils+bstr-devel}"
SRC_URI[aarch64_rust-gix-utils+bstr-devel.sha256sum] = "3fa06153f5129ec8ea86d773d48bc5b893c8c953b0f23462353f9d334c0cce94"

URI_aarch64_rust-gix-utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-utils+default-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-utils+default-devel}"
SRC_URI[aarch64_rust-gix-utils+default-devel.sha256sum] = "bb7a2fbd3c049c152b2188d691fb64ff9a782625706651efe1d97ef3483fe9a9"

URI_aarch64_rust-gix-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-utils-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-utils-devel}"
SRC_URI[aarch64_rust-gix-utils-devel.sha256sum] = "6a2fe2199b5a4f5aee1f4a2b2d85889e9a65406d87b22d4275c88ed64d6c365a"

RDEPENDS:rust-gix-utils+bstr-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-utils-devel \
 "
RDEPENDS:rust-gix-utils+default-devel = " \
 cargo \
 rust-gix-utils-devel \
 "
RDEPENDS:rust-gix-utils-devel = " \
 cargo \
 rust \
 rust-fastrand+default-devel \
 rust-unicode-normalization-devel \
 "
