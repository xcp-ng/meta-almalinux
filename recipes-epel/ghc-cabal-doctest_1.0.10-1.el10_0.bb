# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-cabal-doctest"
PV = "1.0.10"
PR = "1.el10_0"
PACKAGES = " \
 ghc-cabal-doctest \
 ghc-cabal-doctest-devel \
 ghc-cabal-doctest-doc \
 ghc-cabal-doctest-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-cabal-doctest-1.0.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87ae285f06847e525bf08c71a83f1dab6c34f8798e08cf542b06c36e6789fef8"

URI_x86_64_v2_ghc-cabal-doctest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cabal-doctest-1.0.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cabal-doctest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cabal-doctest}"
SRC_URI[x86_64_v2_ghc-cabal-doctest.sha256sum] = "e83dfaffbe2937815d0853de3ce6c0bb22f74bbf56244fd29343557569c5e97e"

URI_x86_64_v2_ghc-cabal-doctest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cabal-doctest-devel-1.0.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cabal-doctest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cabal-doctest-devel}"
SRC_URI[x86_64_v2_ghc-cabal-doctest-devel.sha256sum] = "43b736856d9b2eeb02e019d6321d825ca35d298c81195cec9f649a3abd24a0c7"

URI_x86_64_v2_ghc-cabal-doctest-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cabal-doctest-doc-1.0.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-cabal-doctest-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cabal-doctest-doc}"
SRC_URI[x86_64_v2_ghc-cabal-doctest-doc.sha256sum] = "1af114bbffeccb264bbd97a6884a0c5decc6ee07d1d45dab62080b1cbc60e2d1"

URI_x86_64_v2_ghc-cabal-doctest-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cabal-doctest-prof-1.0.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cabal-doctest-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cabal-doctest-prof}"
SRC_URI[x86_64_v2_ghc-cabal-doctest-prof.sha256sum] = "257e5f8f9aefe93bb83cf47edd6893a91cb6fcd61fb01c7b802f26754e446e34"

URI_aarch64_ghc-cabal-doctest = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cabal-doctest-1.0.10-1.el10_0.aarch64.rpm;name=aarch64_ghc-cabal-doctest;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cabal-doctest}"
SRC_URI[aarch64_ghc-cabal-doctest.sha256sum] = "fdf473b4e96850b1713dc6480393837813261dac2c431397fffcae09dd658e44"

URI_aarch64_ghc-cabal-doctest-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cabal-doctest-devel-1.0.10-1.el10_0.aarch64.rpm;name=aarch64_ghc-cabal-doctest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cabal-doctest-devel}"
SRC_URI[aarch64_ghc-cabal-doctest-devel.sha256sum] = "5e0deadf1a6d68ff09c50853b25cad74053b5fda78be1fb91555d4bf86a277cf"

URI_aarch64_ghc-cabal-doctest-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cabal-doctest-doc-1.0.10-1.el10_0.noarch.rpm;name=aarch64_ghc-cabal-doctest-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cabal-doctest-doc}"
SRC_URI[aarch64_ghc-cabal-doctest-doc.sha256sum] = "eccb80e4c1b9acaf8108a0fb2a2d7bb4c9e5dd4dbb80681daa78c5d81f22f7a8"

URI_aarch64_ghc-cabal-doctest-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cabal-doctest-prof-1.0.10-1.el10_0.aarch64.rpm;name=aarch64_ghc-cabal-doctest-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cabal-doctest-prof}"
SRC_URI[aarch64_ghc-cabal-doctest-prof.sha256sum] = "208acea53b799dbffc80b008997f31ff050546135286b17a5aac5ff5a9ee35a5"

RDEPENDS:ghc-cabal-doctest = " \
 ghc-Cabal \
 ghc-Cabal-syntax \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-cabal-doctest-devel = " \
 ghc-Cabal-devel \
 ghc-base-devel \
 ghc-cabal-doctest \
 ghc-compiler \
 ghc-directory-devel \
 ghc-filepath-devel \
 "
RDEPENDS:ghc-cabal-doctest-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cabal-doctest-prof = " \
 ghc-Cabal-prof \
 ghc-base-prof \
 ghc-cabal-doctest-devel \
 ghc-directory-prof \
 ghc-filepath-prof \
 "
