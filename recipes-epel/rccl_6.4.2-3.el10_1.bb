# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rccl"
PV = "6.4.2"
PR = "3.el10_1"
PACKAGES:x86_64_v2 = " \
 rccl \
 rccl-data \
 rccl-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rccl-6.4.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "406cc023880cbdbec0fe2f6c42c1bffd7602fed8a43ab2b31b4ca97db55130a4"

URI_x86_64_v2_rccl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rccl-6.4.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rccl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rccl}"
SRC_URI[x86_64_v2_rccl.sha256sum] = "752786b9546067c578b225af89a1abfba18cd720ff98340398291c98ca3d1702"

URI_x86_64_v2_rccl-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rccl-data-6.4.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rccl-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rccl-data}"
SRC_URI[x86_64_v2_rccl-data.sha256sum] = "70fd7c1a33b3a90a0d4710d2b276ed58ac1ae793232c99eb394e9eebfb00b1df"

URI_x86_64_v2_rccl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rccl-devel-6.4.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rccl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rccl-devel}"
SRC_URI[x86_64_v2_rccl-devel.sha256sum] = "21679b1b8d08210a2c8b326f599c329dde777e98f59044178f6da07b9c737a2d"

RDEPENDS:rccl = " \
 glibc \
 libgcc \
 libstdc++ \
 rccl-data \
 rocm-hip \
 rocm-smi \
 "
RDEPENDS:rccl-data = " \
 "
RDEPENDS:rccl-devel = " \
 cmake-filesystem \
 rccl \
 "
