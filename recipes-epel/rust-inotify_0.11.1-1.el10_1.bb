# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-inotify"
PV = "0.11.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-inotify+default-devel \
 rust-inotify+futures-core-devel \
 rust-inotify+stream-devel \
 rust-inotify+tokio-devel \
 rust-inotify-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-inotify-0.11.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58ca5f0edd6c2cfeca214eb1a6f59c3eb0e7b97e96afa90798f5798b6b8999f5"

URI_x86_64_v2_rust-inotify+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+default-devel-0.11.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+default-devel}"
SRC_URI[x86_64_v2_rust-inotify+default-devel.sha256sum] = "5c92da09bf8344e523835b1c9e2d21c3259ef50506d3c4eb80285c783e1b76a2"

URI_x86_64_v2_rust-inotify+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+futures-core-devel-0.11.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+futures-core-devel}"
SRC_URI[x86_64_v2_rust-inotify+futures-core-devel.sha256sum] = "29ed279ea5c7d8d95a00fd691b12219108119d7b59efea7c6bccc3c88c003a2b"

URI_x86_64_v2_rust-inotify+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+stream-devel-0.11.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+stream-devel}"
SRC_URI[x86_64_v2_rust-inotify+stream-devel.sha256sum] = "f952f492150c6e4ec549ba5cf0834bd3cd1e53af8a3aa7919c6afe0bc13c4217"

URI_x86_64_v2_rust-inotify+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+tokio-devel-0.11.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+tokio-devel}"
SRC_URI[x86_64_v2_rust-inotify+tokio-devel.sha256sum] = "904e966e0d91bbfb132777c7c701518c9ed8f2f7c384ee74d538483f39e917bc"

URI_x86_64_v2_rust-inotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify-devel-0.11.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify-devel}"
SRC_URI[x86_64_v2_rust-inotify-devel.sha256sum] = "d32de5580c607f393015c997ad525cff1aa6f95489e9f286222748a2bcfab26a"

URI_aarch64_rust-inotify+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+default-devel-0.11.1-1.el10_1.noarch.rpm;name=aarch64_rust-inotify+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+default-devel}"
SRC_URI[aarch64_rust-inotify+default-devel.sha256sum] = "7c736e7cb1842b83dd4573a1df35dd52b537c778969116822f2e886b684403fa"

URI_aarch64_rust-inotify+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+futures-core-devel-0.11.1-1.el10_1.noarch.rpm;name=aarch64_rust-inotify+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+futures-core-devel}"
SRC_URI[aarch64_rust-inotify+futures-core-devel.sha256sum] = "660de31ce8830ff7c5fe11fac6648c7a72105bb1869767fdb8b50411e76f8e3e"

URI_aarch64_rust-inotify+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+stream-devel-0.11.1-1.el10_1.noarch.rpm;name=aarch64_rust-inotify+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+stream-devel}"
SRC_URI[aarch64_rust-inotify+stream-devel.sha256sum] = "95fbe1a53887625b1f1ed5e6337a2892a64afd2fd4cd28af1596bd0d624b358e"

URI_aarch64_rust-inotify+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+tokio-devel-0.11.1-1.el10_1.noarch.rpm;name=aarch64_rust-inotify+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+tokio-devel}"
SRC_URI[aarch64_rust-inotify+tokio-devel.sha256sum] = "05471ff2fe734f982bb0fe2dc972202cb58d56e6d5c80aef0f63e49c97892bc9"

URI_aarch64_rust-inotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify-devel-0.11.1-1.el10_1.noarch.rpm;name=aarch64_rust-inotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify-devel}"
SRC_URI[aarch64_rust-inotify-devel.sha256sum] = "163b1bfd83cac0db5fbe0e304e7df90e7c1d0a3b77dd83938a7d3b2c0c549248"

RDEPENDS:rust-inotify+default-devel = " \
 cargo \
 rust-inotify+stream-devel \
 rust-inotify-devel \
 "
RDEPENDS:rust-inotify+futures-core-devel = " \
 cargo \
 rust-futures-core+default-devel \
 rust-inotify-devel \
 "
RDEPENDS:rust-inotify+stream-devel = " \
 cargo \
 rust-inotify+futures-core-devel \
 rust-inotify+tokio-devel \
 rust-inotify-devel \
 "
RDEPENDS:rust-inotify+tokio-devel = " \
 cargo \
 rust-inotify-devel \
 rust-tokio+default-devel \
 rust-tokio+net-devel \
 "
RDEPENDS:rust-inotify-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-inotify-sys+default-devel \
 rust-libc+default-devel \
 "
