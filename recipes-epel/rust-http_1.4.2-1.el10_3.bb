# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http"
PV = "1.4.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-http+default-devel \
 rust-http+std-devel \
 rust-http-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-1.4.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8bd3a431cb53b2cf6e3c2d9e78a60eb75e21c7f1d7b4cd2651be94b75751c18"

URI_x86_64_v2_rust-http+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http+default-devel-1.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http+default-devel}"
SRC_URI[x86_64_v2_rust-http+default-devel.sha256sum] = "145596407b005ab1b1a4ae48b725ba359c71b70216b048554cd921c74273e26d"

URI_x86_64_v2_rust-http+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http+std-devel-1.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http+std-devel}"
SRC_URI[x86_64_v2_rust-http+std-devel.sha256sum] = "5937795c9692686da7f6ea4f06df17e2f82546493ac8540d68d32d853f078be7"

URI_x86_64_v2_rust-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-devel-1.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-devel}"
SRC_URI[x86_64_v2_rust-http-devel.sha256sum] = "d660bdd72971ee3b6345c4bea6081edddacd9673f99c3ad92f8a2ec475a18e9b"

URI_aarch64_rust-http+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http+default-devel-1.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-http+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http+default-devel}"
SRC_URI[aarch64_rust-http+default-devel.sha256sum] = "4641c5da4a199bc72e96510b4b5de9bbb8a741c9e79bc86821cabc9b0be3ba54"

URI_aarch64_rust-http+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http+std-devel-1.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-http+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http+std-devel}"
SRC_URI[aarch64_rust-http+std-devel.sha256sum] = "b700c40a106c2f287578cbfcebbd9e29225f5838a47f9a5e6ffc206fe00905fd"

URI_aarch64_rust-http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-devel-1.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-devel}"
SRC_URI[aarch64_rust-http-devel.sha256sum] = "494488d1040c4f29c5d2e2467c973af135ed7086f02124b4ec680afbc57969a5"

RDEPENDS:rust-http+default-devel = " \
 cargo \
 rust-http+std-devel \
 rust-http-devel \
 "
RDEPENDS:rust-http+std-devel = " \
 cargo \
 rust-http-devel \
 "
RDEPENDS:rust-http-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-itoa+default-devel \
 "
