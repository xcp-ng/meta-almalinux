# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sleuthkit"
PV = "4.14.0"
PR = "3.el10_0"
PACKAGES = " \
 sleuthkit \
 sleuthkit-devel \
 sleuthkit-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sleuthkit-4.14.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70dcf17c1766d1a5b5444be940d588792dde44d0de4f839d6dc76ceb8c4cfc3d"

URI_x86_64_v2_sleuthkit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleuthkit-4.14.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleuthkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleuthkit}"
SRC_URI[x86_64_v2_sleuthkit.sha256sum] = "5d6236f194680ad895435286b21dba4d1f8320ec3d4ff4b19187668af36015dc"

URI_x86_64_v2_sleuthkit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleuthkit-devel-4.14.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleuthkit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleuthkit-devel}"
SRC_URI[x86_64_v2_sleuthkit-devel.sha256sum] = "c49c7dae7d5abc4d42739307bdc54435d4a8fd343a4eeace76637b7c5cf2925e"

URI_x86_64_v2_sleuthkit-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleuthkit-libs-4.14.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleuthkit-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleuthkit-libs}"
SRC_URI[x86_64_v2_sleuthkit-libs.sha256sum] = "e2b59b46faebee1e1997fffad190c82eb97074849c0ab61179c812e460c6908d"

URI_aarch64_sleuthkit = "${EPEL_MIRROR}/aarch64/Packages/s/sleuthkit-4.14.0-3.el10_0.aarch64.rpm;name=aarch64_sleuthkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleuthkit}"
SRC_URI[aarch64_sleuthkit.sha256sum] = "9dcce39acdd46752e8ceb9cc2c56588957b30f5298e30f6cd3ff51be8434eb59"

URI_aarch64_sleuthkit-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sleuthkit-devel-4.14.0-3.el10_0.aarch64.rpm;name=aarch64_sleuthkit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleuthkit-devel}"
SRC_URI[aarch64_sleuthkit-devel.sha256sum] = "86b25051510dcf8136b7c383decbd68ab3fe19d05cc831ab12128c2fdb2f8250"

URI_aarch64_sleuthkit-libs = "${EPEL_MIRROR}/aarch64/Packages/s/sleuthkit-libs-4.14.0-3.el10_0.aarch64.rpm;name=aarch64_sleuthkit-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleuthkit-libs}"
SRC_URI[aarch64_sleuthkit-libs.sha256sum] = "057acdeaba96e77f11d773062637c213d74fc29feccd6b0e082426823e9cca8b"

RDEPENDS:sleuthkit = " \
 afflib \
 file \
 glibc \
 libewf \
 libgcc \
 libstdc++ \
 mac-robber \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 sleuthkit-libs \
 "
RDEPENDS:sleuthkit-devel = " \
 libewf-devel \
 pkgconf-pkg-config \
 sleuthkit-libs \
 sqlite-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:sleuthkit-libs = " \
 afflib \
 glibc \
 libewf \
 libgcc \
 libstdc++ \
 sqlite-libs \
 zlib-ng-compat \
 "
