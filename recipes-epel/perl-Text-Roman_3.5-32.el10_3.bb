# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-Roman"
PV = "3.5"
PR = "32.el10_3"
PACKAGES = " \
 perl-Text-Roman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-Roman-3.5-32.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5faa959cc08e716f843e704b74bd5579c011f9605cc02b212a69b3f122d6c74"

URI_x86_64_v2_perl-Text-Roman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-Roman-3.5-32.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-Roman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-Roman}"
SRC_URI[x86_64_v2_perl-Text-Roman.sha256sum] = "2fdf8a2cf2c033b799150e3ff3992736bd411a402a2e3eade1ba8e5ab24672e2"

URI_aarch64_perl-Text-Roman = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-Roman-3.5-32.el10_3.noarch.rpm;name=aarch64_perl-Text-Roman;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-Roman}"
SRC_URI[aarch64_perl-Text-Roman.sha256sum] = "f095005a7f7429be9240ca337302402f652f17078c6a0284f2fc1caace6c68c1"

RDEPENDS:perl-Text-Roman = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
