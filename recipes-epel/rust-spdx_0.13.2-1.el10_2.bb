# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-spdx"
PV = "0.13.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-spdx+default-devel \
 rust-spdx+detection-cache-devel \
 rust-spdx+detection-devel \
 rust-spdx+detection-inline-cache-devel \
 rust-spdx+detection-parallel-devel \
 rust-spdx+rayon-devel \
 rust-spdx+regex-devel \
 rust-spdx+text-devel \
 rust-spdx+unicode-normalization-devel \
 rust-spdx+zstd-devel \
 rust-spdx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-spdx-0.13.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "daf4f8e5a1d79a83c0997bee0f636ba22af7d1d0899e8a24b3921c463b7d6aad"

URI_x86_64_v2_rust-spdx+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx+default-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx+default-devel}"
SRC_URI[x86_64_v2_rust-spdx+default-devel.sha256sum] = "61a99874b4940082c9b7cb24c685caeab7b881b5691886e10242550057e09771"

URI_x86_64_v2_rust-spdx+detection-cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx+detection-cache-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx+detection-cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx+detection-cache-devel}"
SRC_URI[x86_64_v2_rust-spdx+detection-cache-devel.sha256sum] = "9217e440a0d1c011daaa2342fce15f5227d353a9ee94760306a754808b5f9419"

URI_x86_64_v2_rust-spdx+detection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx+detection-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx+detection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx+detection-devel}"
SRC_URI[x86_64_v2_rust-spdx+detection-devel.sha256sum] = "a1e35130ae81c4b0d74c84c2fe2b0ca2680eab490f2e5e7e9efb7bbc87ea51e3"

URI_x86_64_v2_rust-spdx+detection-inline-cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx+detection-inline-cache-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx+detection-inline-cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx+detection-inline-cache-devel}"
SRC_URI[x86_64_v2_rust-spdx+detection-inline-cache-devel.sha256sum] = "2f43142878733b89899f83e916ebda65a3687af52c44a0c01ce6eb5bb5938020"

URI_x86_64_v2_rust-spdx+detection-parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx+detection-parallel-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx+detection-parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx+detection-parallel-devel}"
SRC_URI[x86_64_v2_rust-spdx+detection-parallel-devel.sha256sum] = "7dd68f3783818c4eead31ab38b8865ccd9eef4af2c3db5b60f2cb0193934586d"

URI_x86_64_v2_rust-spdx+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx+rayon-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx+rayon-devel}"
SRC_URI[x86_64_v2_rust-spdx+rayon-devel.sha256sum] = "b86f7453bd36cf0e3b7f6e0d890d068354981126ab3a1e8bbfe613a9d5fc861e"

URI_x86_64_v2_rust-spdx+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx+regex-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx+regex-devel}"
SRC_URI[x86_64_v2_rust-spdx+regex-devel.sha256sum] = "35d8d3d30ddf7fa69122e5752f5fbff0d92d62c18b616ce78a7d7a84e4beea03"

URI_x86_64_v2_rust-spdx+text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx+text-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx+text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx+text-devel}"
SRC_URI[x86_64_v2_rust-spdx+text-devel.sha256sum] = "50e2d6fe1ad2e45d06dc09ba07d2a4155c54a650e072aa2fb5d9ddb2568198f2"

URI_x86_64_v2_rust-spdx+unicode-normalization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx+unicode-normalization-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx+unicode-normalization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx+unicode-normalization-devel}"
SRC_URI[x86_64_v2_rust-spdx+unicode-normalization-devel.sha256sum] = "114ec327b1c3e66f368a73a912d67224658b5b8f458efa2e6a5283335ef00526"

URI_x86_64_v2_rust-spdx+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx+zstd-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx+zstd-devel}"
SRC_URI[x86_64_v2_rust-spdx+zstd-devel.sha256sum] = "6ae406490a3a392a55cf8a773a42b902b00289ac03bfa86f70aa34cb58bf0faa"

URI_x86_64_v2_rust-spdx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx-devel}"
SRC_URI[x86_64_v2_rust-spdx-devel.sha256sum] = "382d9d3bedbdc48f206af526303a3fad360c836a27e31209e2db7204ed254396"

URI_aarch64_rust-spdx+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx+default-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-spdx+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx+default-devel}"
SRC_URI[aarch64_rust-spdx+default-devel.sha256sum] = "27f3a144b5a3f6decf49c7ecad7dd9e74e137088a99450b0fdb9eb0375980f1f"

URI_aarch64_rust-spdx+detection-cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx+detection-cache-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-spdx+detection-cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx+detection-cache-devel}"
SRC_URI[aarch64_rust-spdx+detection-cache-devel.sha256sum] = "0e4edc9bc1865ec0f39b142d7ce7db7e94bdc19f288d739436dd6b3036b552eb"

URI_aarch64_rust-spdx+detection-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx+detection-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-spdx+detection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx+detection-devel}"
SRC_URI[aarch64_rust-spdx+detection-devel.sha256sum] = "71afa18155bb1d12133059c829f460b54b1dcdc89e3a45158c0c352ebffb5a81"

URI_aarch64_rust-spdx+detection-inline-cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx+detection-inline-cache-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-spdx+detection-inline-cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx+detection-inline-cache-devel}"
SRC_URI[aarch64_rust-spdx+detection-inline-cache-devel.sha256sum] = "5f9f19553795baaf8e15462ed60a327d3fc2499f765c941f71e962022c24883d"

URI_aarch64_rust-spdx+detection-parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx+detection-parallel-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-spdx+detection-parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx+detection-parallel-devel}"
SRC_URI[aarch64_rust-spdx+detection-parallel-devel.sha256sum] = "284d4e8382deb7cd8c3e02d1912469c9caa11c2261987676afcc997d47787680"

URI_aarch64_rust-spdx+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx+rayon-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-spdx+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx+rayon-devel}"
SRC_URI[aarch64_rust-spdx+rayon-devel.sha256sum] = "6db49c2c314c8fd9e43f98fa7d15849abb474581b317e5586fbb99db06c15eb8"

URI_aarch64_rust-spdx+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx+regex-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-spdx+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx+regex-devel}"
SRC_URI[aarch64_rust-spdx+regex-devel.sha256sum] = "9b9f1c87a4c2c13f9c4e640d422149e236bd237e9ed009679aeff12b1ccc8c1d"

URI_aarch64_rust-spdx+text-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx+text-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-spdx+text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx+text-devel}"
SRC_URI[aarch64_rust-spdx+text-devel.sha256sum] = "12bf9b93cd0110332e1e0d77fd0d711dd810c29464e52b9ae5026201358d4c5d"

URI_aarch64_rust-spdx+unicode-normalization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx+unicode-normalization-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-spdx+unicode-normalization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx+unicode-normalization-devel}"
SRC_URI[aarch64_rust-spdx+unicode-normalization-devel.sha256sum] = "2a856f222aefdeebd8c5b445d34cd3fa1524f808ccb5cc573deb37053039ecf4"

URI_aarch64_rust-spdx+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx+zstd-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-spdx+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx+zstd-devel}"
SRC_URI[aarch64_rust-spdx+zstd-devel.sha256sum] = "790a00d2ed7f924f50df7678b3075b2a4f5758a1667c2316c80e6d5b9687803b"

URI_aarch64_rust-spdx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-spdx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx-devel}"
SRC_URI[aarch64_rust-spdx-devel.sha256sum] = "84e473308a0d131467aa011cb527f1b7933fa05bd182dbadefc6d15253aa609c"

RDEPENDS:rust-spdx+default-devel = " \
 cargo \
 rust-spdx-devel \
 "
RDEPENDS:rust-spdx+detection-cache-devel = " \
 cargo \
 rust-spdx+detection-devel \
 rust-spdx+zstd-devel \
 rust-spdx-devel \
 "
RDEPENDS:rust-spdx+detection-devel = " \
 cargo \
 rust-spdx+regex-devel \
 rust-spdx+unicode-normalization-devel \
 rust-spdx-devel \
 "
RDEPENDS:rust-spdx+detection-inline-cache-devel = " \
 cargo \
 rust-spdx+detection-cache-devel \
 rust-spdx-devel \
 "
RDEPENDS:rust-spdx+detection-parallel-devel = " \
 cargo \
 rust-spdx+detection-devel \
 rust-spdx+rayon-devel \
 rust-spdx-devel \
 "
RDEPENDS:rust-spdx+rayon-devel = " \
 cargo \
 rust-rayon+default-devel \
 rust-spdx-devel \
 "
RDEPENDS:rust-spdx+regex-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-spdx-devel \
 "
RDEPENDS:rust-spdx+text-devel = " \
 cargo \
 rust-spdx-devel \
 "
RDEPENDS:rust-spdx+unicode-normalization-devel = " \
 cargo \
 rust-spdx-devel \
 rust-unicode-normalization+default-devel \
 "
RDEPENDS:rust-spdx+zstd-devel = " \
 cargo \
 rust-spdx-devel \
 rust-zstd+default-devel \
 "
RDEPENDS:rust-spdx-devel = " \
 cargo \
 rust \
 rust-smallvec+default-devel \
 "
