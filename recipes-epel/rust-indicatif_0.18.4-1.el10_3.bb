# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indicatif"
PV = "0.18.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-indicatif+default-devel \
 rust-indicatif+futures-devel \
 rust-indicatif+improved_unicode-devel \
 rust-indicatif+in_memory-devel \
 rust-indicatif+rayon-devel \
 rust-indicatif+tokio-devel \
 rust-indicatif+unicode-segmentation-devel \
 rust-indicatif+unicode-width-devel \
 rust-indicatif+vt100-devel \
 rust-indicatif-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indicatif-0.18.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec0f8ee296f0403901a17f59a13768ff757c4c48681f13c31fff62588f74e47d"

URI_x86_64_v2_rust-indicatif+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+default-devel-0.18.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+default-devel}"
SRC_URI[x86_64_v2_rust-indicatif+default-devel.sha256sum] = "cd78bf76376fc831440d223268713a29ae3378f4622807a3edc2ac81f329b37a"

URI_x86_64_v2_rust-indicatif+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+futures-devel-0.18.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+futures-devel}"
SRC_URI[x86_64_v2_rust-indicatif+futures-devel.sha256sum] = "85a702d943ac795be123d0df9c9abcaa1ea85c2c4da4ae15ce1f791de9eee4fd"

URI_x86_64_v2_rust-indicatif+improved_unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+improved_unicode-devel-0.18.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+improved_unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+improved_unicode-devel}"
SRC_URI[x86_64_v2_rust-indicatif+improved_unicode-devel.sha256sum] = "000c2e0c1d6e96846f35846eb76dc1b827db7c1a41aea0480d305e4895deaf82"

URI_x86_64_v2_rust-indicatif+in_memory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+in_memory-devel-0.18.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+in_memory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+in_memory-devel}"
SRC_URI[x86_64_v2_rust-indicatif+in_memory-devel.sha256sum] = "80184f723ef9ec5501c2601087cd59f2d1f940e8bac1935ce612e23ed2f9216c"

URI_x86_64_v2_rust-indicatif+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+rayon-devel-0.18.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+rayon-devel}"
SRC_URI[x86_64_v2_rust-indicatif+rayon-devel.sha256sum] = "4bef046e289a40d4c209dc11f870efc22975246cbcf2b71fc1e5ebe0dc6ed009"

URI_x86_64_v2_rust-indicatif+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+tokio-devel-0.18.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+tokio-devel}"
SRC_URI[x86_64_v2_rust-indicatif+tokio-devel.sha256sum] = "d6416b7a88ddfe4c69c910508661dcd68cb2893ac0497bcbd637132daf09026d"

URI_x86_64_v2_rust-indicatif+unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+unicode-segmentation-devel-0.18.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-indicatif+unicode-segmentation-devel.sha256sum] = "f0b90a7bce51a647b6ada472f1e458fd4fe9e3000aa92ed56ee9ec44f42f1a5a"

URI_x86_64_v2_rust-indicatif+unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+unicode-width-devel-0.18.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+unicode-width-devel}"
SRC_URI[x86_64_v2_rust-indicatif+unicode-width-devel.sha256sum] = "6d46aaf52e51156efb59b7fdd0e5286a30896ae69ad63c8a575ef5131f603b31"

URI_x86_64_v2_rust-indicatif+vt100-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+vt100-devel-0.18.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+vt100-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+vt100-devel}"
SRC_URI[x86_64_v2_rust-indicatif+vt100-devel.sha256sum] = "3b5fef46daf6ca769bf38f9f2ed11eebe2c3f7787cc5b68828e46ee7aae4b297"

URI_x86_64_v2_rust-indicatif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif-devel-0.18.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif-devel}"
SRC_URI[x86_64_v2_rust-indicatif-devel.sha256sum] = "9463fb867af2d64555194789c44cc181dd8802eb3b8f7b9a6b01c87fa3162a03"

URI_aarch64_rust-indicatif+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+default-devel-0.18.4-1.el10_3.noarch.rpm;name=aarch64_rust-indicatif+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+default-devel}"
SRC_URI[aarch64_rust-indicatif+default-devel.sha256sum] = "506667debf1eea3bf3b20dfe313c417833af61e2e24db96cb9ac38cf26e48e3e"

URI_aarch64_rust-indicatif+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+futures-devel-0.18.4-1.el10_3.noarch.rpm;name=aarch64_rust-indicatif+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+futures-devel}"
SRC_URI[aarch64_rust-indicatif+futures-devel.sha256sum] = "c65405e037f8f5d5db2228f0c7dcfba1cfb988c351ec16924c7f7f62475a7334"

URI_aarch64_rust-indicatif+improved_unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+improved_unicode-devel-0.18.4-1.el10_3.noarch.rpm;name=aarch64_rust-indicatif+improved_unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+improved_unicode-devel}"
SRC_URI[aarch64_rust-indicatif+improved_unicode-devel.sha256sum] = "92d5b7e71f20ca94b9c154a80b5f58ddba9e759ef397e0eedef1cd0b8f715b22"

URI_aarch64_rust-indicatif+in_memory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+in_memory-devel-0.18.4-1.el10_3.noarch.rpm;name=aarch64_rust-indicatif+in_memory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+in_memory-devel}"
SRC_URI[aarch64_rust-indicatif+in_memory-devel.sha256sum] = "42bc2dbbb9e4aa3338c8517497701fa29b71d8b88554ad6309d1b518d6c114c5"

URI_aarch64_rust-indicatif+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+rayon-devel-0.18.4-1.el10_3.noarch.rpm;name=aarch64_rust-indicatif+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+rayon-devel}"
SRC_URI[aarch64_rust-indicatif+rayon-devel.sha256sum] = "458a5d58bfa8b42afa8358663acdb0d958f8289ad42b950ffd213f0a36f6a5c7"

URI_aarch64_rust-indicatif+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+tokio-devel-0.18.4-1.el10_3.noarch.rpm;name=aarch64_rust-indicatif+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+tokio-devel}"
SRC_URI[aarch64_rust-indicatif+tokio-devel.sha256sum] = "9af1c20a7871fd1dfc671771a66a0fb4657acc82cc7746f3fdad38363dbf9849"

URI_aarch64_rust-indicatif+unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+unicode-segmentation-devel-0.18.4-1.el10_3.noarch.rpm;name=aarch64_rust-indicatif+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+unicode-segmentation-devel}"
SRC_URI[aarch64_rust-indicatif+unicode-segmentation-devel.sha256sum] = "4ddad54544636ce8736104b4a6b924dd2437bb9243d246e5451a4c75534471db"

URI_aarch64_rust-indicatif+unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+unicode-width-devel-0.18.4-1.el10_3.noarch.rpm;name=aarch64_rust-indicatif+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+unicode-width-devel}"
SRC_URI[aarch64_rust-indicatif+unicode-width-devel.sha256sum] = "77e98e545ede5a91fdebd8e597470afbf49b4773abfb22cf399afaae3d670621"

URI_aarch64_rust-indicatif+vt100-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+vt100-devel-0.18.4-1.el10_3.noarch.rpm;name=aarch64_rust-indicatif+vt100-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+vt100-devel}"
SRC_URI[aarch64_rust-indicatif+vt100-devel.sha256sum] = "1ed5ad8ab6cfd573a83fa829ef1f0c8232262af5cda8900e52de160ee3f6a8b0"

URI_aarch64_rust-indicatif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif-devel-0.18.4-1.el10_3.noarch.rpm;name=aarch64_rust-indicatif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif-devel}"
SRC_URI[aarch64_rust-indicatif-devel.sha256sum] = "a588d051ee90fe81d9c8b9778d3896c259d8d7be1c12ca915fd62d5650e579d4"

RDEPENDS:rust-indicatif+default-devel = " \
 cargo \
 rust-indicatif+unicode-width-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+futures-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+improved_unicode-devel = " \
 cargo \
 rust-indicatif+unicode-segmentation-devel \
 rust-indicatif+unicode-width-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+in_memory-devel = " \
 cargo \
 rust-indicatif+vt100-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+rayon-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-indicatif+tokio-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-indicatif+unicode-segmentation-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-unicode-segmentation+default-devel \
 "
RDEPENDS:rust-indicatif+unicode-width-devel = " \
 cargo \
 rust-console+unicode-width-devel \
 rust-indicatif-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-indicatif+vt100-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-vt100+default-devel \
 "
RDEPENDS:rust-indicatif-devel = " \
 cargo \
 rust \
 rust-console+ansi-parsing-devel \
 rust-console+std-devel \
 rust-console-devel \
 rust-portable-atomic+default-devel \
 rust-unit-prefix+default-devel \
 "
