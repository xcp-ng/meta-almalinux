# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rgb"
PV = "0.8.52"
PR = "1.el10_0"
PACKAGES = " \
 rust-rgb+argb-devel \
 rust-rgb+as-bytes-devel \
 rust-rgb+bytemuck-devel \
 rust-rgb+checked_fns-devel \
 rust-rgb+default-devel \
 rust-rgb+grb-devel \
 rust-rgb+serde-devel \
 rust-rgb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rgb-0.8.52-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9be4dc6d675ff214e5879f0290ae98cfdb916dd75bb9c54fd223cf69af7508a"

URI_x86_64_v2_rust-rgb+argb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+argb-devel-0.8.52-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+argb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+argb-devel}"
SRC_URI[x86_64_v2_rust-rgb+argb-devel.sha256sum] = "4e91831544fad92cc613f4db37b68cf9c4263f0888d5251215cfde48191f52ef"

URI_x86_64_v2_rust-rgb+as-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+as-bytes-devel-0.8.52-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+as-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+as-bytes-devel}"
SRC_URI[x86_64_v2_rust-rgb+as-bytes-devel.sha256sum] = "47c9490f5b4ebdb9d0e2fd9a27e1e84b170f8b71e1ca3e1f944657a3c073eaa6"

URI_x86_64_v2_rust-rgb+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+bytemuck-devel-0.8.52-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-rgb+bytemuck-devel.sha256sum] = "581fe6374216e6e386bad4613763fea8ccd204cf01b7d1f778f54e7c290203f8"

URI_x86_64_v2_rust-rgb+checked_fns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+checked_fns-devel-0.8.52-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+checked_fns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+checked_fns-devel}"
SRC_URI[x86_64_v2_rust-rgb+checked_fns-devel.sha256sum] = "77bf70d2a2d3732f7ab64e9ff914d4930f4a55c1b350a1c6b01e9e62e2e27eb2"

URI_x86_64_v2_rust-rgb+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+default-devel-0.8.52-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+default-devel}"
SRC_URI[x86_64_v2_rust-rgb+default-devel.sha256sum] = "ec247b2d103a4cee53dbff3750e3d7a0aae0b9f9935aa74698da850735e6a5ef"

URI_x86_64_v2_rust-rgb+grb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+grb-devel-0.8.52-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+grb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+grb-devel}"
SRC_URI[x86_64_v2_rust-rgb+grb-devel.sha256sum] = "f42d481bdde2c1d4e8675fac8f755037920882bcf55161b88320dd398daf4181"

URI_x86_64_v2_rust-rgb+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+serde-devel-0.8.52-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+serde-devel}"
SRC_URI[x86_64_v2_rust-rgb+serde-devel.sha256sum] = "bd3451f080e092ed4803aabfbcf740398e0146991fce41fac1ca7fe3b38bc241"

URI_x86_64_v2_rust-rgb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb-devel-0.8.52-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb-devel}"
SRC_URI[x86_64_v2_rust-rgb-devel.sha256sum] = "d5c0d0758d24449a4a2075d3f491f235d03447e48c42a5c0765874f18354b0cc"

URI_aarch64_rust-rgb+argb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+argb-devel-0.8.52-1.el10_0.noarch.rpm;name=aarch64_rust-rgb+argb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+argb-devel}"
SRC_URI[aarch64_rust-rgb+argb-devel.sha256sum] = "8b29045579bfa8e9c34cc389df5556bb01da46052e31b9b03abf38130950e300"

URI_aarch64_rust-rgb+as-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+as-bytes-devel-0.8.52-1.el10_0.noarch.rpm;name=aarch64_rust-rgb+as-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+as-bytes-devel}"
SRC_URI[aarch64_rust-rgb+as-bytes-devel.sha256sum] = "ade71027e416bd68301bda8a32bae921b17894e6b7c918db27d396b43fdd25ba"

URI_aarch64_rust-rgb+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+bytemuck-devel-0.8.52-1.el10_0.noarch.rpm;name=aarch64_rust-rgb+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+bytemuck-devel}"
SRC_URI[aarch64_rust-rgb+bytemuck-devel.sha256sum] = "d7b20937e6b570a792bf91c5f5499a2dc8ac4d9bb503806ab2cd55f0d09cbc7a"

URI_aarch64_rust-rgb+checked_fns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+checked_fns-devel-0.8.52-1.el10_0.noarch.rpm;name=aarch64_rust-rgb+checked_fns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+checked_fns-devel}"
SRC_URI[aarch64_rust-rgb+checked_fns-devel.sha256sum] = "2515a02032d9c8606b29607e6ae540c926f9e9a9e805fd2f953b9c649d48ea5a"

URI_aarch64_rust-rgb+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+default-devel-0.8.52-1.el10_0.noarch.rpm;name=aarch64_rust-rgb+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+default-devel}"
SRC_URI[aarch64_rust-rgb+default-devel.sha256sum] = "9e84fa2b60c17ce44e1c9299abdbf4d30ebe280a005d130078f12edeccda5f69"

URI_aarch64_rust-rgb+grb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+grb-devel-0.8.52-1.el10_0.noarch.rpm;name=aarch64_rust-rgb+grb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+grb-devel}"
SRC_URI[aarch64_rust-rgb+grb-devel.sha256sum] = "d70b0005a9026daa2d7596578a1d5f224d868285a94b6217015539d00a304caa"

URI_aarch64_rust-rgb+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+serde-devel-0.8.52-1.el10_0.noarch.rpm;name=aarch64_rust-rgb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+serde-devel}"
SRC_URI[aarch64_rust-rgb+serde-devel.sha256sum] = "5ce2767ae5e4c128e140fce637feafb9f3e1cc3aac61850a20e672d950bd2870"

URI_aarch64_rust-rgb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb-devel-0.8.52-1.el10_0.noarch.rpm;name=aarch64_rust-rgb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb-devel}"
SRC_URI[aarch64_rust-rgb-devel.sha256sum] = "f841423483f1deb00de0cd4fd9490932b03c9d37935d88f2224b9c4afc602673"

RDEPENDS:rust-rgb+argb-devel = " \
 cargo \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+as-bytes-devel = " \
 cargo \
 rust-rgb+bytemuck-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+checked_fns-devel = " \
 cargo \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+default-devel = " \
 cargo \
 rust-rgb+argb-devel \
 rust-rgb+as-bytes-devel \
 rust-rgb+grb-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+grb-devel = " \
 cargo \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+serde-devel = " \
 cargo \
 rust-rgb-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rgb-devel = " \
 cargo \
 rust \
 "
