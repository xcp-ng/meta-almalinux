# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign"
PV = "0.18.1"
PR = "6.el10_2"
PACKAGES = " \
 rust-reqsign+aliyun-devel \
 rust-reqsign+aws-devel \
 rust-reqsign+azure-devel \
 rust-reqsign+default-context-devel \
 rust-reqsign+default-devel \
 rust-reqsign+full-devel \
 rust-reqsign+google-devel \
 rust-reqsign+huaweicloud-devel \
 rust-reqsign+oracle-devel \
 rust-reqsign+tencent-devel \
 rust-reqsign-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-0.18.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d999f00a2c4ec0735d3b1ab8c1aa44ca9e9a69f4a5fbaca2ca3e9a46c634f500"

URI_x86_64_v2_rust-reqsign+aliyun-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+aliyun-devel-0.18.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+aliyun-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+aliyun-devel}"
SRC_URI[x86_64_v2_rust-reqsign+aliyun-devel.sha256sum] = "1bd7898a874fe7517954df3d9d6c8944d8648008c36c2422fdb1ddc31edae587"

URI_x86_64_v2_rust-reqsign+aws-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+aws-devel-0.18.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+aws-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+aws-devel}"
SRC_URI[x86_64_v2_rust-reqsign+aws-devel.sha256sum] = "88d4fcf21d02bca9f79b3d86fb8b2dca55deac2d967e97b86d966cc033fbd4a0"

URI_x86_64_v2_rust-reqsign+azure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+azure-devel-0.18.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+azure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+azure-devel}"
SRC_URI[x86_64_v2_rust-reqsign+azure-devel.sha256sum] = "dd4758dc0e6f2818147d15b0ab7742a48bb9cf47accfffc08f1d2813400df6f2"

URI_x86_64_v2_rust-reqsign+default-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+default-context-devel-0.18.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+default-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+default-context-devel}"
SRC_URI[x86_64_v2_rust-reqsign+default-context-devel.sha256sum] = "74572d04525677110078e1023a5c89ae7094dd21f49eb0d9b3807c9d1bd616a9"

URI_x86_64_v2_rust-reqsign+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+default-devel-0.18.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign+default-devel.sha256sum] = "d323384299893313db23e1253164ca36f24f4ebad80fca070b6830d8b011eed5"

URI_x86_64_v2_rust-reqsign+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+full-devel-0.18.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+full-devel}"
SRC_URI[x86_64_v2_rust-reqsign+full-devel.sha256sum] = "95b7183a79630948391c8cdc687ee8cdc2a6b358c36443afcdd51bbce71db70a"

URI_x86_64_v2_rust-reqsign+google-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+google-devel-0.18.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+google-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+google-devel}"
SRC_URI[x86_64_v2_rust-reqsign+google-devel.sha256sum] = "29db75b740c5b49deea8565216cd4822829ee6a4a4be1d9dbff80434c1983a2b"

URI_x86_64_v2_rust-reqsign+huaweicloud-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+huaweicloud-devel-0.18.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+huaweicloud-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+huaweicloud-devel}"
SRC_URI[x86_64_v2_rust-reqsign+huaweicloud-devel.sha256sum] = "08820eaed7557c825bcf1e51c30ebd703b47ca0b4132f22f1aab432a02ad2cee"

URI_x86_64_v2_rust-reqsign+oracle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+oracle-devel-0.18.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+oracle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+oracle-devel}"
SRC_URI[x86_64_v2_rust-reqsign+oracle-devel.sha256sum] = "f9d2a40120c5e6482ba5ef367e94513cd3a1fe9fae60d49adf22b13af4277dbd"

URI_x86_64_v2_rust-reqsign+tencent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+tencent-devel-0.18.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+tencent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+tencent-devel}"
SRC_URI[x86_64_v2_rust-reqsign+tencent-devel.sha256sum] = "e9b9a6332746920fc2d733e3e57615b151c5c297b57939cf0b78e25239235594"

URI_x86_64_v2_rust-reqsign-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-devel-0.18.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-devel}"
SRC_URI[x86_64_v2_rust-reqsign-devel.sha256sum] = "da322793dffd6c8a8fdedeb9dcb0d6ecb69fd75dbd7af3260daa7aa7be71b681"

URI_aarch64_rust-reqsign+aliyun-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+aliyun-devel-0.18.1-6.el10_2.noarch.rpm;name=aarch64_rust-reqsign+aliyun-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+aliyun-devel}"
SRC_URI[aarch64_rust-reqsign+aliyun-devel.sha256sum] = "f2cd9c70400394af9aef08328014c187f8b94320e9d57ba4bc325d08e62cc5ba"

URI_aarch64_rust-reqsign+aws-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+aws-devel-0.18.1-6.el10_2.noarch.rpm;name=aarch64_rust-reqsign+aws-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+aws-devel}"
SRC_URI[aarch64_rust-reqsign+aws-devel.sha256sum] = "4a5d93a6ba8dcfa65569dec6d2a7b3e6d1a89da55a7e2b8783d0b7c12ec996d4"

URI_aarch64_rust-reqsign+azure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+azure-devel-0.18.1-6.el10_2.noarch.rpm;name=aarch64_rust-reqsign+azure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+azure-devel}"
SRC_URI[aarch64_rust-reqsign+azure-devel.sha256sum] = "15de0ee7f46f700a75a7c298340e155093c3ec498217ec9e44b3c7daa4372a61"

URI_aarch64_rust-reqsign+default-context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+default-context-devel-0.18.1-6.el10_2.noarch.rpm;name=aarch64_rust-reqsign+default-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+default-context-devel}"
SRC_URI[aarch64_rust-reqsign+default-context-devel.sha256sum] = "40b3db612cd6c93c74641b9a1cff22b2fb5b79c0387e3625c01abc1fad392b29"

URI_aarch64_rust-reqsign+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+default-devel-0.18.1-6.el10_2.noarch.rpm;name=aarch64_rust-reqsign+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+default-devel}"
SRC_URI[aarch64_rust-reqsign+default-devel.sha256sum] = "fc4ab2d22ed34b8751430c37bf01eaa4aa768e7e29e41f96f400611ffc84463e"

URI_aarch64_rust-reqsign+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+full-devel-0.18.1-6.el10_2.noarch.rpm;name=aarch64_rust-reqsign+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+full-devel}"
SRC_URI[aarch64_rust-reqsign+full-devel.sha256sum] = "152d29702179d386200f0c07eb654028190e348bbce0f3812cfdd2bd47a8abee"

URI_aarch64_rust-reqsign+google-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+google-devel-0.18.1-6.el10_2.noarch.rpm;name=aarch64_rust-reqsign+google-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+google-devel}"
SRC_URI[aarch64_rust-reqsign+google-devel.sha256sum] = "d3979bc6fc1ce849166dab433e36083517142ae391bf92f67d31b217b5b58942"

URI_aarch64_rust-reqsign+huaweicloud-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+huaweicloud-devel-0.18.1-6.el10_2.noarch.rpm;name=aarch64_rust-reqsign+huaweicloud-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+huaweicloud-devel}"
SRC_URI[aarch64_rust-reqsign+huaweicloud-devel.sha256sum] = "03920b295c8531fc1df42dd0ddb7762cff5eac0a262707712d0ce27d359db085"

URI_aarch64_rust-reqsign+oracle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+oracle-devel-0.18.1-6.el10_2.noarch.rpm;name=aarch64_rust-reqsign+oracle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+oracle-devel}"
SRC_URI[aarch64_rust-reqsign+oracle-devel.sha256sum] = "b6e4ef92bbde5c261b8ca1acddb129c294c91011482d1c50c1660065548466f4"

URI_aarch64_rust-reqsign+tencent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+tencent-devel-0.18.1-6.el10_2.noarch.rpm;name=aarch64_rust-reqsign+tencent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+tencent-devel}"
SRC_URI[aarch64_rust-reqsign+tencent-devel.sha256sum] = "6ac22fb2d664957812647ef43012e845c1fc180101018ce005a8a38aeef118b3"

URI_aarch64_rust-reqsign-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-devel-0.18.1-6.el10_2.noarch.rpm;name=aarch64_rust-reqsign-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-devel}"
SRC_URI[aarch64_rust-reqsign-devel.sha256sum] = "5b65f1ad7eb44e43799e5e972ce635dcbfabc60077b8c5dc883b2599beab23f4"

RDEPENDS:rust-reqsign+aliyun-devel = " \
 cargo \
 rust-reqsign-aliyun-oss+default-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+aws-devel = " \
 cargo \
 rust-reqsign-aws-v4+default-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+azure-devel = " \
 cargo \
 rust-reqsign-azure-storage+default-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+default-context-devel = " \
 cargo \
 rust-reqsign-command-execute-tokio+default-devel \
 rust-reqsign-devel \
 rust-reqsign-file-read-tokio+default-devel \
 rust-reqsign-http-send-reqwest+default-devel \
 "
RDEPENDS:rust-reqsign+default-devel = " \
 cargo \
 rust-reqsign+default-context-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+full-devel = " \
 cargo \
 rust-reqsign+aliyun-devel \
 rust-reqsign+aws-devel \
 rust-reqsign+azure-devel \
 rust-reqsign+google-devel \
 rust-reqsign+huaweicloud-devel \
 rust-reqsign+oracle-devel \
 rust-reqsign+tencent-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+google-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-google+default-devel \
 "
RDEPENDS:rust-reqsign+huaweicloud-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-huaweicloud-obs+default-devel \
 "
RDEPENDS:rust-reqsign+oracle-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-oracle+default-devel \
 "
RDEPENDS:rust-reqsign+tencent-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-tencent-cos+default-devel \
 "
RDEPENDS:rust-reqsign-devel = " \
 cargo \
 rust \
 rust-reqsign-core+default-devel \
 "
