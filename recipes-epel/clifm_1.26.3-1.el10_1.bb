# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clifm"
PV = "1.26.3"
PR = "1.el10_1"
PACKAGES = " \
 clifm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clifm-1.26.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acaf6a39e5aa534f1c8995993c24fafe61e529b53c7adbc2b9140d195cc5f0fa"

URI_x86_64_v2_clifm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clifm-1.26.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clifm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clifm}"
SRC_URI[x86_64_v2_clifm.sha256sum] = "752a71bb29da245465f7a090c137f6551d12af33c33a801b5e1337e528093a31"

URI_aarch64_clifm = "${EPEL_MIRROR}/aarch64/Packages/c/clifm-1.26.3-1.el10_1.aarch64.rpm;name=aarch64_clifm;unpack=0"
SRC_URI:append = " ${URI_aarch64_clifm}"
SRC_URI[aarch64_clifm.sha256sum] = "2f01a4b8edd5ad632ab362bae32c63ca1ccdc5d756539c2682cb75d38871dfbc"

RDEPENDS:clifm = " \
 bash \
 file-libs \
 glibc \
 hicolor-icon-theme \
 libacl \
 libcap \
 python3 \
 readline \
 "
