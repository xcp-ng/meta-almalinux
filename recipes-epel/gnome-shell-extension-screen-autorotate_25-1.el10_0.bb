# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-screen-autorotate"
PV = "25"
PR = "1.el10_0"
PACKAGES = " \
 gnome-shell-extension-screen-autorotate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-shell-extension-screen-autorotate-25-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2243412f4cd433f225fb92451e17b516fd0014969bed97831863e9ff06a1cb90"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - gnome-shell-extension-screen-autorotate: gnome-shell >= 40

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - gnome-shell-extension-screen-autorotate: gnome-shell >= 40

URI_x86_64_v2_gnome-shell-extension-screen-autorotate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-shell-extension-screen-autorotate-25-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-shell-extension-screen-autorotate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-screen-autorotate}"
SRC_URI[x86_64_v2_gnome-shell-extension-screen-autorotate.sha256sum] = "769ca746a2fdc7609b1936930d6066d3dd552cae8888e5efc152a4bef3f79d5f"

URI_aarch64_gnome-shell-extension-screen-autorotate = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-shell-extension-screen-autorotate-25-1.el10_0.noarch.rpm;name=aarch64_gnome-shell-extension-screen-autorotate;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-screen-autorotate}"
SRC_URI[aarch64_gnome-shell-extension-screen-autorotate.sha256sum] = "ecaaaf973338b4b3ef72dbb4054a47cfd8679c21de6ed25c4a05a8024b248eb2"

RDEPENDS:gnome-shell-extension-screen-autorotate = " \
 iio-sensor-proxy \
 "
