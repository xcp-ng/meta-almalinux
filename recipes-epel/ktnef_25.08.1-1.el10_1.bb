# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktnef"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 ktnef \
 ktnef-devel \
 ktnef-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktnef-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b6b0ba452a118dd3235ca43b545c968243aa4e0f9e118f848ceb561c2246f4c"

URI_x86_64_v2_ktnef = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktnef;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktnef}"
SRC_URI[x86_64_v2_ktnef.sha256sum] = "f10f520345c2cba3a24aa4527b45954d60c6d9d6b4dd1e8dec62ce3775e2a692"

URI_x86_64_v2_ktnef-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktnef-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktnef-devel}"
SRC_URI[x86_64_v2_ktnef-devel.sha256sum] = "bf77ceb4fba4f5b49f577cfcfc40fbd9708abfdbab921f3458b536bfa28376ec"

URI_x86_64_v2_ktnef-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ktnef-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktnef-doc}"
SRC_URI[x86_64_v2_ktnef-doc.sha256sum] = "652e1dbc5396dd48acf7bd5b679fa166b63f783e22bb798de2d8988f9f59894c"

URI_aarch64_ktnef = "${EPEL_MIRROR}/aarch64/Packages/k/ktnef-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ktnef;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktnef}"
SRC_URI[aarch64_ktnef.sha256sum] = "237ea610ac2558a058a37f0fe992cebd8b33dcc061573ab32b65619cec983625"

URI_aarch64_ktnef-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ktnef-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ktnef-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktnef-devel}"
SRC_URI[aarch64_ktnef-devel.sha256sum] = "f45d1a3f23e8e7ef1f0ec538d52f083bb80aeda6dd15ec810730be84e8d28932"

URI_aarch64_ktnef-doc = "${EPEL_MIRROR}/aarch64/Packages/k/ktnef-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_ktnef-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktnef-doc}"
SRC_URI[aarch64_ktnef-doc.sha256sum] = "6a841ec342ea68b2b6b692b038c1ffeeca79cef51bc1c97a9b87060a81f5f196"

RDEPENDS:ktnef = " \
 glibc \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:ktnef-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 ktnef \
 "
RDEPENDS:ktnef-doc = " \
 "
