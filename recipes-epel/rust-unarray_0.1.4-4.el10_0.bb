# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unarray"
PV = "0.1.4"
PR = "4.el10_0"
PACKAGES = " \
 rust-unarray+default-devel \
 rust-unarray-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unarray-0.1.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23061af0315898fde70228158a824dd62babf149e5c4eaa0deabe2983adc5903"

URI_x86_64_v2_rust-unarray+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unarray+default-devel-0.1.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unarray+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unarray+default-devel}"
SRC_URI[x86_64_v2_rust-unarray+default-devel.sha256sum] = "4ccf2a715a55ac003773e457ee4d86ad4905549c10a52eeeba7ffbca20a693cb"

URI_x86_64_v2_rust-unarray-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unarray-devel-0.1.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unarray-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unarray-devel}"
SRC_URI[x86_64_v2_rust-unarray-devel.sha256sum] = "83d16861d6035b14f76002d984c89e85b0828e9838ffd76e50fca3e16e02b874"

URI_aarch64_rust-unarray+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unarray+default-devel-0.1.4-4.el10_0.noarch.rpm;name=aarch64_rust-unarray+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unarray+default-devel}"
SRC_URI[aarch64_rust-unarray+default-devel.sha256sum] = "6d5c2cf2e4cff4a07d118b3226e01957c54d725671e9ee968e648fa9967ca1dc"

URI_aarch64_rust-unarray-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unarray-devel-0.1.4-4.el10_0.noarch.rpm;name=aarch64_rust-unarray-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unarray-devel}"
SRC_URI[aarch64_rust-unarray-devel.sha256sum] = "8538d278cf9804dd1fb4560c5705b54a1ab2c6643e5376badec1701b19d3f368"

RDEPENDS:rust-unarray+default-devel = " \
 cargo \
 rust-unarray-devel \
 "
RDEPENDS:rust-unarray-devel = " \
 cargo \
 "
