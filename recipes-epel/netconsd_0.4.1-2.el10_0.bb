# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netconsd"
PV = "0.4.1"
PR = "2.el10_0"
PACKAGES = " \
 netconsd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netconsd-0.4.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "965c5921ac60f9c8179a3d0e92be9bd4ab7dade14e726ca9b783cd64b3e79725"

URI_x86_64_v2_netconsd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netconsd-0.4.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netconsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netconsd}"
SRC_URI[x86_64_v2_netconsd.sha256sum] = "d8c328044b64ca85f34e7c38d79e533533855ae60c853a17616ac7039fd91864"

URI_aarch64_netconsd = "${EPEL_MIRROR}/aarch64/Packages/n/netconsd-0.4.1-2.el10_0.aarch64.rpm;name=aarch64_netconsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_netconsd}"
SRC_URI[aarch64_netconsd.sha256sum] = "8877b4f1e3f70933d8d5ab231776df355acf7bd7871d4b090d3504c32eb4b315"

RDEPENDS:netconsd = " \
 glibc \
 "
