# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derivative"
PV = "2.2.0"
PR = "11.el10_0"
PACKAGES = " \
 rust-derivative+default-devel \
 rust-derivative+use_core-devel \
 rust-derivative-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derivative-2.2.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cdde19ef38095ec99a495fda1ad83f79dc85a5a40e27f831f50b501f6e9d5de"

URI_x86_64_v2_rust-derivative+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derivative+default-devel-2.2.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derivative+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derivative+default-devel}"
SRC_URI[x86_64_v2_rust-derivative+default-devel.sha256sum] = "fc00bed028f018f73b98765cd5a3c0bbf20e1e5e31f73baef4c77ce7f6ed521e"

URI_x86_64_v2_rust-derivative+use_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derivative+use_core-devel-2.2.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derivative+use_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derivative+use_core-devel}"
SRC_URI[x86_64_v2_rust-derivative+use_core-devel.sha256sum] = "b89d867af6cf093bddd18eeaad909553312bcbc89e5e7fb788341341b19c3686"

URI_x86_64_v2_rust-derivative-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derivative-devel-2.2.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derivative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derivative-devel}"
SRC_URI[x86_64_v2_rust-derivative-devel.sha256sum] = "92d127f34b87c403a7e3e6f28ab93af4834bd47047fc220ac99235a86a9e63ca"

URI_aarch64_rust-derivative+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derivative+default-devel-2.2.0-11.el10_0.noarch.rpm;name=aarch64_rust-derivative+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derivative+default-devel}"
SRC_URI[aarch64_rust-derivative+default-devel.sha256sum] = "1375aed4611dff9a5523aad2cd652906baec4f5245fc1defeff0b64423077591"

URI_aarch64_rust-derivative+use_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derivative+use_core-devel-2.2.0-11.el10_0.noarch.rpm;name=aarch64_rust-derivative+use_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derivative+use_core-devel}"
SRC_URI[aarch64_rust-derivative+use_core-devel.sha256sum] = "de3ee3039d1638527a42b43c67a5a1e49a2c2fa9e1e4144b7b94c38b4146c0d3"

URI_aarch64_rust-derivative-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derivative-devel-2.2.0-11.el10_0.noarch.rpm;name=aarch64_rust-derivative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derivative-devel}"
SRC_URI[aarch64_rust-derivative-devel.sha256sum] = "61b1945b5ed74b547941cfde06a817b4e62fc07aacc0978a34a99a07b32e373b"

RDEPENDS:rust-derivative+default-devel = " \
 cargo \
 rust-derivative-devel \
 "
RDEPENDS:rust-derivative+use_core-devel = " \
 cargo \
 rust-derivative-devel \
 "
RDEPENDS:rust-derivative-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 rust-syn1+extra-traits-devel \
 rust-syn1+visit-devel \
 "
