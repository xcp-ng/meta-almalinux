# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_lex"
PV = "0.7.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-clap_lex+default-devel \
 rust-clap_lex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_lex-0.7.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b12b2aae9c279810357ab7394ef85e4c20f1487da95b6f52930fcb1a1488a453"

URI_x86_64_v2_rust-clap_lex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_lex+default-devel-0.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_lex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_lex+default-devel}"
SRC_URI[x86_64_v2_rust-clap_lex+default-devel.sha256sum] = "5a7a4671d905e98a35807bf03fb6a8f076ae73c280759f7ef07c63be8d162853"

URI_x86_64_v2_rust-clap_lex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_lex-devel-0.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_lex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_lex-devel}"
SRC_URI[x86_64_v2_rust-clap_lex-devel.sha256sum] = "2952ec1c24fd1360f5ac5be8dd86a74c1df69ee9db712017b2672a0cad325ab3"

URI_aarch64_rust-clap_lex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_lex+default-devel-0.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-clap_lex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_lex+default-devel}"
SRC_URI[aarch64_rust-clap_lex+default-devel.sha256sum] = "4e3d83ae9c3ad49e4f1e7aa56e78b9d44090af42c890c8f827b3ad23ba6742ac"

URI_aarch64_rust-clap_lex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_lex-devel-0.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-clap_lex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_lex-devel}"
SRC_URI[aarch64_rust-clap_lex-devel.sha256sum] = "b17da2d66aaa75eba70173c1182ed13152eeaa3f71cb74f427be718df9b31ac3"

RDEPENDS:rust-clap_lex+default-devel = " \
 cargo \
 rust-clap_lex-devel \
 "
RDEPENDS:rust-clap_lex-devel = " \
 cargo \
 rust \
 "
