# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pulseaudio"
PV = "17.0"
PR = "6.el10"
PACKAGES = " \
 pulseaudio-libs \
 pulseaudio-libs-devel \
 pulseaudio-libs-glib2 \
 pulseaudio-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pulseaudio-17.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97d2f9125de1ff60f292448f51064796a1c9c556d336e2f0e17f3f220db497e8"

URI_x86_64_v2_pulseaudio-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pulseaudio-libs-17.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-libs}"
SRC_URI[x86_64_v2_pulseaudio-libs.sha256sum] = "0253b1364ebbef6a521dd1ba1fa2e789242473874c4a06d63bfc697f72529198"

URI_x86_64_v2_pulseaudio-libs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pulseaudio-libs-devel-17.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-libs-devel}"
SRC_URI[x86_64_v2_pulseaudio-libs-devel.sha256sum] = "2e2bb3d461ccbc89b751c4d366662eb5176dbcfea60a3cc15f404ccf7e0fe156"

URI_x86_64_v2_pulseaudio-libs-glib2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pulseaudio-libs-glib2-17.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-libs-glib2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-libs-glib2}"
SRC_URI[x86_64_v2_pulseaudio-libs-glib2.sha256sum] = "a1a0dc86b23e7fe42e1cb4af4ffa83307a220435be7461e1062b9bee5bd89661"

URI_x86_64_v2_pulseaudio-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pulseaudio-utils-17.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-utils}"
SRC_URI[x86_64_v2_pulseaudio-utils.sha256sum] = "0887b912fd3cfc1a53bd1fa1a195720b0181b98cb82f081d66cec2ce932f10a4"

URI_aarch64_pulseaudio-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pulseaudio-libs-17.0-6.el10.aarch64.rpm;name=aarch64_pulseaudio-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-libs}"
SRC_URI[aarch64_pulseaudio-libs.sha256sum] = "0abf0d6cb7db2be90a1966b6dc5dbeccda408f9a0bac85eab712974ff089ddd6"

URI_aarch64_pulseaudio-libs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pulseaudio-libs-devel-17.0-6.el10.aarch64.rpm;name=aarch64_pulseaudio-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-libs-devel}"
SRC_URI[aarch64_pulseaudio-libs-devel.sha256sum] = "ec4a135522dcc51862bf9a34456cc9602966f580da53826d0858480ccc6d82a7"

URI_aarch64_pulseaudio-libs-glib2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pulseaudio-libs-glib2-17.0-6.el10.aarch64.rpm;name=aarch64_pulseaudio-libs-glib2;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-libs-glib2}"
SRC_URI[aarch64_pulseaudio-libs-glib2.sha256sum] = "801e8fca6fb884def339810ae9dce23daff64176750eb879f13d6c222aa17de8"

URI_aarch64_pulseaudio-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pulseaudio-utils-17.0-6.el10.aarch64.rpm;name=aarch64_pulseaudio-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-utils}"
SRC_URI[aarch64_pulseaudio-utils.sha256sum] = "8864be6d413b51c7bd8fb5b3d52e7a06a4b59196ec3d0b8d25c7f47ab52f40a0"

RDEPENDS:pulseaudio-libs = " \
 dbus-libs \
 glibc \
 libasyncns \
 libsndfile \
 libxcb \
 systemd-libs \
 "
RDEPENDS:pulseaudio-libs-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 pulseaudio-libs \
 pulseaudio-libs-devel \
 pulseaudio-libs-glib2 \
 "
RDEPENDS:pulseaudio-libs-glib2 = " \
 glib2 \
 glibc \
 pulseaudio-libs \
 "
RDEPENDS:pulseaudio-utils = " \
 bash \
 glibc \
 libsndfile \
 libxcb \
 pulseaudio-libs \
 "
