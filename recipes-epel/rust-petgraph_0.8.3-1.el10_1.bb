# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-petgraph"
PV = "0.8.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-petgraph+default-devel \
 rust-petgraph+generate-devel \
 rust-petgraph+graphmap-devel \
 rust-petgraph+matrix_graph-devel \
 rust-petgraph+rayon-devel \
 rust-petgraph+serde-1-devel \
 rust-petgraph+serde-devel \
 rust-petgraph+serde_derive-devel \
 rust-petgraph+stable_graph-devel \
 rust-petgraph+std-devel \
 rust-petgraph+unstable-devel \
 rust-petgraph-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-petgraph-0.8.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2dcb6bdb83f6172c4ab031c01aa70d6cbfe317ea4f48d4eb9587f4bae5bb1420"

URI_x86_64_v2_rust-petgraph+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+default-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+default-devel}"
SRC_URI[x86_64_v2_rust-petgraph+default-devel.sha256sum] = "23dc44f10ebd3aa44a357267a2df7f73b4e7ef02d85845c944e5bf729ef0310f"

URI_x86_64_v2_rust-petgraph+generate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+generate-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+generate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+generate-devel}"
SRC_URI[x86_64_v2_rust-petgraph+generate-devel.sha256sum] = "63d8d2e7f5f0f5792f0b68c79357ba52f7f4bdde311a14905e9d5c25464d5ef7"

URI_x86_64_v2_rust-petgraph+graphmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+graphmap-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+graphmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+graphmap-devel}"
SRC_URI[x86_64_v2_rust-petgraph+graphmap-devel.sha256sum] = "582f3c9dec0654c60f139028618acdf7ae0f9b8bc7da26ad4d7668223ef7bf20"

URI_x86_64_v2_rust-petgraph+matrix_graph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+matrix_graph-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+matrix_graph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+matrix_graph-devel}"
SRC_URI[x86_64_v2_rust-petgraph+matrix_graph-devel.sha256sum] = "b54a316773622ac5456df8a43cd99fb12452d5393e763e11bd663a51ca446e48"

URI_x86_64_v2_rust-petgraph+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+rayon-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+rayon-devel}"
SRC_URI[x86_64_v2_rust-petgraph+rayon-devel.sha256sum] = "f445442e3ea1cf7e1c375c8c1799d91776653254621c55bab62935d7df1d2b66"

URI_x86_64_v2_rust-petgraph+serde-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+serde-1-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+serde-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+serde-1-devel}"
SRC_URI[x86_64_v2_rust-petgraph+serde-1-devel.sha256sum] = "c0ae55555f8db7eb2a7705eac74f7b92902f8e3c36f3cc9ab796127e0375e40a"

URI_x86_64_v2_rust-petgraph+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+serde-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+serde-devel}"
SRC_URI[x86_64_v2_rust-petgraph+serde-devel.sha256sum] = "bb261b2afd2997e65d77a6d64db02dabd59e7f6b73c31d2776d68ddfafe886a8"

URI_x86_64_v2_rust-petgraph+serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+serde_derive-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+serde_derive-devel}"
SRC_URI[x86_64_v2_rust-petgraph+serde_derive-devel.sha256sum] = "60415132d45901ebc7bab68ed0afbf16216c29ad75af460df738b9557767f9af"

URI_x86_64_v2_rust-petgraph+stable_graph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+stable_graph-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+stable_graph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+stable_graph-devel}"
SRC_URI[x86_64_v2_rust-petgraph+stable_graph-devel.sha256sum] = "5857b7e5e1ec269caa803c004003e60e0d76316d06e3e7da1032e244a7a1ff32"

URI_x86_64_v2_rust-petgraph+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+std-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+std-devel}"
SRC_URI[x86_64_v2_rust-petgraph+std-devel.sha256sum] = "5f175a41f3d8e67f41e1ff3c791449d566ae7a2a8b8da120c95625eed484c23e"

URI_x86_64_v2_rust-petgraph+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+unstable-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+unstable-devel}"
SRC_URI[x86_64_v2_rust-petgraph+unstable-devel.sha256sum] = "eb550422a79a21e0b6a804447577e387b41d953845f5791a11d4b6fb6cf7618c"

URI_x86_64_v2_rust-petgraph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph-devel}"
SRC_URI[x86_64_v2_rust-petgraph-devel.sha256sum] = "c4cea55e710f6754df79cfc6df4f090a4509ddc380a24a33dedda8b296fb8e5d"

URI_aarch64_rust-petgraph+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+default-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-petgraph+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+default-devel}"
SRC_URI[aarch64_rust-petgraph+default-devel.sha256sum] = "07478a6961891715b1412f039af5214cb953cbe1e1bf9090856ac29d1a0278d2"

URI_aarch64_rust-petgraph+generate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+generate-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-petgraph+generate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+generate-devel}"
SRC_URI[aarch64_rust-petgraph+generate-devel.sha256sum] = "539abbccac394eb28a5626dbd9a8be295a57a379f7c45a93d7d65a5517e1ff66"

URI_aarch64_rust-petgraph+graphmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+graphmap-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-petgraph+graphmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+graphmap-devel}"
SRC_URI[aarch64_rust-petgraph+graphmap-devel.sha256sum] = "315757ccbaf29d0409a172797b09436517f5de002835b26198199497e402768a"

URI_aarch64_rust-petgraph+matrix_graph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+matrix_graph-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-petgraph+matrix_graph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+matrix_graph-devel}"
SRC_URI[aarch64_rust-petgraph+matrix_graph-devel.sha256sum] = "a7616960396f686fcc65ecfc27f0e61d7281588440b179043589f35106a5b04c"

URI_aarch64_rust-petgraph+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+rayon-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-petgraph+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+rayon-devel}"
SRC_URI[aarch64_rust-petgraph+rayon-devel.sha256sum] = "b7a67efd581f26e73e673ae26604758e88518e67910f49305ad4eedcd2452d1e"

URI_aarch64_rust-petgraph+serde-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+serde-1-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-petgraph+serde-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+serde-1-devel}"
SRC_URI[aarch64_rust-petgraph+serde-1-devel.sha256sum] = "55965274ec2a06b1ad3d5b9223045829a3b6c5d516d51a4cb972c887cadee978"

URI_aarch64_rust-petgraph+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+serde-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-petgraph+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+serde-devel}"
SRC_URI[aarch64_rust-petgraph+serde-devel.sha256sum] = "35af85303789ddfcf808f16068ea79837d21821d8f99ed700c4bbc5fdf6e9b8b"

URI_aarch64_rust-petgraph+serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+serde_derive-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-petgraph+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+serde_derive-devel}"
SRC_URI[aarch64_rust-petgraph+serde_derive-devel.sha256sum] = "1ff8a740dbcbde0c017a550d10c74083377f512ecb7b56b38ceaec170d7df662"

URI_aarch64_rust-petgraph+stable_graph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+stable_graph-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-petgraph+stable_graph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+stable_graph-devel}"
SRC_URI[aarch64_rust-petgraph+stable_graph-devel.sha256sum] = "47c80ca6cd6949576ed6c3f3f0b3a092ab159032cd7fca1aa856aeaddabe3f49"

URI_aarch64_rust-petgraph+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+std-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-petgraph+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+std-devel}"
SRC_URI[aarch64_rust-petgraph+std-devel.sha256sum] = "fdc06045d882f0f9f31a4df2a190138cbbb977bbcb0605feed237235a09a3e2d"

URI_aarch64_rust-petgraph+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+unstable-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-petgraph+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+unstable-devel}"
SRC_URI[aarch64_rust-petgraph+unstable-devel.sha256sum] = "bce8add7a625fdba072604eafc12c4a6bc45180469266388222c46122f70ed72"

URI_aarch64_rust-petgraph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph-devel}"
SRC_URI[aarch64_rust-petgraph-devel.sha256sum] = "4d947fa2ef34879aca929baf7eb9066990f9a4647008ef312065ef175b19ec03"

RDEPENDS:rust-petgraph+default-devel = " \
 cargo \
 rust-petgraph+graphmap-devel \
 rust-petgraph+matrix_graph-devel \
 rust-petgraph+stable_graph-devel \
 rust-petgraph+std-devel \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+generate-devel = " \
 cargo \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+graphmap-devel = " \
 cargo \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+matrix_graph-devel = " \
 cargo \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+rayon-devel = " \
 cargo \
 rust-hashbrown+rayon-devel \
 rust-indexmap+rayon-devel \
 rust-petgraph+std-devel \
 rust-petgraph-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-petgraph+serde-1-devel = " \
 cargo \
 rust-petgraph+serde-devel \
 rust-petgraph+serde_derive-devel \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+serde-devel = " \
 cargo \
 rust-petgraph-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-petgraph+serde_derive-devel = " \
 cargo \
 rust-petgraph-devel \
 rust-serde_derive-devel \
 "
RDEPENDS:rust-petgraph+stable_graph-devel = " \
 cargo \
 rust-petgraph-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-petgraph+std-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+unstable-devel = " \
 cargo \
 rust-petgraph+generate-devel \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph-devel = " \
 cargo \
 rust \
 rust-fixedbitset-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown-devel \
 rust-indexmap-devel \
 "
