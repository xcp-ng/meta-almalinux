# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tungstenite"
PV = "0.23.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-tungstenite+__rustls-tls-devel \
 rust-tungstenite+data-encoding-devel \
 rust-tungstenite+default-devel \
 rust-tungstenite+handshake-devel \
 rust-tungstenite+http-devel \
 rust-tungstenite+httparse-devel \
 rust-tungstenite+native-tls-crate-devel \
 rust-tungstenite+native-tls-devel \
 rust-tungstenite+rustls-devel \
 rust-tungstenite+rustls-native-certs-devel \
 rust-tungstenite+rustls-pki-types-devel \
 rust-tungstenite+rustls-tls-native-roots-devel \
 rust-tungstenite+rustls-tls-webpki-roots-devel \
 rust-tungstenite+sha1-devel \
 rust-tungstenite+url-devel \
 rust-tungstenite+webpki-roots-devel \
 rust-tungstenite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tungstenite-0.23.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "937613d809d37d104687e5d8dc3f03851925588b0a661e882fb71e67ea256c5a"

URI_x86_64_v2_rust-tungstenite+__rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+__rustls-tls-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+__rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+__rustls-tls-devel.sha256sum] = "0bc5436262d1be46957168ea7486cb9af7d8487358303979dcc6e85fdf053896"

URI_x86_64_v2_rust-tungstenite+data-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+data-encoding-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+data-encoding-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+data-encoding-devel.sha256sum] = "cad6e251c4ea9f0aeeef2aae59d417b80ae80cea46c1067ebd96057726f4c910"

URI_x86_64_v2_rust-tungstenite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+default-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+default-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+default-devel.sha256sum] = "0c96ea559a1f964de43dac972e445ccd297cde68d25a37d797d04ea94fcd3422"

URI_x86_64_v2_rust-tungstenite+handshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+handshake-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+handshake-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+handshake-devel.sha256sum] = "d715d7d09db4fce1e4aeb5e0f3be1ca7b624fcd8088288f3e59a994b36c5ec1e"

URI_x86_64_v2_rust-tungstenite+http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+http-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+http-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+http-devel.sha256sum] = "6fd631d74d4e6b7b17fa5674961de643a0bdfcbad73f3918c15cdae805055d9c"

URI_x86_64_v2_rust-tungstenite+httparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+httparse-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+httparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+httparse-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+httparse-devel.sha256sum] = "82ecee3d424ef627dda032ff7c996e1e7354808188b2fefed81ea0e53c4f8ca8"

URI_x86_64_v2_rust-tungstenite+native-tls-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+native-tls-crate-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+native-tls-crate-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+native-tls-crate-devel.sha256sum] = "bee805db234bc76db8cd5f352ac975d9ecf70889b4fe3101a12c85bd6a5d8e35"

URI_x86_64_v2_rust-tungstenite+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+native-tls-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+native-tls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+native-tls-devel.sha256sum] = "bddc29f659c8e2a5c059f2e9e5f22457095ad25e7fac391001551ee93f84df99"

URI_x86_64_v2_rust-tungstenite+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-devel.sha256sum] = "27f0083f41a2d9028252e60fe746865d401a99fddc7a45d11bf319207c0e0d39"

URI_x86_64_v2_rust-tungstenite+rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-native-certs-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-native-certs-devel.sha256sum] = "646a919f7f41bdbeaaf702c610fd7bef35f13d47ee126bc4f224f98092cacfb0"

URI_x86_64_v2_rust-tungstenite+rustls-pki-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-pki-types-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-pki-types-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-pki-types-devel.sha256sum] = "618db554a580b43a4a3847588cf30f0c08a14bcd1a409e5318d4198efb22ec84"

URI_x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-tls-native-roots-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "2c6e0f12dfbdda7dbe1058e5fadf8b0591c7a6033320ffcbea2014c5405bb30e"

URI_x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-tls-webpki-roots-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "64d539b46b434baba3d5b8919b4b160b919afaefa872058f23ffabfb859187ba"

URI_x86_64_v2_rust-tungstenite+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+sha1-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+sha1-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+sha1-devel.sha256sum] = "0aa7e0ad43e2eaea2ded3314dedc07d3e9ecc2e7f81883c2cee34f2d28a64963"

URI_x86_64_v2_rust-tungstenite+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+url-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+url-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+url-devel.sha256sum] = "fde6e3699fe8bf2fa59075b8f6ad1e168eab687d82903a9a73b371748a46783f"

URI_x86_64_v2_rust-tungstenite+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+webpki-roots-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+webpki-roots-devel.sha256sum] = "728924df5765cfb28a4a3a6e27c97f8f1c0dfb3143440ec8f9736f1cb5882b94"

URI_x86_64_v2_rust-tungstenite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite-devel-0.23.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite-devel}"
SRC_URI[x86_64_v2_rust-tungstenite-devel.sha256sum] = "888f8f8dc8b92ca56dd63c37225c2153d9d931b7e22d9dc4a6746e87a744707b"

URI_aarch64_rust-tungstenite+__rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+__rustls-tls-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+__rustls-tls-devel}"
SRC_URI[aarch64_rust-tungstenite+__rustls-tls-devel.sha256sum] = "3d6848b54589d94e70fe02fe559818e234df8e29f764e74a613a672173ffb543"

URI_aarch64_rust-tungstenite+data-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+data-encoding-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+data-encoding-devel}"
SRC_URI[aarch64_rust-tungstenite+data-encoding-devel.sha256sum] = "9185d6a5a9e8c930c83d2736d6c596e4e870f62b314151cd7c283f6b6b3e4260"

URI_aarch64_rust-tungstenite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+default-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+default-devel}"
SRC_URI[aarch64_rust-tungstenite+default-devel.sha256sum] = "52849d835a897e484b1352aeee20afb1a6a0c19201a80af0053fb8b7edf5dfb6"

URI_aarch64_rust-tungstenite+handshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+handshake-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+handshake-devel}"
SRC_URI[aarch64_rust-tungstenite+handshake-devel.sha256sum] = "798d8aac48a3251d74d51151cd31933f189be545421a3a88d6c551763f0883c9"

URI_aarch64_rust-tungstenite+http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+http-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+http-devel}"
SRC_URI[aarch64_rust-tungstenite+http-devel.sha256sum] = "7094153129a4b4999b93abbddcb2e9f3aa2479648953ad78e3cd2363afbdf27d"

URI_aarch64_rust-tungstenite+httparse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+httparse-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+httparse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+httparse-devel}"
SRC_URI[aarch64_rust-tungstenite+httparse-devel.sha256sum] = "8b663c9d30ab413e9f2cdb48736bd6fe019c4825d03b1a0819cd8b725c661628"

URI_aarch64_rust-tungstenite+native-tls-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+native-tls-crate-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+native-tls-crate-devel}"
SRC_URI[aarch64_rust-tungstenite+native-tls-crate-devel.sha256sum] = "e756f3aa6116022144f5bbe4b595ef1730a895454eb5f00796d2fcb940cce569"

URI_aarch64_rust-tungstenite+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+native-tls-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+native-tls-devel}"
SRC_URI[aarch64_rust-tungstenite+native-tls-devel.sha256sum] = "9e5492fe6f73c30df11cb3bdff3170f7254d0ee6017305750c8a3cd73574e7f6"

URI_aarch64_rust-tungstenite+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-devel.sha256sum] = "ae7a25240d6477533aaa3fb950646b0efb020c2613e59e5c95962f327448b81e"

URI_aarch64_rust-tungstenite+rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-native-certs-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-native-certs-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-native-certs-devel.sha256sum] = "35290bb00550439d2c9f97bbf9558af51b79ee37df8fac02f60060d47ee1ee62"

URI_aarch64_rust-tungstenite+rustls-pki-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-pki-types-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-pki-types-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-pki-types-devel.sha256sum] = "dafde49bcb0b88bd243c0a137469cbebeb20732a103706cf837b207b750d59d8"

URI_aarch64_rust-tungstenite+rustls-tls-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-tls-native-roots-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "8e691088fe7365867535837b517a1bea20800a99ab34a20bec47c7b1edcabc0e"

URI_aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-tls-webpki-roots-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "39c901e9bc191ed69014f24f1f7e219776d6d083586dfa9ad56d3bc6f0b996de"

URI_aarch64_rust-tungstenite+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+sha1-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+sha1-devel}"
SRC_URI[aarch64_rust-tungstenite+sha1-devel.sha256sum] = "1289a1b547ff4005cf5ee9e2b73c7e28aa9ad706382002f716317369e6dc989d"

URI_aarch64_rust-tungstenite+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+url-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+url-devel}"
SRC_URI[aarch64_rust-tungstenite+url-devel.sha256sum] = "6232409ea54003f644dbdc63670c4f28073212e0b2d7dc4df6e73d07d09e2287"

URI_aarch64_rust-tungstenite+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+webpki-roots-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+webpki-roots-devel}"
SRC_URI[aarch64_rust-tungstenite+webpki-roots-devel.sha256sum] = "37fcc7ae61b620170a09100b4b88edf313a58b906b457ad14d1f40506ab9f747"

URI_aarch64_rust-tungstenite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite-devel-0.23.0-3.el10_0.noarch.rpm;name=aarch64_rust-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite-devel}"
SRC_URI[aarch64_rust-tungstenite-devel.sha256sum] = "e9116dcffa9348d82965603e38680833c53bcd3c3fef450a6e7fdc4f90b23fa3"

RDEPENDS:rust-tungstenite+__rustls-tls-devel = " \
 cargo \
 rust-tungstenite+rustls-devel \
 rust-tungstenite+rustls-pki-types-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+data-encoding-devel = " \
 cargo \
 rust-data-encoding+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+default-devel = " \
 cargo \
 rust-tungstenite+handshake-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+handshake-devel = " \
 cargo \
 rust-tungstenite+data-encoding-devel \
 rust-tungstenite+http-devel \
 rust-tungstenite+httparse-devel \
 rust-tungstenite+sha1-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+http-devel = " \
 cargo \
 rust-http+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+httparse-devel = " \
 cargo \
 rust-httparse+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+native-tls-crate-devel = " \
 cargo \
 rust-native-tls+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+native-tls-devel = " \
 cargo \
 rust-tungstenite+native-tls-crate-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-devel = " \
 cargo \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-native-certs-devel = " \
 cargo \
 rust-rustls-native-certs0.7+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-pki-types-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-tls-native-roots-devel = " \
 cargo \
 rust-tungstenite+__rustls-tls-devel \
 rust-tungstenite+rustls-native-certs-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-tls-webpki-roots-devel = " \
 cargo \
 rust-tungstenite+__rustls-tls-devel \
 rust-tungstenite+webpki-roots-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+sha1-devel = " \
 cargo \
 rust-sha1+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+url-devel = " \
 cargo \
 rust-tungstenite-devel \
 rust-url+default-devel \
 "
RDEPENDS:rust-tungstenite+webpki-roots-devel = " \
 cargo \
 rust-tungstenite-devel \
 rust-webpki-roots+default-devel \
 "
RDEPENDS:rust-tungstenite-devel = " \
 cargo \
 rust \
 rust-byteorder+default-devel \
 rust-bytes+default-devel \
 rust-log+default-devel \
 rust-rand0.8+default-devel \
 rust-thiserror1+default-devel \
 rust-utf-8+default-devel \
 "
