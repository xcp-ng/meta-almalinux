# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Digest-HMAC"
PV = "1.04"
PR = "12.el10"
PACKAGES = " \
 perl-Digest-HMAC \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Digest-HMAC-1.04-12.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "56ad3e550f89d26fbae65232a92fa7fc0c27963fefd2e822a662b82c0fd8c5d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Digest-HMAC-1.04-12.el10.noarch.rpm;name=x86_64_v2_perl-Digest-HMAC;unpack=0"
SRC_URI[x86_64_v2_perl-Digest-HMAC.sha256sum] = "a176690243964e69f44a2ca0b1e146c063a8b3442687dcb16fdc5132f5cdc4db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Digest-HMAC-1.04-12.el10.noarch.rpm;name=aarch64_perl-Digest-HMAC;unpack=0"
SRC_URI[aarch64_perl-Digest-HMAC.sha256sum] = "a176690243964e69f44a2ca0b1e146c063a8b3442687dcb16fdc5132f5cdc4db"

RDEPENDS:perl-Digest-HMAC = " \
 perl-Digest-HMAC \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
