# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fontawesome-fonts"
PE = "1"
PV = "6.7.2"
PR = "1.el10_0"
PACKAGES = " \
 fontawesome-6-brands-fonts \
 fontawesome-6-free-fonts \
 fontawesome-fonts-all \
 fontawesome-fonts-web \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fontawesome-fonts-6.7.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7cf5d48e654d8923f3a96f708556aeaf7847fee812d46f3e2551fdf81d3b5f03"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fontawesome-6-brands-fonts-6.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fontawesome-6-brands-fonts;unpack=0"
SRC_URI[x86_64_v2_fontawesome-6-brands-fonts.sha256sum] = "d53ec95e20cd312271f24b31f742513f2b17cb5874a51ee08098010f57755233"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fontawesome-6-free-fonts-6.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fontawesome-6-free-fonts;unpack=0"
SRC_URI[x86_64_v2_fontawesome-6-free-fonts.sha256sum] = "0c21ac2249da1c7b108638daac660ad8a2a5020f717437e363ae2cf331b782c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fontawesome-fonts-all-6.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fontawesome-fonts-all;unpack=0"
SRC_URI[x86_64_v2_fontawesome-fonts-all.sha256sum] = "0d571808eba2ae2be16aeffe17f9f7614fddb4dd2607dfd8c296db3398ff30a5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fontawesome-fonts-web-6.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fontawesome-fonts-web;unpack=0"
SRC_URI[x86_64_v2_fontawesome-fonts-web.sha256sum] = "bd586e5d7fe50d76d25961a9c270f12d6620b9c9dd85cec6ae3303775ed55e22"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fontawesome-6-brands-fonts-6.7.2-1.el10_0.noarch.rpm;name=aarch64_fontawesome-6-brands-fonts;unpack=0"
SRC_URI[aarch64_fontawesome-6-brands-fonts.sha256sum] = "bb203e38d7f507ca387c7af656a23fbfab9617af7c88b3c376bdc320e269a942"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fontawesome-6-free-fonts-6.7.2-1.el10_0.noarch.rpm;name=aarch64_fontawesome-6-free-fonts;unpack=0"
SRC_URI[aarch64_fontawesome-6-free-fonts.sha256sum] = "d2277d61c85bb5af3c6be4447c48104612445127cdd87bd7c0fd2a3624a0f36c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fontawesome-fonts-all-6.7.2-1.el10_0.noarch.rpm;name=aarch64_fontawesome-fonts-all;unpack=0"
SRC_URI[aarch64_fontawesome-fonts-all.sha256sum] = "436e77c527b6124d39ac65baa5b5d5dd869e89930c3236bf311aa83c67e8459a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fontawesome-fonts-web-6.7.2-1.el10_0.noarch.rpm;name=aarch64_fontawesome-fonts-web;unpack=0"
SRC_URI[aarch64_fontawesome-fonts-web.sha256sum] = "d6e0ef528cd97d0cb84f7509268fdd4d53ace5981a282489adc768b0998f15d7"

RDEPENDS:fontawesome-6-brands-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:fontawesome-6-free-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:fontawesome-fonts-all = " \
 fontawesome-6-brands-fonts \
 fontawesome-6-free-fonts \
 "
RDEPENDS:fontawesome-fonts-web = " \
 "
