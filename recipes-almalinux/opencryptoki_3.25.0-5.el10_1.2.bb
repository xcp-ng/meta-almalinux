# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opencryptoki"
PV = "3.25.0"
PR = "5.el10_1.2"
PACKAGES:x86_64_v2 = " \
 opencryptoki \
 opencryptoki-ccatok \
 opencryptoki-devel \
 opencryptoki-icsftok \
 opencryptoki-libs \
 opencryptoki-swtok \
"
PACKAGES:aarch64 = " \
 opencryptoki \
 opencryptoki-devel \
 opencryptoki-icsftok \
 opencryptoki-libs \
 opencryptoki-swtok \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/opencryptoki-3.25.0-5.el10_1.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63dbbbefb49cfbb1c6b11b7fbefb705e8322799e6627cbc14e27fd1fb800174b"

URI_x86_64_v2_opencryptoki = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-3.25.0-5.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_opencryptoki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki}"
SRC_URI[x86_64_v2_opencryptoki.sha256sum] = "4b2cb78db645c87ba848b306e925b6ba9174b8589cf5d0715744b9f085be9085"

URI_x86_64_v2_opencryptoki-ccatok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-ccatok-3.25.0-5.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-ccatok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-ccatok}"
SRC_URI[x86_64_v2_opencryptoki-ccatok.sha256sum] = "e8dc9be078f5c092f24de260283b5a83581c7e26d1440b1e992bf18d942d3892"
RPROVIDES:opencryptoki-ccatok:append:x86_64_v2 = " virtual/opencryptoki_token_"

URI_x86_64_v2_opencryptoki-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/opencryptoki-devel-3.25.0-5.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-devel}"
SRC_URI[x86_64_v2_opencryptoki-devel.sha256sum] = "4786aa1bacdfca46f6122e3b5c743cb5dab31c217af4743e0e2d2017c05c492f"

URI_x86_64_v2_opencryptoki-icsftok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-icsftok-3.25.0-5.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-icsftok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-icsftok}"
SRC_URI[x86_64_v2_opencryptoki-icsftok.sha256sum] = "bd02dacf8e8d685af2f7b1aa615c7153fc3e347cd8268a9bbd94bb2fbcb4b0a1"
RPROVIDES:opencryptoki-icsftok:append:x86_64_v2 = " virtual/opencryptoki_token_"

URI_x86_64_v2_opencryptoki-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-libs-3.25.0-5.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-libs}"
SRC_URI[x86_64_v2_opencryptoki-libs.sha256sum] = "747ce745e29f85bc384d5d0912e119da5ff47874167b11c5034e093e0b8fe69e"

URI_x86_64_v2_opencryptoki-swtok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-swtok-3.25.0-5.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-swtok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-swtok}"
SRC_URI[x86_64_v2_opencryptoki-swtok.sha256sum] = "baa7bead25d39ff12bb6df8feb4d893312d196940e68c4af3beffee13de82e33"
RPROVIDES:opencryptoki-swtok:append:x86_64_v2 = " virtual/opencryptoki_token_"

URI_aarch64_opencryptoki = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-3.25.0-5.el10_1.2.aarch64.rpm;name=aarch64_opencryptoki;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki}"
SRC_URI[aarch64_opencryptoki.sha256sum] = "0e52cd14a90ca0ab695f1f028b559ba508e0f09f6457a801a2b1f3dc89b11b3e"

URI_aarch64_opencryptoki-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/opencryptoki-devel-3.25.0-5.el10_1.2.aarch64.rpm;name=aarch64_opencryptoki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki-devel}"
SRC_URI[aarch64_opencryptoki-devel.sha256sum] = "40aeb9c1afb75ada55e5397ccf134cc6f624f42de730f68f108ad76cf97ebfe4"

URI_aarch64_opencryptoki-icsftok = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-icsftok-3.25.0-5.el10_1.2.aarch64.rpm;name=aarch64_opencryptoki-icsftok;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki-icsftok}"
SRC_URI[aarch64_opencryptoki-icsftok.sha256sum] = "729feb67679b3dde12179ad29330bfc382a603ca7064c171cf5928b2b2540fde"
RPROVIDES:opencryptoki-icsftok:append:aarch64 = " virtual/opencryptoki_token_"

URI_aarch64_opencryptoki-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-libs-3.25.0-5.el10_1.2.aarch64.rpm;name=aarch64_opencryptoki-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki-libs}"
SRC_URI[aarch64_opencryptoki-libs.sha256sum] = "82e4d1d091f659aa532304b76b02368395a8a9fd9f9ca07ccb8ee4da2bd7a4e1"

URI_aarch64_opencryptoki-swtok = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-swtok-3.25.0-5.el10_1.2.aarch64.rpm;name=aarch64_opencryptoki-swtok;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki-swtok}"
SRC_URI[aarch64_opencryptoki-swtok.sha256sum] = "9d09daf7fdc838677b0b2d90800f3c2994e2ac61f91e73aa663efae2b4a5b8a5"
RPROVIDES:opencryptoki-swtok:append:aarch64 = " virtual/opencryptoki_token_"

RDEPENDS:opencryptoki = " \
 bash \
 diffutils \
 glibc \
 libcap \
 opencryptoki-libs \
 openssl \
 openssl-libs \
 selinux-policy \
 shadow-utils \
 systemd \
 virtual/coreutils \
 virtual/opencryptoki_token_ \
 "
RDEPENDS:opencryptoki-ccatok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:opencryptoki-devel = " \
 opencryptoki-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:opencryptoki-icsftok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:opencryptoki-libs = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 shadow-utils \
 "
RDEPENDS:opencryptoki-swtok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "
