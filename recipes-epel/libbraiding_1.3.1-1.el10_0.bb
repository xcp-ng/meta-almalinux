# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libbraiding"
PV = "1.3.1"
PR = "1.el10_0"
PACKAGES = " \
 libbraiding \
 libbraiding-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libbraiding-1.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c5300ab797f7b6996cf58a686ea1cbbd10aba6b7f449129cfbb280ac5656b8e"

URI_x86_64_v2_libbraiding = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbraiding-1.3.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbraiding;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbraiding}"
SRC_URI[x86_64_v2_libbraiding.sha256sum] = "ca24b04e1a3e7f56a189a47fbe744a408d15fa5b0f82107d5d86da0725d430c7"

URI_x86_64_v2_libbraiding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbraiding-devel-1.3.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbraiding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbraiding-devel}"
SRC_URI[x86_64_v2_libbraiding-devel.sha256sum] = "cdc91bbd7dc788bc056674d4c44bca01a055a75dd6be2e681b61c3f260ba4c45"

URI_aarch64_libbraiding = "${EPEL_MIRROR}/aarch64/Packages/l/libbraiding-1.3.1-1.el10_0.aarch64.rpm;name=aarch64_libbraiding;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbraiding}"
SRC_URI[aarch64_libbraiding.sha256sum] = "bb6ebc5ff2f82d10166da824da9a224aa5afd58e2a9091be1aa7436c1cdfa6fa"

URI_aarch64_libbraiding-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libbraiding-devel-1.3.1-1.el10_0.aarch64.rpm;name=aarch64_libbraiding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbraiding-devel}"
SRC_URI[aarch64_libbraiding-devel.sha256sum] = "860e27d74192b6f3b1f07f944a69aad4a5304e925f4b82e771afaa7266813d70"

RDEPENDS:libbraiding = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libbraiding-devel = " \
 libbraiding \
 pkgconf-pkg-config \
 "
