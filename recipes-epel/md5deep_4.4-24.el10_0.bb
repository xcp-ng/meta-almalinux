# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "md5deep"
PV = "4.4"
PR = "24.el10_0"
PACKAGES = " \
 md5deep \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/md5deep-4.4-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "161dd18d96f3d3b5aa80c4b014b566566cfc6b03d2e0e396478a0d88606ea925"

URI_x86_64_v2_md5deep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/md5deep-4.4-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_md5deep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_md5deep}"
SRC_URI[x86_64_v2_md5deep.sha256sum] = "d7ca72c608b7181d5adbb4d274c509c0f9211d8fb338bb48b31f5d1d7abc33c9"

URI_aarch64_md5deep = "${EPEL_MIRROR}/aarch64/Packages/m/md5deep-4.4-24.el10_0.aarch64.rpm;name=aarch64_md5deep;unpack=0"
SRC_URI:append = " ${URI_aarch64_md5deep}"
SRC_URI[aarch64_md5deep.sha256sum] = "a199c65543f7202759ff1a9ed9b1c61532107fafae72e93ee0aeda20e27d604a"

RDEPENDS:md5deep = " \
 glibc \
 libgcc \
 libstdc++ \
 "
