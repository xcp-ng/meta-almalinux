# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmbox"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kmbox \
 kmbox-devel \
 kmbox-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmbox-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56c1b0c9e0d31bc410572d4719a89d93b2d9a25d9380578191cf41749f2e64ae"

URI_x86_64_v2_kmbox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmbox}"
SRC_URI[x86_64_v2_kmbox.sha256sum] = "bf05da572d2ae082aad0899c5cb536cf55ff74e9d414b5d2d070367eb0fd1a99"

URI_x86_64_v2_kmbox-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmbox-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmbox-devel}"
SRC_URI[x86_64_v2_kmbox-devel.sha256sum] = "9045bfd9a12af1fe684ad10dcdfc10cb06a909d45f06dfbbc16f63b8f30d6422"

URI_x86_64_v2_kmbox-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kmbox-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmbox-doc}"
SRC_URI[x86_64_v2_kmbox-doc.sha256sum] = "45babbad462429b6130d57067395f22f1e8cfd0e06eb705dc897f162cd8d3f32"

URI_aarch64_kmbox = "${EPEL_MIRROR}/aarch64/Packages/k/kmbox-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmbox}"
SRC_URI[aarch64_kmbox.sha256sum] = "4a8970bdc4fc8b6dd1fe8513f95a0a4d2800e82a40733a81e7c1e09d1adc7a11"

URI_aarch64_kmbox-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kmbox-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmbox-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmbox-devel}"
SRC_URI[aarch64_kmbox-devel.sha256sum] = "1add80cb00f4f21c6acb270e29acc66478a3f2944323380cf9e282fb905b9b00"

URI_aarch64_kmbox-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kmbox-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kmbox-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmbox-doc}"
SRC_URI[aarch64_kmbox-doc.sha256sum] = "303593880e9cf74737257ff361fbc318871fedd8fc8878d848c3363f68983102"

RDEPENDS:kmbox = " \
 glibc \
 kmime \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kmbox-devel = " \
 cmake-filesystem \
 kmbox \
 kmime-devel \
 "
RDEPENDS:kmbox-doc = " \
 "
