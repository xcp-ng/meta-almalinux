# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx_rtd_theme"
PV = "2.0.0"
PR = "5.el10"
PACKAGES = " \
 python-sphinx_rtd_theme-doc \
 python3-sphinx_rtd_theme \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python-sphinx_rtd_theme-2.0.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b50039523a73b7154862aa3239bb24636a164467d739fa84e1f28ed0690961fc"

URI_x86_64_v2_python-sphinx_rtd_theme-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python-sphinx_rtd_theme-doc-2.0.0-5.el10.noarch.rpm;name=x86_64_v2_python-sphinx_rtd_theme-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-sphinx_rtd_theme-doc}"
SRC_URI[x86_64_v2_python-sphinx_rtd_theme-doc.sha256sum] = "674ee1386b6eb1ddc7a06c0c5e901677e390f278e2b5a5d2a8aebc8baa187822"

URI_x86_64_v2_python3-sphinx_rtd_theme = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-sphinx_rtd_theme-2.0.0-5.el10.noarch.rpm;name=x86_64_v2_python3-sphinx_rtd_theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx_rtd_theme}"
SRC_URI[x86_64_v2_python3-sphinx_rtd_theme.sha256sum] = "fd1647475b3a67ae00a59b6fa0931151470c3d745218309a051172e52fdf6fb3"

URI_aarch64_python-sphinx_rtd_theme-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python-sphinx_rtd_theme-doc-2.0.0-5.el10.noarch.rpm;name=aarch64_python-sphinx_rtd_theme-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-sphinx_rtd_theme-doc}"
SRC_URI[aarch64_python-sphinx_rtd_theme-doc.sha256sum] = "674ee1386b6eb1ddc7a06c0c5e901677e390f278e2b5a5d2a8aebc8baa187822"

URI_aarch64_python3-sphinx_rtd_theme = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-sphinx_rtd_theme-2.0.0-5.el10.noarch.rpm;name=aarch64_python3-sphinx_rtd_theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx_rtd_theme}"
SRC_URI[aarch64_python3-sphinx_rtd_theme.sha256sum] = "fd1647475b3a67ae00a59b6fa0931151470c3d745218309a051172e52fdf6fb3"

RDEPENDS:python-sphinx_rtd_theme-doc = " \
 fontawesome4-fonts \
 google-roboto-slab-fonts \
 lato-fonts \
 "
RDEPENDS:python3-sphinx_rtd_theme = " \
 fontawesome4-fonts \
 google-roboto-slab-fonts \
 lato-fonts \
 python3 \
 python3-docutils \
 python3-sphinx \
 python3-sphinxcontrib-jquery \
 "
