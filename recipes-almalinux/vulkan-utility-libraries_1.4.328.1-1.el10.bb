# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-utility-libraries"
PV = "1.4.328.1"
PR = "1.el10"
PACKAGES = " \
 vulkan-utility-libraries-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/vulkan-utility-libraries-1.4.328.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba559fd357b426954ac47a89ddf3b08cdbe43f1e34a6a4a8bbadddcf117dcb16"

URI_x86_64_v2_vulkan-utility-libraries-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/vulkan-utility-libraries-devel-1.4.328.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-utility-libraries-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-utility-libraries-devel}"
SRC_URI[x86_64_v2_vulkan-utility-libraries-devel.sha256sum] = "96c029fda711ebfd9af669739647e31289fa31db1cdb06cb1aae5fad7e80c77b"

URI_aarch64_vulkan-utility-libraries-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/vulkan-utility-libraries-devel-1.4.328.1-1.el10.aarch64.rpm;name=aarch64_vulkan-utility-libraries-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-utility-libraries-devel}"
SRC_URI[aarch64_vulkan-utility-libraries-devel.sha256sum] = "1486e07aa0f1d8409290fe4290ab59cb60f482401bf10c54c35013198f9fc2f8"

RDEPENDS:vulkan-utility-libraries-devel = " \
 cmake-filesystem \
 vulkan-headers \
 "
