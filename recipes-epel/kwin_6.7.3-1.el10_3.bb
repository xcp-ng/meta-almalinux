# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwin"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kwin \
 kwin-common \
 kwin-devel \
 kwin-doc \
 kwin-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwin-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a5bdd2a3fc0b66845c87359a93013632394bb5c0934f036914b6f7de7403ed7"

URI_x86_64_v2_kwin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin}"
SRC_URI[x86_64_v2_kwin.sha256sum] = "d9e0103d17e245239b85beba0beba07db6ffab6aa8591e3caa0741be02fb3a90"
RPROVIDES:kwin:x86_64_v2 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_x86_64_v2_kwin-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-common-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin-common}"
SRC_URI[x86_64_v2_kwin-common.sha256sum] = "0cb3f77fb17b2707cb82ef637444825c8e9da881072fa79a111b396aade3ca21"

URI_x86_64_v2_kwin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin-devel}"
SRC_URI[x86_64_v2_kwin-devel.sha256sum] = "62c0f16f8571c5d13d41ed549d72c66a30c59cf2cf85b04664e613e9971a9cab"

URI_x86_64_v2_kwin-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-doc-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kwin-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin-doc}"
SRC_URI[x86_64_v2_kwin-doc.sha256sum] = "86a065ff033fed92cfe064512791eefa2e39f6a1f0368ca9d51b9baabea434fa"

URI_x86_64_v2_kwin-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-libs-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin-libs}"
SRC_URI[x86_64_v2_kwin-libs.sha256sum] = "98bb7fb8214f20404727e9a8a74ed2b8ca83cd9af9c25d1b49f4fce285cd8196"

URI_aarch64_kwin = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kwin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin}"
SRC_URI[aarch64_kwin.sha256sum] = "4b13fc8bdad195dc1fb59f6abe2959eabbd357e0739b1f034d20fea852647311"
RPROVIDES:kwin:aarch64 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_aarch64_kwin-common = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-common-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kwin-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin-common}"
SRC_URI[aarch64_kwin-common.sha256sum] = "5d197c265131857434dacd893d78dd392ea3864a9058b3a326a260eed1879b7e"

URI_aarch64_kwin-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kwin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin-devel}"
SRC_URI[aarch64_kwin-devel.sha256sum] = "c1e0d80609a884be5af7af8d30c68e9ed941667f9602feecc1bb0d7c2382e6c7"

URI_aarch64_kwin-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-doc-6.7.3-1.el10_3.noarch.rpm;name=aarch64_kwin-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin-doc}"
SRC_URI[aarch64_kwin-doc.sha256sum] = "2d27d8bbe5a8db54ab71b7e58efbabd9d38b35695db67168881e0cdd9ff916e2"

URI_aarch64_kwin-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-libs-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kwin-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin-libs}"
SRC_URI[aarch64_kwin-libs.sha256sum] = "967130fe0fe22dc7e711ed2d76653ea2b78bf6e4f6c6c96a376b2e65af0295e1"

RDEPENDS:kwin = " \
 aurorae \
 glibc \
 iio-sensor-proxy \
 kdecoration \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kirigami \
 kf6-knotifications \
 kf6-ksvg \
 kf6-kwindowsystem \
 kglobalacceld \
 kscreenlocker \
 kwin-common \
 kwin-libs \
 libcanberra \
 libepoxy \
 libplasma \
 libstdc++ \
 libxcb \
 qaccessibilityclient-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 systemd-libs \
 xorg-x11-server-Xwayland \
 "
RDEPENDS:kwin-common = " \
 glibc \
 kdecoration \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-ksvg \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 knighttime \
 kwayland \
 kwin-libs \
 libeis \
 libepoxy \
 libevdev \
 libgcc \
 libstdc++ \
 pipewire-libs \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools \
 systemd-libs \
 "
RDEPENDS:kwin-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kservice-devel \
 kf6-kwindowsystem-devel \
 kwin-common \
 kwin-libs \
 "
RDEPENDS:kwin-doc = " \
 kwin \
 "
RDEPENDS:kwin-libs = " \
 glibc \
 kdecoration \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kglobalacceld \
 kscreenlocker \
 kwayland \
 lcms2 \
 libdisplay-info \
 libdrm \
 libepoxy \
 libgcc \
 libinput \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 libxcb \
 libxcvt \
 libxkbcommon \
 mesa-libgbm \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 systemd-libs \
 vulkan-loader \
 xcb-util-keysyms \
 xcb-util-wm \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

PROVIDES:append:aarch64 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"
