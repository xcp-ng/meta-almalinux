# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-tonistiigi-rosetta"
PV = "0"
PR = "14.20201109git9ba8546.el10_0"
PACKAGES = " \
 golang-github-tonistiigi-rosetta-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-tonistiigi-rosetta-0-14.20201109git9ba8546.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9460a49aa3183ec113cc43fbc3c1c341e13fc8238be45d9a1aefa025fc061e3e"

URI_aarch64_golang-github-tonistiigi-rosetta-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-tonistiigi-rosetta-devel-0-14.20201109git9ba8546.el10_0.noarch.rpm;name=aarch64_golang-github-tonistiigi-rosetta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-tonistiigi-rosetta-devel}"
SRC_URI[aarch64_golang-github-tonistiigi-rosetta-devel.sha256sum] = "77922d5cb45615fd2f396f4e4791a38e72828edd9980463cc6f88d3a69597c1b"

RDEPENDS:golang-github-tonistiigi-rosetta-devel = " \
 go-filesystem \
 "
