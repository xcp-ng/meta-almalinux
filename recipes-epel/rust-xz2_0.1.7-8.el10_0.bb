# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xz2"
PV = "0.1.7"
PR = "8.el10_0"
PACKAGES = " \
 rust-xz2+default-devel \
 rust-xz2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-xz2-0.1.7-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d7280129f6555dbe66b5917ae0f063be7887298b21299ec266b78acbaa8aa74"

URI_x86_64_v2_rust-xz2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xz2+default-devel-0.1.7-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xz2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xz2+default-devel}"
SRC_URI[x86_64_v2_rust-xz2+default-devel.sha256sum] = "e07f0bd8cf566781657ca6b1ee67127eb9fcfc8bbf78da215c34499c950b8522"

URI_x86_64_v2_rust-xz2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xz2-devel-0.1.7-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xz2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xz2-devel}"
SRC_URI[x86_64_v2_rust-xz2-devel.sha256sum] = "4a16f0fdacd48b97a39034d7b9ff3ee378f8a53fd7cad4df24e237d5b66ed5a3"

URI_aarch64_rust-xz2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xz2+default-devel-0.1.7-8.el10_0.noarch.rpm;name=aarch64_rust-xz2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xz2+default-devel}"
SRC_URI[aarch64_rust-xz2+default-devel.sha256sum] = "2208d2e51c08411573cd2c432b4782bdd153a2a3461663fd9bb0316c45cc445e"

URI_aarch64_rust-xz2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xz2-devel-0.1.7-8.el10_0.noarch.rpm;name=aarch64_rust-xz2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xz2-devel}"
SRC_URI[aarch64_rust-xz2-devel.sha256sum] = "a58aa0c6263ffacb004d0cbbfdc546f95203b0f866473dc690e5c8ed547cb134"

RDEPENDS:rust-xz2+default-devel = " \
 cargo \
 rust-xz2-devel \
 "
RDEPENDS:rust-xz2-devel = " \
 cargo \
 rust-lzma-sys+default-devel \
 "
