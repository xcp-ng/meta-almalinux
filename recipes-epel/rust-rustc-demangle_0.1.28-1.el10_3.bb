# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustc-demangle"
PV = "0.1.28"
PR = "1.el10_3"
PACKAGES = " \
 rust-rustc-demangle+default-devel \
 rust-rustc-demangle+std-devel \
 rust-rustc-demangle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustc-demangle-0.1.28-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dcc5ac4be5b11c24bc84ee23bfff611b818dd3b1960541fb093b46904ca0edd"

URI_x86_64_v2_rust-rustc-demangle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-demangle+default-devel-0.1.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-demangle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-demangle+default-devel}"
SRC_URI[x86_64_v2_rust-rustc-demangle+default-devel.sha256sum] = "2a87dbbf295a37fcd97516a60e7687b164b7402a4f6db9a1082a468c76a03121"

URI_x86_64_v2_rust-rustc-demangle+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-demangle+std-devel-0.1.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-demangle+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-demangle+std-devel}"
SRC_URI[x86_64_v2_rust-rustc-demangle+std-devel.sha256sum] = "0a58340fde5d874903f01d0565c81e904da2af7888cec03fc96ed63cde9d1527"

URI_x86_64_v2_rust-rustc-demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-demangle-devel-0.1.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-demangle-devel}"
SRC_URI[x86_64_v2_rust-rustc-demangle-devel.sha256sum] = "7a85c9953d226f46b5e1a36bc0252e2e6641704d3b395c97a49472b69fa9ff54"

URI_aarch64_rust-rustc-demangle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-demangle+default-devel-0.1.28-1.el10_3.noarch.rpm;name=aarch64_rust-rustc-demangle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-demangle+default-devel}"
SRC_URI[aarch64_rust-rustc-demangle+default-devel.sha256sum] = "0b04b7ee85807f38f314065e97ce9b9560809678a95f3d40a05df573be61fe87"

URI_aarch64_rust-rustc-demangle+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-demangle+std-devel-0.1.28-1.el10_3.noarch.rpm;name=aarch64_rust-rustc-demangle+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-demangle+std-devel}"
SRC_URI[aarch64_rust-rustc-demangle+std-devel.sha256sum] = "9871be96591785faa7088619d1a72eabca11b9cc91de52fa934b5a73a4d62a7a"

URI_aarch64_rust-rustc-demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-demangle-devel-0.1.28-1.el10_3.noarch.rpm;name=aarch64_rust-rustc-demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-demangle-devel}"
SRC_URI[aarch64_rust-rustc-demangle-devel.sha256sum] = "e9ddddaa2bbe07b6e114f8d3baf9e85aaa3f2c3d6b53ac7201f82107af76f155"

RDEPENDS:rust-rustc-demangle+default-devel = " \
 cargo \
 rust-rustc-demangle-devel \
 "
RDEPENDS:rust-rustc-demangle+std-devel = " \
 cargo \
 rust-rustc-demangle-devel \
 "
RDEPENDS:rust-rustc-demangle-devel = " \
 cargo \
 "
