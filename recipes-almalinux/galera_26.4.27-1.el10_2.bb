# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "galera"
PV = "26.4.27"
PR = "1.el10_2"
PACKAGES = " \
 galera \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/galera-26.4.27-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3ec2a9b6e4896348e5874282fee05f441e18ebedb3325eefb97f17aba29e4dc5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/galera-26.4.27-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_galera;unpack=0"
SRC_URI[x86_64_v2_galera.sha256sum] = "dc0896eaff1cd93699ed6cfc179acfc1bf19c1b1aef15ccf158ed0ceb496b586"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/galera-26.4.27-1.el10_2.aarch64.rpm;name=aarch64_galera;unpack=0"
SRC_URI[aarch64_galera.sha256sum] = "4b1765b30559da19a735acb4dcf51069e2118753738bacc184d63ea28967fc4b"

RDEPENDS:galera = " \
 bash \
 boost-program-options \
 glibc \
 libgcc \
 libstdc++ \
 nmap-ncat \
 openssl-libs \
 procps-ng \
 systemd \
 "
