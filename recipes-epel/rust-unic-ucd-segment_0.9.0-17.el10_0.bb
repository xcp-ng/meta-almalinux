# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-ucd-segment"
PV = "0.9.0"
PR = "17.el10_0"
PACKAGES = " \
 rust-unic-ucd-segment+default-devel \
 rust-unic-ucd-segment-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-ucd-segment-0.9.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d369771224b6b9719d87e0ab61447a16c7aa1705e6ec87325c565bc200d5c94f"

URI_x86_64_v2_rust-unic-ucd-segment+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-segment+default-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-segment+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-segment+default-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-segment+default-devel.sha256sum] = "1a224f0551ddcaab5cdc99876f19f94a47c2d653397263dbaebae4eb343ccac3"

URI_x86_64_v2_rust-unic-ucd-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-segment-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-segment-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-segment-devel.sha256sum] = "6bc429d32b7eba78ccffe54a3cfc504b18e5da9d719fc78bd79104bb713dc9c1"

URI_aarch64_rust-unic-ucd-segment+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-segment+default-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-ucd-segment+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-segment+default-devel}"
SRC_URI[aarch64_rust-unic-ucd-segment+default-devel.sha256sum] = "70bb2ad5ffde34dda29e2eedd9a8ab79177af8d6957a63af1bea97d69726e46e"

URI_aarch64_rust-unic-ucd-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-segment-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-ucd-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-segment-devel}"
SRC_URI[aarch64_rust-unic-ucd-segment-devel.sha256sum] = "e3e4d580fc6e7c6013fb281064566f8b6c179e1f4971f2223124dbad17f64936"

RDEPENDS:rust-unic-ucd-segment+default-devel = " \
 cargo \
 rust-unic-ucd-segment-devel \
 "
RDEPENDS:rust-unic-ucd-segment-devel = " \
 cargo \
 rust-unic-char-property+default-devel \
 rust-unic-char-range+default-devel \
 rust-unic-ucd-version+default-devel \
 "
