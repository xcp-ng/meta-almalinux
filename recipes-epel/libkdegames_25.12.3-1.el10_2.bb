# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdegames"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 libkdegames \
 libkdegames-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkdegames-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8003a948b6576999d2e8814b66d970af4a7a3d0f4a7a25c909874478e9d6cc8e"

URI_x86_64_v2_libkdegames = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdegames-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdegames;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdegames}"
SRC_URI[x86_64_v2_libkdegames.sha256sum] = "93f1f6535074dc57ea8583e79ff65be4c52b69e6c1b50a1402448193c8102ba8"

URI_x86_64_v2_libkdegames-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdegames-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdegames-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdegames-devel}"
SRC_URI[x86_64_v2_libkdegames-devel.sha256sum] = "638ecd98b2f78329b74bd147cf1e9da385c7eaa579c14b85871d26862ec50f0d"

URI_aarch64_libkdegames = "${EPEL_MIRROR}/aarch64/Packages/l/libkdegames-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkdegames;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdegames}"
SRC_URI[aarch64_libkdegames.sha256sum] = "943c82052635cf810c48d603f478f2bf5e1d79b2a42a4e31bbb94e17c4bb8b5c"

URI_aarch64_libkdegames-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkdegames-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkdegames-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdegames-devel}"
SRC_URI[aarch64_libkdegames-devel.sha256sum] = "cbc842d11f01b08aa5fbd472d4a4a91527e6c131ab45934edd9396fa68e7a5f3"

RDEPENDS:libkdegames = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdnssd \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libsndfile \
 libstdc++ \
 openal-soft \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:libkdegames-devel = " \
 cmake-filesystem \
 kf6-kcompletion-devel \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-ki18n-devel \
 kf6-kwidgetsaddons-devel \
 libkdegames \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
