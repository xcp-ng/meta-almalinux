# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keylime"
PV = "7.14.1"
PR = "7.el10"
PACKAGES = " \
 keylime \
 keylime-base \
 keylime-registrar \
 keylime-selinux \
 keylime-tenant \
 keylime-tools \
 keylime-verifier \
 python3-keylime \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/keylime-7.14.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f31e8377c2b32ef6df9f6712183047dc31dba4af977b9b2efcc4e55ccfca46d1"

URI_x86_64_v2_keylime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-7.14.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_keylime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime}"
SRC_URI[x86_64_v2_keylime.sha256sum] = "97ad84e9b25baa8e2c9d78fc33209345b72ea56994ec406fef8c493d9b867630"

URI_x86_64_v2_keylime-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-base-7.14.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-base}"
SRC_URI[x86_64_v2_keylime-base.sha256sum] = "e8618f99f211479c94cb5c697d7e619ff84907aa7813edad6d6be2a5e6a8db61"

URI_x86_64_v2_keylime-registrar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-registrar-7.14.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-registrar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-registrar}"
SRC_URI[x86_64_v2_keylime-registrar.sha256sum] = "6b4d819ef0728d6f02089ac708ad9c9c4874d1e13e457b05ed94355f71541e4d"

URI_x86_64_v2_keylime-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-selinux-7.14.1-7.el10.noarch.rpm;name=x86_64_v2_keylime-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-selinux}"
SRC_URI[x86_64_v2_keylime-selinux.sha256sum] = "31b0cd0dbb5f36738aa6eadc020aa80dd1144a59f67fb208be17c7c337d59f18"

URI_x86_64_v2_keylime-tenant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-tenant-7.14.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-tenant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-tenant}"
SRC_URI[x86_64_v2_keylime-tenant.sha256sum] = "bd4c41f0182c10d17513171a58b6a55f2c4da48475c535681b348b8e7837afc0"

URI_x86_64_v2_keylime-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-tools-7.14.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-tools}"
SRC_URI[x86_64_v2_keylime-tools.sha256sum] = "fce9da936c7c4b296bdd108e98c3193ca66382269dbced09da2307065c72d862"

URI_x86_64_v2_keylime-verifier = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-verifier-7.14.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-verifier;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-verifier}"
SRC_URI[x86_64_v2_keylime-verifier.sha256sum] = "6b886773305888499a96d47d95fdccabbbbda3648e240ffb02046cd6e80bda62"

URI_x86_64_v2_python3-keylime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-keylime-7.14.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_python3-keylime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keylime}"
SRC_URI[x86_64_v2_python3-keylime.sha256sum] = "b3af116811310328b4832c03ebac999b82ae73ea1b15d223d3c00976e1b00e38"

URI_aarch64_keylime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-7.14.1-7.el10.aarch64.rpm;name=aarch64_keylime;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime}"
SRC_URI[aarch64_keylime.sha256sum] = "b4271e51e5b76cb184e5b8a0f05ad9d373a54a328fadbfda6dcf59c524ada8c5"

URI_aarch64_keylime-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-base-7.14.1-7.el10.aarch64.rpm;name=aarch64_keylime-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-base}"
SRC_URI[aarch64_keylime-base.sha256sum] = "28fe7a8fb8cf01579992ff1e2fb7375b09eae89e6470810b2c161a2e1c2fdf91"

URI_aarch64_keylime-registrar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-registrar-7.14.1-7.el10.aarch64.rpm;name=aarch64_keylime-registrar;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-registrar}"
SRC_URI[aarch64_keylime-registrar.sha256sum] = "68ff6660ae8a0795d99852644f8fe4a5994e18a50ba0a6b4ca45696e1b7bfde2"

URI_aarch64_keylime-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-selinux-7.14.1-7.el10.noarch.rpm;name=aarch64_keylime-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-selinux}"
SRC_URI[aarch64_keylime-selinux.sha256sum] = "31b0cd0dbb5f36738aa6eadc020aa80dd1144a59f67fb208be17c7c337d59f18"

URI_aarch64_keylime-tenant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-tenant-7.14.1-7.el10.aarch64.rpm;name=aarch64_keylime-tenant;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-tenant}"
SRC_URI[aarch64_keylime-tenant.sha256sum] = "c2fc9df85f68020c95b6032c09f1dee7c309706b0a9f79a578a817057d550a75"

URI_aarch64_keylime-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-tools-7.14.1-7.el10.aarch64.rpm;name=aarch64_keylime-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-tools}"
SRC_URI[aarch64_keylime-tools.sha256sum] = "5bad7dfaee28285a3053e9ab69d4d1c0bc6fa34c5cad614989ec6bb863fb76e8"

URI_aarch64_keylime-verifier = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-verifier-7.14.1-7.el10.aarch64.rpm;name=aarch64_keylime-verifier;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-verifier}"
SRC_URI[aarch64_keylime-verifier.sha256sum] = "fd73bc08e3d20c433e2e1bd3f79e540e3bac200dc794b01fb62985475e872e9e"

URI_aarch64_python3-keylime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-keylime-7.14.1-7.el10.aarch64.rpm;name=aarch64_python3-keylime;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keylime}"
SRC_URI[aarch64_python3-keylime.sha256sum] = "20cf86cd14e6301218b5892c8d36b3f9759d649c1d70c249296f095ab040665e"

RDEPENDS:keylime = " \
 keylime-base \
 keylime-registrar \
 keylime-tenant \
 keylime-tools \
 keylime-verifier \
 python3-keylime \
 virtual/keylime-agent \
 "
RDEPENDS:keylime-base = " \
 bash \
 efivar-libs \
 openssl \
 procps-ng \
 python3 \
 python3-jinja2 \
 shadow-utils \
 tpm2-tss \
 "
RDEPENDS:keylime-registrar = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:keylime-tenant = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-tools = " \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-verifier = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:python3-keylime = " \
 keylime-base \
 python3 \
 python3-alembic \
 python3-cryptography \
 python3-gpg \
 python3-jsonschema \
 python3-lark \
 python3-packaging \
 python3-psutil \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-pyyaml \
 python3-requests \
 python3-sqlalchemy \
 python3-tornado \
 python3-typing-extensions \
 tpm2-tools \
 "
