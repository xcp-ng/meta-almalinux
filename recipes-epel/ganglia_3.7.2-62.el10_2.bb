# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ganglia"
PV = "3.7.2"
PR = "62.el10_2"
PACKAGES = " \
 ganglia \
 ganglia-devel \
 ganglia-gmetad \
 ganglia-gmond \
 ganglia-python3-gmond \
 ganglia-web \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ganglia-3.7.2-62.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95168f34e66332540f5aacb94fb7790ca92e21d9055ca32b5f730d86b1db32bc"

URI_x86_64_v2_ganglia = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ganglia-3.7.2-62.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ganglia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ganglia}"
SRC_URI[x86_64_v2_ganglia.sha256sum] = "c61567965080270d9678a72f54ecf6a5823ffe35c264e04813c29c7a9310eeb2"

URI_x86_64_v2_ganglia-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ganglia-devel-3.7.2-62.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ganglia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ganglia-devel}"
SRC_URI[x86_64_v2_ganglia-devel.sha256sum] = "90649ec76ef09ebda014b13a22ea99b7024041adb1d58febe97252135d12eb3c"

URI_x86_64_v2_ganglia-gmetad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ganglia-gmetad-3.7.2-62.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ganglia-gmetad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ganglia-gmetad}"
SRC_URI[x86_64_v2_ganglia-gmetad.sha256sum] = "31d58d1d8d37d556acd7d16a0b77b386b7eb45d65022f58902831297fa38180c"

URI_x86_64_v2_ganglia-gmond = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ganglia-gmond-3.7.2-62.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ganglia-gmond;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ganglia-gmond}"
SRC_URI[x86_64_v2_ganglia-gmond.sha256sum] = "751f0b8f97bef9c939202be75116526a84f19e8f489f6abee9b2eb814dc6f0aa"

URI_x86_64_v2_ganglia-python3-gmond = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ganglia-python3-gmond-3.7.2-62.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ganglia-python3-gmond;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ganglia-python3-gmond}"
SRC_URI[x86_64_v2_ganglia-python3-gmond.sha256sum] = "fabb38d30a4c043ff70a75def94c9c6b42179448ea4eb8663e9d5ed8250312e7"

URI_x86_64_v2_ganglia-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ganglia-web-3.7.6-62.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ganglia-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ganglia-web}"
SRC_URI[x86_64_v2_ganglia-web.sha256sum] = "4508f832ea44dd2a9ce8b746e32e1728c7f1cc6cc237541c8831122a4761658d"

URI_aarch64_ganglia = "${EPEL_MIRROR}/aarch64/Packages/g/ganglia-3.7.2-62.el10_2.aarch64.rpm;name=aarch64_ganglia;unpack=0"
SRC_URI:append = " ${URI_aarch64_ganglia}"
SRC_URI[aarch64_ganglia.sha256sum] = "adb07511ea8b124057382c8ce9c100cd2ad31da2b99abf7fb86204365855dbff"

URI_aarch64_ganglia-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ganglia-devel-3.7.2-62.el10_2.aarch64.rpm;name=aarch64_ganglia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ganglia-devel}"
SRC_URI[aarch64_ganglia-devel.sha256sum] = "cdafacac4472dd8c3225132fa775071ccf580c674a26ef05880eebfcf4ee8273"

URI_aarch64_ganglia-gmetad = "${EPEL_MIRROR}/aarch64/Packages/g/ganglia-gmetad-3.7.2-62.el10_2.aarch64.rpm;name=aarch64_ganglia-gmetad;unpack=0"
SRC_URI:append = " ${URI_aarch64_ganglia-gmetad}"
SRC_URI[aarch64_ganglia-gmetad.sha256sum] = "08a86fa148026c12d5f94f056c9c32c31e19df09437a0f5fb147b037e6228dcb"

URI_aarch64_ganglia-gmond = "${EPEL_MIRROR}/aarch64/Packages/g/ganglia-gmond-3.7.2-62.el10_2.aarch64.rpm;name=aarch64_ganglia-gmond;unpack=0"
SRC_URI:append = " ${URI_aarch64_ganglia-gmond}"
SRC_URI[aarch64_ganglia-gmond.sha256sum] = "6d99f152973c2dbc3ca40607c14996f59c624ceaffdedf2626401411c2e6133c"

URI_aarch64_ganglia-python3-gmond = "${EPEL_MIRROR}/aarch64/Packages/g/ganglia-python3-gmond-3.7.2-62.el10_2.aarch64.rpm;name=aarch64_ganglia-python3-gmond;unpack=0"
SRC_URI:append = " ${URI_aarch64_ganglia-python3-gmond}"
SRC_URI[aarch64_ganglia-python3-gmond.sha256sum] = "8273765daedf25a5f5475ef976d288cc4a948602495f1f83ec22843cd1578078"

URI_aarch64_ganglia-web = "${EPEL_MIRROR}/aarch64/Packages/g/ganglia-web-3.7.6-62.el10_2.aarch64.rpm;name=aarch64_ganglia-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_ganglia-web}"
SRC_URI[aarch64_ganglia-web.sha256sum] = "1666b6abf998799d7c50a042bac405a5c6874c91fbe8945f04068f01162bec8f"

RDEPENDS:ganglia = " \
 apr \
 bash \
 expat \
 glibc \
 libconfuse \
 libtirpc \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:ganglia-devel = " \
 apr-devel \
 bash \
 ganglia \
 libconfuse-devel \
 "
RDEPENDS:ganglia-gmetad = " \
 apr \
 bash \
 expat \
 ganglia \
 glibc \
 libmemcached-awesome \
 rrdtool \
 systemd \
 zlib-ng-compat \
 "
RDEPENDS:ganglia-gmond = " \
 apr \
 bash \
 ganglia \
 glibc \
 libconfuse \
 libtirpc \
 pcre2 \
 systemd \
 zlib-ng-compat \
 "
RDEPENDS:ganglia-python3-gmond = " \
 apr \
 expat \
 ganglia-gmond \
 glibc \
 libconfuse \
 libtirpc \
 pcre2 \
 python3 \
 python3-libs \
 zlib-ng-compat \
 "
RDEPENDS:ganglia-web = " \
 bash \
 ganglia-gmetad \
 rrdtool \
 virtual/php \
 virtual/php-gd \
 virtual/php-xml \
 "
