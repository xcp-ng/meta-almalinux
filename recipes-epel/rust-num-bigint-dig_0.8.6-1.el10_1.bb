# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-bigint-dig"
PV = "0.8.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-num-bigint-dig+arbitrary-devel \
 rust-num-bigint-dig+default-devel \
 rust-num-bigint-dig+fuzz-devel \
 rust-num-bigint-dig+i128-devel \
 rust-num-bigint-dig+prime-devel \
 rust-num-bigint-dig+rand-devel \
 rust-num-bigint-dig+serde-devel \
 rust-num-bigint-dig+std-devel \
 rust-num-bigint-dig+u64_digit-devel \
 rust-num-bigint-dig+zeroize-devel \
 rust-num-bigint-dig-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-bigint-dig-0.8.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6b75b97c71e844afc734523dece0cb8b2375bdec2f3c7c8ffea76a4e007c53a"

URI_x86_64_v2_rust-num-bigint-dig+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+arbitrary-devel-0.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+arbitrary-devel.sha256sum] = "051c3b5a362fa87f208249ee3b8663374e6d9fdb31519425585905a76d86f723"

URI_x86_64_v2_rust-num-bigint-dig+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+default-devel-0.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+default-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+default-devel.sha256sum] = "32ad6622f66d761eb657706ab33146add8e510fdd9875578dc4774c83e67a0a9"

URI_x86_64_v2_rust-num-bigint-dig+fuzz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+fuzz-devel-0.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+fuzz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+fuzz-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+fuzz-devel.sha256sum] = "e99187fa2219128298c9f5bab7d9e10138401dcfdd0cd732308e653a024912d9"

URI_x86_64_v2_rust-num-bigint-dig+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+i128-devel-0.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+i128-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+i128-devel.sha256sum] = "7a3963adac4be8919e8a41dd54fa3a670e3ced423c4366b31403718093f295e7"

URI_x86_64_v2_rust-num-bigint-dig+prime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+prime-devel-0.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+prime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+prime-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+prime-devel.sha256sum] = "f3f3dfeac98e0fec7ca4cc530a3050a711166db92dd3412a75b481b0638b9697"

URI_x86_64_v2_rust-num-bigint-dig+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+rand-devel-0.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+rand-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+rand-devel.sha256sum] = "6acb4d3fcb05500a12d4d302ac81f65a825594623d51137e1bb5c15507445f25"

URI_x86_64_v2_rust-num-bigint-dig+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+serde-devel-0.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+serde-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+serde-devel.sha256sum] = "54b3885e8ab69ed21a828c694eb978ec1fd5bc48119be5f875a50dfd115ed7dc"

URI_x86_64_v2_rust-num-bigint-dig+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+std-devel-0.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+std-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+std-devel.sha256sum] = "434313277345f6ae140c79885445501ac326af1af9497540d895a5813196e1b1"

URI_x86_64_v2_rust-num-bigint-dig+u64_digit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+u64_digit-devel-0.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+u64_digit-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+u64_digit-devel.sha256sum] = "cc37b7513012f8dbae0b596a0aef2cf99ffd6a86c0984fc2ac234bc35c34fae7"

URI_x86_64_v2_rust-num-bigint-dig+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+zeroize-devel-0.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+zeroize-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+zeroize-devel.sha256sum] = "3e692a1c26bc8058f531a260624a823d51e5e44006bb1f9ae1c0cca984dc268f"

URI_x86_64_v2_rust-num-bigint-dig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig-devel-0.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig-devel.sha256sum] = "7746c5322b10d2910c4210fff6d77315633d81f1f86b732f325d0013865522fc"

URI_aarch64_rust-num-bigint-dig+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+arbitrary-devel-0.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-num-bigint-dig+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+arbitrary-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+arbitrary-devel.sha256sum] = "7be87f663d25074ef298012f104a6639b1e8e4d1a0f20fbe43fc833f8c2f41b4"

URI_aarch64_rust-num-bigint-dig+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+default-devel-0.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-num-bigint-dig+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+default-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+default-devel.sha256sum] = "8e4d9773bae436f8f6c4cee149dff2d0242e3b4c1aa4505591d4c7ec14c4f295"

URI_aarch64_rust-num-bigint-dig+fuzz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+fuzz-devel-0.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-num-bigint-dig+fuzz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+fuzz-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+fuzz-devel.sha256sum] = "9e509d7d908d5939600fa2d62c5470b33f85ea46e2e872aef47b543d1ff3fdfc"

URI_aarch64_rust-num-bigint-dig+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+i128-devel-0.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-num-bigint-dig+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+i128-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+i128-devel.sha256sum] = "a2aaf88d71cddb1620c740341c2f638087054e338b13ab1c2f21eb793513faec"

URI_aarch64_rust-num-bigint-dig+prime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+prime-devel-0.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-num-bigint-dig+prime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+prime-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+prime-devel.sha256sum] = "54b9da15168a17055f6f1b516ff977213f5572beb30a1ae3b43ab8cf229f2ba9"

URI_aarch64_rust-num-bigint-dig+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+rand-devel-0.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-num-bigint-dig+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+rand-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+rand-devel.sha256sum] = "61863af7477ef5f34b44d26c119c17da2692b5777854a1e7a421d874fc1c004f"

URI_aarch64_rust-num-bigint-dig+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+serde-devel-0.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-num-bigint-dig+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+serde-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+serde-devel.sha256sum] = "c150cfc8007dc33a9f8f938c5b29a3b3523b891729af420b924970b0302ad723"

URI_aarch64_rust-num-bigint-dig+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+std-devel-0.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-num-bigint-dig+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+std-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+std-devel.sha256sum] = "7676494844582409c44c9e832c567f3987990ef996f8cd12e51c83505f0e9016"

URI_aarch64_rust-num-bigint-dig+u64_digit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+u64_digit-devel-0.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-num-bigint-dig+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+u64_digit-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+u64_digit-devel.sha256sum] = "ba179389da7b6cb693968cf676ba44b3a26ca2833e9564898a3273cd8079eccd"

URI_aarch64_rust-num-bigint-dig+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+zeroize-devel-0.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-num-bigint-dig+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+zeroize-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+zeroize-devel.sha256sum] = "2eaa57a790898da6acdf8dcf8a069e1693058fcc642f87f0b33a7d6c626f4e1c"

URI_aarch64_rust-num-bigint-dig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig-devel-0.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-num-bigint-dig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig-devel}"
SRC_URI[aarch64_rust-num-bigint-dig-devel.sha256sum] = "16496d128d6d2b825bab403befa6ca751c86275645b3d4ed84a4d7c71a3339cd"

RDEPENDS:rust-num-bigint-dig+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+default-devel = " \
 cargo \
 rust-num-bigint-dig+std-devel \
 rust-num-bigint-dig+u64_digit-devel \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+fuzz-devel = " \
 cargo \
 rust-num-bigint-dig+arbitrary-devel \
 rust-num-bigint-dig-devel \
 rust-smallvec+arbitrary-devel \
 "
RDEPENDS:rust-num-bigint-dig+i128-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+prime-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-num-bigint-dig+rand-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-num-bigint-dig+serde-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-num-bigint-dig+std-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-num-integer+std-devel \
 rust-num-traits+std-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8-devel \
 rust-serde+alloc-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-smallvec+write-devel \
 "
RDEPENDS:rust-num-bigint-dig+u64_digit-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+zeroize-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-num-bigint-dig-devel = " \
 bash \
 cargo \
 rust \
 rust-lazy_static+spin_no_std-devel \
 rust-lazy_static-devel \
 rust-libm+default-devel \
 rust-num-integer+i128-devel \
 rust-num-integer-devel \
 rust-num-iter-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 rust-smallvec-devel \
 "
