# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ignition"
PV = "2.27.0"
PR = "2.el10"
PACKAGES = " \
 butane \
 ignition \
 ignition-edge \
 ignition-grub \
 ignition-validate \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ignition-2.27.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7f0a109e5e4316d3892a80c6e458a33520ea3ea0cd7bfa1a3962d881b62afa6a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/butane-2.27.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_butane;unpack=0"
SRC_URI[x86_64_v2_butane.sha256sum] = "30a703708cc19592c38b2738b44f2a056ea9f833ab31b8a020c9b06810ac6e93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-2.27.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_ignition;unpack=0"
SRC_URI[x86_64_v2_ignition.sha256sum] = "5fb15cfe64ea627359296013cf9d052ffa670a81e0b289ee3d3e3432ba011259"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-edge-2.27.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_ignition-edge;unpack=0"
SRC_URI[x86_64_v2_ignition-edge.sha256sum] = "ea4170d61039d38623f9180357e73f4f711d3a2abc8e20bde81bdf97198d4f88"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-grub-2.27.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_ignition-grub;unpack=0"
SRC_URI[x86_64_v2_ignition-grub.sha256sum] = "4e1b996618d0420bdf10ac5fc6907a850aa516fe1f53f071ca8e1d789b0d8353"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-validate-2.27.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_ignition-validate;unpack=0"
SRC_URI[x86_64_v2_ignition-validate.sha256sum] = "1854c79f4dcd201117043d0ccec2d74f93a2b36d54a0fcbf7b5485aaeaf5178e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/butane-2.27.0-2.el10.aarch64.rpm;name=aarch64_butane;unpack=0"
SRC_URI[aarch64_butane.sha256sum] = "2c3138f9302a219a79cfc9b18c39ed880a483289ffab7806ff5bf17096d40eb2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-2.27.0-2.el10.aarch64.rpm;name=aarch64_ignition;unpack=0"
SRC_URI[aarch64_ignition.sha256sum] = "3ad007138a297b3a2c2f4333aae6a543dac80cedbbceddc77c6f70cce296bd17"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-edge-2.27.0-2.el10.aarch64.rpm;name=aarch64_ignition-edge;unpack=0"
SRC_URI[aarch64_ignition-edge.sha256sum] = "6fb8786cd3ba2898b86d304020a6a0051ea720abcfd1749b5dd38730b2ac8d27"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-grub-2.27.0-2.el10.aarch64.rpm;name=aarch64_ignition-grub;unpack=0"
SRC_URI[aarch64_ignition-grub.sha256sum] = "c4677a3a38b49ae2b3146f00aeae45cfec068350f3a26bad182e7eee58ead651"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-validate-2.27.0-2.el10.aarch64.rpm;name=aarch64_ignition-validate;unpack=0"
SRC_URI[aarch64_ignition-validate.sha256sum] = "9bbbf5fc5de5b6791ad80ac0be116947e89fadf8390c15d5a67b6c60022614f9"

RDEPENDS:butane = " \
 glibc \
 "
RDEPENDS:ignition = " \
 bash \
 dosfstools \
 dracut \
 dracut-network \
 glibc \
 libblkid \
 libgcc \
 libstdc++ \
 libuuid \
 popt \
 "
RDEPENDS:ignition-edge = " \
 bash \
 "
RDEPENDS:ignition-grub = " \
 "
RDEPENDS:ignition-validate = " \
 glibc \
 "
