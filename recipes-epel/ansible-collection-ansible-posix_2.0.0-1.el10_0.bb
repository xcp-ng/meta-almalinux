# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-ansible-posix"
PV = "2.0.0"
PR = "1.el10_0"
PACKAGES = " \
 ansible-collection-ansible-posix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-collection-ansible-posix-2.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74dbe5f984c0f22c7ae8bb7bf52fa6abf2585591489b2bed1ce4d7ba2c349d0f"

URI_x86_64_v2_ansible-collection-ansible-posix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-collection-ansible-posix-2.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-collection-ansible-posix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-ansible-posix}"
SRC_URI[x86_64_v2_ansible-collection-ansible-posix.sha256sum] = "b8ed693203202e120bb3dd5c0391b6dcff37d92eb55866b972ea819804e3a9c9"

URI_aarch64_ansible-collection-ansible-posix = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-collection-ansible-posix-2.0.0-1.el10_0.noarch.rpm;name=aarch64_ansible-collection-ansible-posix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-ansible-posix}"
SRC_URI[aarch64_ansible-collection-ansible-posix.sha256sum] = "625ea8ad4f7431363448ac87fc395c77032d19f130bd789996a27ee5cf40a06d"

RDEPENDS:ansible-collection-ansible-posix = " \
 ansible-core \
 "
