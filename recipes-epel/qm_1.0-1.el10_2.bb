# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qm"
PV = "1.0"
PR = "1.el10_2"
PACKAGES = " \
 qm \
 qm-ctl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qm-1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b8b8e302bc3e6e4ce0f5fede2311e1e2e02c5bd7539110282481a2c1e17fd03"

URI_x86_64_v2_qm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qm-1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qm}"
SRC_URI[x86_64_v2_qm.sha256sum] = "9ed79df02312ab0f9cac03e1c28a886ef445d627a54969b2d5208dc7ae8f56d6"

URI_x86_64_v2_qm-ctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qm-ctl-1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qm-ctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qm-ctl}"
SRC_URI[x86_64_v2_qm-ctl.sha256sum] = "a7d43e6e6aed5cab3dfbd84e38fff589bbe9a1b4d8cd0601597a02a5f0f25a1a"

URI_aarch64_qm = "${EPEL_MIRROR}/aarch64/Packages/q/qm-1.0-1.el10_2.noarch.rpm;name=aarch64_qm;unpack=0"
SRC_URI:append = " ${URI_aarch64_qm}"
SRC_URI[aarch64_qm.sha256sum] = "732915e43332cf1b05c22e8400f994fe1e16924f755ac92233be55a94f8dc13c"

URI_aarch64_qm-ctl = "${EPEL_MIRROR}/aarch64/Packages/q/qm-ctl-1.0-1.el10_2.noarch.rpm;name=aarch64_qm-ctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qm-ctl}"
SRC_URI[aarch64_qm-ctl.sha256sum] = "e9920ab482b0cf5b43e1fc68379a4a65c7b3f89543e64dde447ca75bf10c4b17"

RDEPENDS:qm = " \
 bash \
 containers-common \
 jq \
 libselinux-utils \
 parted \
 podman \
 policycoreutils \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.9 \
 "
RDEPENDS:qm-ctl = " \
 python3 \
 qm \
 "
