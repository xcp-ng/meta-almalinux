# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wait-timeout"
PV = "0.2.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-wait-timeout+default-devel \
 rust-wait-timeout-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wait-timeout-0.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84d46332c181f5405713d5b3054f2570b38466c9cb69892ff72f10d8e65afb3f"

URI_x86_64_v2_rust-wait-timeout+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wait-timeout+default-devel-0.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wait-timeout+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wait-timeout+default-devel}"
SRC_URI[x86_64_v2_rust-wait-timeout+default-devel.sha256sum] = "6c947b89b8396db5ad8dcfc2da137c0b70e138e304a73f663ffb2f0131569290"

URI_x86_64_v2_rust-wait-timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wait-timeout-devel-0.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wait-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wait-timeout-devel}"
SRC_URI[x86_64_v2_rust-wait-timeout-devel.sha256sum] = "38bea99bbe6067401cf38195d967a4f79e925a1eb5060debdb8c4c3ad4c24d0e"

URI_aarch64_rust-wait-timeout+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wait-timeout+default-devel-0.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-wait-timeout+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wait-timeout+default-devel}"
SRC_URI[aarch64_rust-wait-timeout+default-devel.sha256sum] = "21edb6fa18297d949581e352ef3c2bd198f23542c1cb2d12a127aca8d0577097"

URI_aarch64_rust-wait-timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wait-timeout-devel-0.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-wait-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wait-timeout-devel}"
SRC_URI[aarch64_rust-wait-timeout-devel.sha256sum] = "e055394585c10f73326a07bfcdd69249d18374b75b0e268678665204d9592dc3"

RDEPENDS:rust-wait-timeout+default-devel = " \
 cargo \
 rust-wait-timeout-devel \
 "
RDEPENDS:rust-wait-timeout-devel = " \
 cargo \
 rust-libc+default-devel \
 "
