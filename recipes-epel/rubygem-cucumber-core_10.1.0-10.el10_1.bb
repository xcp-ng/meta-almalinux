# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-cucumber-core"
PV = "10.1.0"
PR = "10.el10_1"
PACKAGES = " \
 rubygem-cucumber-core \
 rubygem-cucumber-core-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-cucumber-core-10.1.0-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61e0a8e26945814cd9d73f8708d3980c23829e6c91e45f946f409c83cba648ef"

URI_x86_64_v2_rubygem-cucumber-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-core-10.1.0-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-core}"
SRC_URI[x86_64_v2_rubygem-cucumber-core.sha256sum] = "832769b4d04305473fe78dacb7213b5836074a4bccf62dfd0b546d136605d754"

URI_x86_64_v2_rubygem-cucumber-core-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-core-doc-10.1.0-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-core-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-core-doc}"
SRC_URI[x86_64_v2_rubygem-cucumber-core-doc.sha256sum] = "8d1b0ede45d18c8292f11bcc07ad3eb08234c9da491ba9abd04e4f0bec75c653"

URI_aarch64_rubygem-cucumber-core = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-core-10.1.0-10.el10_1.noarch.rpm;name=aarch64_rubygem-cucumber-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-core}"
SRC_URI[aarch64_rubygem-cucumber-core.sha256sum] = "59ac3665cc85e96534908a99d0f2561fcec650dc4e25a13dbba59789afb47951"

URI_aarch64_rubygem-cucumber-core-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-core-doc-10.1.0-10.el10_1.noarch.rpm;name=aarch64_rubygem-cucumber-core-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-core-doc}"
SRC_URI[aarch64_rubygem-cucumber-core-doc.sha256sum] = "26bfaf4fd37372261212fd1057d3d0d485b487d363a2ec90aec3dad824701a98"

RDEPENDS:rubygem-cucumber-core = " \
 rubygem-cucumber-gherkin \
 rubygem-cucumber-messages \
 rubygem-cucumber-tag-expressions \
 rubygems \
 "
RDEPENDS:rubygem-cucumber-core-doc = " \
 rubygem-cucumber-core \
 "
