# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-sqv"
PV = "1.3.0.1"
PR = "1.el10"
PACKAGES = " \
 sequoia-sqv \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-sequoia-sqv-1.3.0.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5b1b8a1e09cf3a2d3873b8432d3bfaad3cf51f135f3049643a7d282e00689025"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sequoia-sqv-1.3.0.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_sequoia-sqv;unpack=0"
SRC_URI[x86_64_v2_sequoia-sqv.sha256sum] = "b5feaba2a9cfe78d5362f2e87adc19498052283bbce7bd4fbe3b35b4481b4040"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sequoia-sqv-1.3.0.1-1.el10.aarch64.rpm;name=aarch64_sequoia-sqv;unpack=0"
SRC_URI[aarch64_sequoia-sqv.sha256sum] = "a1e0af3f8a6a5e0b4e3e0e1ed1c24aeea9fa2e4c9d8568f2b2eade18ecfbb71f"

RDEPENDS:sequoia-sqv = " \
 glibc \
 libgcc \
 openssl-libs \
 "
