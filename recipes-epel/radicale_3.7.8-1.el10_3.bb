# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radicale"
PV = "3.7.8"
PR = "1.el10_3"
PACKAGES = " \
 python3-radicale3 \
 radicale3 \
 radicale3-InfCloud \
 radicale3-InfCloud-fontware \
 radicale3-httpd \
 radicale3-logwatch \
 radicale3-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/radicale-3.7.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afb3a644752f98c5b264c195f17158a393923059a06b13693de6ddae62a6b9a1"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - radicale3-selinux: selinux-policy >= 42.1.26

URI_x86_64_v2_python3-radicale3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-radicale3-3.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-radicale3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-radicale3}"
SRC_URI[x86_64_v2_python3-radicale3.sha256sum] = "c6105f731d8a9d4410b76ce5d456ab2cd5d2c2e867635b34d3ffee50bbe5e550"

URI_x86_64_v2_radicale3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-3.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radicale3}"
SRC_URI[x86_64_v2_radicale3.sha256sum] = "96a740eb143ae873bcee60f0371353d4a3c969bdc51d83cdab84f62d75c41a94"

URI_x86_64_v2_radicale3-InfCloud = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-InfCloud-3.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-InfCloud;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radicale3-InfCloud}"
SRC_URI[x86_64_v2_radicale3-InfCloud.sha256sum] = "0d69d3882f61f7655c96b6fa031afa1b7f8856ea2b126a477c700cd4051fa8f3"

URI_x86_64_v2_radicale3-InfCloud-fontware = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-InfCloud-fontware-3.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-InfCloud-fontware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radicale3-InfCloud-fontware}"
SRC_URI[x86_64_v2_radicale3-InfCloud-fontware.sha256sum] = "3847df915d9e1b49fe1360328c864db3f14646f9ac9db2257ffa51ff0a326602"

URI_x86_64_v2_radicale3-httpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-httpd-3.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radicale3-httpd}"
SRC_URI[x86_64_v2_radicale3-httpd.sha256sum] = "a3c86f3c98a33baa6377c1084e00144d25cba6a9da014c642dff62fd8e163eb3"

URI_x86_64_v2_radicale3-logwatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-logwatch-3.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-logwatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radicale3-logwatch}"
SRC_URI[x86_64_v2_radicale3-logwatch.sha256sum] = "7feca0c1857e9cbd93f7bbddb44477fb2971b2864a21d7c3447adee157650177"

URI_x86_64_v2_radicale3-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-selinux-3.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radicale3-selinux}"
SRC_URI[x86_64_v2_radicale3-selinux.sha256sum] = "d14d99754591c31ca2fb88d585d345e8c7d701116d28424ac1238098a312520c"

URI_aarch64_python3-radicale3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-radicale3-3.7.8-1.el10_3.noarch.rpm;name=aarch64_python3-radicale3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-radicale3}"
SRC_URI[aarch64_python3-radicale3.sha256sum] = "9e0aa73e080ed3ec5fb7df2194baec79bac6494189b968683ff1c808c8fe22f1"

URI_aarch64_radicale3 = "${EPEL_MIRROR}/aarch64/Packages/r/radicale3-3.7.8-1.el10_3.noarch.rpm;name=aarch64_radicale3;unpack=0"
SRC_URI:append = " ${URI_aarch64_radicale3}"
SRC_URI[aarch64_radicale3.sha256sum] = "c3c4fd590f05d5090ec63a8625d3d3ea3cd73a9fea9dfea892f92622c9f7ca57"

URI_aarch64_radicale3-InfCloud = "${EPEL_MIRROR}/aarch64/Packages/r/radicale3-InfCloud-3.7.8-1.el10_3.noarch.rpm;name=aarch64_radicale3-InfCloud;unpack=0"
SRC_URI:append = " ${URI_aarch64_radicale3-InfCloud}"
SRC_URI[aarch64_radicale3-InfCloud.sha256sum] = "89cc1376c7ecacd96ca710dd4125ab531ce35c81a5a8f81f55206f02e2fc54f2"

URI_aarch64_radicale3-InfCloud-fontware = "${EPEL_MIRROR}/aarch64/Packages/r/radicale3-InfCloud-fontware-3.7.8-1.el10_3.noarch.rpm;name=aarch64_radicale3-InfCloud-fontware;unpack=0"
SRC_URI:append = " ${URI_aarch64_radicale3-InfCloud-fontware}"
SRC_URI[aarch64_radicale3-InfCloud-fontware.sha256sum] = "5caa7d2336dd3b16c2cf06ab14f0d36fde13a857f1dae8c031fd6c540fd94413"

URI_aarch64_radicale3-httpd = "${EPEL_MIRROR}/aarch64/Packages/r/radicale3-httpd-3.7.8-1.el10_3.noarch.rpm;name=aarch64_radicale3-httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_radicale3-httpd}"
SRC_URI[aarch64_radicale3-httpd.sha256sum] = "b8164a23f47b03247ed1c5897ec59e7054101eb54a31110dbfb5a70ab0b34c19"

URI_aarch64_radicale3-logwatch = "${EPEL_MIRROR}/aarch64/Packages/r/radicale3-logwatch-3.7.8-1.el10_3.noarch.rpm;name=aarch64_radicale3-logwatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_radicale3-logwatch}"
SRC_URI[aarch64_radicale3-logwatch.sha256sum] = "4e7398be260e581d8df817c2129f9cb876eea57741a26413ba76f05a23646a43"

URI_aarch64_radicale3-selinux = "${EPEL_MIRROR}/aarch64/Packages/r/radicale3-selinux-3.7.8-1.el10_3.noarch.rpm;name=aarch64_radicale3-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_radicale3-selinux}"
SRC_URI[aarch64_radicale3-selinux.sha256sum] = "cab8bc2bea0ab83f7bf9d169fa619b68f5f52a65b13c347dc85ba6b2bcfc3ade"

RDEPENDS:python3-radicale3 = " \
 bash \
 python3 \
 python3-defusedxml \
 python3-passlib \
 python3-pika \
 python3-requests \
 python3-vobject \
 "
RDEPENDS:radicale3 = " \
 bash \
 python3 \
 python3-radicale3 \
 shadow-utils \
 systemd \
 "
RDEPENDS:radicale3-InfCloud = " \
 ed \
 python3-radicale3 \
 radicale3-InfCloud-fontware \
 "
RDEPENDS:radicale3-InfCloud-fontware = " \
 radicale3-InfCloud \
 "
RDEPENDS:radicale3-httpd = " \
 bash \
 httpd \
 python3-mod_wsgi \
 radicale3 \
 "
RDEPENDS:radicale3-logwatch = " \
 logwatch \
 radicale3 \
 "
RDEPENDS:radicale3-selinux:x86_64_v2 = " \
 bash \
 policycoreutils \
 policycoreutils-python-utils \
 radicale3 \
 selinux-policy \
"
RDEPENDS:radicale3-selinux:aarch64 = " \
 bash \
 policycoreutils \
 policycoreutils-python-utils \
 radicale3 \
"
