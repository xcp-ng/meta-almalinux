# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lzma-rs"
PV = "0.3.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-lzma-rs+default-devel \
 rust-lzma-rs+enable_logging-devel \
 rust-lzma-rs+env_logger-devel \
 rust-lzma-rs+log-devel \
 rust-lzma-rs+raw_decoder-devel \
 rust-lzma-rs+stream-devel \
 rust-lzma-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lzma-rs-0.3.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5de873963b92a93868c21b3b622db3c2ee661107302c96df8135358c1200d3c8"

URI_x86_64_v2_rust-lzma-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rs+default-devel-0.3.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rs+default-devel}"
SRC_URI[x86_64_v2_rust-lzma-rs+default-devel.sha256sum] = "1c69326ab9711f18be9d353d2feb5b012ecb8cee4bc79d17c4fd920267416739"

URI_x86_64_v2_rust-lzma-rs+enable_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rs+enable_logging-devel-0.3.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rs+enable_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rs+enable_logging-devel}"
SRC_URI[x86_64_v2_rust-lzma-rs+enable_logging-devel.sha256sum] = "dd48337e0974d4f1ba7a1e346c36d476234b1bdb7a90aefa71e9e0610286716a"

URI_x86_64_v2_rust-lzma-rs+env_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rs+env_logger-devel-0.3.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rs+env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rs+env_logger-devel}"
SRC_URI[x86_64_v2_rust-lzma-rs+env_logger-devel.sha256sum] = "4bb2bf292d28b8017917f8d8be95c9c7a7c26fb10ec6636e29dfe803c9c04139"

URI_x86_64_v2_rust-lzma-rs+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rs+log-devel-0.3.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rs+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rs+log-devel}"
SRC_URI[x86_64_v2_rust-lzma-rs+log-devel.sha256sum] = "658f51c8774176968ee4512358ff9d6a1d2399f79a81da3f50fd86aa3a458ae5"

URI_x86_64_v2_rust-lzma-rs+raw_decoder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rs+raw_decoder-devel-0.3.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rs+raw_decoder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rs+raw_decoder-devel}"
SRC_URI[x86_64_v2_rust-lzma-rs+raw_decoder-devel.sha256sum] = "3a1ddcb38761f54c4af378d9fa5d3629445aa09a60613b011b49a60995a10981"

URI_x86_64_v2_rust-lzma-rs+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rs+stream-devel-0.3.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rs+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rs+stream-devel}"
SRC_URI[x86_64_v2_rust-lzma-rs+stream-devel.sha256sum] = "db4cc89cb0b454c15731796974800ae9e08ebded987f7bdef5d33b1ee6a260f1"

URI_x86_64_v2_rust-lzma-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rs-devel-0.3.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rs-devel}"
SRC_URI[x86_64_v2_rust-lzma-rs-devel.sha256sum] = "5fadf969522ba46b2d538f11c292055fe936f6b597eaffbe3adbd70615c5595d"

URI_aarch64_rust-lzma-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rs+default-devel-0.3.0-4.el10_0.noarch.rpm;name=aarch64_rust-lzma-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rs+default-devel}"
SRC_URI[aarch64_rust-lzma-rs+default-devel.sha256sum] = "91e7f584a0ef9d3871a80d9dbad41713555ed377ca528bdea993ad7ce1930f85"

URI_aarch64_rust-lzma-rs+enable_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rs+enable_logging-devel-0.3.0-4.el10_0.noarch.rpm;name=aarch64_rust-lzma-rs+enable_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rs+enable_logging-devel}"
SRC_URI[aarch64_rust-lzma-rs+enable_logging-devel.sha256sum] = "0692bc0673d28d1f0395414f310780dba1133938b593033d597ad2cd5dafe763"

URI_aarch64_rust-lzma-rs+env_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rs+env_logger-devel-0.3.0-4.el10_0.noarch.rpm;name=aarch64_rust-lzma-rs+env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rs+env_logger-devel}"
SRC_URI[aarch64_rust-lzma-rs+env_logger-devel.sha256sum] = "b8ea9812ed0259bca897a542c66dd37a4a9e7c9613b7e966a298f5033012fe66"

URI_aarch64_rust-lzma-rs+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rs+log-devel-0.3.0-4.el10_0.noarch.rpm;name=aarch64_rust-lzma-rs+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rs+log-devel}"
SRC_URI[aarch64_rust-lzma-rs+log-devel.sha256sum] = "2e1ff639b8250f02dbdf3f407e3f0ae27b104df22ec6b1df693e7ccec7d927ff"

URI_aarch64_rust-lzma-rs+raw_decoder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rs+raw_decoder-devel-0.3.0-4.el10_0.noarch.rpm;name=aarch64_rust-lzma-rs+raw_decoder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rs+raw_decoder-devel}"
SRC_URI[aarch64_rust-lzma-rs+raw_decoder-devel.sha256sum] = "0d190eca7df3a699ab39ad2aed68a4d7980349ef798aa558971d17accf7e6bfb"

URI_aarch64_rust-lzma-rs+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rs+stream-devel-0.3.0-4.el10_0.noarch.rpm;name=aarch64_rust-lzma-rs+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rs+stream-devel}"
SRC_URI[aarch64_rust-lzma-rs+stream-devel.sha256sum] = "7216ae2d2e6cc1bc4ea48bf7a164c34b81821ade7bda66ce17d905ca76a27574"

URI_aarch64_rust-lzma-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rs-devel-0.3.0-4.el10_0.noarch.rpm;name=aarch64_rust-lzma-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rs-devel}"
SRC_URI[aarch64_rust-lzma-rs-devel.sha256sum] = "e58bd5c53a0e674023afd554d3a131e745712f0cc20f25e46235c28fbd54f5d9"

RDEPENDS:rust-lzma-rs+default-devel = " \
 cargo \
 rust-lzma-rs-devel \
 "
RDEPENDS:rust-lzma-rs+enable_logging-devel = " \
 cargo \
 rust-lzma-rs+env_logger-devel \
 rust-lzma-rs+log-devel \
 rust-lzma-rs-devel \
 "
RDEPENDS:rust-lzma-rs+env_logger-devel = " \
 cargo \
 rust-env_logger0.9+default-devel \
 rust-lzma-rs-devel \
 "
RDEPENDS:rust-lzma-rs+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-lzma-rs-devel \
 "
RDEPENDS:rust-lzma-rs+raw_decoder-devel = " \
 cargo \
 rust-lzma-rs-devel \
 "
RDEPENDS:rust-lzma-rs+stream-devel = " \
 cargo \
 rust-lzma-rs-devel \
 "
RDEPENDS:rust-lzma-rs-devel = " \
 cargo \
 rust-byteorder+default-devel \
 rust-crc+default-devel \
 "
