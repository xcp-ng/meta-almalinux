# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dejavu-fonts"
PV = "2.37"
PR = "25.el10"
PACKAGES = " \
 dejavu-lgc-sans-fonts \
 dejavu-lgc-sans-mono-fonts \
 dejavu-lgc-serif-fonts \
 dejavu-sans-fonts \
 dejavu-sans-mono-fonts \
 dejavu-serif-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dejavu-fonts-2.37-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a4d1c473174133b8ff31df6e088bd8d8d3bc9eb27b5b4f4948a32a0510d5da3"

URI_x86_64_v2_dejavu-lgc-sans-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dejavu-lgc-sans-fonts-2.37-25.el10.noarch.rpm;name=x86_64_v2_dejavu-lgc-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dejavu-lgc-sans-fonts}"
SRC_URI[x86_64_v2_dejavu-lgc-sans-fonts.sha256sum] = "00b4d7337bb25b89a2f93b909f4134f94c9f2afd165972322b7a0e8bd8878855"

URI_x86_64_v2_dejavu-lgc-sans-mono-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dejavu-lgc-sans-mono-fonts-2.37-25.el10.noarch.rpm;name=x86_64_v2_dejavu-lgc-sans-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dejavu-lgc-sans-mono-fonts}"
SRC_URI[x86_64_v2_dejavu-lgc-sans-mono-fonts.sha256sum] = "ff8ea4b6f009aba46d3f6f1b886b490bd46a3c63e0d3110149b702fbd6a361a5"

URI_x86_64_v2_dejavu-lgc-serif-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dejavu-lgc-serif-fonts-2.37-25.el10.noarch.rpm;name=x86_64_v2_dejavu-lgc-serif-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dejavu-lgc-serif-fonts}"
SRC_URI[x86_64_v2_dejavu-lgc-serif-fonts.sha256sum] = "a32bb81c2ef0317f177b3338a94cedc45bacc8fd7012187ac6c964e43e198964"

URI_x86_64_v2_dejavu-sans-fonts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dejavu-sans-fonts-2.37-25.el10.noarch.rpm;name=x86_64_v2_dejavu-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dejavu-sans-fonts}"
SRC_URI[x86_64_v2_dejavu-sans-fonts.sha256sum] = "42dd4d1ab62f0da288c5cc56bb833a88b861dc5fb237b6c7f81e32e7147d1a23"

URI_x86_64_v2_dejavu-sans-mono-fonts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dejavu-sans-mono-fonts-2.37-25.el10.noarch.rpm;name=x86_64_v2_dejavu-sans-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dejavu-sans-mono-fonts}"
SRC_URI[x86_64_v2_dejavu-sans-mono-fonts.sha256sum] = "1c90ed14525d1ad38acdda7ef7d173fccfd3685ab92d446ebe00cd38d02c1137"

URI_x86_64_v2_dejavu-serif-fonts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dejavu-serif-fonts-2.37-25.el10.noarch.rpm;name=x86_64_v2_dejavu-serif-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dejavu-serif-fonts}"
SRC_URI[x86_64_v2_dejavu-serif-fonts.sha256sum] = "1b386fc4285b5e9e22d7936effbd07702eea7cb45f3ed204849dcd8bd522d96e"

URI_aarch64_dejavu-lgc-sans-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dejavu-lgc-sans-fonts-2.37-25.el10.noarch.rpm;name=aarch64_dejavu-lgc-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dejavu-lgc-sans-fonts}"
SRC_URI[aarch64_dejavu-lgc-sans-fonts.sha256sum] = "00b4d7337bb25b89a2f93b909f4134f94c9f2afd165972322b7a0e8bd8878855"

URI_aarch64_dejavu-lgc-sans-mono-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dejavu-lgc-sans-mono-fonts-2.37-25.el10.noarch.rpm;name=aarch64_dejavu-lgc-sans-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dejavu-lgc-sans-mono-fonts}"
SRC_URI[aarch64_dejavu-lgc-sans-mono-fonts.sha256sum] = "ff8ea4b6f009aba46d3f6f1b886b490bd46a3c63e0d3110149b702fbd6a361a5"

URI_aarch64_dejavu-lgc-serif-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dejavu-lgc-serif-fonts-2.37-25.el10.noarch.rpm;name=aarch64_dejavu-lgc-serif-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dejavu-lgc-serif-fonts}"
SRC_URI[aarch64_dejavu-lgc-serif-fonts.sha256sum] = "a32bb81c2ef0317f177b3338a94cedc45bacc8fd7012187ac6c964e43e198964"

URI_aarch64_dejavu-sans-fonts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dejavu-sans-fonts-2.37-25.el10.noarch.rpm;name=aarch64_dejavu-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dejavu-sans-fonts}"
SRC_URI[aarch64_dejavu-sans-fonts.sha256sum] = "42dd4d1ab62f0da288c5cc56bb833a88b861dc5fb237b6c7f81e32e7147d1a23"

URI_aarch64_dejavu-sans-mono-fonts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dejavu-sans-mono-fonts-2.37-25.el10.noarch.rpm;name=aarch64_dejavu-sans-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dejavu-sans-mono-fonts}"
SRC_URI[aarch64_dejavu-sans-mono-fonts.sha256sum] = "1c90ed14525d1ad38acdda7ef7d173fccfd3685ab92d446ebe00cd38d02c1137"

URI_aarch64_dejavu-serif-fonts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dejavu-serif-fonts-2.37-25.el10.noarch.rpm;name=aarch64_dejavu-serif-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dejavu-serif-fonts}"
SRC_URI[aarch64_dejavu-serif-fonts.sha256sum] = "1b386fc4285b5e9e22d7936effbd07702eea7cb45f3ed204849dcd8bd522d96e"

RDEPENDS:dejavu-lgc-sans-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:dejavu-lgc-sans-mono-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:dejavu-lgc-serif-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:dejavu-sans-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:dejavu-sans-mono-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:dejavu-serif-fonts = " \
 fonts-filesystem \
 "
