# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_collator_data"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_collator_data+default-devel \
 rust-icu_collator_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_collator_data-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d2d017363abdc39553614e98967e8c041285d8ea3d85a3d29842ec31d9880e7"

URI_x86_64_v2_rust-icu_collator_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator_data+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_collator_data+default-devel.sha256sum] = "20844eeef4e7a1a8d104857606b9d771f3730bc2fd9c918564950e5f74bb2ccc"

URI_x86_64_v2_rust-icu_collator_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator_data-devel}"
SRC_URI[x86_64_v2_rust-icu_collator_data-devel.sha256sum] = "4b7d1cb1a0b191150ae7fa772c2b90997eb43111ef76cd8f1b0e66a0b42994dd"

URI_aarch64_rust-icu_collator_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator_data+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_collator_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator_data+default-devel}"
SRC_URI[aarch64_rust-icu_collator_data+default-devel.sha256sum] = "02e2bff2c1024ad5ab9abca479f5b5e385e40c690a40fe323205e4c36b74916e"

URI_aarch64_rust-icu_collator_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_collator_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator_data-devel}"
SRC_URI[aarch64_rust-icu_collator_data-devel.sha256sum] = "9ff1cf39534bc4eee77532b1e5724712056cb6b4eb4190cd558c621cc1a3f4c3"

RDEPENDS:rust-icu_collator_data+default-devel = " \
 cargo \
 rust-icu_collator_data-devel \
 "
RDEPENDS:rust-icu_collator_data-devel = " \
 cargo \
 rust \
 "
