# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXrender"
PV = "0.9.11"
PR = "8.el10"
PACKAGES = " \
 libXrender \
 libXrender-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXrender-0.9.11-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e10278d14e3fb7f09122bb4e13063fd54d34a57945ed51c0ee5adef0a36008c6"

URI_x86_64_v2_libXrender = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXrender-0.9.11-8.el10.x86_64_v2.rpm;name=x86_64_v2_libXrender;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXrender}"
SRC_URI[x86_64_v2_libXrender.sha256sum] = "a817b33f2055f76ab174c1392a2b465ed456a8e709e70f2019a5c69c36b08dfc"

URI_x86_64_v2_libXrender-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXrender-devel-0.9.11-8.el10.x86_64_v2.rpm;name=x86_64_v2_libXrender-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXrender-devel}"
SRC_URI[x86_64_v2_libXrender-devel.sha256sum] = "3abf52f8fe75eb01a38989c0bb859a2a5291e96e96410bf129c6e7d61ef89de5"

URI_aarch64_libXrender = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXrender-0.9.11-8.el10.aarch64.rpm;name=aarch64_libXrender;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXrender}"
SRC_URI[aarch64_libXrender.sha256sum] = "406ae5f238bdb45f5d6d7e33581ba4935d2d1e1397dabea9eefa4b5941396931"

URI_aarch64_libXrender-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXrender-devel-0.9.11-8.el10.aarch64.rpm;name=aarch64_libXrender-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXrender-devel}"
SRC_URI[aarch64_libXrender-devel.sha256sum] = "d1da503a8d3fc93f9d5e205d9cd23cd2c99c939736604ee79a2bc23e3444bb47"

RDEPENDS:libXrender = " \
 glibc \
 libX11 \
 "
RDEPENDS:libXrender-devel = " \
 libX11-devel \
 libXrender \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
