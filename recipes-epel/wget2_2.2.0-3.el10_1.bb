# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wget2"
PV = "2.2.0"
PR = "3.el10_1"
PACKAGES = " \
 wget2 \
 wget2-devel \
 wget2-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wget2-2.2.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca84ab101d8098d1d47dd866479eaeba1ab0682cc0eb69940f0e116e3a6146ad"

URI_x86_64_v2_wget2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wget2-2.2.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wget2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wget2}"
SRC_URI[x86_64_v2_wget2.sha256sum] = "b87d2f7fe96c107605da9650e2b3bb7b6350d0a4e1a55336522cf60a3bd9ff37"

URI_x86_64_v2_wget2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wget2-devel-2.2.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wget2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wget2-devel}"
SRC_URI[x86_64_v2_wget2-devel.sha256sum] = "d93001f92bf0680aefe7f4d6aeba6dcc19d8d2753cedadc3c399b4eadff78c1f"

URI_x86_64_v2_wget2-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wget2-libs-2.2.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wget2-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wget2-libs}"
SRC_URI[x86_64_v2_wget2-libs.sha256sum] = "ef3ebb860fd073e81e99b0367e06328a39058fc5647a28b43ac2664a3a22df0b"

URI_aarch64_wget2 = "${EPEL_MIRROR}/aarch64/Packages/w/wget2-2.2.0-3.el10_1.aarch64.rpm;name=aarch64_wget2;unpack=0"
SRC_URI:append = " ${URI_aarch64_wget2}"
SRC_URI[aarch64_wget2.sha256sum] = "b29d3bbd17f966ad15bad00c7ce259fd0073bd31fdc2f20c35014f6bc62d4fa3"

URI_aarch64_wget2-devel = "${EPEL_MIRROR}/aarch64/Packages/w/wget2-devel-2.2.0-3.el10_1.aarch64.rpm;name=aarch64_wget2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wget2-devel}"
SRC_URI[aarch64_wget2-devel.sha256sum] = "86b06d159399a88a15ba9c910c22628408f9910ef79877648c05a67a8ba0e60b"

URI_aarch64_wget2-libs = "${EPEL_MIRROR}/aarch64/Packages/w/wget2-libs-2.2.0-3.el10_1.aarch64.rpm;name=aarch64_wget2-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_wget2-libs}"
SRC_URI[aarch64_wget2-libs.sha256sum] = "8bbfffe006851ed96146165520b86df4a1ed4ebea052886fd0bb5ff4f3888740"

RDEPENDS:wget2 = " \
 glibc \
 gpgme \
 pcre2 \
 wget2-libs \
 "
RDEPENDS:wget2-devel = " \
 pkgconf-pkg-config \
 wget2-libs \
 "
RDEPENDS:wget2-libs = " \
 glibc \
 gnutls \
 gnutls-dane \
 gpgme \
 libbrotli \
 libidn2 \
 libnghttp2 \
 libpsl \
 libzstd \
 pcre2 \
 zlib-ng-compat \
 "
