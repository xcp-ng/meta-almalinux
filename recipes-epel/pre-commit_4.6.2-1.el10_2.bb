# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pre-commit"
PV = "4.6.2"
PR = "1.el10_2"
PACKAGES = " \
 pre-commit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pre-commit-4.6.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d363047627315ade09d438f6ae1e347b526858cba50f39820d2f67280cdcceb"

URI_x86_64_v2_pre-commit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pre-commit-4.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pre-commit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pre-commit}"
SRC_URI[x86_64_v2_pre-commit.sha256sum] = "4bd647bac0b3c2c8d5e640c48bb4acf0ebcc35a33a11d7df18c8a0aa5489e6a6"

URI_aarch64_pre-commit = "${EPEL_MIRROR}/aarch64/Packages/p/pre-commit-4.6.2-1.el10_2.noarch.rpm;name=aarch64_pre-commit;unpack=0"
SRC_URI:append = " ${URI_aarch64_pre-commit}"
SRC_URI[aarch64_pre-commit.sha256sum] = "45e565c50a231968cf3813600f0dfdd4b2ee2c761973ec9d89d086f2cf6b54dd"

RDEPENDS:pre-commit = " \
 bash \
 git-core \
 python3 \
 python3-cfgv \
 python3-identify \
 python3-nodeenv \
 python3-pyyaml \
 python3-virtualenv \
 "
