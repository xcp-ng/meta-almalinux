# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num_threads"
PV = "0.1.7"
PR = "2.el10_0"
PACKAGES = " \
 rust-num_threads+default-devel \
 rust-num_threads-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num_threads-0.1.7-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e69416aa8500c4388823dcd12308ca94c01a928f907bcaa62d017748ca17a631"

URI_x86_64_v2_rust-num_threads+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_threads+default-devel-0.1.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_threads+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_threads+default-devel}"
SRC_URI[x86_64_v2_rust-num_threads+default-devel.sha256sum] = "46a1679b438ebf72b657aec46a4950484be12d2d1800e575a16697407d63bbd7"

URI_x86_64_v2_rust-num_threads-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_threads-devel-0.1.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_threads-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_threads-devel}"
SRC_URI[x86_64_v2_rust-num_threads-devel.sha256sum] = "907ee8e4e15d77dc33a34815cf3d24bf940756b56f366cf9c5a42202295cf2e9"

URI_aarch64_rust-num_threads+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_threads+default-devel-0.1.7-2.el10_0.noarch.rpm;name=aarch64_rust-num_threads+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_threads+default-devel}"
SRC_URI[aarch64_rust-num_threads+default-devel.sha256sum] = "1ef2680e7ef00d98990713ea5e473b324b12efbe4a75b1a72c4ead51213d03fe"

URI_aarch64_rust-num_threads-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_threads-devel-0.1.7-2.el10_0.noarch.rpm;name=aarch64_rust-num_threads-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_threads-devel}"
SRC_URI[aarch64_rust-num_threads-devel.sha256sum] = "eaa503b962f3e4df0b70bdfeec089d4b3121b608e137073e31dad40783a09401"

RDEPENDS:rust-num_threads+default-devel = " \
 cargo \
 rust-num_threads-devel \
 "
RDEPENDS:rust-num_threads-devel = " \
 cargo \
 "
