# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-cached-json-file"
PV = "0.1.1"
PR = "7.el10_0"
PACKAGES = " \
 ghc-cached-json-file \
 ghc-cached-json-file-devel \
 ghc-cached-json-file-doc \
 ghc-cached-json-file-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-cached-json-file-0.1.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "010376ddfd5abd4c259afedcb97501bb5d487cf2c60fb25587b774d4b7f77e70"

URI_x86_64_v2_ghc-cached-json-file = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cached-json-file-0.1.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cached-json-file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cached-json-file}"
SRC_URI[x86_64_v2_ghc-cached-json-file.sha256sum] = "780b27e0bb31f2c80e1f1a08b09e4ee0ed15852b426d7b742a9a85b65ed1d688"

URI_x86_64_v2_ghc-cached-json-file-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cached-json-file-devel-0.1.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cached-json-file-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cached-json-file-devel}"
SRC_URI[x86_64_v2_ghc-cached-json-file-devel.sha256sum] = "d7525e15612791ca5035a7cb9e1d0d35d5883513b3826c8c81c2115d29d4b3a7"

URI_x86_64_v2_ghc-cached-json-file-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cached-json-file-doc-0.1.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-cached-json-file-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cached-json-file-doc}"
SRC_URI[x86_64_v2_ghc-cached-json-file-doc.sha256sum] = "9f887d015820f9fa733ff903a03ae8724809853e9a06ebbc06f06040450d9e71"

URI_x86_64_v2_ghc-cached-json-file-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cached-json-file-prof-0.1.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cached-json-file-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cached-json-file-prof}"
SRC_URI[x86_64_v2_ghc-cached-json-file-prof.sha256sum] = "483fe4ac8b5b8a300bf59b255b91aefe8ec68445d3dae078e4254ebb8a3b31c4"

URI_aarch64_ghc-cached-json-file = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cached-json-file-0.1.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-cached-json-file;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cached-json-file}"
SRC_URI[aarch64_ghc-cached-json-file.sha256sum] = "2d4c2845b1aa6223e615000b567ae4e06fe281b162fc237a82e7f1dc95c2573a"

URI_aarch64_ghc-cached-json-file-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cached-json-file-devel-0.1.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-cached-json-file-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cached-json-file-devel}"
SRC_URI[aarch64_ghc-cached-json-file-devel.sha256sum] = "934e92039ee79004babc06fd11ff681960a12ec8cfa6fff12df794e089877e70"

URI_aarch64_ghc-cached-json-file-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cached-json-file-doc-0.1.1-7.el10_0.noarch.rpm;name=aarch64_ghc-cached-json-file-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cached-json-file-doc}"
SRC_URI[aarch64_ghc-cached-json-file-doc.sha256sum] = "0f61de169d9763d185dd164b4aa8612f6b262789d1d9be1cafd9b6479c10dac9"

URI_aarch64_ghc-cached-json-file-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cached-json-file-prof-0.1.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-cached-json-file-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cached-json-file-prof}"
SRC_URI[aarch64_ghc-cached-json-file-prof.sha256sum] = "5ccf65af0d94ac42910e91be13b96a814d428f119d1f43838ad294c4ecbcb20a"

RDEPENDS:ghc-cached-json-file = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-conduit \
 ghc-http-query \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xdg-basedir \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-cached-json-file-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-cached-json-file \
 ghc-compiler \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-http-query-devel \
 ghc-time-devel \
 ghc-xdg-basedir-devel \
 "
RDEPENDS:ghc-cached-json-file-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cached-json-file-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cached-json-file-devel \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-http-query-prof \
 ghc-time-prof \
 ghc-xdg-basedir-prof \
 "
