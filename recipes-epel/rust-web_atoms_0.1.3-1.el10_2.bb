# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-web_atoms"
PV = "0.1.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-web_atoms+default-devel \
 rust-web_atoms-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-web_atoms-0.1.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfdbfabd5884e9d4fbd72515a93a8c28c8c092b7deefa2884f8848efd04ad03f"

URI_x86_64_v2_rust-web_atoms+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-web_atoms+default-devel-0.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-web_atoms+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-web_atoms+default-devel}"
SRC_URI[x86_64_v2_rust-web_atoms+default-devel.sha256sum] = "3df0afb9858fa46fd35d2ee63c12befa8caef53d31dbeab668a359f921c70e92"

URI_x86_64_v2_rust-web_atoms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-web_atoms-devel-0.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-web_atoms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-web_atoms-devel}"
SRC_URI[x86_64_v2_rust-web_atoms-devel.sha256sum] = "93ef671debcfa3b5ea1cad25df02de9633797e085e6681cb1602cb3d504f44b4"

URI_aarch64_rust-web_atoms+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-web_atoms+default-devel-0.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-web_atoms+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-web_atoms+default-devel}"
SRC_URI[aarch64_rust-web_atoms+default-devel.sha256sum] = "f65e28f7ef0aece79404717f1ead532449a24d58c91aa9d1919959c70d15425d"

URI_aarch64_rust-web_atoms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-web_atoms-devel-0.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-web_atoms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-web_atoms-devel}"
SRC_URI[aarch64_rust-web_atoms-devel.sha256sum] = "c0a6ba91bb0a9383ebf6e2d2e6683f352492fd6d940b82df96d86fe7a68bca6b"

RDEPENDS:rust-web_atoms+default-devel = " \
 cargo \
 rust-web_atoms-devel \
 "
RDEPENDS:rust-web_atoms-devel = " \
 cargo \
 rust \
 rust-phf0.11+default-devel \
 rust-phf_codegen0.11+default-devel \
 rust-string_cache+default-devel \
 rust-string_cache_codegen+default-devel \
 "
