# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "daala"
PV = "0^20250205git24f889a"
PR = "1.el10_2"
PACKAGES = " \
 daala-devel \
 daala-libs \
 daala-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/daala-0^20250205git24f889a-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5679f2f91c04fa68e8795ecccbf4ddb040092405b009d0ef5c8c9ac95bcb3ed1"

URI_x86_64_v2_daala-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/daala-devel-0^20250205git24f889a-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_daala-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daala-devel}"
SRC_URI[x86_64_v2_daala-devel.sha256sum] = "e81d4e42ab636e68499ffae00356bc4064d0b3aabb85b65283cd790fdfa668c3"

URI_x86_64_v2_daala-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/daala-libs-0^20250205git24f889a-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_daala-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daala-libs}"
SRC_URI[x86_64_v2_daala-libs.sha256sum] = "32624954f5a2d3830d34fce1106d5807a05ea7528bc4c402d40a45c70ddc8b77"

URI_x86_64_v2_daala-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/daala-tools-0^20250205git24f889a-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_daala-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daala-tools}"
SRC_URI[x86_64_v2_daala-tools.sha256sum] = "97e127176821aa11ca3681b9a5f249780badf6eadb2d59470e9ed39e143c466a"

URI_aarch64_daala-devel = "${EPEL_MIRROR}/aarch64/Packages/d/daala-devel-0^20250205git24f889a-1.el10_2.aarch64.rpm;name=aarch64_daala-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_daala-devel}"
SRC_URI[aarch64_daala-devel.sha256sum] = "1cf9dfa30bad0db0bcdc750e5aeec5e9f6011567837028c5a0884f4f451b0e1f"

URI_aarch64_daala-libs = "${EPEL_MIRROR}/aarch64/Packages/d/daala-libs-0^20250205git24f889a-1.el10_2.aarch64.rpm;name=aarch64_daala-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_daala-libs}"
SRC_URI[aarch64_daala-libs.sha256sum] = "aa59e0dcfb3810cc8930fc93f3ca3baa552d36610a8430a0abe573c5e387fb9a"

URI_aarch64_daala-tools = "${EPEL_MIRROR}/aarch64/Packages/d/daala-tools-0^20250205git24f889a-1.el10_2.aarch64.rpm;name=aarch64_daala-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_daala-tools}"
SRC_URI[aarch64_daala-tools.sha256sum] = "4f3cde52228a718f3190b38b78dd93ec6aafc62bad8f35399ccde38b5c8054f9"

RDEPENDS:daala-devel = " \
 daala-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:daala-libs = " \
 glibc \
 "
RDEPENDS:daala-tools = " \
 daala-libs \
 glibc \
 libgcc \
 libgomp \
 libjpeg-turbo \
 libogg \
 libpng \
 "
