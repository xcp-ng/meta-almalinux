# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qttools"
PV = "6.10.1"
PR = "2.el10"
PACKAGES = " \
 qt6-assistant \
 qt6-designer \
 qt6-doctools \
 qt6-linguist \
 qt6-qdbusviewer \
 qt6-qttools \
 qt6-qttools-common \
 qt6-qttools-devel \
 qt6-qttools-examples \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 qt6-qttools-libs-help \
 qt6-qttools-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qttools-6.10.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a063e9167460f3dc4d4bd80913edd216055b6b81679c782f8c672d90bb0e5965"

URI_x86_64_v2_qt6-assistant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-assistant-6.10.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-assistant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-assistant}"
SRC_URI[x86_64_v2_qt6-assistant.sha256sum] = "39f613e9375ffe6e72691fc775930e954f3b441fc17f8868d9237aa9f58cf749"

URI_x86_64_v2_qt6-designer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-designer-6.10.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-designer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-designer}"
SRC_URI[x86_64_v2_qt6-designer.sha256sum] = "bf6fb3738531284aa808bf5cde948b748e09d3f6629b9f2b0b6958fff75360ae"

URI_x86_64_v2_qt6-doctools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-doctools-6.10.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-doctools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-doctools}"
SRC_URI[x86_64_v2_qt6-doctools.sha256sum] = "5f6e339ec7d3c250b590c7309bdf8b7fd6ba64dd1f5f5189d38ef973a837f468"

URI_x86_64_v2_qt6-linguist = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-linguist-6.10.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-linguist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-linguist}"
SRC_URI[x86_64_v2_qt6-linguist.sha256sum] = "46dd36d0a1d3da7ecdca48f0c0c09e05525730181ba8a10c74719bc427ef2a28"

URI_x86_64_v2_qt6-qdbusviewer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qdbusviewer-6.10.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qdbusviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qdbusviewer}"
SRC_URI[x86_64_v2_qt6-qdbusviewer.sha256sum] = "cf2296925a40a09f1c32d8e415e81aba76b1749502b726194228477543caf021"

URI_x86_64_v2_qt6-qttools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-6.10.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools}"
SRC_URI[x86_64_v2_qt6-qttools.sha256sum] = "759029e4ac13ed344953a29cbdd7a24a617317e4f683160bc7ca506dfbf25644"

URI_x86_64_v2_qt6-qttools-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-common-6.10.1-2.el10.noarch.rpm;name=x86_64_v2_qt6-qttools-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-common}"
SRC_URI[x86_64_v2_qt6-qttools-common.sha256sum] = "93106271e14a338f8973b1491f5255f0b9b9f1a8113811d8818f167367e554df"

URI_x86_64_v2_qt6-qttools-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-devel-6.10.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-devel}"
SRC_URI[x86_64_v2_qt6-qttools-devel.sha256sum] = "501490ff34b059ea749f30023183f67a9f76584bc8bf4445ffa00467413d711c"

URI_x86_64_v2_qt6-qttools-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qttools-examples-6.10.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-examples}"
SRC_URI[x86_64_v2_qt6-qttools-examples.sha256sum] = "ccb86661b8aa58bb7fb60498736ce7e53e7e097c188bb8b32b2d643a68cbd6ea"

URI_x86_64_v2_qt6-qttools-libs-designer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-libs-designer-6.10.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-libs-designer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-libs-designer}"
SRC_URI[x86_64_v2_qt6-qttools-libs-designer.sha256sum] = "80c9fdc93f3893685d826aca16bb121bcf117a7f74ff0df83b8afc600c8db5b1"

URI_x86_64_v2_qt6-qttools-libs-designercomponents = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-libs-designercomponents-6.10.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-libs-designercomponents;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-libs-designercomponents}"
SRC_URI[x86_64_v2_qt6-qttools-libs-designercomponents.sha256sum] = "f8bea8b4ff9105f50da47d5fde58524ac9ec7037a1a3a1040201fe8281617137"

URI_x86_64_v2_qt6-qttools-libs-help = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-libs-help-6.10.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-libs-help;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-libs-help}"
SRC_URI[x86_64_v2_qt6-qttools-libs-help.sha256sum] = "7ef1dcd766eff166091978761c45cbc28ba18c62c4b8f9c5a41e83f430a63aa1"

URI_x86_64_v2_qt6-qttools-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qttools-static-6.10.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-static}"
SRC_URI[x86_64_v2_qt6-qttools-static.sha256sum] = "063005870f3bcf1605cd40cd3eecbb1341045ab3bc09f16b1c3d3ecb3814e46f"

URI_aarch64_qt6-assistant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-assistant-6.10.1-2.el10.aarch64.rpm;name=aarch64_qt6-assistant;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-assistant}"
SRC_URI[aarch64_qt6-assistant.sha256sum] = "438cce2da475fc23213190947a3c34f1737a362f60009333011ba648cb524df1"

URI_aarch64_qt6-designer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-designer-6.10.1-2.el10.aarch64.rpm;name=aarch64_qt6-designer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-designer}"
SRC_URI[aarch64_qt6-designer.sha256sum] = "b90d40ad63f648705b817792cab5a05e0118eb44f16c6768d289c73ab1f17f9b"

URI_aarch64_qt6-doctools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-doctools-6.10.1-2.el10.aarch64.rpm;name=aarch64_qt6-doctools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-doctools}"
SRC_URI[aarch64_qt6-doctools.sha256sum] = "1071ea7e84fa5be1664efff39f610e81b713a9e23536857bd2762b802055c1e3"

URI_aarch64_qt6-linguist = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-linguist-6.10.1-2.el10.aarch64.rpm;name=aarch64_qt6-linguist;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-linguist}"
SRC_URI[aarch64_qt6-linguist.sha256sum] = "5361b934f91f2359efbb42da22b114fd4a70acdf0f4c3aa45b412582ba14cf5a"

URI_aarch64_qt6-qdbusviewer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qdbusviewer-6.10.1-2.el10.aarch64.rpm;name=aarch64_qt6-qdbusviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qdbusviewer}"
SRC_URI[aarch64_qt6-qdbusviewer.sha256sum] = "86fba1c8c191bf25efa94311cad4cbfc679708fc199735be94698458be5def79"

URI_aarch64_qt6-qttools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-6.10.1-2.el10.aarch64.rpm;name=aarch64_qt6-qttools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools}"
SRC_URI[aarch64_qt6-qttools.sha256sum] = "a19ab0984187a820a1a366b4c0379ba077372961fbced7bcdb5fb3b581da9458"

URI_aarch64_qt6-qttools-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-common-6.10.1-2.el10.noarch.rpm;name=aarch64_qt6-qttools-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-common}"
SRC_URI[aarch64_qt6-qttools-common.sha256sum] = "93106271e14a338f8973b1491f5255f0b9b9f1a8113811d8818f167367e554df"

URI_aarch64_qt6-qttools-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-devel-6.10.1-2.el10.aarch64.rpm;name=aarch64_qt6-qttools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-devel}"
SRC_URI[aarch64_qt6-qttools-devel.sha256sum] = "3e533bea6f4bc907edb3a02c96ab069c121f8364c0cdcae178a7328c9ef0c0de"

URI_aarch64_qt6-qttools-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qttools-examples-6.10.1-2.el10.aarch64.rpm;name=aarch64_qt6-qttools-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-examples}"
SRC_URI[aarch64_qt6-qttools-examples.sha256sum] = "43150488f676ed4c9d0ae7ec22287398325bda53223191d6a4757821d13ee556"

URI_aarch64_qt6-qttools-libs-designer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-libs-designer-6.10.1-2.el10.aarch64.rpm;name=aarch64_qt6-qttools-libs-designer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-libs-designer}"
SRC_URI[aarch64_qt6-qttools-libs-designer.sha256sum] = "12d84a820dbc2f1e24889d774c691b5ffffbe3cdf9b3e5b8435885dbf88fe3f6"

URI_aarch64_qt6-qttools-libs-designercomponents = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-libs-designercomponents-6.10.1-2.el10.aarch64.rpm;name=aarch64_qt6-qttools-libs-designercomponents;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-libs-designercomponents}"
SRC_URI[aarch64_qt6-qttools-libs-designercomponents.sha256sum] = "0bc7272f8b9a15e109c7c21ad108adf4338dbdac4b044c5f0a85b76a580bef52"

URI_aarch64_qt6-qttools-libs-help = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-libs-help-6.10.1-2.el10.aarch64.rpm;name=aarch64_qt6-qttools-libs-help;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-libs-help}"
SRC_URI[aarch64_qt6-qttools-libs-help.sha256sum] = "a65db99bdd51f6717df74f0e546fe3a6785750efe36a77a1c8533c9bbc06599f"

URI_aarch64_qt6-qttools-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qttools-static-6.10.1-2.el10.aarch64.rpm;name=aarch64_qt6-qttools-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-static}"
SRC_URI[aarch64_qt6-qttools-static.sha256sum] = "81313f92d3bb79a02f3df899044c5e891fd1bc85bee02eba41c0938ea62b50d4"

RDEPENDS:qt6-assistant = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 qt6-qttools-libs-help \
 "
RDEPENDS:qt6-designer = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 "
RDEPENDS:qt6-doctools = " \
 clang-libs \
 glibc \
 libstdc++ \
 llvm-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools-libs-help \
 "
RDEPENDS:qt6-linguist = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qdbusviewer = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qttools = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qttools-common = " \
 "
RDEPENDS:qt6-qttools-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-designer \
 qt6-doctools \
 qt6-linguist \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qttools \
 qt6-qttools-devel \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 qt6-qttools-libs-help \
 "
RDEPENDS:qt6-qttools-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools \
 qt6-qttools-common \
 qt6-qttools-libs-help \
 "
RDEPENDS:qt6-qttools-libs-designer = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qttools-libs-designercomponents = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 qt6-qttools-libs-designer \
 "
RDEPENDS:qt6-qttools-libs-help = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qttools-static = " \
 qt6-qttools-devel \
 "
