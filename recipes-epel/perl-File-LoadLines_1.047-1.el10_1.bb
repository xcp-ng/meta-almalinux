# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-LoadLines"
PV = "1.047"
PR = "1.el10_1"
PACKAGES = " \
 perl-File-LoadLines \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-LoadLines-1.047-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebce07f1412c1299f69c7dc5feefa7f64c7244c4ee54bf220214509f18c26ee2"

URI_x86_64_v2_perl-File-LoadLines = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-LoadLines-1.047-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-LoadLines;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-LoadLines}"
SRC_URI[x86_64_v2_perl-File-LoadLines.sha256sum] = "7f4dc8b32f92876cf58ebce97132586e6781729522e10d538f8aeaa0a1b5b6d4"

URI_aarch64_perl-File-LoadLines = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-LoadLines-1.047-1.el10_1.noarch.rpm;name=aarch64_perl-File-LoadLines;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-LoadLines}"
SRC_URI[aarch64_perl-File-LoadLines.sha256sum] = "8e4027b2c48be17a5bafaf4ee5cff19ef2087875b9a75aa9d0d0b6fadb721f16"

RDEPENDS:perl-File-LoadLines = " \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-libs \
 "
