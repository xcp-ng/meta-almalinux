# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipa-healthcheck"
PV = "0.19"
PR = "1.el10"
PACKAGES = " \
 ipa-healthcheck \
 ipa-healthcheck-core \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ipa-healthcheck-0.19-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a90fb2bd5e7b314447ea97bb08da11d844b78fb4023fb8c62edbc6b4d41bdf1"

URI_x86_64_v2_ipa-healthcheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-healthcheck-0.19-1.el10.noarch.rpm;name=x86_64_v2_ipa-healthcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-healthcheck}"
SRC_URI[x86_64_v2_ipa-healthcheck.sha256sum] = "08f3b47f91974abc71f5b522b26437bb31cd928280353aac91ee38124f6b51f2"

URI_x86_64_v2_ipa-healthcheck-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-healthcheck-core-0.19-1.el10.noarch.rpm;name=x86_64_v2_ipa-healthcheck-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-healthcheck-core}"
SRC_URI[x86_64_v2_ipa-healthcheck-core.sha256sum] = "999fe245abd91917d537b160e666ee78fb0456569b098501bb1bfdb587e1f839"

URI_aarch64_ipa-healthcheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-healthcheck-0.19-1.el10.noarch.rpm;name=aarch64_ipa-healthcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-healthcheck}"
SRC_URI[aarch64_ipa-healthcheck.sha256sum] = "08f3b47f91974abc71f5b522b26437bb31cd928280353aac91ee38124f6b51f2"

URI_aarch64_ipa-healthcheck-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-healthcheck-core-0.19-1.el10.noarch.rpm;name=aarch64_ipa-healthcheck-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-healthcheck-core}"
SRC_URI[aarch64_ipa-healthcheck-core.sha256sum] = "999fe245abd91917d537b160e666ee78fb0456569b098501bb1bfdb587e1f839"

RDEPENDS:ipa-healthcheck = " \
 bash \
 cronie-anacron \
 ipa-healthcheck-core \
 ipa-server \
 logrotate \
 python3 \
 python3-ipalib \
 python3-ipaserver \
 python3-lib389 \
 systemd \
 "
RDEPENDS:ipa-healthcheck-core = " \
 python3 \
 "
