# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nsd"
PV = "4.14.0"
PR = "1.el10_1"
PACKAGES = " \
 nsd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nsd-4.14.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56009d4f8ccb74dfabe3bef160476a5ed2938390b7c00c015e04c464e2ea285e"

URI_x86_64_v2_nsd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nsd-4.14.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nsd}"
SRC_URI[x86_64_v2_nsd.sha256sum] = "a33c4c3dd42c01ad2c8f8f4820371eee513e0d812f23461a82409cbca385b432"

URI_aarch64_nsd = "${EPEL_MIRROR}/aarch64/Packages/n/nsd-4.14.0-1.el10_1.aarch64.rpm;name=aarch64_nsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nsd}"
SRC_URI[aarch64_nsd.sha256sum] = "cd4fd57c6dab6e9a3e021bd832211d4db2e0ef1fc1a0ee0131305fba1b1f2821"

RDEPENDS:nsd = " \
 bash \
 fstrm \
 glibc \
 libevent \
 openssl-libs \
 protobuf-c \
 systemd-libs \
 "
