# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_datetime"
PV = "0.7.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-toml_datetime+alloc-devel \
 rust-toml_datetime+default-devel \
 rust-toml_datetime+serde-devel \
 rust-toml_datetime+std-devel \
 rust-toml_datetime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_datetime-0.7.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6f5a485998c44c2550631575fc8c0c3d296fce68cfd9e5a62a232faf518c1eb"

URI_x86_64_v2_rust-toml_datetime+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime+alloc-devel-0.7.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime+alloc-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime+alloc-devel.sha256sum] = "074ddcc64ac58b2d080c11a60e37d0a39b8b9841ce5e6b39dc87d22bb566cb36"

URI_x86_64_v2_rust-toml_datetime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime+default-devel-0.7.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime+default-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime+default-devel.sha256sum] = "568734ff56e2cd7acd1a1f0571cfd5a6cdfb1fb60f9a142b7fffe88ef9968f39"

URI_x86_64_v2_rust-toml_datetime+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime+serde-devel-0.7.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime+serde-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime+serde-devel.sha256sum] = "602f457d4cf76258af24ed82f70935feeeb8c29e0ed2241d308967c8272cc552"

URI_x86_64_v2_rust-toml_datetime+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime+std-devel-0.7.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime+std-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime+std-devel.sha256sum] = "115532890435573a31ce4744ec4b857f5589cb6d7854d2a0580ff5257ba4b7b9"

URI_x86_64_v2_rust-toml_datetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime-devel-0.7.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime-devel.sha256sum] = "9b497a61d2ed0c4bc96415e2be5e0030a7fb8e2bd62cce69ca40a8d987b79e26"

URI_aarch64_rust-toml_datetime+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime+alloc-devel-0.7.5-1.el10_1.noarch.rpm;name=aarch64_rust-toml_datetime+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime+alloc-devel}"
SRC_URI[aarch64_rust-toml_datetime+alloc-devel.sha256sum] = "540b2b73d0a85636f072cbf50b62d15c4409e4b5654849759791c81b13c67c0e"

URI_aarch64_rust-toml_datetime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime+default-devel-0.7.5-1.el10_1.noarch.rpm;name=aarch64_rust-toml_datetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime+default-devel}"
SRC_URI[aarch64_rust-toml_datetime+default-devel.sha256sum] = "07581872c0f6f196adade4b5e5c5aab1b4c5ba792b7229d9d7260e3338c7be88"

URI_aarch64_rust-toml_datetime+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime+serde-devel-0.7.5-1.el10_1.noarch.rpm;name=aarch64_rust-toml_datetime+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime+serde-devel}"
SRC_URI[aarch64_rust-toml_datetime+serde-devel.sha256sum] = "ffc5f46c4606e2a61c151e799a97bce92e6c9319f6928e590a1aa590c4829989"

URI_aarch64_rust-toml_datetime+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime+std-devel-0.7.5-1.el10_1.noarch.rpm;name=aarch64_rust-toml_datetime+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime+std-devel}"
SRC_URI[aarch64_rust-toml_datetime+std-devel.sha256sum] = "1f98424bbb923391ecf5d2e83cf3ea73874374abf733ed1476b2875c7415c2ef"

URI_aarch64_rust-toml_datetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime-devel-0.7.5-1.el10_1.noarch.rpm;name=aarch64_rust-toml_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime-devel}"
SRC_URI[aarch64_rust-toml_datetime-devel.sha256sum] = "78aa80955d7d9fa85453e119151bece620cb63a9d6fabd48fdc353267a6b2605"

RDEPENDS:rust-toml_datetime+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-toml_datetime-devel \
 "
RDEPENDS:rust-toml_datetime+default-devel = " \
 cargo \
 rust-toml_datetime+std-devel \
 rust-toml_datetime-devel \
 "
RDEPENDS:rust-toml_datetime+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-toml_datetime-devel \
 "
RDEPENDS:rust-toml_datetime+std-devel = " \
 cargo \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-toml_datetime+alloc-devel \
 rust-toml_datetime-devel \
 "
RDEPENDS:rust-toml_datetime-devel = " \
 cargo \
 rust \
 "
