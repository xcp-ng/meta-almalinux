# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "partio"
PV = "1.20.0"
PR = "1.el10_2"
PACKAGES = " \
 partio \
 partio-devel \
 partio-doc \
 partio-libs \
 python3-partio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/partio-1.20.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55c344ee084850735108ebc86f9e6af74b917f6e4667cf914ea5b81fec27ba8a"

URI_x86_64_v2_partio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/partio-1.20.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_partio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_partio}"
SRC_URI[x86_64_v2_partio.sha256sum] = "8f3f18bc256ed4d9c3dbc86f2619fa2022b8f9e5fb62ceafefb7aae5f6074978"

URI_x86_64_v2_partio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/partio-devel-1.20.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_partio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_partio-devel}"
SRC_URI[x86_64_v2_partio-devel.sha256sum] = "dfc4cac3937cb249121e3758d0b09886827a24bd38047a2a903f32d5f51a548a"

URI_x86_64_v2_partio-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/partio-doc-1.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_partio-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_partio-doc}"
SRC_URI[x86_64_v2_partio-doc.sha256sum] = "172bfdcf3f7d2a53eb72e3145c221b00d4aff84939af156ba12528d8ef971a23"

URI_x86_64_v2_partio-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/partio-libs-1.20.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_partio-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_partio-libs}"
SRC_URI[x86_64_v2_partio-libs.sha256sum] = "531e0e9d3fb19bd6447d1cd0d5e9eac487ce4b37eca3255ee8238c89c9f6d0d9"

URI_x86_64_v2_python3-partio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-partio-1.20.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-partio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-partio}"
SRC_URI[x86_64_v2_python3-partio.sha256sum] = "6eec7d59231134adcb18730e1baf293a53b4652957943cb412217aa6c7f87d79"

URI_aarch64_partio = "${EPEL_MIRROR}/aarch64/Packages/p/partio-1.20.0-1.el10_2.aarch64.rpm;name=aarch64_partio;unpack=0"
SRC_URI:append = " ${URI_aarch64_partio}"
SRC_URI[aarch64_partio.sha256sum] = "da2cd9e5a6d277e0985692c8f79c1e552328c2aff88774c773f2332801a28965"

URI_aarch64_partio-devel = "${EPEL_MIRROR}/aarch64/Packages/p/partio-devel-1.20.0-1.el10_2.aarch64.rpm;name=aarch64_partio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_partio-devel}"
SRC_URI[aarch64_partio-devel.sha256sum] = "fd880570ef0024c931fe09b2293c7eb95df0c3c3a46da4a1b5103cd5849743b2"

URI_aarch64_partio-doc = "${EPEL_MIRROR}/aarch64/Packages/p/partio-doc-1.20.0-1.el10_2.noarch.rpm;name=aarch64_partio-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_partio-doc}"
SRC_URI[aarch64_partio-doc.sha256sum] = "b2e0fb467923c063e5fb979afb53207a54e6f76e2f799adca54e67797fb2e8f6"

URI_aarch64_partio-libs = "${EPEL_MIRROR}/aarch64/Packages/p/partio-libs-1.20.0-1.el10_2.aarch64.rpm;name=aarch64_partio-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_partio-libs}"
SRC_URI[aarch64_partio-libs.sha256sum] = "2c258a7d3119d260d4e2379759354bb42c8fc11859b3a1e053229c303861afdb"

URI_aarch64_python3-partio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-partio-1.20.0-1.el10_2.aarch64.rpm;name=aarch64_python3-partio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-partio}"
SRC_URI[aarch64_python3-partio.sha256sum] = "864ea7148ca1787971b3a3997d1d4b267e0e6b148e0d738fb2e714f7b7e61ffa"

RDEPENDS:partio = " \
 freeglut \
 glibc \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 mesa-libGLU \
 partio-libs \
 python3 \
 "
RDEPENDS:partio-devel = " \
 partio-libs \
 "
RDEPENDS:partio-doc = " \
 partio \
 "
RDEPENDS:partio-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:python3-partio = " \
 glibc \
 libgcc \
 libstdc++ \
 partio-libs \
 python3 \
 python3-libs \
 "
