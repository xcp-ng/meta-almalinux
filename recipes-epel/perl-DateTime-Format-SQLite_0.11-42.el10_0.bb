# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-Format-SQLite"
PV = "0.11"
PR = "42.el10_0"
PACKAGES = " \
 perl-DateTime-Format-SQLite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-Format-SQLite-0.11-42.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87ef749279968f739a2637fcebcbbb879d2697506044635f5f70f1182c02d739"

URI_x86_64_v2_perl-DateTime-Format-SQLite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-Format-SQLite-0.11-42.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-Format-SQLite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-Format-SQLite}"
SRC_URI[x86_64_v2_perl-DateTime-Format-SQLite.sha256sum] = "7b45d7c4d1200671d7ca3ac3e9bbcb89a621324b6454c40355629e34b206e00a"

URI_aarch64_perl-DateTime-Format-SQLite = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-Format-SQLite-0.11-42.el10_0.noarch.rpm;name=aarch64_perl-DateTime-Format-SQLite;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-Format-SQLite}"
SRC_URI[aarch64_perl-DateTime-Format-SQLite.sha256sum] = "41dd80ae9bba644fa87d2e19998c8191da40217388930f841d48d94b298408ad"

RDEPENDS:perl-DateTime-Format-SQLite = " \
 perl-DateTime-Format-Builder \
 perl-libs \
 perl-vars \
 "
