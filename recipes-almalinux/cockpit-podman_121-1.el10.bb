# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-podman"
PV = "121"
PR = "1.el10"
PACKAGES = " \
 cockpit-podman \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-podman-121-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9ab05a39a7fdf80ffd66a89bc8242e9e73dfe67e60cc3ebfccd59dea1ff0f74"

URI_x86_64_v2_cockpit-podman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-podman-121-1.el10.noarch.rpm;name=x86_64_v2_cockpit-podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-podman}"
SRC_URI[x86_64_v2_cockpit-podman.sha256sum] = "e662831dd214d5cec8283f99e116297a43860ca8f26c858ce04eda0add959cf3"

URI_aarch64_cockpit-podman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-podman-121-1.el10.noarch.rpm;name=aarch64_cockpit-podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-podman}"
SRC_URI[aarch64_cockpit-podman.sha256sum] = "e662831dd214d5cec8283f99e116297a43860ca8f26c858ce04eda0add959cf3"

RDEPENDS:cockpit-podman = " \
 cockpit-bridge \
 podman \
 "
