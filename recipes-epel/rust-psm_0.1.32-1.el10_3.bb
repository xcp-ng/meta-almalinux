# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-psm"
PV = "0.1.32"
PR = "1.el10_3"
PACKAGES = " \
 rust-psm+default-devel \
 rust-psm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-psm-0.1.32-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89a0feef5ead808e086288fea53c8265bc44039ce5248965db1fc17465454dbb"

URI_x86_64_v2_rust-psm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psm+default-devel-0.1.32-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psm+default-devel}"
SRC_URI[x86_64_v2_rust-psm+default-devel.sha256sum] = "629674686b3f9e3d2e646e1a746aeb6d65a9280dc8bf6a01a1f224da39f475ec"

URI_x86_64_v2_rust-psm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psm-devel-0.1.32-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psm-devel}"
SRC_URI[x86_64_v2_rust-psm-devel.sha256sum] = "16f0e3077f8fdcb2049ac8253998545cc0fb99f10099b6d6786219f855b18ad9"

URI_aarch64_rust-psm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psm+default-devel-0.1.32-1.el10_3.noarch.rpm;name=aarch64_rust-psm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psm+default-devel}"
SRC_URI[aarch64_rust-psm+default-devel.sha256sum] = "7ab28416a8bf637ba611343f8216c8ba8414108cd148aa712323be6e564a13bf"

URI_aarch64_rust-psm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psm-devel-0.1.32-1.el10_3.noarch.rpm;name=aarch64_rust-psm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psm-devel}"
SRC_URI[aarch64_rust-psm-devel.sha256sum] = "f10726d83fd8706ca7bf1697bb863e6cac506add2468cb722539abdb85a221a1"

RDEPENDS:rust-psm+default-devel = " \
 cargo \
 rust-psm-devel \
 "
RDEPENDS:rust-psm-devel = " \
 cargo \
 rust \
 rust-ar_archive_writer+default-devel \
 rust-cc+default-devel \
 "
