# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-LWP-Protocol-PSGI"
PV = "0.11"
PR = "16.el10_0"
PACKAGES = " \
 perl-LWP-Protocol-PSGI \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-LWP-Protocol-PSGI-0.11-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "336f56769e4502b9a54d4b09b9a9013d3840edd8212ca261bf8815a7840d6ee6"

URI_x86_64_v2_perl-LWP-Protocol-PSGI = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-LWP-Protocol-PSGI-0.11-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-LWP-Protocol-PSGI;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-LWP-Protocol-PSGI}"
SRC_URI[x86_64_v2_perl-LWP-Protocol-PSGI.sha256sum] = "3d40b1d7b22454f17cc5f596b8af0b4532c3a34a7dc83d0a6164753135b76b93"

URI_aarch64_perl-LWP-Protocol-PSGI = "${EPEL_MIRROR}/aarch64/Packages/p/perl-LWP-Protocol-PSGI-0.11-16.el10_0.noarch.rpm;name=aarch64_perl-LWP-Protocol-PSGI;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-LWP-Protocol-PSGI}"
SRC_URI[aarch64_perl-LWP-Protocol-PSGI.sha256sum] = "fe4da9e6f287f2b1ef3361d3395fabe8ccc4257c076ce8d8c7e5d17a3782b9c3"

RDEPENDS:perl-LWP-Protocol-PSGI = " \
 perl-Carp \
 perl-Plack \
 perl-libs \
 perl-libwww-perl \
 perl-parent \
 "
