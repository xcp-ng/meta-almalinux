# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "botan2"
PV = "2.19.5"
PR = "8.el10_1"
PACKAGES = " \
 botan2 \
 botan2-devel \
 botan2-doc \
 python3-botan2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/botan2-2.19.5-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3a14890ef042ab4b6554a75409d3168561935ba69599b7fc4766b5f739882f9"

URI_x86_64_v2_botan2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/botan2-2.19.5-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_botan2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_botan2}"
SRC_URI[x86_64_v2_botan2.sha256sum] = "4a45cdfb93af17e650c80dc22ca71397342f9ee7a9c116fe632fa13db646f714"

URI_x86_64_v2_botan2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/botan2-devel-2.19.5-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_botan2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_botan2-devel}"
SRC_URI[x86_64_v2_botan2-devel.sha256sum] = "c6915e83af15041d1f9f6c480c51533f271557dcdcbf37bd50f4dc321b5c344c"

URI_x86_64_v2_botan2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/botan2-doc-2.19.5-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_botan2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_botan2-doc}"
SRC_URI[x86_64_v2_botan2-doc.sha256sum] = "d62cf7900e151f83a7c13ba30a182b445c54037fdddddb8f184aa441b6a7cb0a"

URI_x86_64_v2_python3-botan2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-botan2-2.19.5-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-botan2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-botan2}"
SRC_URI[x86_64_v2_python3-botan2.sha256sum] = "32ada31d4a94197c4b88c2235438d0432c78aa0960dfb4f2c390700caf428198"

URI_aarch64_botan2 = "${EPEL_MIRROR}/aarch64/Packages/b/botan2-2.19.5-8.el10_1.aarch64.rpm;name=aarch64_botan2;unpack=0"
SRC_URI:append = " ${URI_aarch64_botan2}"
SRC_URI[aarch64_botan2.sha256sum] = "375b0f5be51c1b429e6fbf5be4147e4293d6bf755a7464de74816f7552ae3658"

URI_aarch64_botan2-devel = "${EPEL_MIRROR}/aarch64/Packages/b/botan2-devel-2.19.5-8.el10_1.aarch64.rpm;name=aarch64_botan2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_botan2-devel}"
SRC_URI[aarch64_botan2-devel.sha256sum] = "462d771ad36acc319e43e44025cfb97a17e1ce264b21fb620efa91d86be4a1a3"

URI_aarch64_botan2-doc = "${EPEL_MIRROR}/aarch64/Packages/b/botan2-doc-2.19.5-8.el10_1.noarch.rpm;name=aarch64_botan2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_botan2-doc}"
SRC_URI[aarch64_botan2-doc.sha256sum] = "5bda13275f019e2c23a6a21d810295ee1ca4e86c8d3a92ec54b6358d5ebe4f19"

URI_aarch64_python3-botan2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-botan2-2.19.5-8.el10_1.noarch.rpm;name=aarch64_python3-botan2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-botan2}"
SRC_URI[aarch64_python3-botan2.sha256sum] = "bc0e93a9bf0cdeb5d0022b7d087b6189ad8b518db916e508ec86eb971ae860c4"

RDEPENDS:botan2 = " \
 bzip2-libs \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:botan2-devel = " \
 botan2 \
 pkgconf-pkg-config \
 "
RDEPENDS:botan2-doc = " \
 "
RDEPENDS:python3-botan2 = " \
 botan2 \
 python3 \
 "
