# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtdatavis3d"
PV = "6.9.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtdatavis3d \
 qt6-qtdatavis3d-devel \
 qt6-qtdatavis3d-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtdatavis3d-6.9.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0e62d26ea04548b5ba5fc3855597af9cb0ec630d28d2063be5ec0f57d5ba433"

URI_x86_64_v2_qt6-qtdatavis3d = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtdatavis3d-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdatavis3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdatavis3d}"
SRC_URI[x86_64_v2_qt6-qtdatavis3d.sha256sum] = "7715188e6170a89137e427957b454c5cfc10a1da213292ffc59fe97af04a688d"

URI_x86_64_v2_qt6-qtdatavis3d-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtdatavis3d-devel-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdatavis3d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdatavis3d-devel}"
SRC_URI[x86_64_v2_qt6-qtdatavis3d-devel.sha256sum] = "4ede83f08b22c8a07dec7a3ba092b0d7c2f338828c18c9e187138911f73b5e49"

URI_x86_64_v2_qt6-qtdatavis3d-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtdatavis3d-examples-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdatavis3d-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdatavis3d-examples}"
SRC_URI[x86_64_v2_qt6-qtdatavis3d-examples.sha256sum] = "59f5048462b7f393da40456356470aa5586951b8955d6bb961494211f84a73f6"

URI_aarch64_qt6-qtdatavis3d = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtdatavis3d-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtdatavis3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdatavis3d}"
SRC_URI[aarch64_qt6-qtdatavis3d.sha256sum] = "a49697f7fb98e961ae6b0643ceb9fbe25d11c57d3d350c11e9a91e719b33cabb"

URI_aarch64_qt6-qtdatavis3d-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtdatavis3d-devel-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtdatavis3d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdatavis3d-devel}"
SRC_URI[aarch64_qt6-qtdatavis3d-devel.sha256sum] = "7cb7444b6c92fd8fcbe35aac9fb1ec4559f793235df111d77e89f75b83f69263"

URI_aarch64_qt6-qtdatavis3d-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtdatavis3d-examples-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtdatavis3d-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdatavis3d-examples}"
SRC_URI[aarch64_qt6-qtdatavis3d-examples.sha256sum] = "503885eae9e5c7e30c675d116ae03d3e6cdbdffffeccdc6879df6523e3325ec1"

RDEPENDS:qt6-qtdatavis3d = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtdatavis3d-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdatavis3d \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:qt6-qtdatavis3d-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdatavis3d \
 qt6-qtdeclarative \
 "
