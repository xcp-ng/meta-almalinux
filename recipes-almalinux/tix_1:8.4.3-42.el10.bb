# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tix"
PE = "1"
PV = "8.4.3"
PR = "42.el10"
PACKAGES = " \
 tix \
 tix-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/tix-8.4.3-42.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "337a430a664a5653eacca8247e2d71e9fb380291683eea4537a2cabfafa13941"

URI_x86_64_v2_tix = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/tix-8.4.3-42.el10.x86_64_v2.rpm;name=x86_64_v2_tix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tix}"
SRC_URI[x86_64_v2_tix.sha256sum] = "94a521d2aaa9812bde2dd907165b90cb071940cc49d98459708cee195d3d6e7c"

URI_x86_64_v2_tix-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/tix-devel-8.4.3-42.el10.x86_64_v2.rpm;name=x86_64_v2_tix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tix-devel}"
SRC_URI[x86_64_v2_tix-devel.sha256sum] = "eff0b06842dbbe083e265885f71fed70bed0bbacaa29d311c433ecf233c7d42f"

URI_aarch64_tix = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/tix-8.4.3-42.el10.aarch64.rpm;name=aarch64_tix;unpack=0"
SRC_URI:append = " ${URI_aarch64_tix}"
SRC_URI[aarch64_tix.sha256sum] = "30460e1611607b54ccbb9a384db55c87629bc82297790a76426ab079f08cdbe3"

URI_aarch64_tix-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/tix-devel-8.4.3-42.el10.aarch64.rpm;name=aarch64_tix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tix-devel}"
SRC_URI[aarch64_tix-devel.sha256sum] = "3d0cbd9c922e481222e83d4da264bb225a34e97bd8bb6404a8608809e1a9c0ed"

RDEPENDS:tix = " \
 glibc \
 libX11 \
 tcl \
 tk \
 "
RDEPENDS:tix-devel = " \
 tix \
 "
