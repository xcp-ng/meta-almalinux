# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grub2"
PE = "1"
PV = "2.12"
PR = "15.el10_0.alma.1"
PACKAGES:x86_64_v2 = " \
 grub2-common \
 grub2-efi-aa64-modules \
 grub2-efi-x64 \
 grub2-efi-x64-cdboot \
 grub2-efi-x64-modules \
 grub2-pc \
 grub2-pc-modules \
 grub2-ppc64le-modules \
 grub2-tools \
 grub2-tools-efi \
 grub2-tools-extra \
 grub2-tools-minimal \
"
PACKAGES:aarch64 = " \
 grub2-common \
 grub2-efi-aa64 \
 grub2-efi-aa64-cdboot \
 grub2-efi-aa64-modules \
 grub2-efi-x64-modules \
 grub2-pc-modules \
 grub2-ppc64le-modules \
 grub2-tools \
 grub2-tools-extra \
 grub2-tools-minimal \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/grub2-2.12-15.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90e824b5c67e2c9cf8220916d846406e70d11c04db631843282576c3ccd700c9"

URI_x86_64_v2_grub2-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-common-2.12-15.el10_0.alma.1.noarch.rpm;name=x86_64_v2_grub2-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-common}"
SRC_URI[x86_64_v2_grub2-common.sha256sum] = "10d34fa091dd5509dd851c15e1dcdd6c7267369e34578e39e62c6d8d9a580328"

URI_x86_64_v2_grub2-efi-aa64-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-aa64-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=x86_64_v2_grub2-efi-aa64-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-aa64-modules}"
SRC_URI[x86_64_v2_grub2-efi-aa64-modules.sha256sum] = "2685ce5f8ee053b3c923cf8f3f3b35e9bd4a362ccca7d830a5d421414dba3482"

URI_x86_64_v2_grub2-efi-x64 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-efi-x64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-x64}"
SRC_URI[x86_64_v2_grub2-efi-x64.sha256sum] = "68fcce54de294db25ba4689f569cdf63b8282322170db0f878b6ce7141d4bee8"

URI_x86_64_v2_grub2-efi-x64-cdboot = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-cdboot-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-efi-x64-cdboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-x64-cdboot}"
SRC_URI[x86_64_v2_grub2-efi-x64-cdboot.sha256sum] = "152d413ba37d33dc314a6fddc7b956316bb7c15d3505658c2252708e6d98dd9d"

URI_x86_64_v2_grub2-efi-x64-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=x86_64_v2_grub2-efi-x64-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-x64-modules}"
SRC_URI[x86_64_v2_grub2-efi-x64-modules.sha256sum] = "b6a5e895111465b5609ddfc06a19983ea21a98ab4e68a41c16565796056a8091"

URI_x86_64_v2_grub2-pc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-pc-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-pc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-pc}"
SRC_URI[x86_64_v2_grub2-pc.sha256sum] = "ff6b1b2ff61a4cab2573539b8375b7a63946eaf9287033e7ab7528f6e1b55bea"

URI_x86_64_v2_grub2-pc-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-pc-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=x86_64_v2_grub2-pc-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-pc-modules}"
SRC_URI[x86_64_v2_grub2-pc-modules.sha256sum] = "9f462d4092a8b459dd2ccf0e90bc78bb6c9bc2e9baa40cd7011ce1701dbb1169"

URI_x86_64_v2_grub2-ppc64le-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-ppc64le-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=x86_64_v2_grub2-ppc64le-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-ppc64le-modules}"
SRC_URI[x86_64_v2_grub2-ppc64le-modules.sha256sum] = "bdb7903060e02fd572719360c7c9f1116c4f1a72216e6910a4ad8896b304740f"

URI_x86_64_v2_grub2-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools}"
SRC_URI[x86_64_v2_grub2-tools.sha256sum] = "7e8b2af35350af492baff69b34d8bfbf66d354b6ec7907272b07a7223f739910"

URI_x86_64_v2_grub2-tools-efi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-efi-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-efi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools-efi}"
SRC_URI[x86_64_v2_grub2-tools-efi.sha256sum] = "21e21b0dae36a28554bda628122191416db2e1b4f164e2e796df22de44528bc0"

URI_x86_64_v2_grub2-tools-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-extra-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools-extra}"
SRC_URI[x86_64_v2_grub2-tools-extra.sha256sum] = "054dc6451de63941bd1dccd017323126744ed9fc53e510be3637ed76f091bbcb"

URI_x86_64_v2_grub2-tools-minimal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-minimal-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools-minimal}"
SRC_URI[x86_64_v2_grub2-tools-minimal.sha256sum] = "c6b54bda9f0a6ea8df565fa95e7dd018dff6b342057fdb0877fa2e54519cc805"

URI_aarch64_grub2-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-common-2.12-15.el10_0.alma.1.noarch.rpm;name=aarch64_grub2-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-common}"
SRC_URI[aarch64_grub2-common.sha256sum] = "10d34fa091dd5509dd851c15e1dcdd6c7267369e34578e39e62c6d8d9a580328"

URI_aarch64_grub2-efi-aa64 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-2.12-15.el10_0.alma.1.aarch64.rpm;name=aarch64_grub2-efi-aa64;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-aa64}"
SRC_URI[aarch64_grub2-efi-aa64.sha256sum] = "b27c0361f9a0b395291015a70472b288d74fec63f49cc41cdcc8beb6169e9461"

URI_aarch64_grub2-efi-aa64-cdboot = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-cdboot-2.12-15.el10_0.alma.1.aarch64.rpm;name=aarch64_grub2-efi-aa64-cdboot;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-aa64-cdboot}"
SRC_URI[aarch64_grub2-efi-aa64-cdboot.sha256sum] = "a1ab6cb9ed955828641115afb3e89f54fe2ddc52b3b643b31681ba21f3957e5a"

URI_aarch64_grub2-efi-aa64-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=aarch64_grub2-efi-aa64-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-aa64-modules}"
SRC_URI[aarch64_grub2-efi-aa64-modules.sha256sum] = "2685ce5f8ee053b3c923cf8f3f3b35e9bd4a362ccca7d830a5d421414dba3482"

URI_aarch64_grub2-efi-x64-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-x64-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=aarch64_grub2-efi-x64-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-x64-modules}"
SRC_URI[aarch64_grub2-efi-x64-modules.sha256sum] = "b6a5e895111465b5609ddfc06a19983ea21a98ab4e68a41c16565796056a8091"

URI_aarch64_grub2-pc-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-pc-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=aarch64_grub2-pc-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-pc-modules}"
SRC_URI[aarch64_grub2-pc-modules.sha256sum] = "9f462d4092a8b459dd2ccf0e90bc78bb6c9bc2e9baa40cd7011ce1701dbb1169"

URI_aarch64_grub2-ppc64le-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-ppc64le-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=aarch64_grub2-ppc64le-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-ppc64le-modules}"
SRC_URI[aarch64_grub2-ppc64le-modules.sha256sum] = "bdb7903060e02fd572719360c7c9f1116c4f1a72216e6910a4ad8896b304740f"

URI_aarch64_grub2-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-2.12-15.el10_0.alma.1.aarch64.rpm;name=aarch64_grub2-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-tools}"
SRC_URI[aarch64_grub2-tools.sha256sum] = "2badcd2aab3791fa304af586443d9f99adb1fe28436bdf75c9b49b8b273a0bd3"

URI_aarch64_grub2-tools-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-extra-2.12-15.el10_0.alma.1.aarch64.rpm;name=aarch64_grub2-tools-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-tools-extra}"
SRC_URI[aarch64_grub2-tools-extra.sha256sum] = "6f78727e6bc6d32c37136b4b04db5a87ce54c8c1d662638a3c5ffce89ab4b841"

URI_aarch64_grub2-tools-minimal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-minimal-2.12-15.el10_0.alma.1.aarch64.rpm;name=aarch64_grub2-tools-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-tools-minimal}"
SRC_URI[aarch64_grub2-tools-minimal.sha256sum] = "c7d8fcae1429bcbb6fbd354a20e11e301236ad12529d796736647ed9ac764658"

RDEPENDS:grub2-common = " \
 bash \
 grep \
 util-linux-core \
 virtual/coreutils \
 "
RDEPENDS:grub2-efi-aa64-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-efi-x64 = " \
 efi-filesystem \
 grub2-common \
 grub2-tools \
 grub2-tools-minimal \
 "
RDEPENDS:grub2-efi-x64-cdboot = " \
 grub2-common \
 "
RDEPENDS:grub2-efi-x64-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-pc = " \
 dracut \
 file \
 gettext-runtime \
 grub2-common \
 grub2-pc-modules \
 grub2-tools \
 grub2-tools-minimal \
 which \
 "
RDEPENDS:grub2-pc-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-ppc64le-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-tools = " \
 bash \
 device-mapper-libs \
 dracut \
 file \
 gettext-runtime \
 glibc \
 grep \
 grub2-common \
 os-prober \
 sed \
 systemd \
 xz-libs \
 "
RDEPENDS:grub2-tools-efi = " \
 device-mapper-libs \
 file \
 gettext-runtime \
 glibc \
 grub2-common \
 os-prober \
 "
RDEPENDS:grub2-tools-extra = " \
 bash \
 device-mapper-libs \
 file \
 freetype \
 gettext-runtime \
 glibc \
 grub2-common \
 grub2-tools-minimal \
 mtools \
 os-prober \
 xz-libs \
 "
RDEPENDS:grub2-tools-minimal = " \
 bash \
 device-mapper-libs \
 fuse-libs \
 gettext-runtime \
 glibc \
 grub2-common \
 xz-libs \
 "
RDEPENDS:grub2-efi-aa64 = " \
 efi-filesystem \
 grub2-common \
 grub2-tools \
 grub2-tools-minimal \
 "
RDEPENDS:grub2-efi-aa64-cdboot = " \
 grub2-common \
 "
