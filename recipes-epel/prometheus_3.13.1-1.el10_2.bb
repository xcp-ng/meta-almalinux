# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prometheus"
PV = "3.13.1"
PR = "1.el10_2"
PACKAGES = " \
 prometheus \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/prometheus-3.13.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df72a1bd4bf5cb19081037ede00cb2685f888c66b18fbe1cc268e7ba496f1798"

URI_x86_64_v2_prometheus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/prometheus-3.13.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_prometheus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_prometheus}"
SRC_URI[x86_64_v2_prometheus.sha256sum] = "10d33165f3e5fe97f88f52de2db3d3947f82f7a95fb126d78ccef74e6fe1d258"

URI_aarch64_prometheus = "${EPEL_MIRROR}/aarch64/Packages/p/prometheus-3.13.1-1.el10_2.aarch64.rpm;name=aarch64_prometheus;unpack=0"
SRC_URI:append = " ${URI_aarch64_prometheus}"
SRC_URI[aarch64_prometheus.sha256sum] = "f2f0699b32346c22e321c041097d50c0b4cbc7430d9b80e86678f8f50468c19c"

RDEPENDS:prometheus = " \
 bash \
 glibc \
 shadow-utils \
 "
