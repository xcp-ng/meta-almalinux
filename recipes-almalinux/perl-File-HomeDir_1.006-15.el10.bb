# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-HomeDir"
PV = "1.006"
PR = "15.el10"
PACKAGES = " \
 perl-File-HomeDir \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-File-HomeDir-1.006-15.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7abcfaaf477f93d852da1fd74e32bf9e0488ed084287cd73ef1bd73ab2b1bbca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-HomeDir-1.006-15.el10.noarch.rpm;name=x86_64_v2_perl-File-HomeDir;unpack=0"
SRC_URI[x86_64_v2_perl-File-HomeDir.sha256sum] = "eeeed0c4996e6bc6c9a3d6f43a7eee2612cc1cd2672a6367c489c2de78d22b73"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-HomeDir-1.006-15.el10.noarch.rpm;name=aarch64_perl-File-HomeDir;unpack=0"
SRC_URI[aarch64_perl-File-HomeDir.sha256sum] = "eeeed0c4996e6bc6c9a3d6f43a7eee2612cc1cd2672a6367c489c2de78d22b73"

RDEPENDS:perl-File-HomeDir = " \
 perl-Carp \
 perl-Exporter \
 perl-File-HomeDir \
 perl-File-Path \
 perl-File-Temp \
 perl-File-Which \
 perl-PathTools \
 perl-base \
 perl-libs \
 perl-vars \
 "
