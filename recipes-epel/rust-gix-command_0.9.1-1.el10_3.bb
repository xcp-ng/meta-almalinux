# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-command"
PV = "0.9.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-command+default-devel \
 rust-gix-command-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-command-0.9.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2f4da34875147a363a7f8f420f95a2f2918e158266959f9664551d4538f2dbb"

URI_x86_64_v2_rust-gix-command+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-command+default-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-command+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-command+default-devel}"
SRC_URI[x86_64_v2_rust-gix-command+default-devel.sha256sum] = "f4ed88d64b7329dcc97be9e7d0f1b3d0c787802dea523b2511d084d8b542a025"

URI_x86_64_v2_rust-gix-command-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-command-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-command-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-command-devel}"
SRC_URI[x86_64_v2_rust-gix-command-devel.sha256sum] = "ed2e55e831acbb1aa5d7da91d334338593af7906be97a1ad6a62b31618d8612c"

URI_aarch64_rust-gix-command+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-command+default-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-command+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-command+default-devel}"
SRC_URI[aarch64_rust-gix-command+default-devel.sha256sum] = "028de1882c0f6c0070bb387483b01aa965e250c8b00bff3fdc514eb16790136c"

URI_aarch64_rust-gix-command-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-command-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-command-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-command-devel}"
SRC_URI[aarch64_rust-gix-command-devel.sha256sum] = "e8edb47ee37fcdee109b59daeae684a38dceb2094f388cbda5336b4b9c52514e"

RDEPENDS:rust-gix-command+default-devel = " \
 cargo \
 rust-gix-command-devel \
 "
RDEPENDS:rust-gix-command-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-trace+default-devel \
 rust-shell-words+default-devel \
 "
