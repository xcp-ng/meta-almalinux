# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libevent"
PV = "2.1.13"
PR = "1.el10_2"
PACKAGES = " \
 libevent \
 libevent-devel \
 libevent-doc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libevent-2.1.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b41e9848404b1335d6cb2ceb74b198c4fcc04bf151e0df793a9be3e49f6d47d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libevent-2.1.13-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libevent;unpack=0"
SRC_URI[x86_64_v2_libevent.sha256sum] = "d53b8fbfa85ac5c4d7cffcd711c38a594a648f1cd44a415caaa18f2d63ac15c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libevent-devel-2.1.13-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libevent-devel;unpack=0"
SRC_URI[x86_64_v2_libevent-devel.sha256sum] = "47c956fdc81f080bfb31e24d4e37e925f402ba4c111bf315ad287d868542275c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libevent-doc-2.1.13-1.el10_2.noarch.rpm;name=x86_64_v2_libevent-doc;unpack=0"
SRC_URI[x86_64_v2_libevent-doc.sha256sum] = "8f97e5ea7d9bd2f38f36ae5c546a1143c2438ea22193be05cfb08d3a9e3159b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libevent-2.1.13-1.el10_2.aarch64.rpm;name=aarch64_libevent;unpack=0"
SRC_URI[aarch64_libevent.sha256sum] = "22ef3aca098d62bce9e86ee8759a96c95f60a7a2ed61a81b9c156db3bb9d585b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libevent-devel-2.1.13-1.el10_2.aarch64.rpm;name=aarch64_libevent-devel;unpack=0"
SRC_URI[aarch64_libevent-devel.sha256sum] = "5918ff49b4a7fa05bfcf2069ba4e4067b7cdfe09999bf0483a88096fdcaea7be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libevent-doc-2.1.13-1.el10_2.noarch.rpm;name=aarch64_libevent-doc;unpack=0"
SRC_URI[aarch64_libevent-doc.sha256sum] = "8f97e5ea7d9bd2f38f36ae5c546a1143c2438ea22193be05cfb08d3a9e3159b3"

RDEPENDS:libevent = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:libevent-devel = " \
 libevent \
 libevent-devel \
 pkgconf-pkg-config \
 python3 \
 "
RDEPENDS:libevent-doc = " \
 "
