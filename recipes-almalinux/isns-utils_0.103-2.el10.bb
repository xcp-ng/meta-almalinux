# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "isns-utils"
PV = "0.103"
PR = "2.el10"
PACKAGES = " \
 isns-utils \
 isns-utils-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/isns-utils-0.103-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ea26ad770634ea38d9af76c685a282308433012b36ae0060a8f53b64f1c2f861"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/isns-utils-0.103-2.el10.x86_64_v2.rpm;name=x86_64_v2_isns-utils;unpack=0"
SRC_URI[x86_64_v2_isns-utils.sha256sum] = "463ea57f5a54be6f465277f924ed28b641871262c9cb4b9f9ea4bc319ddcbab0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/isns-utils-libs-0.103-2.el10.x86_64_v2.rpm;name=x86_64_v2_isns-utils-libs;unpack=0"
SRC_URI[x86_64_v2_isns-utils-libs.sha256sum] = "15fb7c6e2ee9112f47263d6103ccd60cfb814dc2217b9962ee277838f8cf826d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/isns-utils-0.103-2.el10.aarch64.rpm;name=aarch64_isns-utils;unpack=0"
SRC_URI[aarch64_isns-utils.sha256sum] = "0f688ec713a7fc3464e52c83b1cbc4cb839132c423d14978f1be32e65b838bfe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/isns-utils-libs-0.103-2.el10.aarch64.rpm;name=aarch64_isns-utils-libs;unpack=0"
SRC_URI[aarch64_isns-utils-libs.sha256sum] = "c3ab69362067606dbfa6a8368d2088ffd096952d969c4d2811e4af512932f2f4"

RDEPENDS:isns-utils = " \
 bash \
 glibc \
 isns-utils-libs \
 systemd \
 "
RDEPENDS:isns-utils-libs = " \
 glibc \
 "
