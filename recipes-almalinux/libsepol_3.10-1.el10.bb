# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsepol"
PV = "3.10"
PR = "1.el10"
PACKAGES = " \
 libsepol \
 libsepol-devel \
 libsepol-static \
 libsepol-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libsepol-3.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80264ca5e267311bdd277713338951751609364902da046c630127e8efd256ee"

URI_x86_64_v2_libsepol = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsepol-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol}"
SRC_URI[x86_64_v2_libsepol.sha256sum] = "0f98a0dfef073527259eab7343149143a1eee5e70b76d386d2919c5746f13ea8"

URI_x86_64_v2_libsepol-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsepol-devel-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol-devel}"
SRC_URI[x86_64_v2_libsepol-devel.sha256sum] = "aee6e1753409bb215a52146171355b36377fd63231f753bdbb84c9ff83e69333"

URI_x86_64_v2_libsepol-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsepol-static-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol-static}"
SRC_URI[x86_64_v2_libsepol-static.sha256sum] = "4709ccb98717218806ea54db444ccb3f98b8772546c42e1298d181c3bc52e956"

URI_x86_64_v2_libsepol-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsepol-utils-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol-utils}"
SRC_URI[x86_64_v2_libsepol-utils.sha256sum] = "42aeb8843a94a4b5e610a3da64cc14067a5e8d8026e4c4a0ff4923d0f85e71de"

URI_aarch64_libsepol = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsepol-3.10-1.el10.aarch64.rpm;name=aarch64_libsepol;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol}"
SRC_URI[aarch64_libsepol.sha256sum] = "de7717dd210fc2b4680fd5cce635128470347a5aca424742f0c3ce298534ab97"

URI_aarch64_libsepol-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsepol-devel-3.10-1.el10.aarch64.rpm;name=aarch64_libsepol-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol-devel}"
SRC_URI[aarch64_libsepol-devel.sha256sum] = "d4622271a87060da71344022d392f878fb19c8b734700fa3f994e45e23e1ca39"

URI_aarch64_libsepol-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsepol-static-3.10-1.el10.aarch64.rpm;name=aarch64_libsepol-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol-static}"
SRC_URI[aarch64_libsepol-static.sha256sum] = "e155e5a86c85a8f2f14cd03bdb52da7cf86d2578e7ff764128157296d26dc449"

URI_aarch64_libsepol-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsepol-utils-3.10-1.el10.aarch64.rpm;name=aarch64_libsepol-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol-utils}"
SRC_URI[aarch64_libsepol-utils.sha256sum] = "394d270a9ed1ca1f75ecb45bc8f680850a0f866c646d482778d279dfe721e172"

RDEPENDS:libsepol = " \
 glibc \
 "
RDEPENDS:libsepol-devel = " \
 libsepol \
 pkgconf-pkg-config \
 "
RDEPENDS:libsepol-static = " \
 libsepol-devel \
 "
RDEPENDS:libsepol-utils = " \
 glibc \
 libsepol \
 "
