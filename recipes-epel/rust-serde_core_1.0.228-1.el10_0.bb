# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_core"
PV = "1.0.228"
PR = "1.el10_0"
PACKAGES = " \
 rust-serde_core+alloc-devel \
 rust-serde_core+default-devel \
 rust-serde_core+rc-devel \
 rust-serde_core+result-devel \
 rust-serde_core+std-devel \
 rust-serde_core+unstable-devel \
 rust-serde_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_core-1.0.228-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "853585b8029f3220df280f03d3384a40ae2e00115c01d21c8f746882042be06c"

URI_x86_64_v2_rust-serde_core+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+alloc-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde_core+alloc-devel.sha256sum] = "811b6c777e80a01ad36d7fd586108641fc0f063c14796c286c4ae5d6f8b9fd17"

URI_x86_64_v2_rust-serde_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+default-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+default-devel}"
SRC_URI[x86_64_v2_rust-serde_core+default-devel.sha256sum] = "0f17199b97183ad5436235d37577118538c8b13f10d4c124e868bdc139cbcd86"

URI_x86_64_v2_rust-serde_core+rc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+rc-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+rc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+rc-devel}"
SRC_URI[x86_64_v2_rust-serde_core+rc-devel.sha256sum] = "edc54197a6ff5749683e53b06f96e9f83c42bdfff10b13089bdcebb0db7e8415"

URI_x86_64_v2_rust-serde_core+result-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+result-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+result-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+result-devel}"
SRC_URI[x86_64_v2_rust-serde_core+result-devel.sha256sum] = "150ac597fbe6b0a0ce4c883a461f6eb932aa6f3a6d3a374f841420fa50a39918"

URI_x86_64_v2_rust-serde_core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+std-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+std-devel}"
SRC_URI[x86_64_v2_rust-serde_core+std-devel.sha256sum] = "87183910db3bc7266ae4a3c2c2ee72098c1aa2413f8adfbc45ae84d262a9ecea"

URI_x86_64_v2_rust-serde_core+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+unstable-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+unstable-devel}"
SRC_URI[x86_64_v2_rust-serde_core+unstable-devel.sha256sum] = "018ded903076b47ba6ce8b149972b3c33a750d8883c1b77839b3c86bd516d8a3"

URI_x86_64_v2_rust-serde_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core-devel}"
SRC_URI[x86_64_v2_rust-serde_core-devel.sha256sum] = "80d808c5191bf48300702c38d71c10ac9effc50695229ceaecee46efcf1e52e7"

URI_aarch64_rust-serde_core+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+alloc-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde_core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+alloc-devel}"
SRC_URI[aarch64_rust-serde_core+alloc-devel.sha256sum] = "3ac12854d5be791c8c698e76fd8be248bd067bd7f85c61885d9b89097c0ee862"

URI_aarch64_rust-serde_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+default-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+default-devel}"
SRC_URI[aarch64_rust-serde_core+default-devel.sha256sum] = "943b53d7cca476c361168c5d6080da652109e532ce551d094f8d28b5390aaead"

URI_aarch64_rust-serde_core+rc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+rc-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde_core+rc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+rc-devel}"
SRC_URI[aarch64_rust-serde_core+rc-devel.sha256sum] = "120c133089ca34f87eb403394751188a5b88b2be672806f669f8fcdb8018f273"

URI_aarch64_rust-serde_core+result-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+result-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde_core+result-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+result-devel}"
SRC_URI[aarch64_rust-serde_core+result-devel.sha256sum] = "187553e704fdab1cdc5b7baa7f12d61a777c1d77e0c99061990925da096e8421"

URI_aarch64_rust-serde_core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+std-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde_core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+std-devel}"
SRC_URI[aarch64_rust-serde_core+std-devel.sha256sum] = "83b29161b7c7c5f3bbcdf9488d6d3a7a2e15b5cbb17c6cd2ca55045b459122d4"

URI_aarch64_rust-serde_core+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+unstable-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde_core+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+unstable-devel}"
SRC_URI[aarch64_rust-serde_core+unstable-devel.sha256sum] = "debedba585cfd5ca5d0a163916481c4cb138ab4ec278a3a4248321e8f6d55966"

URI_aarch64_rust-serde_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core-devel}"
SRC_URI[aarch64_rust-serde_core-devel.sha256sum] = "b0c07a468c15a1f2bcaec850054c623036160edbe43fdc18c5f2e08de9a0df05"

RDEPENDS:rust-serde_core+alloc-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+default-devel = " \
 cargo \
 rust-serde_core+result-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+rc-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+result-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+std-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+unstable-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core-devel = " \
 cargo \
 rust \
 rust-serde_derive+default-devel \
 "
