# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openscap"
PE = "1"
PV = "1.4.4"
PR = "1.el10_2.alma.1"
PACKAGES = " \
 openscap \
 openscap-engine-sce \
 openscap-scanner \
 openscap-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openscap-1.4.4-1.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba84db2e220a2e92c642ea33bcc5e3e4c362d63d0fd2ee6d9ff56f6cb81becdc"

URI_x86_64_v2_openscap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-1.4.4-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap}"
SRC_URI[x86_64_v2_openscap.sha256sum] = "bfbdd38314dd7f7ade52219efa6afaaedb0dfc556f580e31218c85b98cd23980"

URI_x86_64_v2_openscap-engine-sce = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-engine-sce-1.4.4-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap-engine-sce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap-engine-sce}"
SRC_URI[x86_64_v2_openscap-engine-sce.sha256sum] = "90f88959802c9c30ab9ebfb69274e831fd24713743409593aa5435906031d8c0"

URI_x86_64_v2_openscap-scanner = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-scanner-1.4.4-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap-scanner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap-scanner}"
SRC_URI[x86_64_v2_openscap-scanner.sha256sum] = "65927af4f9c5a54aafb0b7e29edb207f4585bb4b65d33f5e1f15936e47a18ab1"

URI_x86_64_v2_openscap-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-utils-1.4.4-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap-utils}"
SRC_URI[x86_64_v2_openscap-utils.sha256sum] = "ffcb537a01f4b8307fa93cd61b04e957bc53404124bfd0bac8a2299fc26a609f"

URI_aarch64_openscap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-1.4.4-1.el10_2.alma.1.aarch64.rpm;name=aarch64_openscap;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap}"
SRC_URI[aarch64_openscap.sha256sum] = "326767a744d30e5f959aaab05f439d21fcd1bb0ac32c3663014bf16506f71b59"

URI_aarch64_openscap-engine-sce = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-engine-sce-1.4.4-1.el10_2.alma.1.aarch64.rpm;name=aarch64_openscap-engine-sce;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap-engine-sce}"
SRC_URI[aarch64_openscap-engine-sce.sha256sum] = "011ccd32adaf1f8562b0d6f055a421ea1f170d3f5dcbe0f749ee2e2a956e2857"

URI_aarch64_openscap-scanner = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-scanner-1.4.4-1.el10_2.alma.1.aarch64.rpm;name=aarch64_openscap-scanner;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap-scanner}"
SRC_URI[aarch64_openscap-scanner.sha256sum] = "fdb475e403e28e8de6125dcbdbf1c3c54793e26843f31627523687aa6fc862d9"

URI_aarch64_openscap-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-utils-1.4.4-1.el10_2.alma.1.aarch64.rpm;name=aarch64_openscap-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap-utils}"
SRC_URI[aarch64_openscap-utils.sha256sum] = "59ad083b969e1f07cbaeb6aa75185e0f37a696559a8e3b57e34ab2df51d2dc38"

RDEPENDS:openscap = " \
 bash \
 bzip2-libs \
 dbus \
 dbus-libs \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libcap \
 libgcc \
 libselinux \
 libxml2 \
 libxslt \
 libyaml \
 nss \
 openldap \
 pcre2 \
 popt \
 procps-ng \
 rpm-libs \
 virtual/libcurl.so.4___64bit_ \
 xmlsec1 \
 xmlsec1-openssl \
 "
RDEPENDS:openscap-engine-sce = " \
 glibc \
 openscap \
 "
RDEPENDS:openscap-scanner = " \
 bash \
 glibc \
 openscap \
 virtual/libcurl_ge_7.12.0 \
 "
RDEPENDS:openscap-utils = " \
 bash \
 openscap \
 openscap-scanner \
 python3 \
 rpm-build \
 rpmdevtools \
 "
