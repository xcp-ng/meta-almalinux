# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "groff"
PV = "1.23.0"
PR = "10.el10"
PACKAGES = " \
 groff \
 groff-base \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/groff-1.23.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87f4c97bf8a52df512800693f5f1bbb67b3fe7fb0267d65330fe0460bc88ac7d"

URI_x86_64_v2_groff = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/groff-1.23.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_groff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_groff}"
SRC_URI[x86_64_v2_groff.sha256sum] = "e22e111655b6425866b3cdc4d2ff50bcf33da5a7e4455852d3f980d47d3b13d1"

URI_x86_64_v2_groff-base = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/groff-base-1.23.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_groff-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_groff-base}"
SRC_URI[x86_64_v2_groff-base.sha256sum] = "46e0e7b3ae9c88d5bbb8640a66d1203b3759c2a3ad6ae9505d377a19aac5614a"

URI_aarch64_groff = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/groff-1.23.0-10.el10.aarch64.rpm;name=aarch64_groff;unpack=0"
SRC_URI:append = " ${URI_aarch64_groff}"
SRC_URI[aarch64_groff.sha256sum] = "5fc857bc36299353d82989d2eb1e4fbddde50f1794b907322bd081bf78090211"

URI_aarch64_groff-base = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/groff-base-1.23.0-10.el10.aarch64.rpm;name=aarch64_groff-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_groff-base}"
SRC_URI[aarch64_groff-base.sha256sum] = "e521de553036e6bb35f6bc7edb8c6989de55812cc5c5241700e73a0d762fb94e"

RDEPENDS:groff = " \
 alternatives \
 bash \
 glibc \
 groff-base \
 libgcc \
 libstdc++ \
 virtual/coreutils \
 "
RDEPENDS:groff-base = " \
 alternatives \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
