# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Config-IniFiles"
PV = "3.000003"
PR = "15.el10_0"
PACKAGES = " \
 perl-Config-IniFiles \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Config-IniFiles-3.000003-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47c1ab005b52c69c52abf11340c59ad127a3437705dad23da43c8b5eb46d9abd"

URI_x86_64_v2_perl-Config-IniFiles = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Config-IniFiles-3.000003-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Config-IniFiles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Config-IniFiles}"
SRC_URI[x86_64_v2_perl-Config-IniFiles.sha256sum] = "91e4e993150e9de1e3a256bda4177c78af9ec73f10115ff38f18b99fa3f38876"

URI_aarch64_perl-Config-IniFiles = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Config-IniFiles-3.000003-15.el10_0.noarch.rpm;name=aarch64_perl-Config-IniFiles;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Config-IniFiles}"
SRC_URI[aarch64_perl-Config-IniFiles.sha256sum] = "e9992e1e9e9d164c982c83c065c18efa93150163056e4fcdd7f353785bfac463"

RDEPENDS:perl-Config-IniFiles = " \
 perl-Carp \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Temp \
 perl-IO-stringy \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-libs \
 perl-vars \
 "
