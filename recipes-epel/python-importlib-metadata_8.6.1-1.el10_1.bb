# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-importlib-metadata"
PV = "8.6.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-importlib-metadata \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-importlib-metadata-8.6.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f735e596e31b652b1b3aef0798f194912d203ff53a937cbd2e1f30ccc4a8e854"

URI_x86_64_v2_python3-importlib-metadata = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-importlib-metadata-8.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-importlib-metadata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-importlib-metadata}"
SRC_URI[x86_64_v2_python3-importlib-metadata.sha256sum] = "8f714605915fef33766a9ebac9330d8e1e891c199e175b68422952c1f3b6f686"

URI_aarch64_python3-importlib-metadata = "${EPEL_MIRROR}/aarch64/Packages/p/python3-importlib-metadata-8.6.1-1.el10_1.noarch.rpm;name=aarch64_python3-importlib-metadata;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-importlib-metadata}"
SRC_URI[aarch64_python3-importlib-metadata.sha256sum] = "91784f3af2cb7c72c0f8e4fd6c36514f0696e1cd11651a69b44e331b5ca9acd5"

RDEPENDS:python3-importlib-metadata = " \
 python3 \
 python3-zipp \
 "
