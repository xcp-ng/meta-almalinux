# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-image-builder"
PV = "94.3"
PR = "1.el10_2"
PACKAGES = " \
 cockpit-image-builder \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-image-builder-94.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cca32852b060f5abaa46cc710b0937872ef0116d35b1bb975a59c214af662a6"

URI_x86_64_v2_cockpit-image-builder = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-image-builder-94.3-1.el10_2.noarch.rpm;name=x86_64_v2_cockpit-image-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-image-builder}"
SRC_URI[x86_64_v2_cockpit-image-builder.sha256sum] = "12665f32f63f669500c763fd701ed20d437ac9478c0c50e8b63439b4879d4b39"

URI_aarch64_cockpit-image-builder = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-image-builder-94.3-1.el10_2.noarch.rpm;name=aarch64_cockpit-image-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-image-builder}"
SRC_URI[aarch64_cockpit-image-builder.sha256sum] = "12665f32f63f669500c763fd701ed20d437ac9478c0c50e8b63439b4879d4b39"

RDEPENDS:cockpit-image-builder = " \
 cockpit \
 cockpit-files \
 osbuild-composer \
 "
