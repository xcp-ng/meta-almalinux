# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "7zip"
PV = "24.09"
PR = "4.el10_0"
PACKAGES = " \
 7zip \
 7zip-reduced \
 7zip-standalone \
 7zip-standalone-all \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/7/7zip-24.09-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07168c22bcb6f2a8b3d23327e16ca847ebaf7982f4ffa2d81cf4b216459b0ea6"

URI_x86_64_v2_7zip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-24.09-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip}"
SRC_URI[x86_64_v2_7zip.sha256sum] = "9fdba4844da92fc8d9705b968acb2f766c9727157e5950acb3ccf6cc2fdc461c"

URI_x86_64_v2_7zip-reduced = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-reduced-24.09-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-reduced;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip-reduced}"
SRC_URI[x86_64_v2_7zip-reduced.sha256sum] = "016b71b5f724333d8005fef3d6dd5cb7d06682bde95ec654191df34d050138a9"

URI_x86_64_v2_7zip-standalone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-standalone-24.09-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-standalone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip-standalone}"
SRC_URI[x86_64_v2_7zip-standalone.sha256sum] = "1482090f4b69a53f2a5197030bf4e78b2483d1fcf2771d6b31ca24aa9217f10c"

URI_x86_64_v2_7zip-standalone-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-standalone-all-24.09-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-standalone-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip-standalone-all}"
SRC_URI[x86_64_v2_7zip-standalone-all.sha256sum] = "c7614bca98c9ea2156dec1f57ce880520046b37d99ef04229ca6be48f4c954aa"

URI_aarch64_7zip = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-24.09-4.el10_0.aarch64.rpm;name=aarch64_7zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip}"
SRC_URI[aarch64_7zip.sha256sum] = "e71230f5b736966d0e9f49496343376b04000b881e9a23b0668130f2fdc3e5cc"

URI_aarch64_7zip-reduced = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-reduced-24.09-4.el10_0.aarch64.rpm;name=aarch64_7zip-reduced;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip-reduced}"
SRC_URI[aarch64_7zip-reduced.sha256sum] = "8f076ce18aa5018f9e818755e923c03054824c9b56eec9f18f895f4f802b8345"

URI_aarch64_7zip-standalone = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-standalone-24.09-4.el10_0.aarch64.rpm;name=aarch64_7zip-standalone;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip-standalone}"
SRC_URI[aarch64_7zip-standalone.sha256sum] = "8f55e81c0610c29fe424b73e27168664ca94b022c1288fca8be1bce92b0ee6d7"

URI_aarch64_7zip-standalone-all = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-standalone-all-24.09-4.el10_0.aarch64.rpm;name=aarch64_7zip-standalone-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip-standalone-all}"
SRC_URI[aarch64_7zip-standalone-all.sha256sum] = "5f6f448a437fa11564ab6b28565e042a2fc5250eed67d723061e31373c678a7e"

RDEPENDS:7zip = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-reduced = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-standalone = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-standalone-all = " \
 glibc \
 libgcc \
 libstdc++ \
 "
