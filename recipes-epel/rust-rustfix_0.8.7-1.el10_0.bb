# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustfix"
PV = "0.8.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-rustfix+default-devel \
 rust-rustfix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustfix-0.8.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "345ae57a47eac749ff99b553a39cf7ae0ee0d44a9921fc152965a42583a47b8f"

URI_x86_64_v2_rust-rustfix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfix+default-devel-0.8.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustfix+default-devel}"
SRC_URI[x86_64_v2_rust-rustfix+default-devel.sha256sum] = "552f94ea2d00520c383901d5093c62c705ef9798951326bde2a4fe9d873de47d"

URI_x86_64_v2_rust-rustfix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfix-devel-0.8.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustfix-devel}"
SRC_URI[x86_64_v2_rust-rustfix-devel.sha256sum] = "e60b8c708273ede0fe3a4276b1ffc2bebefa09c275009ea315f4c6b7976019c6"

URI_aarch64_rust-rustfix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfix+default-devel-0.8.7-1.el10_0.noarch.rpm;name=aarch64_rust-rustfix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustfix+default-devel}"
SRC_URI[aarch64_rust-rustfix+default-devel.sha256sum] = "a5630dfe622020b925687390ac2cef55fdf717e24ca442c71127e40f08b34723"

URI_aarch64_rust-rustfix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfix-devel-0.8.7-1.el10_0.noarch.rpm;name=aarch64_rust-rustfix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustfix-devel}"
SRC_URI[aarch64_rust-rustfix-devel.sha256sum] = "8543c28b13bfce8739ce2c3996de4fb269fd2e065df5b83ac65d176d76096ba1"

RDEPENDS:rust-rustfix+default-devel = " \
 cargo \
 rust-rustfix-devel \
 "
RDEPENDS:rust-rustfix-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror1+default-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
