# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jemalloc"
PV = "5.3.0"
PR = "10.el10_1"
PACKAGES = " \
 jemalloc \
 jemalloc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jemalloc-5.3.0-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5b64ea66095905ea3ea75b7d7d9ae4035312757b006ee11cc1642dd6969376d"

URI_x86_64_v2_jemalloc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jemalloc-5.3.0-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jemalloc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jemalloc}"
SRC_URI[x86_64_v2_jemalloc.sha256sum] = "b232967ade984a5f201896ebc66e596b3210e5c424a3de83e44810ae683aa396"

URI_x86_64_v2_jemalloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jemalloc-devel-5.3.0-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jemalloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jemalloc-devel}"
SRC_URI[x86_64_v2_jemalloc-devel.sha256sum] = "f658ec8997ecf228a86639f50311c28a116eefbbad2371a3ca30061e7c307649"

URI_aarch64_jemalloc = "${EPEL_MIRROR}/aarch64/Packages/j/jemalloc-5.3.0-10.el10_1.aarch64.rpm;name=aarch64_jemalloc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jemalloc}"
SRC_URI[aarch64_jemalloc.sha256sum] = "ddb892280f7ef6a3740c0576832bbecde5cf6e70b0bdb0351950c25da804cab9"

URI_aarch64_jemalloc-devel = "${EPEL_MIRROR}/aarch64/Packages/j/jemalloc-devel-5.3.0-10.el10_1.aarch64.rpm;name=aarch64_jemalloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jemalloc-devel}"
SRC_URI[aarch64_jemalloc-devel.sha256sum] = "3044e2ef65c64cade2a0f95cd39b44d6dcbc0dffbe7a29ef28d7b813facd73ee"

RDEPENDS:jemalloc:x86_64_v2 = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
"
RDEPENDS:jemalloc:aarch64 = " \
 bash \
 glibc \
"
RDEPENDS:jemalloc-devel = " \
 bash \
 jemalloc \
 perl-Getopt-Long \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 "
