# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tar-codec"
PV = "0.0.14"
PR = "1.el10_3"
PACKAGES = " \
 rust-tar-codec+default-devel \
 rust-tar-codec-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tar-codec-0.0.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "67384dcc439bb5f5ec8446fd8993c1405b901ba0f19124cebdfb06269036d726"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar-codec+default-devel-0.0.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar-codec+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tar-codec+default-devel.sha256sum] = "c6348f82ae1d18ad2ce0c273b9744f069075d5365ed34ec413bc380462d915b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar-codec-devel-0.0.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar-codec-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tar-codec-devel.sha256sum] = "b341ad992baa916aaee0812f4e22a6ada5fa30c4626b191ff29671eb2be2d6ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tar-codec+default-devel-0.0.14-1.el10_3.noarch.rpm;name=aarch64_rust-tar-codec+default-devel;unpack=0"
SRC_URI[aarch64_rust-tar-codec+default-devel.sha256sum] = "5d30cb929dd7d528533a0cb1f513f96d6ed99abe9511421d414716094741b4ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tar-codec-devel-0.0.14-1.el10_3.noarch.rpm;name=aarch64_rust-tar-codec-devel;unpack=0"
SRC_URI[aarch64_rust-tar-codec-devel.sha256sum] = "dfd1820c57bfcdd7b6327fc4a7edd6e239af5a2d20d8a867f515821865ea2742"

RDEPENDS:rust-tar-codec+default-devel = " \
 cargo \
 rust-tar-codec-devel \
 "
RDEPENDS:rust-tar-codec-devel = " \
 cargo \
 rust-archive-trait+default-devel \
 rust-tar-framing+default-devel \
 rust-thiserror+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 "
