# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "needrestart"
PV = "3.8"
PR = "3.el10_1"
PACKAGES = " \
 needrestart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/needrestart-3.8-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96a897fddd4541c55ddd0ecc54f7e1e559fe46684a01e85abffda53c17c3c6cf"

URI_x86_64_v2_needrestart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/needrestart-3.8-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_needrestart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_needrestart}"
SRC_URI[x86_64_v2_needrestart.sha256sum] = "4efebea432f09468fef7efcdb7183d39b618d48ec6615d72d082b1b016a3dd46"

URI_aarch64_needrestart = "${EPEL_MIRROR}/aarch64/Packages/n/needrestart-3.8-3.el10_1.noarch.rpm;name=aarch64_needrestart;unpack=0"
SRC_URI:append = " ${URI_aarch64_needrestart}"
SRC_URI[aarch64_needrestart.sha256sum] = "0e64fa2dfd4edb59988db23cd36f02a2cdcd33306f363fbd7cbe95ccfa491063"

RDEPENDS:needrestart = " \
 bash \
 needrestart \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Std \
 perl-Module-Find \
 perl-POSIX \
 perl-PathTools \
 perl-Proc-ProcessTable \
 perl-Scalar-List-Utils \
 perl-Sort-Naturally \
 perl-TermReadKey \
 perl-Text-Tabs+Wrap \
 perl-constant \
 perl-interpreter \
 perl-libintl-perl \
 perl-libs \
 perl-parent \
 python3 \
 python3-dnf \
 xz \
 "
