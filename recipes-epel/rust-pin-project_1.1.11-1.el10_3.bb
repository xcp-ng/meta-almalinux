# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pin-project"
PV = "1.1.11"
PR = "1.el10_3"
PACKAGES = " \
 rust-pin-project+default-devel \
 rust-pin-project-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pin-project-1.1.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07aebc53d7cd4977e192e124dcc4c63bd38b136b076d9d72fab46c7b6d0a4d5a"

URI_x86_64_v2_rust-pin-project+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project+default-devel-1.1.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project+default-devel}"
SRC_URI[x86_64_v2_rust-pin-project+default-devel.sha256sum] = "78241e6c3ee4aff3395f423ab6d20bc1c4ebabcd5d212b06971daa6fb8da1e72"

URI_x86_64_v2_rust-pin-project-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-devel-1.1.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-devel}"
SRC_URI[x86_64_v2_rust-pin-project-devel.sha256sum] = "ea7a89a29cd16866f127a617fb2659dbc7240176fd5b9c67bc89b43630533172"

URI_aarch64_rust-pin-project+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project+default-devel-1.1.11-1.el10_3.noarch.rpm;name=aarch64_rust-pin-project+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project+default-devel}"
SRC_URI[aarch64_rust-pin-project+default-devel.sha256sum] = "8496abe702eb75059105ecb61cffdc07de6bc6809d1d1da16a08f54dcaffb5e1"

URI_aarch64_rust-pin-project-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-devel-1.1.11-1.el10_3.noarch.rpm;name=aarch64_rust-pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-devel}"
SRC_URI[aarch64_rust-pin-project-devel.sha256sum] = "9238b4d4e25cd69d22f5de8bd12a43f9e8a1b46a9539917bd234f0f809800619"

RDEPENDS:rust-pin-project+default-devel = " \
 cargo \
 rust-pin-project-devel \
 "
RDEPENDS:rust-pin-project-devel = " \
 cargo \
 rust \
 rust-pin-project-internal+default-devel \
 "
