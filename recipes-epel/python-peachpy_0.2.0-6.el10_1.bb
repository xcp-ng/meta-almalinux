# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-peachpy"
PV = "0.2.0"
PR = "6.el10_1"
PACKAGES = " \
 python3-peachpy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-peachpy-0.2.0-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e2b4c5dd6cace5fcfad1232570b3ee430622c474762601113a0f6485faa8618"

URI_x86_64_v2_python3-peachpy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-peachpy-0.2.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-peachpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-peachpy}"
SRC_URI[x86_64_v2_python3-peachpy.sha256sum] = "e077864714e747e6417624aef7fb018aa7db89d00d7e6c01cc4f5c66b975fed1"

URI_aarch64_python3-peachpy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-peachpy-0.2.0-6.el10_1.noarch.rpm;name=aarch64_python3-peachpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-peachpy}"
SRC_URI[aarch64_python3-peachpy.sha256sum] = "23f97a53529035758ce681e3044ec3ea6277fd713d65467148eb2d2df2568c04"

RDEPENDS:python3-peachpy = " \
 python3 \
 python3-six \
 "
