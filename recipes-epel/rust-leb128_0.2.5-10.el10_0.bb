# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-leb128"
PV = "0.2.5"
PR = "10.el10_0"
PACKAGES = " \
 leb128 \
 rust-leb128+default-devel \
 rust-leb128+nightly-devel \
 rust-leb128-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-leb128-0.2.5-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "145f7d0714c40a2233ae6472cf72183ada92c0a3712bee9ee28f1eb5822aeb43"

URI_x86_64_v2_leb128 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/leb128-0.2.5-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_leb128;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_leb128}"
SRC_URI[x86_64_v2_leb128.sha256sum] = "c619ecc2a9218e6913aa96f98eee31ef8d6d5676f4da5e953ea75decaa540039"

URI_x86_64_v2_rust-leb128+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-leb128+default-devel-0.2.5-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-leb128+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-leb128+default-devel}"
SRC_URI[x86_64_v2_rust-leb128+default-devel.sha256sum] = "2140dee893ecaa3c0bfb40ecd91bd21db34729a2e457da682740a7574ce4d358"

URI_x86_64_v2_rust-leb128+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-leb128+nightly-devel-0.2.5-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-leb128+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-leb128+nightly-devel}"
SRC_URI[x86_64_v2_rust-leb128+nightly-devel.sha256sum] = "4071973479c07664450e2cf409409800113ed6050c58e73482c76b08395de6d0"

URI_x86_64_v2_rust-leb128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-leb128-devel-0.2.5-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-leb128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-leb128-devel}"
SRC_URI[x86_64_v2_rust-leb128-devel.sha256sum] = "767052d07cf4cd5efb1e2fa986ce4da5ef264f9a3ff0b009acb848e68f9a2c81"

URI_aarch64_leb128 = "${EPEL_MIRROR}/aarch64/Packages/l/leb128-0.2.5-10.el10_0.aarch64.rpm;name=aarch64_leb128;unpack=0"
SRC_URI:append = " ${URI_aarch64_leb128}"
SRC_URI[aarch64_leb128.sha256sum] = "687c81e655984e5d9872e2eac0ad8fcd9550ba5e9204e3e8f4bf9abe1de518de"

URI_aarch64_rust-leb128+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-leb128+default-devel-0.2.5-10.el10_0.noarch.rpm;name=aarch64_rust-leb128+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-leb128+default-devel}"
SRC_URI[aarch64_rust-leb128+default-devel.sha256sum] = "bbf5a5f2c19afb93b9755b4c2f75015fe2998d4061b4a81dc502c4771b713223"

URI_aarch64_rust-leb128+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-leb128+nightly-devel-0.2.5-10.el10_0.noarch.rpm;name=aarch64_rust-leb128+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-leb128+nightly-devel}"
SRC_URI[aarch64_rust-leb128+nightly-devel.sha256sum] = "dee45ec98ed5423e0d066782bd8848accc282d6fee8570286b8895a6a8574727"

URI_aarch64_rust-leb128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-leb128-devel-0.2.5-10.el10_0.noarch.rpm;name=aarch64_rust-leb128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-leb128-devel}"
SRC_URI[aarch64_rust-leb128-devel.sha256sum] = "52db97f7260d88a00731e2dcc604ded56a45649f54cd3bdf691d3b7b916705d4"

RDEPENDS:leb128 = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-leb128+default-devel = " \
 cargo \
 rust-leb128-devel \
 "
RDEPENDS:rust-leb128+nightly-devel = " \
 cargo \
 rust-leb128-devel \
 "
RDEPENDS:rust-leb128-devel = " \
 cargo \
 "
