# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_normalizer_data"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_normalizer_data+default-devel \
 rust-icu_normalizer_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_normalizer_data-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92ad418239b1540fa57a784f9e60dffc673d1ead58f566f0ec157c2c65745149"

URI_x86_64_v2_rust-icu_normalizer_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer_data+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer_data+default-devel.sha256sum] = "066b6893d243556f0d487e1bb075072451e8246198342546b5e5d62fe23b52e6"

URI_x86_64_v2_rust-icu_normalizer_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer_data-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer_data-devel.sha256sum] = "aa212f486443d0de4dff0839ddc19e1194d1a3e95ec457fe1abea8aee2942764"

URI_aarch64_rust-icu_normalizer_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer_data+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_normalizer_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer_data+default-devel}"
SRC_URI[aarch64_rust-icu_normalizer_data+default-devel.sha256sum] = "d66a3b5a248c215b6afeba46558c928d0d6fb5df3a4b999ffe492beef9f8e91a"

URI_aarch64_rust-icu_normalizer_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_normalizer_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer_data-devel}"
SRC_URI[aarch64_rust-icu_normalizer_data-devel.sha256sum] = "38167e4ee7c11730f0d390d756f42f968991ec8e2990ff79caf34f4ccdb19777"

RDEPENDS:rust-icu_normalizer_data+default-devel = " \
 cargo \
 rust-icu_normalizer_data-devel \
 "
RDEPENDS:rust-icu_normalizer_data-devel = " \
 cargo \
 rust \
 "
