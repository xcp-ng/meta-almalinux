# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak"
PV = "1.18.0"
PR = "1.el10"
PACKAGES = " \
 flatpak \
 flatpak-devel \
 flatpak-libs \
 flatpak-selinux \
 flatpak-session-helper \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/flatpak-1.18.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35e57dd4f9853cd130846f9168387a42daddbfd945540c02b3098b369156238c"

URI_x86_64_v2_flatpak = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-1.18.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak}"
SRC_URI[x86_64_v2_flatpak.sha256sum] = "96d4788e74bc68790a87d76eeebce2ad8767095bb3e60c7c955603b3e8a53cd7"

URI_x86_64_v2_flatpak-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/flatpak-devel-1.18.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-devel}"
SRC_URI[x86_64_v2_flatpak-devel.sha256sum] = "b573737a2e70de5c59113e7bb10d8b7534eb0e4b1c243edbfcf2be74d99f155d"

URI_x86_64_v2_flatpak-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-libs-1.18.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-libs}"
SRC_URI[x86_64_v2_flatpak-libs.sha256sum] = "4b852210fa4c3019deb502ccb75b0be5b7db6068dcedd1cb5f3c0e03140f644a"

URI_x86_64_v2_flatpak-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-selinux-1.18.0-1.el10.noarch.rpm;name=x86_64_v2_flatpak-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-selinux}"
SRC_URI[x86_64_v2_flatpak-selinux.sha256sum] = "28e834cb416496b7c56b3564b200aa76f4a57958e6cd19f71c47a588c94183ec"

URI_x86_64_v2_flatpak-session-helper = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-session-helper-1.18.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-session-helper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-session-helper}"
SRC_URI[x86_64_v2_flatpak-session-helper.sha256sum] = "85d2f0d0d62a71308cba1819eb64440998adb5d2a817a401780a2d52690009d9"

URI_aarch64_flatpak = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-1.18.0-1.el10.aarch64.rpm;name=aarch64_flatpak;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak}"
SRC_URI[aarch64_flatpak.sha256sum] = "61f3eaea3fdf100c7e6ba7da0d01e327bdb15e1e3582e8811cd309faa2cdacf8"

URI_aarch64_flatpak-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/flatpak-devel-1.18.0-1.el10.aarch64.rpm;name=aarch64_flatpak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-devel}"
SRC_URI[aarch64_flatpak-devel.sha256sum] = "f6d4569e302d9e88cc2a6430ad0b17104b1f800108d8bfe9618797f311b0117e"

URI_aarch64_flatpak-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-libs-1.18.0-1.el10.aarch64.rpm;name=aarch64_flatpak-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-libs}"
SRC_URI[aarch64_flatpak-libs.sha256sum] = "ba9bd448f7328189e80056d47368bcaa1bc15cad9e5a99210e23d454e837359e"

URI_aarch64_flatpak-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-selinux-1.18.0-1.el10.noarch.rpm;name=aarch64_flatpak-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-selinux}"
SRC_URI[aarch64_flatpak-selinux.sha256sum] = "28e834cb416496b7c56b3564b200aa76f4a57958e6cd19f71c47a588c94183ec"

URI_aarch64_flatpak-session-helper = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-session-helper-1.18.0-1.el10.aarch64.rpm;name=aarch64_flatpak-session-helper;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-session-helper}"
SRC_URI[aarch64_flatpak-session-helper.sha256sum] = "c212062adf52bebc514727af525f10f48dce79d9e919fe0f74bf83b887d2811b"

RDEPENDS:flatpak:x86_64_v2 = " \
 appstream \
 bash \
 bubblewrap \
 dconf \
 flatpak-selinux \
 flatpak-session-helper \
 fuse3 \
 fuse3-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gpgme \
 json-glib \
 libXau \
 libarchive \
 libgcc \
 librsvg2 \
 libseccomp \
 libwayland-client \
 libxml2 \
 libzstd \
 ostree-libs \
 polkit-libs \
 python3 \
 shadow-utils \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__ge_7.29.0 \
 xdg-dbus-proxy \
"
RDEPENDS:flatpak:aarch64 = " \
 appstream \
 bash \
 bubblewrap \
 dconf \
 flatpak-selinux \
 flatpak-session-helper \
 fuse3 \
 fuse3-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gpgme \
 json-glib \
 libXau \
 libarchive \
 libgcc \
 librsvg2 \
 libseccomp \
 libwayland-client \
 libxml2 \
 libzstd \
 ostree-libs \
 polkit-libs \
 python3 \
 shadow-utils \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__ge_7.29.0 \
 xdg-dbus-proxy \
"
RDEPENDS:flatpak-devel = " \
 dconf-devel \
 flatpak \
 flatpak-libs \
 glib2-devel \
 json-glib-devel \
 libXau-devel \
 libarchive-devel \
 libcurl-devel \
 libseccomp-devel \
 libxml2-devel \
 libzstd-devel \
 ostree-devel \
 pkgconf-pkg-config \
 polkit-devel \
 systemd-devel \
 virtual/pkgconfig_gpgme__ge_1.8.0 \
 wayland-devel \
 "
RDEPENDS:flatpak-libs = " \
 bubblewrap \
 dconf \
 glib2 \
 glibc \
 gpgme \
 json-glib \
 libXau \
 libarchive \
 libgcc \
 libseccomp \
 libwayland-client \
 libxml2 \
 libzstd \
 ostree-libs \
 polkit-libs \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:flatpak-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
RDEPENDS:flatpak-session-helper = " \
 glib2 \
 glibc \
 libgcc \
 systemd \
 "
