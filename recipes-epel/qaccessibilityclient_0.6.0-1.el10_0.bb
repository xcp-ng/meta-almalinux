# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qaccessibilityclient"
PV = "0.6.0"
PR = "1.el10_0"
PACKAGES = " \
 qaccessibilityclient-qt6 \
 qaccessibilityclient-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qaccessibilityclient-0.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "970cddc79e05bac015aea369c0229da2b15e3f3dfc64876eeb4b70daa8bb9159"

URI_x86_64_v2_qaccessibilityclient-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qaccessibilityclient-qt6-0.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qaccessibilityclient-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qaccessibilityclient-qt6}"
SRC_URI[x86_64_v2_qaccessibilityclient-qt6.sha256sum] = "d9f36038c1859010f5557c96c6a65a49cf6bd6c93425e99de50855b00080a2ff"

URI_x86_64_v2_qaccessibilityclient-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qaccessibilityclient-qt6-devel-0.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qaccessibilityclient-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qaccessibilityclient-qt6-devel}"
SRC_URI[x86_64_v2_qaccessibilityclient-qt6-devel.sha256sum] = "15ac14fe1bef107fe598d7dfbb6a47cca0df379bba025de36630e10255cdce02"

URI_aarch64_qaccessibilityclient-qt6 = "${EPEL_MIRROR}/aarch64/Packages/q/qaccessibilityclient-qt6-0.6.0-1.el10_0.aarch64.rpm;name=aarch64_qaccessibilityclient-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_qaccessibilityclient-qt6}"
SRC_URI[aarch64_qaccessibilityclient-qt6.sha256sum] = "ba41e2786df2f2f8ae3e9c55d053fc763c458ed821d7af0c99b9c5bbddcc00bf"

URI_aarch64_qaccessibilityclient-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qaccessibilityclient-qt6-devel-0.6.0-1.el10_0.aarch64.rpm;name=aarch64_qaccessibilityclient-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qaccessibilityclient-qt6-devel}"
SRC_URI[aarch64_qaccessibilityclient-qt6-devel.sha256sum] = "21db3704111b5c0461164456c3552793c652766631bf36bdf089f76942fe1d19"

RDEPENDS:qaccessibilityclient-qt6 = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:qaccessibilityclient-qt6-devel = " \
 cmake-filesystem \
 qaccessibilityclient-qt6 \
 qt6-qtbase-devel \
 "
