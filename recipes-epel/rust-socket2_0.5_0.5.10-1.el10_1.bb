# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-socket2_0.5"
PV = "0.5.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-socket2_0.5+all-devel \
 rust-socket2_0.5+default-devel \
 rust-socket2_0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-socket2_0.5-0.5.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8aca659d2d1d37e84a9d688cddfd3d41c900ca0ddc26a9543d42ce1ec4f79e9"

URI_x86_64_v2_rust-socket2_0.5+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2_0.5+all-devel-0.5.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2_0.5+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2_0.5+all-devel}"
SRC_URI[x86_64_v2_rust-socket2_0.5+all-devel.sha256sum] = "a6d44c1089ab81c3935893f829c993aa25e6641f51a24216122e87459642ca1e"
RPROVIDES:rust-socket2_0.5+all-devel:append:x86_64_v2 = " virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~"

URI_x86_64_v2_rust-socket2_0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2_0.5+default-devel-0.5.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2_0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2_0.5+default-devel}"
SRC_URI[x86_64_v2_rust-socket2_0.5+default-devel.sha256sum] = "4320da48c7a5ef676c1a3ebedb7ef8ace54546d4d39cc81b68f7fce69c5e5f50"
RPROVIDES:rust-socket2_0.5+default-devel:append:x86_64_v2 = " virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"

URI_x86_64_v2_rust-socket2_0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2_0.5-devel-0.5.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2_0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2_0.5-devel}"
SRC_URI[x86_64_v2_rust-socket2_0.5-devel.sha256sum] = "c41931cfe240b1445ae2cfae718f03a8742e27dae882f043401e198068249893"

URI_aarch64_rust-socket2_0.5+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2_0.5+all-devel-0.5.10-1.el10_1.noarch.rpm;name=aarch64_rust-socket2_0.5+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2_0.5+all-devel}"
SRC_URI[aarch64_rust-socket2_0.5+all-devel.sha256sum] = "66adb2a1c99a5eb4bba6508cfc96bdc07a87f3c255d65a08c9059fdb7c5bf278"
RPROVIDES:rust-socket2_0.5+all-devel:append:aarch64 = " virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~"

URI_aarch64_rust-socket2_0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2_0.5+default-devel-0.5.10-1.el10_1.noarch.rpm;name=aarch64_rust-socket2_0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2_0.5+default-devel}"
SRC_URI[aarch64_rust-socket2_0.5+default-devel.sha256sum] = "5d7c889cc457f72c5c6344a058e1bf0ab8aa14c4f6ee9c0c133afe2ee362f57e"
RPROVIDES:rust-socket2_0.5+default-devel:append:aarch64 = " virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"

URI_aarch64_rust-socket2_0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2_0.5-devel-0.5.10-1.el10_1.noarch.rpm;name=aarch64_rust-socket2_0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2_0.5-devel}"
SRC_URI[aarch64_rust-socket2_0.5-devel.sha256sum] = "d76357426c224a4ebdcc09af26eb68bd7d81a1cdb0cb2547a648545612e2d2cc"

RDEPENDS:rust-socket2_0.5+all-devel = " \
 cargo \
 rust-socket2_0.5-devel \
 "
RDEPENDS:rust-socket2_0.5+default-devel = " \
 cargo \
 rust-socket2_0.5-devel \
 "
RDEPENDS:rust-socket2_0.5-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
