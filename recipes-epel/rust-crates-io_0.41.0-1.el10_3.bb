# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crates-io"
PV = "0.41.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-crates-io+default-devel \
 rust-crates-io-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crates-io-0.41.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9cf501a3245969aca3056fe31c9525a195fc63afc2d29791e34322feecb3a456"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crates-io+default-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crates-io+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crates-io+default-devel.sha256sum] = "a4f4330d0929385a97464a211caf3294053260af695d317535d7da7351443b64"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crates-io-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crates-io-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crates-io-devel.sha256sum] = "c3c6c5638962c6216f51b5bd1afd3fcffe9da4f5fd89619e5df9f9096b503244"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crates-io+default-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-crates-io+default-devel;unpack=0"
SRC_URI[aarch64_rust-crates-io+default-devel.sha256sum] = "6cc7e8f46cd255acfbae917777443ef7fb0a100ecf13ebbe6d39215b1f57d0e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crates-io-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-crates-io-devel;unpack=0"
SRC_URI[aarch64_rust-crates-io-devel.sha256sum] = "9e69aaf50ffccb23e9b7004bb87de6b7859efbb89fdce03c74527a9c9d247313"

RDEPENDS:rust-crates-io+default-devel = " \
 cargo \
 rust-crates-io-devel \
 "
RDEPENDS:rust-crates-io-devel = " \
 cargo \
 rust \
 rust-http+default-devel \
 rust-percent-encoding+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 rust-url+default-devel \
 "
