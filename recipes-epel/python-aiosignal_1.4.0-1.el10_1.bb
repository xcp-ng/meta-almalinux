# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiosignal"
PV = "1.4.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-aiosignal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aiosignal-1.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00a02ba2eaf390a072ecf9db0891a3a79c9e309ff757072ed68f6316ac824afb"

URI_x86_64_v2_python3-aiosignal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiosignal-1.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aiosignal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiosignal}"
SRC_URI[x86_64_v2_python3-aiosignal.sha256sum] = "934922d15ff9e4f896fdc650d69cf958011e9fd90f5c5d7ec53f7faa142a91c8"

URI_aarch64_python3-aiosignal = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiosignal-1.4.0-1.el10_1.noarch.rpm;name=aarch64_python3-aiosignal;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiosignal}"
SRC_URI[aarch64_python3-aiosignal.sha256sum] = "9396c20dc246b1c45b6f508892ee7dd8084da5af23dd6ae81061ba424922eae9"

RDEPENDS:python3-aiosignal = " \
 python3 \
 python3-frozenlist \
 python3-typing-extensions \
 "
