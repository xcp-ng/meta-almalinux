# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-slab"
PV = "0.4.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-slab+default-devel \
 rust-slab+serde-devel \
 rust-slab+std-devel \
 rust-slab-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-slab-0.4.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0345ae7777d50a5dc365dc621928c2f30a462216ec9a039a717baf795e67f872"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slab+default-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slab+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-slab+default-devel.sha256sum] = "c44536a87b5437aed2c38c37e3d670cc49697e0303a48af675e419a590a74629"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slab+serde-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slab+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-slab+serde-devel.sha256sum] = "4509ce5749e3ce417da0fa0325cc726d8773eb1cd8db0694771f48395b5f3524"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slab+std-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slab+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-slab+std-devel.sha256sum] = "9d9d6bb5585eb5497cefba22e17d28db8158a05dadf55c143d91bf6e4359a51b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slab-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slab-devel;unpack=0"
SRC_URI[x86_64_v2_rust-slab-devel.sha256sum] = "95fd1d99703322c05c1ec07c80bc9ec249812f1ea7dee689aa502994082f7a87"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-slab+default-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-slab+default-devel;unpack=0"
SRC_URI[aarch64_rust-slab+default-devel.sha256sum] = "d5923916910e8598f643814f8784bcc5ffabf5978453454be8cb2ad34f53d237"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-slab+serde-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-slab+serde-devel;unpack=0"
SRC_URI[aarch64_rust-slab+serde-devel.sha256sum] = "33bbc5a2888f210c12d46d23cfeba65cd62f0775badb34839f07da37017eacce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-slab+std-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-slab+std-devel;unpack=0"
SRC_URI[aarch64_rust-slab+std-devel.sha256sum] = "4e186ea92860751bda2fe107a5b4bf311615726d827aafca916df709f85c383b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-slab-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-slab-devel;unpack=0"
SRC_URI[aarch64_rust-slab-devel.sha256sum] = "0deca7db3756d0af22577e4b85efead323d5df1578146a0416ed28c82414c0be"

RDEPENDS:rust-slab+default-devel = " \
 cargo \
 rust-slab+std-devel \
 rust-slab-devel \
 "
RDEPENDS:rust-slab+serde-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-slab-devel \
 "
RDEPENDS:rust-slab+std-devel = " \
 cargo \
 rust-slab-devel \
 "
RDEPENDS:rust-slab-devel = " \
 cargo \
 rust \
 "
