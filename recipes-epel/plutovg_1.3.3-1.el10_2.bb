# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plutovg"
PV = "1.3.3"
PR = "1.el10_2"
PACKAGES = " \
 plutovg \
 plutovg-devel \
 plutovg-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plutovg-1.3.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a521801c22f15bf495f7515c90c28d2765f8a5d61df4d927bba6399e91944855"

URI_x86_64_v2_plutovg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutovg-1.3.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutovg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutovg}"
SRC_URI[x86_64_v2_plutovg.sha256sum] = "0637e61f4eb5b5c19dfd1576e97dda4f03a2184ef435c36e17c4d0ce57009df8"

URI_x86_64_v2_plutovg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutovg-devel-1.3.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutovg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutovg-devel}"
SRC_URI[x86_64_v2_plutovg-devel.sha256sum] = "4b09a31584cad91d7f5c15b5439984ff301fd197f6a4d8ffa50ecf4ea28872f0"

URI_x86_64_v2_plutovg-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutovg-samples-1.3.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutovg-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutovg-samples}"
SRC_URI[x86_64_v2_plutovg-samples.sha256sum] = "cf23c6b84221338f81743307ce3cca2ffd871cc6d54df440444761a6b00543df"

URI_aarch64_plutovg = "${EPEL_MIRROR}/aarch64/Packages/p/plutovg-1.3.3-1.el10_2.aarch64.rpm;name=aarch64_plutovg;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutovg}"
SRC_URI[aarch64_plutovg.sha256sum] = "64df79ab6c9251cbd92e945cdfde5ae20e1c49f6cca5dc1622be6a86e35a157f"

URI_aarch64_plutovg-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plutovg-devel-1.3.3-1.el10_2.aarch64.rpm;name=aarch64_plutovg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutovg-devel}"
SRC_URI[aarch64_plutovg-devel.sha256sum] = "a18b2f4b0f621729486da0f1b61e2b522b06a96b8add0b6455fd4b967ebed78b"

URI_aarch64_plutovg-samples = "${EPEL_MIRROR}/aarch64/Packages/p/plutovg-samples-1.3.3-1.el10_2.aarch64.rpm;name=aarch64_plutovg-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutovg-samples}"
SRC_URI[aarch64_plutovg-samples.sha256sum] = "559dfbf3f2f73aaa3ca4d8e6fd277057b99df2ca0912ba3775db9fd209f83599"

RDEPENDS:plutovg = " \
 glibc \
 "
RDEPENDS:plutovg-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 plutovg \
 "
RDEPENDS:plutovg-samples = " \
 glibc \
 plutovg \
 "
