# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kactivitymanagerd"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kactivitymanagerd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kactivitymanagerd-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "671200c558cdbbc3d5fd5ce2649f97c5897481d9824d602f1d28332505e582dd"

URI_x86_64_v2_kactivitymanagerd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kactivitymanagerd-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kactivitymanagerd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kactivitymanagerd}"
SRC_URI[x86_64_v2_kactivitymanagerd.sha256sum] = "83c08b4fcdce09be3598de87c5a9d7e04a0cf9ce71cbcdd6f032216bc3b2cd68"

URI_aarch64_kactivitymanagerd = "${EPEL_MIRROR}/aarch64/Packages/k/kactivitymanagerd-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kactivitymanagerd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kactivitymanagerd}"
SRC_URI[aarch64_kactivitymanagerd.sha256sum] = "5a85b697753e263c0ba64feaf7bd355d699dde39e7fc51bab9d3c240b68a0d32"

RDEPENDS:kactivitymanagerd = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
