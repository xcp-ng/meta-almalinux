# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CPAN-02Packages-Search"
PV = "0.100"
PR = "5.el10_1"
PACKAGES = " \
 perl-CPAN-02Packages-Search \
 perl-CPAN-02Packages-Search-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-CPAN-02Packages-Search-0.100-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bf8fbe6dfdfe8f79592b3b8e0cc974f1f7211948fd0b81efe4fadc1e4f3e56b"

URI_x86_64_v2_perl-CPAN-02Packages-Search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CPAN-02Packages-Search-0.100-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CPAN-02Packages-Search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CPAN-02Packages-Search}"
SRC_URI[x86_64_v2_perl-CPAN-02Packages-Search.sha256sum] = "49b549a616d411138a99b9df1fc58b65a17af62655d7959935276aec17525029"

URI_x86_64_v2_perl-CPAN-02Packages-Search-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CPAN-02Packages-Search-tests-0.100-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CPAN-02Packages-Search-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CPAN-02Packages-Search-tests}"
SRC_URI[x86_64_v2_perl-CPAN-02Packages-Search-tests.sha256sum] = "48c15fd2b0653aed1a74cc0b2462f393a5c78b36c602ba022f4bcb08fbdf8853"

URI_aarch64_perl-CPAN-02Packages-Search = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CPAN-02Packages-Search-0.100-5.el10_1.noarch.rpm;name=aarch64_perl-CPAN-02Packages-Search;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CPAN-02Packages-Search}"
SRC_URI[aarch64_perl-CPAN-02Packages-Search.sha256sum] = "84b859ec184623b8316e306fabe3d0b4e62a9c010c2927da33eacaabf4e4d589"

URI_aarch64_perl-CPAN-02Packages-Search-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CPAN-02Packages-Search-tests-0.100-5.el10_1.noarch.rpm;name=aarch64_perl-CPAN-02Packages-Search-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CPAN-02Packages-Search-tests}"
SRC_URI[aarch64_perl-CPAN-02Packages-Search-tests.sha256sum] = "1f16cd1309ae4d485b1ce35f927e47592d231bfa8791ade003b6c8f69138330c"

RDEPENDS:perl-CPAN-02Packages-Search = " \
 perl-Search-Dict \
 perl-Symbol \
 perl-Tie-Handle-Offset \
 perl-libs \
 "
RDEPENDS:perl-CPAN-02Packages-Search-tests = " \
 bash \
 perl-CPAN-02Packages-Search \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
