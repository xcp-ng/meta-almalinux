# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ntfs-3g-system-compression"
PV = "1.1"
PR = "1.el10_2"
PACKAGES = " \
 ntfs-3g-system-compression \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ntfs-3g-system-compression-1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45de97fc6121ea098a07b3f6a8a4fb58ae524be7cfd4b37b192dbf1c32f40a5e"

URI_x86_64_v2_ntfs-3g-system-compression = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfs-3g-system-compression-1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfs-3g-system-compression;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfs-3g-system-compression}"
SRC_URI[x86_64_v2_ntfs-3g-system-compression.sha256sum] = "4c6888dbac5999913ba15c65e0ffb3642e41ed1a6cd1eab58ebc104ba9d0798d"

URI_aarch64_ntfs-3g-system-compression = "${EPEL_MIRROR}/aarch64/Packages/n/ntfs-3g-system-compression-1.1-1.el10_2.aarch64.rpm;name=aarch64_ntfs-3g-system-compression;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfs-3g-system-compression}"
SRC_URI[aarch64_ntfs-3g-system-compression.sha256sum] = "e4db685a64ea7c518087b457aa56d95fcdeae107b756b4abf056dde849cb6a9d"

RDEPENDS:ntfs-3g-system-compression = " \
 glibc \
 ntfs-3g-libs \
 "
