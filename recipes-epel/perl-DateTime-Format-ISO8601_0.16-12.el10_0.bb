# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-Format-ISO8601"
PV = "0.16"
PR = "12.el10_0"
PACKAGES = " \
 perl-DateTime-Format-ISO8601 \
 perl-DateTime-Format-ISO8601-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-Format-ISO8601-0.16-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e389ed927cdecfeeab14d4e0fcfab8515303e98696583b58f8726a998b90f49b"

URI_x86_64_v2_perl-DateTime-Format-ISO8601 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-Format-ISO8601-0.16-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-Format-ISO8601;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-Format-ISO8601}"
SRC_URI[x86_64_v2_perl-DateTime-Format-ISO8601.sha256sum] = "c977594faa00bae029d9b0ca4bcceb3d2b24d8047e8e6b8b54f0415ee326ee70"

URI_x86_64_v2_perl-DateTime-Format-ISO8601-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-Format-ISO8601-tests-0.16-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-Format-ISO8601-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-Format-ISO8601-tests}"
SRC_URI[x86_64_v2_perl-DateTime-Format-ISO8601-tests.sha256sum] = "20ddfc0d399a4add7e7259dbd8868f5b783ced8e2f7d27ba378bc6c03edde76c"

URI_aarch64_perl-DateTime-Format-ISO8601 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-Format-ISO8601-0.16-12.el10_0.noarch.rpm;name=aarch64_perl-DateTime-Format-ISO8601;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-Format-ISO8601}"
SRC_URI[aarch64_perl-DateTime-Format-ISO8601.sha256sum] = "3fbec579aacae138281e352f55c4b501d06ca66c914ca8d214d846e4c11df881"

URI_aarch64_perl-DateTime-Format-ISO8601-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-Format-ISO8601-tests-0.16-12.el10_0.noarch.rpm;name=aarch64_perl-DateTime-Format-ISO8601-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-Format-ISO8601-tests}"
SRC_URI[aarch64_perl-DateTime-Format-ISO8601-tests.sha256sum] = "6440043279cf2a3ca6d6e83dfcf9446701b9fff1f5888856dbcd2e9ccfc6281f"

RDEPENDS:perl-DateTime-Format-ISO8601 = " \
 perl-Carp \
 perl-DateTime \
 perl-DateTime-Format-Builder \
 perl-DateTime-Format-ISO8601 \
 perl-Params-ValidationCompiler \
 perl-Specio \
 perl-libs \
 perl-namespace-autoclean \
 perl-parent \
 "
RDEPENDS:perl-DateTime-Format-ISO8601-tests = " \
 bash \
 perl-DateTime \
 perl-DateTime-Format-ISO8601 \
 perl-ExtUtils-MakeMaker \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Test2-Suite \
 perl-interpreter \
 perl-libs \
 "
