# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-util-schemas"
PV = "0.3.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-cargo-util-schemas+default-devel \
 rust-cargo-util-schemas-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-util-schemas-0.3.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0867a891e300e438e774f4125b093d9bc936b9ca4382bd85baab89b8f2b89255"

URI_x86_64_v2_rust-cargo-util-schemas+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-schemas+default-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-schemas+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-util-schemas+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-util-schemas+default-devel.sha256sum] = "3fb0973e76deee9766f08f659d78a2a684c72070bcd46850c4b003da1d3629b4"

URI_x86_64_v2_rust-cargo-util-schemas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-schemas-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-schemas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-util-schemas-devel}"
SRC_URI[x86_64_v2_rust-cargo-util-schemas-devel.sha256sum] = "b86585379258ff2be5c240e32f2fc2d1a55f90e90fbefd0b2a9acf9359004098"

URI_aarch64_rust-cargo-util-schemas+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-schemas+default-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-cargo-util-schemas+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-util-schemas+default-devel}"
SRC_URI[aarch64_rust-cargo-util-schemas+default-devel.sha256sum] = "bf20a1d8acdf728eb05045422f4c0effef2b34f812e21b90d4170d52effa05c2"

URI_aarch64_rust-cargo-util-schemas-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-schemas-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-cargo-util-schemas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-util-schemas-devel}"
SRC_URI[aarch64_rust-cargo-util-schemas-devel.sha256sum] = "ae43aeb349f3b7a6d380eb54673d7d16093c84ae430946b12e1a38395f60a292"

RDEPENDS:rust-cargo-util-schemas+default-devel = " \
 cargo \
 rust-cargo-util-schemas-devel \
 "
RDEPENDS:rust-cargo-util-schemas-devel = " \
 cargo \
 rust \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde-untagged+default-devel \
 rust-serde-value+default-devel \
 rust-thiserror1+default-devel \
 rust-toml+default-devel \
 rust-unicode-xid+default-devel \
 rust-url+default-devel \
 "
