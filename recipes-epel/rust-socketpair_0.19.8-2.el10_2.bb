# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-socketpair"
PV = "0.19.8"
PR = "2.el10_2"
PACKAGES = " \
 rust-socketpair+async-std-devel \
 rust-socketpair+default-devel \
 rust-socketpair+tokio-devel \
 rust-socketpair+use_async_std-devel \
 rust-socketpair+use_tokio-devel \
 rust-socketpair-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-socketpair-0.19.8-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9292b2bf89ed0c9d7a06f96c7ee3f07331e228dc9ccae6c8e72d36ce71eed6fb"

URI_x86_64_v2_rust-socketpair+async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socketpair+async-std-devel-0.19.8-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socketpair+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socketpair+async-std-devel}"
SRC_URI[x86_64_v2_rust-socketpair+async-std-devel.sha256sum] = "cd5a9e14a15a1b74f19ffa663689865e1a0e8298824bfd42264eb59669908669"

URI_x86_64_v2_rust-socketpair+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socketpair+default-devel-0.19.8-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socketpair+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socketpair+default-devel}"
SRC_URI[x86_64_v2_rust-socketpair+default-devel.sha256sum] = "5a8277b17f18344ecb171dc72f2d74a1d822be12c427767b7e9637f63302647b"

URI_x86_64_v2_rust-socketpair+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socketpair+tokio-devel-0.19.8-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socketpair+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socketpair+tokio-devel}"
SRC_URI[x86_64_v2_rust-socketpair+tokio-devel.sha256sum] = "9c52e4f621d40f97b144879298f59efc5c575230814689b097f4b95bc55e5019"

URI_x86_64_v2_rust-socketpair+use_async_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socketpair+use_async_std-devel-0.19.8-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socketpair+use_async_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socketpair+use_async_std-devel}"
SRC_URI[x86_64_v2_rust-socketpair+use_async_std-devel.sha256sum] = "bbecd3276054bf94bf09358a5b3c7c0594418dcbabc576d6c01f01bc435b7a44"

URI_x86_64_v2_rust-socketpair+use_tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socketpair+use_tokio-devel-0.19.8-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socketpair+use_tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socketpair+use_tokio-devel}"
SRC_URI[x86_64_v2_rust-socketpair+use_tokio-devel.sha256sum] = "dfe9b19d45d5b544a26049a593e9f5ca64d03bed475062b6b458d4f42aba6ddb"

URI_x86_64_v2_rust-socketpair-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socketpair-devel-0.19.8-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socketpair-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socketpair-devel}"
SRC_URI[x86_64_v2_rust-socketpair-devel.sha256sum] = "4c353815f5761300150f7edfdb8c3ed9e8eab31d62ac81b95485d13c850650d5"

URI_aarch64_rust-socketpair+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socketpair+async-std-devel-0.19.8-2.el10_2.noarch.rpm;name=aarch64_rust-socketpair+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socketpair+async-std-devel}"
SRC_URI[aarch64_rust-socketpair+async-std-devel.sha256sum] = "ff2f8c8cfae2ce209c3fac97c468c22f9ca28b64d173f21c5f12266bb5e33a96"

URI_aarch64_rust-socketpair+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socketpair+default-devel-0.19.8-2.el10_2.noarch.rpm;name=aarch64_rust-socketpair+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socketpair+default-devel}"
SRC_URI[aarch64_rust-socketpair+default-devel.sha256sum] = "90b98aa2c0b7de2dc1e6353ed7bd12fdba02ce5f1155209fc2cedbffb82c02ed"

URI_aarch64_rust-socketpair+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socketpair+tokio-devel-0.19.8-2.el10_2.noarch.rpm;name=aarch64_rust-socketpair+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socketpair+tokio-devel}"
SRC_URI[aarch64_rust-socketpair+tokio-devel.sha256sum] = "82b0807807232d74fb7d8e9ea3484e4140556bfed545e37f6e03fed364393651"

URI_aarch64_rust-socketpair+use_async_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socketpair+use_async_std-devel-0.19.8-2.el10_2.noarch.rpm;name=aarch64_rust-socketpair+use_async_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socketpair+use_async_std-devel}"
SRC_URI[aarch64_rust-socketpair+use_async_std-devel.sha256sum] = "3845d3998cdb34771b615c495bad77292af338d6b8ededcec925ae0aaa0454e7"

URI_aarch64_rust-socketpair+use_tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socketpair+use_tokio-devel-0.19.8-2.el10_2.noarch.rpm;name=aarch64_rust-socketpair+use_tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socketpair+use_tokio-devel}"
SRC_URI[aarch64_rust-socketpair+use_tokio-devel.sha256sum] = "c6d2f683ff19fe1c59acfe1929fa37f44007e2cb9da16453d5f89b9d8b4389c7"

URI_aarch64_rust-socketpair-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socketpair-devel-0.19.8-2.el10_2.noarch.rpm;name=aarch64_rust-socketpair-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socketpair-devel}"
SRC_URI[aarch64_rust-socketpair-devel.sha256sum] = "0cd6629418013fa96b06721164aeec775343b94b827e983ae34250f2c710a9c8"

RDEPENDS:rust-socketpair+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-async-std+io_safety-devel \
 rust-socketpair-devel \
 "
RDEPENDS:rust-socketpair+default-devel = " \
 cargo \
 rust-socketpair-devel \
 "
RDEPENDS:rust-socketpair+tokio-devel = " \
 cargo \
 rust-socketpair-devel \
 rust-tokio+default-devel \
 "
RDEPENDS:rust-socketpair+use_async_std-devel = " \
 cargo \
 rust-io-extras+async-std-devel \
 rust-socketpair+async-std-devel \
 rust-socketpair-devel \
 "
RDEPENDS:rust-socketpair+use_tokio-devel = " \
 cargo \
 rust-io-extras+tokio-devel \
 rust-socketpair+tokio-devel \
 rust-socketpair-devel \
 "
RDEPENDS:rust-socketpair-devel = " \
 cargo \
 rust-io-extras+default-devel \
 rust-io-lifetimes-devel \
 rust-rustix+default-devel \
 rust-rustix+net-devel \
 "
