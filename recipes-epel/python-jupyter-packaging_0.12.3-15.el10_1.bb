# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jupyter-packaging"
PV = "0.12.3"
PR = "15.el10_1"
PACKAGES = " \
 python3-jupyter-packaging \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jupyter-packaging-0.12.3-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "197385b8e0bee97e46421d2a15f674483cafeb4cabde2f843fd625600f688b60"

URI_x86_64_v2_python3-jupyter-packaging = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jupyter-packaging-0.12.3-15.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jupyter-packaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jupyter-packaging}"
SRC_URI[x86_64_v2_python3-jupyter-packaging.sha256sum] = "618477043d46da12801e51720c7361f35e3f1318846f614a3f065bc7d4f2f931"

URI_aarch64_python3-jupyter-packaging = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jupyter-packaging-0.12.3-15.el10_1.noarch.rpm;name=aarch64_python3-jupyter-packaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jupyter-packaging}"
SRC_URI[aarch64_python3-jupyter-packaging.sha256sum] = "4621800164cb530d854fc8b2b104b633376e3b0ff2063565c04adef97eb542c2"

RDEPENDS:python3-jupyter-packaging = " \
 python3 \
 python3-deprecation \
 python3-packaging \
 python3-setuptools \
 python3-tomlkit \
 python3-wheel \
 "
