# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "juk"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 juk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/juk-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45d08acc2831af4e5bb070fac17db666b80a95c41632bf579848643310fcc8a6"

URI_x86_64_v2_juk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/juk-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_juk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_juk}"
SRC_URI[x86_64_v2_juk.sha256sum] = "de11d1b58bf7b4752bc72d81e5e8d5b0cb1022995208bb40810cd857f0144621"

URI_aarch64_juk = "${EPEL_MIRROR}/aarch64/Packages/j/juk-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_juk;unpack=0"
SRC_URI:append = " ${URI_aarch64_juk}"
SRC_URI[aarch64_juk.sha256sum] = "cd3f715fc022bdcc453f30c071d98dde3a0b0b4bb8563f05741f373f1cf07524"

RDEPENDS:juk = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 phonon-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 taglib \
 "
