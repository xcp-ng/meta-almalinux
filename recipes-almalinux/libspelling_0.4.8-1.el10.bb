# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libspelling"
PV = "0.4.8"
PR = "1.el10"
PACKAGES = " \
 libspelling \
 libspelling-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libspelling-0.4.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "497556bda4ac6e5b9f8829132e61b53f90460db0e93ab604bca613900240f41d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libspelling-0.4.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_libspelling;unpack=0"
SRC_URI[x86_64_v2_libspelling.sha256sum] = "aa4ed83cb84b53ff01f3b19343b7c50a015801462226bc6429bbac2cf7fd3524"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libspelling-devel-0.4.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_libspelling-devel;unpack=0"
SRC_URI[x86_64_v2_libspelling-devel.sha256sum] = "4acb8450d2f9abbcfe465801736cbbedb6c1c5e7ce6d8614dacd80394039eff4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libspelling-0.4.8-1.el10.aarch64.rpm;name=aarch64_libspelling;unpack=0"
SRC_URI[aarch64_libspelling.sha256sum] = "3f820c572c83a4345c59772b35ddbb3e67528061eb98fa36e58dd13ed1150b75"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libspelling-devel-0.4.8-1.el10.aarch64.rpm;name=aarch64_libspelling-devel;unpack=0"
SRC_URI[aarch64_libspelling-devel.sha256sum] = "32226db710590b245da3b68406224598fd4ef03f1a769ea113b50f73a01b9b36"

RDEPENDS:libspelling = " \
 enchant2 \
 glib2 \
 glibc \
 gtk4 \
 gtksourceview5 \
 libgcc \
 libicu \
 pango \
 "
RDEPENDS:libspelling-devel = " \
 glib2-devel \
 gtk4-devel \
 gtksourceview5-devel \
 libspelling \
 pkgconf-pkg-config \
 "
