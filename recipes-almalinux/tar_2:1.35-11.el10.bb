# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tar"
PE = "2"
PV = "1.35"
PR = "11.el10"
PACKAGES = " \
 tar \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tar-1.35-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1440681c55278918c4ebd07279f9902f88df74065b28fbac625b15616b6cf99"

URI_x86_64_v2_tar = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tar-1.35-11.el10.x86_64_v2.rpm;name=x86_64_v2_tar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tar}"
SRC_URI[x86_64_v2_tar.sha256sum] = "e0fc58d951d2247823c872423fb5e5a4f2c26e3e14a7e17e8885a1e7adef1c53"

URI_aarch64_tar = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tar-1.35-11.el10.aarch64.rpm;name=aarch64_tar;unpack=0"
SRC_URI:append = " ${URI_aarch64_tar}"
SRC_URI[aarch64_tar.sha256sum] = "ed1cd8d2efe0700c09906e0e3a0c79962272c72b48df9898766084385a33b162"

RDEPENDS:tar = " \
 glibc \
 libacl \
 libselinux \
 "
