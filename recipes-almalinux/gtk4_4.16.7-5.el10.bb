# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtk4"
PV = "4.16.7"
PR = "5.el10"
PACKAGES = " \
 gtk4 \
 gtk4-devel \
 gtk4-devel-docs \
 gtk4-devel-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gtk4-4.16.7-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aab0120294b4ad46e9a6e4d9fb66979e441d04daa0b6a86a6d4dcd5d0cde8071"

URI_x86_64_v2_gtk4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk4-4.16.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk4}"
SRC_URI[x86_64_v2_gtk4.sha256sum] = "d117bf9d3764f477d4bcc0384d57f9e06ab194a5ec4b06f799e0d73634994a4d"

URI_x86_64_v2_gtk4-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk4-devel-4.16.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk4-devel}"
SRC_URI[x86_64_v2_gtk4-devel.sha256sum] = "97848290fb7e088ba6e76f872be3fcf69e81e34395ecc23d3626be7db9477fa4"

URI_x86_64_v2_gtk4-devel-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gtk4-devel-docs-4.16.7-5.el10.noarch.rpm;name=x86_64_v2_gtk4-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk4-devel-docs}"
SRC_URI[x86_64_v2_gtk4-devel-docs.sha256sum] = "f0d8bf4934974fbc7b2e55db7196ef86df43476b259da4e95026a845fcd97b0a"

URI_x86_64_v2_gtk4-devel-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gtk4-devel-tools-4.16.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_gtk4-devel-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk4-devel-tools}"
SRC_URI[x86_64_v2_gtk4-devel-tools.sha256sum] = "607a57c26b9de3447aef3288042e7496802c8e30678622eccd4f6b9be2265ea3"

URI_aarch64_gtk4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk4-4.16.7-5.el10.aarch64.rpm;name=aarch64_gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk4}"
SRC_URI[aarch64_gtk4.sha256sum] = "cc15e787d3704adbf3f75472254b60861082204f5ce26bccad40d82f38caf306"

URI_aarch64_gtk4-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk4-devel-4.16.7-5.el10.aarch64.rpm;name=aarch64_gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk4-devel}"
SRC_URI[aarch64_gtk4-devel.sha256sum] = "2e969adf5c0d5e489cb44fd17769b3fe28d784268468186df1511dddd773a43c"

URI_aarch64_gtk4-devel-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gtk4-devel-docs-4.16.7-5.el10.noarch.rpm;name=aarch64_gtk4-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk4-devel-docs}"
SRC_URI[aarch64_gtk4-devel-docs.sha256sum] = "f0d8bf4934974fbc7b2e55db7196ef86df43476b259da4e95026a845fcd97b0a"

URI_aarch64_gtk4-devel-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gtk4-devel-tools-4.16.7-5.el10.aarch64.rpm;name=aarch64_gtk4-devel-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk4-devel-tools}"
SRC_URI[aarch64_gtk4-devel-tools.sha256sum] = "45b0f2fdb1a9a502d53266c74c75817bd549289e98d0baac6e7c5dc0c43cae9a"

RDEPENDS:gtk4 = " \
 adwaita-icon-theme \
 cairo \
 cairo-gobject \
 colord-libs \
 cups-libs \
 fontconfig \
 fribidi \
 gdk-pixbuf2 \
 gdk-pixbuf2-modules \
 glib2 \
 glibc \
 graphene \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk-update-icon-cache \
 harfbuzz \
 hicolor-icon-theme \
 libX11 \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libepoxy \
 libjpeg-turbo \
 libpng \
 libtiff \
 libtracker-sparql \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxkbcommon \
 pango \
 vulkan-loader \
 "
RDEPENDS:gtk4-devel = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 cairo-gobject-devel \
 fontconfig \
 fribidi \
 gdk-pixbuf2 \
 gdk-pixbuf2-devel \
 glib2 \
 glib2-devel \
 glibc \
 graphene \
 graphene-devel \
 gtk4 \
 gtk4-devel \
 harfbuzz \
 libX11 \
 libX11-devel \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libepoxy \
 libjpeg-turbo \
 libpng \
 libtiff \
 libtracker-sparql \
 libwayland-client \
 libwayland-egl \
 libxkbcommon \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 vulkan-loader \
 vulkan-loader-devel \
 wayland-devel \
 "
RDEPENDS:gtk4-devel-docs = " \
 gtk4 \
 "
RDEPENDS:gtk4-devel-tools = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 harfbuzz \
 libepoxy \
 pango \
 "
