# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gridftp-server"
PV = "13.25"
PR = "3.el10_0"
PACKAGES = " \
 globus-gridftp-server \
 globus-gridftp-server-devel \
 globus-gridftp-server-progs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gridftp-server-13.25-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "331e2f2a6b7a7d9919caab513ec7a7d27c06ae14be9c81bba054a44bd64b25a2"

URI_x86_64_v2_globus-gridftp-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridftp-server-13.25-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridftp-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridftp-server}"
SRC_URI[x86_64_v2_globus-gridftp-server.sha256sum] = "6f42038e5a0dc8b1130f28eb6e69635b9e73e93bab857a472c37a90e1f109cd4"

URI_x86_64_v2_globus-gridftp-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridftp-server-devel-13.25-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridftp-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridftp-server-devel}"
SRC_URI[x86_64_v2_globus-gridftp-server-devel.sha256sum] = "67caf963e35c1848c1ad64decb5f770680c86a1f3e77590f0cae4d2eb8c56780"

URI_x86_64_v2_globus-gridftp-server-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridftp-server-progs-13.25-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridftp-server-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridftp-server-progs}"
SRC_URI[x86_64_v2_globus-gridftp-server-progs.sha256sum] = "227aaf0db3c14fdcc2b1cac1b83cff7b2e0384d5544a04e05ce9062885081fcd"

URI_aarch64_globus-gridftp-server = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridftp-server-13.25-3.el10_0.aarch64.rpm;name=aarch64_globus-gridftp-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridftp-server}"
SRC_URI[aarch64_globus-gridftp-server.sha256sum] = "577bef080d54139ddf06f1f5edd5b5e23e45af36b350bfd77c239eb5a5a27b07"

URI_aarch64_globus-gridftp-server-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridftp-server-devel-13.25-3.el10_0.aarch64.rpm;name=aarch64_globus-gridftp-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridftp-server-devel}"
SRC_URI[aarch64_globus-gridftp-server-devel.sha256sum] = "8328d51c78c9ff450aa9b53c60adc2a374cb8aab7729525ea3755d4d86cc6313"

URI_aarch64_globus-gridftp-server-progs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridftp-server-progs-13.25-3.el10_0.aarch64.rpm;name=aarch64_globus-gridftp-server-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridftp-server-progs}"
SRC_URI[aarch64_globus-gridftp-server-progs.sha256sum] = "ed9f3cb97e621c8b048094c7383bfb7158516585e6b43ce39ced6a4942869ff2"

RDEPENDS:globus-gridftp-server = " \
 glibc \
 globus-authz \
 globus-common \
 globus-ftp-control \
 globus-gfork \
 globus-gridftp-server-control \
 globus-gsi-credential \
 globus-gsi-sysconfig \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-io \
 globus-xio \
 globus-xio-gsi-driver \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:globus-gridftp-server-devel = " \
 globus-authz-devel \
 globus-common-devel \
 globus-ftp-control-devel \
 globus-gfork-devel \
 globus-gridftp-server \
 globus-gridftp-server-control-devel \
 globus-gsi-credential-devel \
 globus-gsi-sysconfig-devel \
 globus-gss-assist-devel \
 globus-gssapi-gsi-devel \
 globus-io-devel \
 globus-xio-devel \
 globus-xio-gsi-driver-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gridftp-server-progs = " \
 bash \
 glibc \
 globus-common \
 globus-gfork \
 globus-gridftp-server \
 globus-gssapi-gsi \
 globus-xio \
 libtool-ltdl \
 perl-English \
 perl-File-Path \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 systemd \
 "
