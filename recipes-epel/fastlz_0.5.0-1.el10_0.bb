# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fastlz"
PV = "0.5.0"
PR = "1.el10_0"
PACKAGES = " \
 fastlz \
 fastlz-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fastlz-0.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f83c7cdb4bfb1e4c53fb2ee9366ae6defd8173c85ff12ebc79c24c7221daa5ea"

URI_x86_64_v2_fastlz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fastlz-0.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fastlz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fastlz}"
SRC_URI[x86_64_v2_fastlz.sha256sum] = "26f6c580f0f2226dd2e11c167fff09e78aef996b8903011c3a4a2105f142572d"

URI_x86_64_v2_fastlz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fastlz-devel-0.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fastlz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fastlz-devel}"
SRC_URI[x86_64_v2_fastlz-devel.sha256sum] = "d231941b41fb16cd22c01ef27a20fe002949e2633d38fede03def13561093f19"

URI_aarch64_fastlz = "${EPEL_MIRROR}/aarch64/Packages/f/fastlz-0.5.0-1.el10_0.aarch64.rpm;name=aarch64_fastlz;unpack=0"
SRC_URI:append = " ${URI_aarch64_fastlz}"
SRC_URI[aarch64_fastlz.sha256sum] = "c8cf0a8f6d4d24399da0e5baa0346f2a723a22c5037d8cc3531406ab90c03b37"

URI_aarch64_fastlz-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fastlz-devel-0.5.0-1.el10_0.aarch64.rpm;name=aarch64_fastlz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fastlz-devel}"
SRC_URI[aarch64_fastlz-devel.sha256sum] = "169927df2dee71195245bd8b98a9ca7b6a0041b856586ea8b04eed739630a26a"

RDEPENDS:fastlz = " \
 glibc \
 "
RDEPENDS:fastlz-devel = " \
 fastlz \
 "
