# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-resolver"
PV = "0.26.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-hickory-resolver+default-devel \
 rust-hickory-resolver+metrics-devel \
 rust-hickory-resolver+recursor-devel \
 rust-hickory-resolver+serde-devel \
 rust-hickory-resolver+system-config-devel \
 rust-hickory-resolver+tokio-devel \
 rust-hickory-resolver+toml-devel \
 rust-hickory-resolver+webpki-roots-devel \
 rust-hickory-resolver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-resolver-0.26.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d954faf6341b3c41d56717f489464e6abbe92ac4fc5f2454c770afbfe1399b5"

URI_x86_64_v2_rust-hickory-resolver+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+default-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+default-devel.sha256sum] = "15bfdb486ab40be5a712fb484842bf9ac775db19bf14ee1df649a3e35e393f8b"

URI_x86_64_v2_rust-hickory-resolver+metrics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+metrics-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+metrics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+metrics-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+metrics-devel.sha256sum] = "b82b209beb6266380518e799cad511d9d83732c12bb3e571d396db7123c58120"

URI_x86_64_v2_rust-hickory-resolver+recursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+recursor-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+recursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+recursor-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+recursor-devel.sha256sum] = "97f9c962be8ca76fe75c7e7537326b12db862873ce093259ae5eff7ffe747555"

URI_x86_64_v2_rust-hickory-resolver+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+serde-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+serde-devel.sha256sum] = "1f14990c9a1112ab710a1632bbe3396386d0bdfaac01c9d206d6f3fb6732b4a8"

URI_x86_64_v2_rust-hickory-resolver+system-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+system-config-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+system-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+system-config-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+system-config-devel.sha256sum] = "195f2785ae4fa5c182a84268aab84eb0d0514a445fa4646238d85e7f56f4fd6e"

URI_x86_64_v2_rust-hickory-resolver+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+tokio-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+tokio-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+tokio-devel.sha256sum] = "46c8aac83b90d6c8ed06aae1d086f95dafe0b768974db9fd0c0b8434dab4eaea"

URI_x86_64_v2_rust-hickory-resolver+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+toml-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+toml-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+toml-devel.sha256sum] = "7f8eabc00fe1d5fa2fb05c111c0d6f08c4e76cfcb680c4597a146649b0aec4a4"

URI_x86_64_v2_rust-hickory-resolver+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+webpki-roots-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+webpki-roots-devel.sha256sum] = "07e48c99c988c909f82894e6a9729ba4f434580f2b78478984c2898d911c053b"

URI_x86_64_v2_rust-hickory-resolver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver-devel.sha256sum] = "5044bce9e1af776592a621bfc17b2c8986e6b94058c0490e7929e8c240c3b6f6"

URI_aarch64_rust-hickory-resolver+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+default-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+default-devel}"
SRC_URI[aarch64_rust-hickory-resolver+default-devel.sha256sum] = "cee4050d333aa411cf736343be88bc38bc3618e357ee65eacb348d09eef38852"

URI_aarch64_rust-hickory-resolver+metrics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+metrics-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+metrics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+metrics-devel}"
SRC_URI[aarch64_rust-hickory-resolver+metrics-devel.sha256sum] = "9d8a102ba33860b8e36c20e17aab0344694873606576ba97b497aced91b792c5"

URI_aarch64_rust-hickory-resolver+recursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+recursor-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+recursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+recursor-devel}"
SRC_URI[aarch64_rust-hickory-resolver+recursor-devel.sha256sum] = "3676fb4e3a8bc3b882492049abe1fc7fed888b3f657a549e21938ae77c04c033"

URI_aarch64_rust-hickory-resolver+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+serde-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+serde-devel}"
SRC_URI[aarch64_rust-hickory-resolver+serde-devel.sha256sum] = "d0e1d747b7b60a27e30dd72719dc6870ee100d0fb0c1214f67563cb8692e7c09"

URI_aarch64_rust-hickory-resolver+system-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+system-config-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+system-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+system-config-devel}"
SRC_URI[aarch64_rust-hickory-resolver+system-config-devel.sha256sum] = "8b45a36cd4f49d93a612fbef9700efce39d0f656578f05062a2026f1ac29057d"

URI_aarch64_rust-hickory-resolver+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+tokio-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+tokio-devel}"
SRC_URI[aarch64_rust-hickory-resolver+tokio-devel.sha256sum] = "7212405fb5f0d4df9c6f9a6794b643c07377f09ff5d8dc56ec7d322962d9be4f"

URI_aarch64_rust-hickory-resolver+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+toml-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+toml-devel}"
SRC_URI[aarch64_rust-hickory-resolver+toml-devel.sha256sum] = "399506d6a74f3e09d62951b5d2fe944e569adea2b04df844755f39379385b5ab"

URI_aarch64_rust-hickory-resolver+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+webpki-roots-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+webpki-roots-devel}"
SRC_URI[aarch64_rust-hickory-resolver+webpki-roots-devel.sha256sum] = "1f95ac650a1a485d173cfc83601ba9377491fafeabd8e029184bc86039344adb"

URI_aarch64_rust-hickory-resolver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver-devel}"
SRC_URI[aarch64_rust-hickory-resolver-devel.sha256sum] = "3098feac16d3320f9efd02554640c1fb24997e6c3f129874059289c748b7275c"

RDEPENDS:rust-hickory-resolver+default-devel = " \
 cargo \
 rust-hickory-resolver+system-config-devel \
 rust-hickory-resolver+tokio-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+metrics-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-metrics+default-devel \
 "
RDEPENDS:rust-hickory-resolver+recursor-devel = " \
 cargo \
 rust-async-recursion+default-devel \
 rust-hickory-resolver-devel \
 rust-lru-cache+default-devel \
 "
RDEPENDS:rust-hickory-resolver+serde-devel = " \
 cargo \
 rust-hickory-proto+serde-devel \
 rust-hickory-resolver-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 "
RDEPENDS:rust-hickory-resolver+system-config-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-resolv-conf+default-devel \
 rust-resolv-conf+system-devel \
 "
RDEPENDS:rust-hickory-resolver+tokio-devel = " \
 cargo \
 rust-hickory-net+tokio-devel \
 rust-hickory-resolver-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 "
RDEPENDS:rust-hickory-resolver+toml-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-toml+default-devel \
 "
RDEPENDS:rust-hickory-resolver+webpki-roots-devel = " \
 cargo \
 rust-hickory-net+webpki-roots-devel \
 rust-hickory-resolver-devel \
 rust-webpki-roots+default-devel \
 "
RDEPENDS:rust-hickory-resolver-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-hickory-net-devel \
 rust-hickory-proto+access-control-devel \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 rust-ipnet+serde-devel \
 rust-ipnet-devel \
 rust-moka+default-devel \
 rust-moka+sync-devel \
 rust-once_cell+critical-section-devel \
 rust-once_cell-devel \
 rust-parking_lot+default-devel \
 rust-rand+alloc-devel \
 rust-rand-devel \
 rust-smallvec+default-devel \
 rust-thiserror-devel \
 rust-tracing-devel \
 "
