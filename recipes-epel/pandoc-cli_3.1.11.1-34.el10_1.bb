# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pandoc-cli"
PV = "3.1.11.1"
PR = "34.el10_1"
PACKAGES:x86_64_v2 = " \
 ghc-hslua-cli \
 ghc-hslua-cli-devel \
 ghc-hslua-cli-doc \
 ghc-hslua-list \
 ghc-hslua-list-devel \
 ghc-hslua-list-doc \
 ghc-hslua-module-doclayout \
 ghc-hslua-module-doclayout-devel \
 ghc-hslua-module-doclayout-doc \
 ghc-hslua-module-path \
 ghc-hslua-module-path-devel \
 ghc-hslua-module-path-doc \
 ghc-hslua-module-system \
 ghc-hslua-module-system-devel \
 ghc-hslua-module-system-doc \
 ghc-hslua-module-version \
 ghc-hslua-module-version-devel \
 ghc-hslua-module-version-doc \
 ghc-hslua-module-zip \
 ghc-hslua-module-zip-devel \
 ghc-hslua-module-zip-doc \
 ghc-hslua-repl \
 ghc-hslua-repl-devel \
 ghc-hslua-repl-doc \
 ghc-lpeg \
 ghc-lpeg-devel \
 ghc-lpeg-doc \
 ghc-pandoc-lua-engine \
 ghc-pandoc-lua-engine-devel \
 ghc-pandoc-lua-engine-doc \
 ghc-pandoc-lua-marshal \
 ghc-pandoc-lua-marshal-devel \
 ghc-pandoc-lua-marshal-doc \
 pandoc \
 pandoc-pdf \
"
PACKAGES:aarch64 = " \
 ghc-hslua-cli \
 ghc-hslua-cli-devel \
 ghc-hslua-cli-doc \
 ghc-hslua-cli-prof \
 ghc-hslua-list \
 ghc-hslua-list-devel \
 ghc-hslua-list-doc \
 ghc-hslua-list-prof \
 ghc-hslua-module-doclayout \
 ghc-hslua-module-doclayout-devel \
 ghc-hslua-module-doclayout-doc \
 ghc-hslua-module-doclayout-prof \
 ghc-hslua-module-path \
 ghc-hslua-module-path-devel \
 ghc-hslua-module-path-doc \
 ghc-hslua-module-path-prof \
 ghc-hslua-module-system \
 ghc-hslua-module-system-devel \
 ghc-hslua-module-system-doc \
 ghc-hslua-module-system-prof \
 ghc-hslua-module-version \
 ghc-hslua-module-version-devel \
 ghc-hslua-module-version-doc \
 ghc-hslua-module-version-prof \
 ghc-hslua-module-zip \
 ghc-hslua-module-zip-devel \
 ghc-hslua-module-zip-doc \
 ghc-hslua-module-zip-prof \
 ghc-hslua-repl \
 ghc-hslua-repl-devel \
 ghc-hslua-repl-doc \
 ghc-hslua-repl-prof \
 ghc-lpeg \
 ghc-lpeg-devel \
 ghc-lpeg-doc \
 ghc-lpeg-prof \
 ghc-pandoc-lua-engine \
 ghc-pandoc-lua-engine-devel \
 ghc-pandoc-lua-engine-doc \
 ghc-pandoc-lua-engine-prof \
 ghc-pandoc-lua-marshal \
 ghc-pandoc-lua-marshal-devel \
 ghc-pandoc-lua-marshal-doc \
 ghc-pandoc-lua-marshal-prof \
 pandoc \
 pandoc-pdf \
"

URI_src = "${EPELSRC_MIRROR}/Packages/p/pandoc-cli-3.1.11.1-34.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2145a864cecaf833d8643b82597b37be53826d41afbb800604935224b85d22b"

URI_x86_64_v2_ghc-hslua-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-cli-1.4.3-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-cli}"
SRC_URI[x86_64_v2_ghc-hslua-cli.sha256sum] = "5888d826baa41c3f79f9eff1026798a5638fd948b137dc60e52dc956f7d46400"

URI_x86_64_v2_ghc-hslua-cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-cli-devel-1.4.3-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-cli-devel}"
SRC_URI[x86_64_v2_ghc-hslua-cli-devel.sha256sum] = "73ad89968a13845c91f86b1a3efcc278cb8aa41b11e9d96eaa5a9ece08485985"

URI_x86_64_v2_ghc-hslua-cli-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-cli-doc-1.4.3-34.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-cli-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-cli-doc}"
SRC_URI[x86_64_v2_ghc-hslua-cli-doc.sha256sum] = "e40945f9564f2d451d5f73a0bb027ee7608467db4d00b4d0ad69a673804a3259"

URI_x86_64_v2_ghc-hslua-list = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-list-1.1.1-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-list;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-list}"
SRC_URI[x86_64_v2_ghc-hslua-list.sha256sum] = "e12caa7dd1b7b59c3d3fb6e5ef6d2d2926ec1f2c4184354159cf06b7b580803c"

URI_x86_64_v2_ghc-hslua-list-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-list-devel-1.1.1-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-list-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-list-devel}"
SRC_URI[x86_64_v2_ghc-hslua-list-devel.sha256sum] = "3417ce05005d4f7a087b402799654b3b6e8ab75763cf5b7bf09ef72a9e528f84"

URI_x86_64_v2_ghc-hslua-list-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-list-doc-1.1.1-34.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-list-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-list-doc}"
SRC_URI[x86_64_v2_ghc-hslua-list-doc.sha256sum] = "05403dd05ede1be9031d0156f037dd95a943af6720b0b54dfec99a3a85259fce"

URI_x86_64_v2_ghc-hslua-module-doclayout = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-doclayout-1.1.1.2-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-doclayout;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-doclayout}"
SRC_URI[x86_64_v2_ghc-hslua-module-doclayout.sha256sum] = "a94868a56768454efb9e4f2316d536f09ae1a9ee5aa939d69f6a562fe68d749e"

URI_x86_64_v2_ghc-hslua-module-doclayout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-doclayout-devel-1.1.1.2-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-doclayout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-doclayout-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-doclayout-devel.sha256sum] = "952cb6ba31b80da1b898bffcf2ef8cc5f27575bc18d0e74d57b1b846ba635360"

URI_x86_64_v2_ghc-hslua-module-doclayout-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-doclayout-doc-1.1.1.2-34.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-doclayout-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-doclayout-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-doclayout-doc.sha256sum] = "727a9c6aa4f12522f94516a04f67398e61e99d5d3a97cb49fb5c584c4b9dea57"

URI_x86_64_v2_ghc-hslua-module-path = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-path-1.1.1-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-path;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-path}"
SRC_URI[x86_64_v2_ghc-hslua-module-path.sha256sum] = "14552ac233f509fd38329bba47550f5de3285086f283108edeed282f7ebe737b"

URI_x86_64_v2_ghc-hslua-module-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-path-devel-1.1.1-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-path-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-path-devel.sha256sum] = "4b6768885c41c4578f12f5a8b22b3bb3b93a35f2cd8c0a03ab1494b58eee910b"

URI_x86_64_v2_ghc-hslua-module-path-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-path-doc-1.1.1-34.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-path-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-path-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-path-doc.sha256sum] = "db619573ce4322100f17cbbc73d028e8a180577ba90e77667516894053791845"

URI_x86_64_v2_ghc-hslua-module-system = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-system-1.1.2-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-system;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-system}"
SRC_URI[x86_64_v2_ghc-hslua-module-system.sha256sum] = "694b23923c69bedcef157a8045060ca5727e9c91e50b4c81f697a81349d13de0"

URI_x86_64_v2_ghc-hslua-module-system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-system-devel-1.1.2-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-system-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-system-devel.sha256sum] = "c773441db2292e551ad4328281277636af75a0497206ccd770d87a282d592496"

URI_x86_64_v2_ghc-hslua-module-system-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-system-doc-1.1.2-34.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-system-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-system-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-system-doc.sha256sum] = "045187d08b0211b5c656fbb116857c4d1a71b9e9d76682efdd0f79bebfec7519"

URI_x86_64_v2_ghc-hslua-module-version = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-version-1.1.1-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-version;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-version}"
SRC_URI[x86_64_v2_ghc-hslua-module-version.sha256sum] = "f34eeb1d637ffd0e5296a763946066f302e3069679bd1c4f2991c1a6f5e515d0"

URI_x86_64_v2_ghc-hslua-module-version-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-version-devel-1.1.1-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-version-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-version-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-version-devel.sha256sum] = "689998d038cba00b848f1190dd4ecf9dc12a4e1a3ec337423888a56cd6f52d19"

URI_x86_64_v2_ghc-hslua-module-version-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-version-doc-1.1.1-34.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-version-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-version-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-version-doc.sha256sum] = "ef0c8f87245910f31f412118c124686e07c3ee526c01517cba6fe3ade51b29c5"

URI_x86_64_v2_ghc-hslua-module-zip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-zip-1.1.3-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-zip}"
SRC_URI[x86_64_v2_ghc-hslua-module-zip.sha256sum] = "f2dde9c8bd57bff6cb05838c0adad830f54d0fceb2f456440fdb221c5d3aa3de"

URI_x86_64_v2_ghc-hslua-module-zip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-zip-devel-1.1.3-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-zip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-zip-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-zip-devel.sha256sum] = "b4f57db5fcd9fe07e65d626c6cfabb9cf0dabc0593485c4838b4b5e24aa5e3ce"

URI_x86_64_v2_ghc-hslua-module-zip-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-zip-doc-1.1.3-34.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-zip-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-zip-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-zip-doc.sha256sum] = "43fd96b9931494a4cb9c4af3789a2767897c85db1fb2661d8a389b22df6a5cd8"

URI_x86_64_v2_ghc-hslua-repl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-repl-0.1.2-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-repl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-repl}"
SRC_URI[x86_64_v2_ghc-hslua-repl.sha256sum] = "e71a1a394512d4aaa572f027f5d56d67cbeda384d669afeb5dea35a3eca2433f"

URI_x86_64_v2_ghc-hslua-repl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-repl-devel-0.1.2-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-repl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-repl-devel}"
SRC_URI[x86_64_v2_ghc-hslua-repl-devel.sha256sum] = "d968cec2861176aea1d306ae8dd3f000f3f93eab3b8039ce6a3386a7b02fd28b"

URI_x86_64_v2_ghc-hslua-repl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-repl-doc-0.1.2-34.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-repl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-repl-doc}"
SRC_URI[x86_64_v2_ghc-hslua-repl-doc.sha256sum] = "cb0ea704c7cf9aa069f862f5a32e74665296f20a6147f7a8b6117119595a0c07"

URI_x86_64_v2_ghc-lpeg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lpeg-1.0.4-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lpeg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lpeg}"
SRC_URI[x86_64_v2_ghc-lpeg.sha256sum] = "4a298a1606e721843d9ed39f8e6c94129f09efdce5c2784025e9ee62dba6bbf2"

URI_x86_64_v2_ghc-lpeg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lpeg-devel-1.0.4-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lpeg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lpeg-devel}"
SRC_URI[x86_64_v2_ghc-lpeg-devel.sha256sum] = "2f31a7943ad9aef6cf7bee32fb59eb30c19f3fecff58fe24fb36bd7f8032eeeb"

URI_x86_64_v2_ghc-lpeg-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lpeg-doc-1.0.4-34.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-lpeg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lpeg-doc}"
SRC_URI[x86_64_v2_ghc-lpeg-doc.sha256sum] = "36b92d8382266051fb7b2638651f632cb9b6d808710d5f517bf7e5d45c158ca7"

URI_x86_64_v2_ghc-pandoc-lua-engine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-engine-0.2.1.2-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-lua-engine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-engine}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-engine.sha256sum] = "4104f60c3ae9b6d4f9a4195f134471f41d607ef2e734fc1a602af3fe9737acc4"

URI_x86_64_v2_ghc-pandoc-lua-engine-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-engine-devel-0.2.1.2-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-lua-engine-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-engine-devel}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-engine-devel.sha256sum] = "0d0771bbfdd7c7937e9edb5880dd301ecee946fa8c9e6eb6d15e848f1ce34a63"

URI_x86_64_v2_ghc-pandoc-lua-engine-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-engine-doc-0.2.1.2-34.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pandoc-lua-engine-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-engine-doc}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-engine-doc.sha256sum] = "6837ef599386f4c83254c80956749bc4763661d7150984572800c5a4c860834a"

URI_x86_64_v2_ghc-pandoc-lua-marshal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-marshal-0.2.7.1-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-lua-marshal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-marshal}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-marshal.sha256sum] = "ff27b3a7c61044e55df6bfc71915276f233fb202dc44de99db15a1b132710664"

URI_x86_64_v2_ghc-pandoc-lua-marshal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-marshal-devel-0.2.7.1-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-lua-marshal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-marshal-devel}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-marshal-devel.sha256sum] = "63a279eacc160e54c7de1f72107b295c4f21c7b11f8041845f437d7489ab2be1"

URI_x86_64_v2_ghc-pandoc-lua-marshal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-marshal-doc-0.2.7.1-34.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pandoc-lua-marshal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-marshal-doc}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-marshal-doc.sha256sum] = "797d84db5453f8a3c07456c67f6998aafc3886912809e547d75c2018b4cbbb22"

URI_x86_64_v2_pandoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pandoc-3.1.11.1-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pandoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pandoc}"
SRC_URI[x86_64_v2_pandoc.sha256sum] = "45bda8c2a4c91e40cf8663024c3a211300e5a60335c96a6417050d4e805408cc"

URI_x86_64_v2_pandoc-pdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pandoc-pdf-3.1.11.1-34.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pandoc-pdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pandoc-pdf}"
SRC_URI[x86_64_v2_pandoc-pdf.sha256sum] = "a651bc1a96cd3f217b19ecb542290c46599a35ae22d348862e4ff9ad845084cb"

URI_aarch64_ghc-hslua-cli = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-cli-1.4.3-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-cli}"
SRC_URI[aarch64_ghc-hslua-cli.sha256sum] = "ef284b46a02a2a77e84f3d465c375758a8e4d6adc8223798da473938570a34a2"

URI_aarch64_ghc-hslua-cli-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-cli-devel-1.4.3-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-cli-devel}"
SRC_URI[aarch64_ghc-hslua-cli-devel.sha256sum] = "efc6e72a28051e73e7fe80a741ec9bd27cdc9eb97852c730e3e696d8d63c0d23"

URI_aarch64_ghc-hslua-cli-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-cli-doc-1.4.3-34.el10_1.noarch.rpm;name=aarch64_ghc-hslua-cli-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-cli-doc}"
SRC_URI[aarch64_ghc-hslua-cli-doc.sha256sum] = "e75380c1b3bb532370cc69e7b44e999488a80e797d713df92f961f26d94311b4"

URI_aarch64_ghc-hslua-cli-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-cli-prof-1.4.3-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-cli-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-cli-prof}"
SRC_URI[aarch64_ghc-hslua-cli-prof.sha256sum] = "58d7210c3e77020422b784767b59355476ed32e07b64d200dad79871c3086b69"

URI_aarch64_ghc-hslua-list = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-list-1.1.1-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-list;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-list}"
SRC_URI[aarch64_ghc-hslua-list.sha256sum] = "be106613dfb75d8ced6af04e55dc75c5bab6ae3aab4c3fcd112a5b30792e4fb4"

URI_aarch64_ghc-hslua-list-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-list-devel-1.1.1-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-list-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-list-devel}"
SRC_URI[aarch64_ghc-hslua-list-devel.sha256sum] = "8a5b0589c042ea52602d7004e069c3620201c58f4567c6cd1e4192e2f680a0cc"

URI_aarch64_ghc-hslua-list-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-list-doc-1.1.1-34.el10_1.noarch.rpm;name=aarch64_ghc-hslua-list-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-list-doc}"
SRC_URI[aarch64_ghc-hslua-list-doc.sha256sum] = "7b44e5b86103bc6f4308a380311164565b22df39eb21d95c7fbc608a72d68f38"

URI_aarch64_ghc-hslua-list-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-list-prof-1.1.1-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-list-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-list-prof}"
SRC_URI[aarch64_ghc-hslua-list-prof.sha256sum] = "e06e27e96a7f923867d712ff993618c4fad9c132847346e378ed379127749784"

URI_aarch64_ghc-hslua-module-doclayout = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-doclayout-1.1.1.2-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-doclayout;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-doclayout}"
SRC_URI[aarch64_ghc-hslua-module-doclayout.sha256sum] = "d8e2eebc972c69bbf31327d81c6846633ffe043b3fe02ff7d196150683208926"

URI_aarch64_ghc-hslua-module-doclayout-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-doclayout-devel-1.1.1.2-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-doclayout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-doclayout-devel}"
SRC_URI[aarch64_ghc-hslua-module-doclayout-devel.sha256sum] = "aa48c0860c8e0bf8d0f5aa39925d07caf4f1d9d5df3b2855aba28d6e4a5b2617"

URI_aarch64_ghc-hslua-module-doclayout-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-doclayout-doc-1.1.1.2-34.el10_1.noarch.rpm;name=aarch64_ghc-hslua-module-doclayout-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-doclayout-doc}"
SRC_URI[aarch64_ghc-hslua-module-doclayout-doc.sha256sum] = "c5827753d74e63301e331770f5cb1cf1d4c0dade6dd496f257eab5ce6a704c24"

URI_aarch64_ghc-hslua-module-doclayout-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-doclayout-prof-1.1.1.2-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-doclayout-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-doclayout-prof}"
SRC_URI[aarch64_ghc-hslua-module-doclayout-prof.sha256sum] = "177729207561e58664545ce6b427f79af915e7eb85c0d82d8a3c822889d469c9"

URI_aarch64_ghc-hslua-module-path = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-path-1.1.1-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-path;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-path}"
SRC_URI[aarch64_ghc-hslua-module-path.sha256sum] = "2c283178730f89356a714034fed93c4aa41a5458dd64ad79871ca6ceacfe7eff"

URI_aarch64_ghc-hslua-module-path-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-path-devel-1.1.1-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-path-devel}"
SRC_URI[aarch64_ghc-hslua-module-path-devel.sha256sum] = "e4db3cf2760045b20746823d70fc8a916692922353a1e505329aaac7bbbd074c"

URI_aarch64_ghc-hslua-module-path-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-path-doc-1.1.1-34.el10_1.noarch.rpm;name=aarch64_ghc-hslua-module-path-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-path-doc}"
SRC_URI[aarch64_ghc-hslua-module-path-doc.sha256sum] = "2c6844f4ba79e4f8b00299af43235f1d5716b66995635a5925d02c6979151fec"

URI_aarch64_ghc-hslua-module-path-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-path-prof-1.1.1-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-path-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-path-prof}"
SRC_URI[aarch64_ghc-hslua-module-path-prof.sha256sum] = "6c71309e835b9f581e0df46269663a01ccea25d9d87a553b2b8999962aa79213"

URI_aarch64_ghc-hslua-module-system = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-system-1.1.2-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-system;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-system}"
SRC_URI[aarch64_ghc-hslua-module-system.sha256sum] = "fa7a8f8a56480c6af8ab2d015ccffce96fa21b572d3f4316fa35a3a7343d7c91"

URI_aarch64_ghc-hslua-module-system-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-system-devel-1.1.2-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-system-devel}"
SRC_URI[aarch64_ghc-hslua-module-system-devel.sha256sum] = "f438685f015d3e110c0af7bd1a7a7247315fffa5e05cc666f2b628000580f9aa"

URI_aarch64_ghc-hslua-module-system-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-system-doc-1.1.2-34.el10_1.noarch.rpm;name=aarch64_ghc-hslua-module-system-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-system-doc}"
SRC_URI[aarch64_ghc-hslua-module-system-doc.sha256sum] = "88568d9ba696f0c18d30777792663404b705cccdc6a5debd2c611fbcad8c761a"

URI_aarch64_ghc-hslua-module-system-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-system-prof-1.1.2-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-system-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-system-prof}"
SRC_URI[aarch64_ghc-hslua-module-system-prof.sha256sum] = "3f8516e55684966f34a0d88126093002dc6785a5d5981359de7f36c8752eccd7"

URI_aarch64_ghc-hslua-module-version = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-version-1.1.1-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-version;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-version}"
SRC_URI[aarch64_ghc-hslua-module-version.sha256sum] = "a14daf4fdafa2572aa16963fa1acf66e1e87257ba9296ee7c4c951bf0d1b8782"

URI_aarch64_ghc-hslua-module-version-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-version-devel-1.1.1-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-version-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-version-devel}"
SRC_URI[aarch64_ghc-hslua-module-version-devel.sha256sum] = "529a77522a5983d5307e6920bfa85f871edb7e7f24782fda70d88f43a856371e"

URI_aarch64_ghc-hslua-module-version-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-version-doc-1.1.1-34.el10_1.noarch.rpm;name=aarch64_ghc-hslua-module-version-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-version-doc}"
SRC_URI[aarch64_ghc-hslua-module-version-doc.sha256sum] = "911095fb5503e8abbce1ff1fadc7d4f8ea9f49131a352257d0263e7eb0946088"

URI_aarch64_ghc-hslua-module-version-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-version-prof-1.1.1-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-version-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-version-prof}"
SRC_URI[aarch64_ghc-hslua-module-version-prof.sha256sum] = "26864344dc1af051c4ac95faf9aaed77f6ea11aedd8cfd098ee338af7e34d1cc"

URI_aarch64_ghc-hslua-module-zip = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-zip-1.1.3-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-zip}"
SRC_URI[aarch64_ghc-hslua-module-zip.sha256sum] = "d7b5f2c6eb6c8b69d1e1c70ee7c1a219a1a02cd82cf89dd2ee0ccababb0fdbe6"

URI_aarch64_ghc-hslua-module-zip-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-zip-devel-1.1.3-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-zip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-zip-devel}"
SRC_URI[aarch64_ghc-hslua-module-zip-devel.sha256sum] = "de31d881c5a11ce1a0653ae7d24a1e36d937151a365f9cb1ba62de95f5f9a0cf"

URI_aarch64_ghc-hslua-module-zip-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-zip-doc-1.1.3-34.el10_1.noarch.rpm;name=aarch64_ghc-hslua-module-zip-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-zip-doc}"
SRC_URI[aarch64_ghc-hslua-module-zip-doc.sha256sum] = "562a2941e8321ca8f11ee6590c6a0deab7bf0ddf25e8e13e74a6b00e56e1d1f4"

URI_aarch64_ghc-hslua-module-zip-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-zip-prof-1.1.3-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-module-zip-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-zip-prof}"
SRC_URI[aarch64_ghc-hslua-module-zip-prof.sha256sum] = "add768580d84b66809a0e34eb7b0f99bc9f60d052e9318d304842ffc6b257bb3"

URI_aarch64_ghc-hslua-repl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-repl-0.1.2-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-repl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-repl}"
SRC_URI[aarch64_ghc-hslua-repl.sha256sum] = "b49986d758706a81f72e3f24d99aa728fdd13a28a5ee3f626a6535eae9321126"

URI_aarch64_ghc-hslua-repl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-repl-devel-0.1.2-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-repl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-repl-devel}"
SRC_URI[aarch64_ghc-hslua-repl-devel.sha256sum] = "a40148554f1d1aca09d8d1d5b57ec8a0399d4f0751295784f6e570e4de674fb5"

URI_aarch64_ghc-hslua-repl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-repl-doc-0.1.2-34.el10_1.noarch.rpm;name=aarch64_ghc-hslua-repl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-repl-doc}"
SRC_URI[aarch64_ghc-hslua-repl-doc.sha256sum] = "89ed6b450bf8d3260415dfb55ca342096160e960563cbe5a8bdd82f30e1b30fd"

URI_aarch64_ghc-hslua-repl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-repl-prof-0.1.2-34.el10_1.aarch64.rpm;name=aarch64_ghc-hslua-repl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-repl-prof}"
SRC_URI[aarch64_ghc-hslua-repl-prof.sha256sum] = "1c12a6822ad58095e39c7f4e4e26887fa15561a1933a85f3231dfa10f32f7b0f"

URI_aarch64_ghc-lpeg = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lpeg-1.0.4-34.el10_1.aarch64.rpm;name=aarch64_ghc-lpeg;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lpeg}"
SRC_URI[aarch64_ghc-lpeg.sha256sum] = "73208ae1b740e08a284cf0f0e1efe5e8a7521ede7f5d6792952b0c526fb6ec96"

URI_aarch64_ghc-lpeg-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lpeg-devel-1.0.4-34.el10_1.aarch64.rpm;name=aarch64_ghc-lpeg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lpeg-devel}"
SRC_URI[aarch64_ghc-lpeg-devel.sha256sum] = "67963c795a9c925d6aa46b746908907950d301d9ed5811e8a75a5ce99b1d7bcc"

URI_aarch64_ghc-lpeg-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lpeg-doc-1.0.4-34.el10_1.noarch.rpm;name=aarch64_ghc-lpeg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lpeg-doc}"
SRC_URI[aarch64_ghc-lpeg-doc.sha256sum] = "632dad6d633e84dbbee23afd5ea19cfc0296665fe9d2737ecbdb913680db2e0e"

URI_aarch64_ghc-lpeg-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lpeg-prof-1.0.4-34.el10_1.aarch64.rpm;name=aarch64_ghc-lpeg-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lpeg-prof}"
SRC_URI[aarch64_ghc-lpeg-prof.sha256sum] = "5cec5dbb5b3856e7c99270bc02f7ebbc84369f51bde4ac66ceab1ce747ae382e"

URI_aarch64_ghc-pandoc-lua-engine = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-engine-0.2.1.2-34.el10_1.aarch64.rpm;name=aarch64_ghc-pandoc-lua-engine;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-engine}"
SRC_URI[aarch64_ghc-pandoc-lua-engine.sha256sum] = "77344ce987ad16306871cac6f8535ae0220c15325f5f0420bc23bc4e15b30cd2"

URI_aarch64_ghc-pandoc-lua-engine-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-engine-devel-0.2.1.2-34.el10_1.aarch64.rpm;name=aarch64_ghc-pandoc-lua-engine-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-engine-devel}"
SRC_URI[aarch64_ghc-pandoc-lua-engine-devel.sha256sum] = "c39e5e8e7529cc962e8559c0c894ef2cba1778f582f8527f361d868a201c3a44"

URI_aarch64_ghc-pandoc-lua-engine-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-engine-doc-0.2.1.2-34.el10_1.noarch.rpm;name=aarch64_ghc-pandoc-lua-engine-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-engine-doc}"
SRC_URI[aarch64_ghc-pandoc-lua-engine-doc.sha256sum] = "92283f20a5d68b192c1bfaa1d7578270258165926fa88d9b1fdd06465c6a898d"

URI_aarch64_ghc-pandoc-lua-engine-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-engine-prof-0.2.1.2-34.el10_1.aarch64.rpm;name=aarch64_ghc-pandoc-lua-engine-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-engine-prof}"
SRC_URI[aarch64_ghc-pandoc-lua-engine-prof.sha256sum] = "a256d0011dd5f418055c4ca1bd5c93ceed1ff386ee3d07226b2a50a01b067d6b"

URI_aarch64_ghc-pandoc-lua-marshal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-marshal-0.2.7.1-34.el10_1.aarch64.rpm;name=aarch64_ghc-pandoc-lua-marshal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-marshal}"
SRC_URI[aarch64_ghc-pandoc-lua-marshal.sha256sum] = "10912d763c99e973047ec4b13aca8812aee0bc27037a13a66957a4b5071689a6"

URI_aarch64_ghc-pandoc-lua-marshal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-marshal-devel-0.2.7.1-34.el10_1.aarch64.rpm;name=aarch64_ghc-pandoc-lua-marshal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-marshal-devel}"
SRC_URI[aarch64_ghc-pandoc-lua-marshal-devel.sha256sum] = "1e12c99891bdb80f5fea817975a6fed8a7daec0c51b4fb5aa4e3ea91219238bc"

URI_aarch64_ghc-pandoc-lua-marshal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-marshal-doc-0.2.7.1-34.el10_1.noarch.rpm;name=aarch64_ghc-pandoc-lua-marshal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-marshal-doc}"
SRC_URI[aarch64_ghc-pandoc-lua-marshal-doc.sha256sum] = "4cb14fe3a573e9593c0ec21792760c7a38bf4b97db794c86b02bca648b306367"

URI_aarch64_ghc-pandoc-lua-marshal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-marshal-prof-0.2.7.1-34.el10_1.aarch64.rpm;name=aarch64_ghc-pandoc-lua-marshal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-marshal-prof}"
SRC_URI[aarch64_ghc-pandoc-lua-marshal-prof.sha256sum] = "3c2b94a250a4bae0cd7a031616a44c60d80155f2ed9a53b61ba6dc3f2172bd52"

URI_aarch64_pandoc = "${EPEL_MIRROR}/aarch64/Packages/p/pandoc-3.1.11.1-34.el10_1.aarch64.rpm;name=aarch64_pandoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pandoc}"
SRC_URI[aarch64_pandoc.sha256sum] = "79c8b318a00868085e4b3f7ebc3c7b0bca34f2d1889f3c0efb5ed49906a5a9ef"

URI_aarch64_pandoc-pdf = "${EPEL_MIRROR}/aarch64/Packages/p/pandoc-pdf-3.1.11.1-34.el10_1.aarch64.rpm;name=aarch64_pandoc-pdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pandoc-pdf}"
SRC_URI[aarch64_pandoc-pdf.sha256sum] = "1bbb7214faeabd31b0a477d41a6f9988bce89bbb7dc93e051afaaf3dc4146afb"

RDEPENDS:ghc-hslua-cli = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-repl \
 ghc-isocline \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-cli-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-hslua-cli \
 ghc-hslua-core-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-repl-devel \
 ghc-lua-devel \
 ghc-text-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-hslua-cli-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-list = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-list-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-hslua-core-devel \
 ghc-hslua-list \
 "
RDEPENDS:ghc-hslua-list-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-doclayout = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-doclayout \
 ghc-emojis \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hslua \
 ghc-hslua-aeson \
 ghc-hslua-classes \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-lua \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-module-doclayout-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-doclayout-devel \
 ghc-hslua-devel \
 ghc-hslua-module-doclayout \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-module-doclayout-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-path = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-module-path-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-filepath-devel \
 ghc-hslua-core-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-module-path \
 ghc-hslua-packaging-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-module-path-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-system = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-random \
 ghc-splitmix \
 ghc-stm \
 ghc-template-haskell \
 ghc-temporary \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-module-system-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-hslua-core-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-module-system \
 ghc-hslua-packaging-devel \
 ghc-temporary-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-module-system-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-version = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-module-version-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-filepath-devel \
 ghc-hslua-core-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-module-version \
 ghc-hslua-packaging-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-module-version-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-zip = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-digest \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-list \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-zip-archive \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-hslua-module-zip-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-filepath-devel \
 ghc-hslua-core-devel \
 ghc-hslua-list-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-module-zip \
 ghc-hslua-packaging-devel \
 ghc-hslua-typing-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-zip-archive-devel \
 "
RDEPENDS:ghc-hslua-module-zip-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-repl = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-isocline \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-repl-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-hslua-core-devel \
 ghc-hslua-repl \
 ghc-isocline-devel \
 ghc-lua-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-repl-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-lpeg = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-lua \
 glibc \
 gmp \
 "
RDEPENDS:ghc-lpeg-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-lpeg \
 ghc-lua-devel \
 "
RDEPENDS:ghc-lpeg-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pandoc-lua-engine = " \
 ghc-Glob \
 ghc-JuicyPixels \
 ghc-OneTuple \
 ghc-Only \
 ghc-QuickCheck \
 ghc-SHA \
 ghc-StateVar \
 ghc-aeson \
 ghc-aeson-pretty \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base16-bytestring \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cassava \
 ghc-cereal \
 ghc-citeproc \
 ghc-colour \
 ghc-commonmark \
 ghc-commonmark-extensions \
 ghc-commonmark-pandoc \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-fix \
 ghc-deepseq \
 ghc-digest \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-doclayout \
 ghc-doctemplates \
 ghc-emojis \
 ghc-exceptions \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-gridtables \
 ghc-haddock-library \
 ghc-hashable \
 ghc-haskell-lexer \
 ghc-hourglass \
 ghc-hslua \
 ghc-hslua-aeson \
 ghc-hslua-classes \
 ghc-hslua-core \
 ghc-hslua-list \
 ghc-hslua-marshalling \
 ghc-hslua-module-doclayout \
 ghc-hslua-module-path \
 ghc-hslua-module-system \
 ghc-hslua-module-text \
 ghc-hslua-module-version \
 ghc-hslua-module-zip \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-repl \
 ghc-hslua-typing \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-ipynb \
 ghc-isocline \
 ghc-jira-wiki-markup \
 ghc-libyaml \
 ghc-lpeg \
 ghc-lua \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-ordered-containers \
 ghc-os-string \
 ghc-pandoc \
 ghc-pandoc-lua-marshal \
 ghc-pandoc-types \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-pretty-show \
 ghc-prettyprinter \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-regex-base \
 ghc-regex-tdfa \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-skylighting \
 ghc-skylighting-core \
 ghc-skylighting-format-ansi \
 ghc-skylighting-format-blaze-html \
 ghc-skylighting-format-context \
 ghc-skylighting-format-latex \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-syb \
 ghc-tagged \
 ghc-tagsoup \
 ghc-template-haskell \
 ghc-temporary \
 ghc-texmath \
 ghc-text \
 ghc-text-conversions \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-toml-parser \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-typst \
 ghc-typst-symbols \
 ghc-unicode-collation \
 ghc-unicode-data \
 ghc-unicode-transforms \
 ghc-uniplate \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-yaml \
 ghc-zip-archive \
 ghc-zlib \
 glibc \
 gmp \
 libyaml \
 zlib-ng-compat \
 "
RDEPENDS:ghc-pandoc-lua-engine-devel = " \
 ghc-SHA-devel \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-citeproc-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-data-default-devel \
 ghc-doclayout-devel \
 ghc-doctemplates-devel \
 ghc-exceptions-devel \
 ghc-hslua-devel \
 ghc-hslua-module-doclayout-devel \
 ghc-hslua-module-path-devel \
 ghc-hslua-module-system-devel \
 ghc-hslua-module-text-devel \
 ghc-hslua-module-version-devel \
 ghc-hslua-module-zip-devel \
 ghc-hslua-repl-devel \
 ghc-lpeg-devel \
 ghc-mtl-devel \
 ghc-pandoc-devel \
 ghc-pandoc-lua-engine \
 ghc-pandoc-lua-marshal-devel \
 ghc-pandoc-types-devel \
 ghc-parsec-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-pandoc-lua-engine-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pandoc-lua-marshal = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hslua \
 ghc-hslua-aeson \
 ghc-hslua-classes \
 ghc-hslua-core \
 ghc-hslua-list \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-lua \
 ghc-mtl \
 ghc-os-string \
 ghc-pandoc-types \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-syb \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-pandoc-lua-marshal-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-exceptions-devel \
 ghc-hslua-devel \
 ghc-hslua-list-devel \
 ghc-hslua-marshalling-devel \
 ghc-pandoc-lua-marshal \
 ghc-pandoc-types-devel \
 ghc-safe-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-pandoc-lua-marshal-doc = " \
 ghc-filesystem \
 "
RDEPENDS:pandoc = " \
 glibc \
 gmp \
 libffi \
 libyaml \
 pandoc-common \
 zlib-ng-compat \
 "
RDEPENDS:pandoc-pdf = " \
 pandoc \
 texlive-collection-latex \
 texlive-ec \
 "
RDEPENDS:ghc-hslua-cli-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-hslua-cli-devel \
 ghc-hslua-core-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-repl-prof \
 ghc-lua-prof \
 ghc-text-prof \
 ghc-unix-prof \
 "
RDEPENDS:ghc-hslua-list-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-hslua-core-prof \
 ghc-hslua-list-devel \
 "
RDEPENDS:ghc-hslua-module-doclayout-prof = " \
 ghc-base-prof \
 ghc-doclayout-prof \
 ghc-hslua-module-doclayout-devel \
 ghc-hslua-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-hslua-module-path-prof = " \
 ghc-base-prof \
 ghc-filepath-prof \
 ghc-hslua-core-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-module-path-devel \
 ghc-hslua-packaging-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-hslua-module-system-prof = " \
 ghc-base-prof \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-hslua-core-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-module-system-devel \
 ghc-hslua-packaging-prof \
 ghc-temporary-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-hslua-module-version-prof = " \
 ghc-base-prof \
 ghc-filepath-prof \
 ghc-hslua-core-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-module-version-devel \
 ghc-hslua-packaging-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-hslua-module-zip-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-filepath-prof \
 ghc-hslua-core-prof \
 ghc-hslua-list-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-module-zip-devel \
 ghc-hslua-packaging-prof \
 ghc-hslua-typing-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-zip-archive-prof \
 "
RDEPENDS:ghc-hslua-repl-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-hslua-core-prof \
 ghc-hslua-repl-devel \
 ghc-isocline-prof \
 ghc-lua-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-lpeg-prof = " \
 ghc-base-prof \
 ghc-lpeg-devel \
 ghc-lua-prof \
 "
RDEPENDS:ghc-pandoc-lua-engine-prof = " \
 ghc-SHA-prof \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-citeproc-prof \
 ghc-containers-prof \
 ghc-data-default-prof \
 ghc-doclayout-prof \
 ghc-doctemplates-prof \
 ghc-exceptions-prof \
 ghc-hslua-module-doclayout-prof \
 ghc-hslua-module-path-prof \
 ghc-hslua-module-system-prof \
 ghc-hslua-module-text-prof \
 ghc-hslua-module-version-prof \
 ghc-hslua-module-zip-prof \
 ghc-hslua-prof \
 ghc-hslua-repl-prof \
 ghc-lpeg-prof \
 ghc-mtl-prof \
 ghc-pandoc-lua-engine-devel \
 ghc-pandoc-lua-marshal-prof \
 ghc-pandoc-prof \
 ghc-pandoc-types-prof \
 ghc-parsec-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-pandoc-lua-marshal-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-exceptions-prof \
 ghc-hslua-list-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-prof \
 ghc-pandoc-lua-marshal-devel \
 ghc-pandoc-types-prof \
 ghc-safe-prof \
 ghc-text-prof \
 "
