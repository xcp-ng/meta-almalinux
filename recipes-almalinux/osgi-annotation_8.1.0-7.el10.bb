# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osgi-annotation"
PV = "8.1.0"
PR = "7.el10"
PACKAGES = " \
 osgi-annotation \
 osgi-annotation-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/osgi-annotation-8.1.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7b367f73b2b3f281a6279ac8eb222bfd1741b312a102c059e64f4e1780827e68"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/osgi-annotation-8.1.0-7.el10.noarch.rpm;name=x86_64_v2_osgi-annotation;unpack=0"
SRC_URI[x86_64_v2_osgi-annotation.sha256sum] = "b668b2921de2140bc744ea6570bb5f9a04b0be7d9bf4c4090963ea737184b34b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/osgi-annotation-javadoc-8.1.0-7.el10.noarch.rpm;name=x86_64_v2_osgi-annotation-javadoc;unpack=0"
SRC_URI[x86_64_v2_osgi-annotation-javadoc.sha256sum] = "ce307901ccb672ba0741e711d01c9d8617d3a16762e26985ed59850f346bbac8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/osgi-annotation-8.1.0-7.el10.noarch.rpm;name=aarch64_osgi-annotation;unpack=0"
SRC_URI[aarch64_osgi-annotation.sha256sum] = "b668b2921de2140bc744ea6570bb5f9a04b0be7d9bf4c4090963ea737184b34b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/osgi-annotation-javadoc-8.1.0-7.el10.noarch.rpm;name=aarch64_osgi-annotation-javadoc;unpack=0"
SRC_URI[aarch64_osgi-annotation-javadoc.sha256sum] = "ce307901ccb672ba0741e711d01c9d8617d3a16762e26985ed59850f346bbac8"

RDEPENDS:osgi-annotation = " \
 javapackages-filesystem \
 "
RDEPENDS:osgi-annotation-javadoc = " \
 javapackages-filesystem \
 "
