# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "calendarsupport"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 calendarsupport \
 calendarsupport-devel \
 calendarsupport-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/calendarsupport-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3e5fad1d7589c7c0a9c36fabee26aae0378879b1c18d633815a5ad5b8265655"

URI_x86_64_v2_calendarsupport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calendarsupport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calendarsupport}"
SRC_URI[x86_64_v2_calendarsupport.sha256sum] = "077009f04a472a28fed25f0f1af6c5f02af71921855ada8376c0dca7fdcf2640"

URI_x86_64_v2_calendarsupport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calendarsupport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calendarsupport-devel}"
SRC_URI[x86_64_v2_calendarsupport-devel.sha256sum] = "bc09ed858ed666cb378cdbfa6b751bd077af51955c302b664b0bb509931984a3"

URI_x86_64_v2_calendarsupport-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_calendarsupport-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calendarsupport-doc}"
SRC_URI[x86_64_v2_calendarsupport-doc.sha256sum] = "7757456f92f61c290586b1f4303503027d7d027e8c0f75761e81b045b6336d6e"

URI_aarch64_calendarsupport = "${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_calendarsupport;unpack=0"
SRC_URI:append = " ${URI_aarch64_calendarsupport}"
SRC_URI[aarch64_calendarsupport.sha256sum] = "1640544c23e1d2ead93149b354dc604ca689f70f9841301b2bca3bcc2d40e223"

URI_aarch64_calendarsupport-devel = "${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_calendarsupport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_calendarsupport-devel}"
SRC_URI[aarch64_calendarsupport-devel.sha256sum] = "f3f2e7cfb39bc2656ae2499a084a5767a9e72249dd45b434535d0a4a1556eff3"

URI_aarch64_calendarsupport-doc = "${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_calendarsupport-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_calendarsupport-doc}"
SRC_URI[aarch64_calendarsupport-doc.sha256sum] = "8df3ce803303ef764053b2e2c6d3d991a809c335ac20f53b26ad6377800f6781"

RDEPENDS:calendarsupport = " \
 akonadi-calendar \
 akonadi-server \
 glibc \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:calendarsupport-devel = " \
 akonadi-calendar-devel \
 calendarsupport \
 cmake-filesystem \
 kidentitymanagement-devel \
 kmime-devel \
 "
RDEPENDS:calendarsupport-doc = " \
 "
