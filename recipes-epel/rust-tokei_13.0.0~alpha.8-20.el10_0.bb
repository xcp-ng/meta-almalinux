# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokei"
PV = "13.0.0~alpha.8"
PR = "20.el10_0"
PACKAGES = " \
 rust-tokei+all-devel \
 rust-tokei+cbor-devel \
 rust-tokei+default-devel \
 rust-tokei+yaml-devel \
 rust-tokei-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokei-13.0.0~alpha.8-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04bd44d8e17ab4cbe649d9c8063f84a77971b7641a061e33684e1fe0da316d10"

URI_x86_64_v2_rust-tokei+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+all-devel-13.0.0~alpha.8-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+all-devel}"
SRC_URI[x86_64_v2_rust-tokei+all-devel.sha256sum] = "7caa08b7ae435ea1832bc7958d9800ed80d28870941d18dae1cc85ff484e95f2"

URI_x86_64_v2_rust-tokei+cbor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+cbor-devel-13.0.0~alpha.8-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+cbor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+cbor-devel}"
SRC_URI[x86_64_v2_rust-tokei+cbor-devel.sha256sum] = "fdfeede7a9c27d1ea99ffad7ccc5a55ef0a73078f10b52057e20f98d4c6742d4"

URI_x86_64_v2_rust-tokei+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+default-devel-13.0.0~alpha.8-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+default-devel}"
SRC_URI[x86_64_v2_rust-tokei+default-devel.sha256sum] = "2129b4e6a18a38a15b0c99af18aff655a936cce56837cd6d7f8d99458b6dde5c"

URI_x86_64_v2_rust-tokei+yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+yaml-devel-13.0.0~alpha.8-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+yaml-devel}"
SRC_URI[x86_64_v2_rust-tokei+yaml-devel.sha256sum] = "ad97aca68610c06ef225bbae025de6904b240a4ec310d79852acc9dbfa9b193a"

URI_x86_64_v2_rust-tokei-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei-devel-13.0.0~alpha.8-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei-devel}"
SRC_URI[x86_64_v2_rust-tokei-devel.sha256sum] = "cca611a376c2c29fcdd5e8c45414385e1148fba2ce384eab8bcfb5c7c0cba751"

URI_aarch64_rust-tokei+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+all-devel-13.0.0~alpha.8-20.el10_0.noarch.rpm;name=aarch64_rust-tokei+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+all-devel}"
SRC_URI[aarch64_rust-tokei+all-devel.sha256sum] = "acffbdb578153bbf9cc3f7861430421613508b38f5cd18173eeb06db3e3844cf"

URI_aarch64_rust-tokei+cbor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+cbor-devel-13.0.0~alpha.8-20.el10_0.noarch.rpm;name=aarch64_rust-tokei+cbor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+cbor-devel}"
SRC_URI[aarch64_rust-tokei+cbor-devel.sha256sum] = "8ec55c28f70e0d9ea96f92f9c57d6acecda72a8090a7274a1ce34d1c7edf7af9"

URI_aarch64_rust-tokei+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+default-devel-13.0.0~alpha.8-20.el10_0.noarch.rpm;name=aarch64_rust-tokei+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+default-devel}"
SRC_URI[aarch64_rust-tokei+default-devel.sha256sum] = "2bfe831da84ab6c439b9c4b632f3bd380c64054ac84bdaa7dda7798acfeee169"

URI_aarch64_rust-tokei+yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+yaml-devel-13.0.0~alpha.8-20.el10_0.noarch.rpm;name=aarch64_rust-tokei+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+yaml-devel}"
SRC_URI[aarch64_rust-tokei+yaml-devel.sha256sum] = "a47e005bbd7d335b5ffb3aa3c57aa9d63e87fc7b7c08b45f7fff8ce49c31ce84"

URI_aarch64_rust-tokei-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei-devel-13.0.0~alpha.8-20.el10_0.noarch.rpm;name=aarch64_rust-tokei-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei-devel}"
SRC_URI[aarch64_rust-tokei-devel.sha256sum] = "9572e217980b682098bf7e7636bc1c035b4277532c2b3e2962f3ac0043d84546"

RDEPENDS:rust-tokei+all-devel = " \
 cargo \
 rust-tokei+cbor-devel \
 rust-tokei+yaml-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei+cbor-devel = " \
 cargo \
 rust-hex+default-devel \
 rust-serde_cbor+default-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei+default-devel = " \
 cargo \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei+yaml-devel = " \
 cargo \
 rust-serde_yaml+default-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei-devel = " \
 cargo \
 rust \
 rust-aho-corasick+default-devel \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-clap+cargo-devel \
 rust-clap+default-devel \
 rust-clap+string-devel \
 rust-clap+wrap_help-devel \
 rust-colored2+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-dashmap+default-devel \
 rust-dashmap+serde-devel \
 rust-encoding_rs_io+default-devel \
 rust-env_logger+default-devel \
 rust-etcetera+default-devel \
 rust-grep-searcher+default-devel \
 rust-ignore+default-devel \
 rust-json5+default-devel \
 rust-log+default-devel \
 rust-num-format+default-devel \
 rust-once_cell+default-devel \
 rust-parking_lot+default-devel \
 rust-rayon+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde_json+default-devel \
 rust-table_formatter+default-devel \
 rust-tera+default-devel \
 rust-term_size+default-devel \
 rust-toml+default-devel \
 "
