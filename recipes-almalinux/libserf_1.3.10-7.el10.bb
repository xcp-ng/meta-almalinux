# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libserf"
PV = "1.3.10"
PR = "7.el10"
PACKAGES = " \
 libserf \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libserf-1.3.10-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bac70d704d12ac586dae80c64cf2cc8bd5390e9468df48a6904041f563fb336"

URI_x86_64_v2_libserf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libserf-1.3.10-7.el10.x86_64_v2.rpm;name=x86_64_v2_libserf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libserf}"
SRC_URI[x86_64_v2_libserf.sha256sum] = "19f23e6558b0018e600e5729ee8eab2846ca385504d3db26b3262150e0eaff0e"

URI_aarch64_libserf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libserf-1.3.10-7.el10.aarch64.rpm;name=aarch64_libserf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libserf}"
SRC_URI[aarch64_libserf.sha256sum] = "2c450b09c1c04d091159a40fd03fc4d91e5634053992a1632c6bb74974a77563"

RDEPENDS:libserf = " \
 apr \
 apr-util \
 glibc \
 krb5-libs \
 openssl-libs \
 zlib-ng-compat \
 "
