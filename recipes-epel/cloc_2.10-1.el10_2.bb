# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cloc"
PV = "2.10"
PR = "1.el10_2"
PACKAGES = " \
 cloc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cloc-2.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a26f428639989ddf21c19a94585a7509717102c9ac0fd868d63debf4d99c892"

URI_x86_64_v2_cloc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cloc-2.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_cloc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cloc}"
SRC_URI[x86_64_v2_cloc.sha256sum] = "2713101cc7fbc1338ba649a4cb271b78fefa340d467bb767f59ac7c15e54507a"

URI_aarch64_cloc = "${EPEL_MIRROR}/aarch64/Packages/c/cloc-2.10-1.el10_2.noarch.rpm;name=aarch64_cloc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cloc}"
SRC_URI[aarch64_cloc.sha256sum] = "0d2a00eca03b8ab1d259638dcf56e39ce4695ad4b3f0e58033e4342c3c1badb7"

RDEPENDS:cloc = " \
 perl-Algorithm-Diff \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Encode \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-POSIX \
 perl-Parallel-ForkManager \
 perl-PathTools \
 perl-Regexp-Common \
 perl-Scalar-List-Utils \
 perl-Text-Tabs+Wrap \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 "
