# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vcs-diff-lint"
PV = "6.7"
PR = "1.el10_1"
PACKAGES = " \
 vcs-diff-lint \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vcs-diff-lint-6.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5612248cd46b226f5f74acc71a6d37331bf92b678978ff842425dbb6275c96ae"

URI_x86_64_v2_vcs-diff-lint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vcs-diff-lint-6.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_vcs-diff-lint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vcs-diff-lint}"
SRC_URI[x86_64_v2_vcs-diff-lint.sha256sum] = "f464d2ca801e3f85f30b1a5f8ac99dc82cada1cf76f6c72bf7cd22db2a04e7da"

URI_aarch64_vcs-diff-lint = "${EPEL_MIRROR}/aarch64/Packages/v/vcs-diff-lint-6.7-1.el10_1.noarch.rpm;name=aarch64_vcs-diff-lint;unpack=0"
SRC_URI:append = " ${URI_aarch64_vcs-diff-lint}"
SRC_URI[aarch64_vcs-diff-lint.sha256sum] = "fc5cd3409062501934031119255c649eddf8fddd30238d25bd4db95e2788fa6d"

RDEPENDS:vcs-diff-lint = " \
 csdiff \
 git-core \
 python3 \
 "
