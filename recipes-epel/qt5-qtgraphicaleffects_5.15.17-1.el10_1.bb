# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtgraphicaleffects"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtgraphicaleffects \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtgraphicaleffects-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4e93ca0154ed1aac027afe9c6fdedaef69d13b05f8f5c1a0a2f69f11ac35724"

URI_x86_64_v2_qt5-qtgraphicaleffects = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgraphicaleffects-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtgraphicaleffects;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgraphicaleffects}"
SRC_URI[x86_64_v2_qt5-qtgraphicaleffects.sha256sum] = "0e3678a87cf4598afcab6cd7ad64a4776d97f8327029470a38a79b84d1d06e8f"

URI_aarch64_qt5-qtgraphicaleffects = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgraphicaleffects-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtgraphicaleffects;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgraphicaleffects}"
SRC_URI[aarch64_qt5-qtgraphicaleffects.sha256sum] = "92215cb381599d7cb8970fdbd4bd74a1591f1bc428fc60fdf3e26f7a6bc92de4"

RDEPENDS:qt5-qtgraphicaleffects = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
