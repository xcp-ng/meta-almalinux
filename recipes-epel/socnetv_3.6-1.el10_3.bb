# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "socnetv"
PV = "3.6"
PR = "1.el10_3"
PACKAGES = " \
 socnetv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/socnetv-3.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26d9c36e8b7b56bfba0708ba6dd814e38ca7e12c64dc5877d580db3c8eb5a060"

URI_x86_64_v2_socnetv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/socnetv-3.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_socnetv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_socnetv}"
SRC_URI[x86_64_v2_socnetv.sha256sum] = "99a5089f80e40abecb50841971147543c0476937ef73222df985be37a3230793"

URI_aarch64_socnetv = "${EPEL_MIRROR}/aarch64/Packages/s/socnetv-3.6-1.el10_3.aarch64.rpm;name=aarch64_socnetv;unpack=0"
SRC_URI:append = " ${URI_aarch64_socnetv}"
SRC_URI[aarch64_socnetv.sha256sum] = "cc9f1218557bbe2b116711d11ecf9f0f2a5ad62571e8a9aba9644d6a78459305"

RDEPENDS:socnetv = " \
 bash \
 glibc \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtsvg \
 "
