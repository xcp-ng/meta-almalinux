# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-cop"
PV = "0.3"
PR = "30.el10"
PACKAGES = " \
 hunspell-cop \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-cop-0.3-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69b181a6eb685ef164e51035414fe02babc72fb83f7c4deeb9b2779c2770ee06"

URI_x86_64_v2_hunspell-cop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-cop-0.3-30.el10.noarch.rpm;name=x86_64_v2_hunspell-cop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-cop}"
SRC_URI[x86_64_v2_hunspell-cop.sha256sum] = "78a87fcca71d2e124ea8d4c2bbeec0cfaee5e39397265cb6c022aebaf902bbfa"

URI_aarch64_hunspell-cop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-cop-0.3-30.el10.noarch.rpm;name=aarch64_hunspell-cop;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-cop}"
SRC_URI[aarch64_hunspell-cop.sha256sum] = "78a87fcca71d2e124ea8d4c2bbeec0cfaee5e39397265cb6c022aebaf902bbfa"

RDEPENDS:hunspell-cop = " \
 hunspell-filesystem \
 "
