# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rancor"
PV = "0.1.1"
PR = "3.el10_1"
PACKAGES = " \
 rust-rancor+alloc-devel \
 rust-rancor+default-devel \
 rust-rancor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rancor-0.1.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe1ebaf540d34d8b7865a6f19e4ccd57211ce6bc3471ebe9af78d3f5f2c7d1cc"

URI_x86_64_v2_rust-rancor+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rancor+alloc-devel-0.1.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rancor+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rancor+alloc-devel}"
SRC_URI[x86_64_v2_rust-rancor+alloc-devel.sha256sum] = "25a13d16af57a3880a838b36b14b9b528d79399b97dd28954043577b7453317a"

URI_x86_64_v2_rust-rancor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rancor+default-devel-0.1.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rancor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rancor+default-devel}"
SRC_URI[x86_64_v2_rust-rancor+default-devel.sha256sum] = "9f41d12db2ff1b58f1cb256846798c7a27eb9911ace9c203536fd9a7f5138c5b"

URI_x86_64_v2_rust-rancor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rancor-devel-0.1.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rancor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rancor-devel}"
SRC_URI[x86_64_v2_rust-rancor-devel.sha256sum] = "420e741ca7cffc31a0b91fe6621438e7f6a3dd2f6d39407799e25192bfb36098"

URI_aarch64_rust-rancor+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rancor+alloc-devel-0.1.1-3.el10_1.noarch.rpm;name=aarch64_rust-rancor+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rancor+alloc-devel}"
SRC_URI[aarch64_rust-rancor+alloc-devel.sha256sum] = "7244a9955ecf67bdf00a3ac5a46bbe770ebc4ed71d033c5681b7401dfa53a025"

URI_aarch64_rust-rancor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rancor+default-devel-0.1.1-3.el10_1.noarch.rpm;name=aarch64_rust-rancor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rancor+default-devel}"
SRC_URI[aarch64_rust-rancor+default-devel.sha256sum] = "1511cd7add3ea857d7135aca425f622da11d8a3edb2e3c4a551a318e912a8090"

URI_aarch64_rust-rancor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rancor-devel-0.1.1-3.el10_1.noarch.rpm;name=aarch64_rust-rancor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rancor-devel}"
SRC_URI[aarch64_rust-rancor-devel.sha256sum] = "a78c510b3dde315525cb517ee2166bd02baa327dae65467a0cc897fee20eee11"

RDEPENDS:rust-rancor+alloc-devel = " \
 cargo \
 rust-rancor-devel \
 "
RDEPENDS:rust-rancor+default-devel = " \
 cargo \
 rust-rancor+alloc-devel \
 rust-rancor-devel \
 "
RDEPENDS:rust-rancor-devel = " \
 cargo \
 rust \
 rust-ptr_meta+derive-devel \
 rust-ptr_meta-devel \
 "
