# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnutls"
PV = "3.8.9"
PR = "9.el10_0.14"
PACKAGES = " \
 gnutls \
 gnutls-c++ \
 gnutls-dane \
 gnutls-devel \
 gnutls-fips \
 gnutls-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gnutls-3.8.9-9.el10_0.14.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e4b539d7faa9859b0e56a17dc13e1c6acb1063f0a7f767fe1d9b02e2abc795f"

URI_x86_64_v2_gnutls = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gnutls-3.8.9-9.el10_0.14.x86_64_v2.rpm;name=x86_64_v2_gnutls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls}"
SRC_URI[x86_64_v2_gnutls.sha256sum] = "d22a2cc124b117ccd1b4f381a1c3713b0b8033cf9853d0d848b90b200d3d427a"

URI_x86_64_v2_gnutls-c++ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-c++-3.8.9-9.el10_0.14.x86_64_v2.rpm;name=x86_64_v2_gnutls-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-c++}"
SRC_URI[x86_64_v2_gnutls-c++.sha256sum] = "211d6a9bfb399bbf85c96ecb36fd2d4a49cb1023b5bce96942b9de75fdc01730"

URI_x86_64_v2_gnutls-dane = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-dane-3.8.9-9.el10_0.14.x86_64_v2.rpm;name=x86_64_v2_gnutls-dane;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-dane}"
SRC_URI[x86_64_v2_gnutls-dane.sha256sum] = "dabe94a9ed2b17e6f2bc4174b0f34edcabe876a4904ecca4b117f4cd76db5885"

URI_x86_64_v2_gnutls-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-devel-3.8.9-9.el10_0.14.x86_64_v2.rpm;name=x86_64_v2_gnutls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-devel}"
SRC_URI[x86_64_v2_gnutls-devel.sha256sum] = "b45d7b48942fa423fa2ab542af892798a658cd4110024600d72276795b85f1de"

URI_x86_64_v2_gnutls-fips = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-fips-3.8.9-9.el10_0.14.x86_64_v2.rpm;name=x86_64_v2_gnutls-fips;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-fips}"
SRC_URI[x86_64_v2_gnutls-fips.sha256sum] = "c16b09f98843719af018143e61e4e3a6b5c801db27185b57135ceec8ad968758"

URI_x86_64_v2_gnutls-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-utils-3.8.9-9.el10_0.14.x86_64_v2.rpm;name=x86_64_v2_gnutls-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-utils}"
SRC_URI[x86_64_v2_gnutls-utils.sha256sum] = "7cf0611dcf1920e97c97c8df2387b72d10dc066ccf3a1b8beb48393bfaf9a19d"

URI_aarch64_gnutls = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gnutls-3.8.9-9.el10_0.14.aarch64.rpm;name=aarch64_gnutls;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls}"
SRC_URI[aarch64_gnutls.sha256sum] = "9ef6650a67b05089682806e1c01e9b8548e3e9ecc25e44acc12e4ba865457565"

URI_aarch64_gnutls-c++ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-c++-3.8.9-9.el10_0.14.aarch64.rpm;name=aarch64_gnutls-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-c++}"
SRC_URI[aarch64_gnutls-c++.sha256sum] = "6a8e134ff651cde22089738b3f98081abfb218004b516862e117bae6680a41c5"

URI_aarch64_gnutls-dane = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-dane-3.8.9-9.el10_0.14.aarch64.rpm;name=aarch64_gnutls-dane;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-dane}"
SRC_URI[aarch64_gnutls-dane.sha256sum] = "4641bd6a315e682d723870cf20aedfc6b5b0fe64e899087655e6b0e85c9161fa"

URI_aarch64_gnutls-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-devel-3.8.9-9.el10_0.14.aarch64.rpm;name=aarch64_gnutls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-devel}"
SRC_URI[aarch64_gnutls-devel.sha256sum] = "620ffbcca116fd769bca7a04cf9e477734bb3e7a5105c324f8fc684e2418e52e"

URI_aarch64_gnutls-fips = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-fips-3.8.9-9.el10_0.14.aarch64.rpm;name=aarch64_gnutls-fips;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-fips}"
SRC_URI[aarch64_gnutls-fips.sha256sum] = "1567a9a6159d9df2123ac962bf98ab775e02a77dfa0a3a4c3a456692492db1e0"

URI_aarch64_gnutls-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-utils-3.8.9-9.el10_0.14.aarch64.rpm;name=aarch64_gnutls-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-utils}"
SRC_URI[aarch64_gnutls-utils.sha256sum] = "be396d666efbe188c4d89682341bca4f5c22d9ae1a299d8d7e4810f7cd873cc3"

RDEPENDS:gnutls = " \
 crypto-policies \
 glibc \
 libidn2 \
 libtasn1 \
 libunistring \
 p11-kit \
 p11-kit-trust \
 "
RDEPENDS:gnutls-c++ = " \
 glibc \
 gnutls \
 libgcc \
 libidn2 \
 libstdc++ \
 libtasn1 \
 libunistring \
 p11-kit \
 "
RDEPENDS:gnutls-dane = " \
 glibc \
 gnutls \
 libidn2 \
 libtasn1 \
 libunistring \
 p11-kit \
 unbound-libs \
 "
RDEPENDS:gnutls-devel = " \
 gnutls \
 gnutls-c++ \
 gnutls-dane \
 gnutls-devel \
 libidn2-devel \
 libtasn1-devel \
 p11-kit-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gnutls-fips = " \
 gnutls \
 "
RDEPENDS:gnutls-utils = " \
 glibc \
 gnutls \
 gnutls-dane \
 libtasn1 \
 "
