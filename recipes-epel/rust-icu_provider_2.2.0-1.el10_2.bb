# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_provider"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_provider+alloc-devel \
 rust-icu_provider+baked-devel \
 rust-icu_provider+default-devel \
 rust-icu_provider+deserialize_bincode_1-devel \
 rust-icu_provider+deserialize_json-devel \
 rust-icu_provider+deserialize_postcard_1-devel \
 rust-icu_provider+export-devel \
 rust-icu_provider+logging-devel \
 rust-icu_provider+serde-devel \
 rust-icu_provider+std-devel \
 rust-icu_provider+sync-devel \
 rust-icu_provider+zerotrie-devel \
 rust-icu_provider-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_provider-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb54842f9f2a9da66f9859e9fa92341b83d565f317d59c0e8f1f427de042a7e9"

URI_x86_64_v2_rust-icu_provider+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+alloc-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+alloc-devel.sha256sum] = "381a78f0d8ae6368fd059eee6c817d1dbc2bac3c6c11296554fb08ed443a3c2e"

URI_x86_64_v2_rust-icu_provider+baked-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+baked-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+baked-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+baked-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+baked-devel.sha256sum] = "6a050c133bfa3f391a26b51489c03cbb7bc3b3b3fa712aa29f88c1fdb9cc86a4"

URI_x86_64_v2_rust-icu_provider+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+default-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+default-devel.sha256sum] = "9695f11ad893912632e36ac8885afe277d051aaa7481762b1abbccc09bcf28aa"

URI_x86_64_v2_rust-icu_provider+deserialize_bincode_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+deserialize_bincode_1-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+deserialize_bincode_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+deserialize_bincode_1-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+deserialize_bincode_1-devel.sha256sum] = "5bb986ddf470d12b1b09c89c2d08466245ba9ae58e31e54a215cfa30e1b5f337"

URI_x86_64_v2_rust-icu_provider+deserialize_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+deserialize_json-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+deserialize_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+deserialize_json-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+deserialize_json-devel.sha256sum] = "96b752ccddf7edf5d597aeb40b119087fb5cee66dbbfdd3264a26ef462fd8f46"

URI_x86_64_v2_rust-icu_provider+deserialize_postcard_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+deserialize_postcard_1-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+deserialize_postcard_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+deserialize_postcard_1-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+deserialize_postcard_1-devel.sha256sum] = "45b3725b4c96dc485c402c0becbdbd0357e07c9424de543709dde411932ed678"

URI_x86_64_v2_rust-icu_provider+export-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+export-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+export-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+export-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+export-devel.sha256sum] = "93386b8700c6978abe88b8c8f1048e6f67fd31b9df541fd148d4f57dbd86eaf0"

URI_x86_64_v2_rust-icu_provider+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+logging-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+logging-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+logging-devel.sha256sum] = "41063c9c10eba3b019106e07a1a030fa56ba2ba6a2ad413473f2932967cfc4f1"

URI_x86_64_v2_rust-icu_provider+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+serde-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+serde-devel.sha256sum] = "0ebc20f92da5a56f46cd8280fd2a515ba8434ab2308332d4901dd29bbcb6f20c"

URI_x86_64_v2_rust-icu_provider+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+std-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+std-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+std-devel.sha256sum] = "4eba746e27a7368f03f5f6ffef9b132fea365a7a707cac0a401b14f230998a20"

URI_x86_64_v2_rust-icu_provider+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+sync-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+sync-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+sync-devel.sha256sum] = "de675c15ec8685f488ba00b83cda0b36023932ebdbfcf98d42317e3b1ecfd03f"

URI_x86_64_v2_rust-icu_provider+zerotrie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+zerotrie-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+zerotrie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+zerotrie-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+zerotrie-devel.sha256sum] = "760fd2a1b4aa616f936c5a34238ce518e68d8fb7c0661e168f2764f61f44c652"

URI_x86_64_v2_rust-icu_provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider-devel}"
SRC_URI[x86_64_v2_rust-icu_provider-devel.sha256sum] = "6d1c9b33ba413d04d517ef6fe6c7fa17dbb28a8fa94383b67be1fb8360e8e0ea"

URI_aarch64_rust-icu_provider+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+alloc-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_provider+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+alloc-devel}"
SRC_URI[aarch64_rust-icu_provider+alloc-devel.sha256sum] = "6b11a500cdab9406fb1e91955cb69c7bb90913cf746dd50105ba0bcc3295d41d"

URI_aarch64_rust-icu_provider+baked-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+baked-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_provider+baked-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+baked-devel}"
SRC_URI[aarch64_rust-icu_provider+baked-devel.sha256sum] = "57387c0451ee1b34cb359e0b1ae9df44f3a4de2917a803084acc72269420dc7d"

URI_aarch64_rust-icu_provider+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_provider+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+default-devel}"
SRC_URI[aarch64_rust-icu_provider+default-devel.sha256sum] = "897c0e81031d9a7b832bb36b60748ca5c66104e4c3aca6453d7ab63ecaf2d909"

URI_aarch64_rust-icu_provider+deserialize_bincode_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+deserialize_bincode_1-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_provider+deserialize_bincode_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+deserialize_bincode_1-devel}"
SRC_URI[aarch64_rust-icu_provider+deserialize_bincode_1-devel.sha256sum] = "d516b6e8732ca3d65a84276a11714c367dd5d8765a99c541592d77bafd743c8c"

URI_aarch64_rust-icu_provider+deserialize_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+deserialize_json-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_provider+deserialize_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+deserialize_json-devel}"
SRC_URI[aarch64_rust-icu_provider+deserialize_json-devel.sha256sum] = "13152ee230fa5548a1b018c3f1a5e5b1f1700e96b1ab5edf69bf12106bbab389"

URI_aarch64_rust-icu_provider+deserialize_postcard_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+deserialize_postcard_1-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_provider+deserialize_postcard_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+deserialize_postcard_1-devel}"
SRC_URI[aarch64_rust-icu_provider+deserialize_postcard_1-devel.sha256sum] = "ccfa6d013c6f804fd14452756ef2b7ad822cb847926a956a0f821153dd3b3469"

URI_aarch64_rust-icu_provider+export-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+export-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_provider+export-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+export-devel}"
SRC_URI[aarch64_rust-icu_provider+export-devel.sha256sum] = "8f3bb1dbf6ee6abec93c441cf8d7453a3b8498263bca2567d7c0769cd1380434"

URI_aarch64_rust-icu_provider+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+logging-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_provider+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+logging-devel}"
SRC_URI[aarch64_rust-icu_provider+logging-devel.sha256sum] = "4c28175a3565b669e7823c76f166bdcefb21eef03082ad458b1cb5431ab24758"

URI_aarch64_rust-icu_provider+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+serde-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_provider+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+serde-devel}"
SRC_URI[aarch64_rust-icu_provider+serde-devel.sha256sum] = "1fdf30a68607bdc355ceac36b37acd5f38c502515a6ad41bb22b7fcd60a2647e"

URI_aarch64_rust-icu_provider+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+std-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_provider+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+std-devel}"
SRC_URI[aarch64_rust-icu_provider+std-devel.sha256sum] = "94b0ffcaef396f247222fb6b3923777f8a81503ef795377d00d1ae977a2a1ba8"

URI_aarch64_rust-icu_provider+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+sync-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_provider+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+sync-devel}"
SRC_URI[aarch64_rust-icu_provider+sync-devel.sha256sum] = "14eaa5eccfae8a276eff97c100acf57ffad570136da5f08934aca0415f3fa7b0"

URI_aarch64_rust-icu_provider+zerotrie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+zerotrie-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_provider+zerotrie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+zerotrie-devel}"
SRC_URI[aarch64_rust-icu_provider+zerotrie-devel.sha256sum] = "cea10309a8237a0e8af70ba1eb67b5b7fad181663c9bac4cba4c0b00a8c6883a"

URI_aarch64_rust-icu_provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider-devel}"
SRC_URI[aarch64_rust-icu_provider-devel.sha256sum] = "996a5062b3e3ef3e8c375c600e67dabfbe414f5f01d1fa8c74829141f2fc6e16"

RDEPENDS:rust-icu_provider+alloc-devel = " \
 cargo \
 rust-icu_locale_core+alloc-devel \
 rust-icu_provider-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-stable_deref_trait-devel \
 rust-writeable-devel \
 rust-yoke+alloc-devel \
 rust-zerofrom+alloc-devel \
 rust-zerotrie+alloc-devel \
 rust-zerotrie-devel \
 rust-zerovec+alloc-devel \
 "
RDEPENDS:rust-icu_provider+baked-devel = " \
 cargo \
 rust-icu_provider-devel \
 rust-writeable-devel \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-icu_provider+default-devel = " \
 cargo \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider+deserialize_bincode_1-devel = " \
 cargo \
 rust-bincode1+default-devel \
 rust-icu_provider+serde-devel \
 rust-icu_provider+std-devel \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider+deserialize_json-devel = " \
 cargo \
 rust-icu_provider+serde-devel \
 rust-icu_provider-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-icu_provider+deserialize_postcard_1-devel = " \
 cargo \
 rust-icu_provider+serde-devel \
 rust-icu_provider-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-icu_provider+export-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-erased-serde+default-devel \
 rust-icu_provider+serde-devel \
 rust-icu_provider+std-devel \
 rust-icu_provider+sync-devel \
 rust-icu_provider-devel \
 rust-postcard-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_provider+logging-devel = " \
 cargo \
 rust-icu_provider-devel \
 rust-log-devel \
 "
RDEPENDS:rust-icu_provider+serde-devel = " \
 cargo \
 rust-icu_provider-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-yoke+serde-devel \
 "
RDEPENDS:rust-icu_provider+std-devel = " \
 cargo \
 rust-icu_provider+alloc-devel \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider+sync-devel = " \
 cargo \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider+zerotrie-devel = " \
 cargo \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-icu_locale_core-devel \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 rust-zerovec+derive-devel \
 rust-zerovec-devel \
 "
