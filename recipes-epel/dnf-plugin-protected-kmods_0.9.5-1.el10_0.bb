# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf-plugin-protected-kmods"
PV = "0.9.5"
PR = "1.el10_0"
PACKAGES = " \
 python3-dnf-plugin-protected-kmods \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dnf-plugin-protected-kmods-0.9.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5b2879576c81c06f03e9e7dc8821b524d9bb09f5e720fa3f546314831962a27"

URI_x86_64_v2_python3-dnf-plugin-protected-kmods = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dnf-plugin-protected-kmods-0.9.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-protected-kmods;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-protected-kmods}"
SRC_URI[x86_64_v2_python3-dnf-plugin-protected-kmods.sha256sum] = "c007965773bf7f9bf5f43a0699f0c1f9bb7647da8b524096a746a056a349cafc"

URI_aarch64_python3-dnf-plugin-protected-kmods = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dnf-plugin-protected-kmods-0.9.5-1.el10_0.noarch.rpm;name=aarch64_python3-dnf-plugin-protected-kmods;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-protected-kmods}"
SRC_URI[aarch64_python3-dnf-plugin-protected-kmods.sha256sum] = "afe0415caa5548532f63dc1e5f702c21627f4a0735415023af14f1b42cbf9506"

RDEPENDS:python3-dnf-plugin-protected-kmods = " \
 python3 \
 python3-dnf \
 "
