# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-segmentation"
PV = "1.13.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-unicode-segmentation+default-devel \
 rust-unicode-segmentation+no_std-devel \
 rust-unicode-segmentation-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-segmentation-1.13.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "489c0c2f45ab801e8b190141ed035b93bb90f38f44ae8bc386005e97873b8289"

URI_x86_64_v2_rust-unicode-segmentation+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-segmentation+default-devel-1.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-segmentation+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-segmentation+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-segmentation+default-devel.sha256sum] = "326a0875d2ff5dfaeea3406d1e1fb3d9e9c84ac594345002e3bf806930970f47"

URI_x86_64_v2_rust-unicode-segmentation+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-segmentation+no_std-devel-1.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-segmentation+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-segmentation+no_std-devel}"
SRC_URI[x86_64_v2_rust-unicode-segmentation+no_std-devel.sha256sum] = "59ddf9e2274e3108df9227602432f9bc91db49e639b84bf3d3690c7134c01934"

URI_x86_64_v2_rust-unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-segmentation-devel-1.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-unicode-segmentation-devel.sha256sum] = "efcbda4384600b35a630bc9b84dd3c6dcf6d83a303f6f09ec491b0ff3a0b9d92"

URI_aarch64_rust-unicode-segmentation+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-segmentation+default-devel-1.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-unicode-segmentation+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-segmentation+default-devel}"
SRC_URI[aarch64_rust-unicode-segmentation+default-devel.sha256sum] = "73c3d6e0f20c6d13986dc670091f292612ed1c8628952d5e31fa0608dbfaa4c0"

URI_aarch64_rust-unicode-segmentation+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-segmentation+no_std-devel-1.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-unicode-segmentation+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-segmentation+no_std-devel}"
SRC_URI[aarch64_rust-unicode-segmentation+no_std-devel.sha256sum] = "971254971b94ad2b1253e90de46f3ce079a1272c6bc73d667aaf24aa20e590de"

URI_aarch64_rust-unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-segmentation-devel-1.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-segmentation-devel}"
SRC_URI[aarch64_rust-unicode-segmentation-devel.sha256sum] = "0b1657eaed1fab7fb7869483bfc50564dedf4b823f4cb37c29c69b9f5215c07e"

RDEPENDS:rust-unicode-segmentation+default-devel = " \
 cargo \
 rust-unicode-segmentation-devel \
 "
RDEPENDS:rust-unicode-segmentation+no_std-devel = " \
 cargo \
 rust-unicode-segmentation-devel \
 "
RDEPENDS:rust-unicode-segmentation-devel = " \
 cargo \
 rust \
 "
