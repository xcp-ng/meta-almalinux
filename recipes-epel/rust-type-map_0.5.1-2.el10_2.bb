# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-type-map"
PV = "0.5.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-type-map+default-devel \
 rust-type-map-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-type-map-0.5.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd1ec8f2b3c7b375a9d6b0140568293525bbfee0568434803fa0c3270422885d"

URI_x86_64_v2_rust-type-map+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-type-map+default-devel-0.5.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-type-map+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-type-map+default-devel}"
SRC_URI[x86_64_v2_rust-type-map+default-devel.sha256sum] = "4c7d79092f770eb765ec9924acedeaa1c17f703adc2f6105758faebb4238d5e1"

URI_x86_64_v2_rust-type-map-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-type-map-devel-0.5.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-type-map-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-type-map-devel}"
SRC_URI[x86_64_v2_rust-type-map-devel.sha256sum] = "dc2d4fc1bd7b0721db0f3ced23cd6c744c436f75aa0c01e56fe5945cecf702eb"

URI_aarch64_rust-type-map+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-type-map+default-devel-0.5.1-2.el10_2.noarch.rpm;name=aarch64_rust-type-map+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-type-map+default-devel}"
SRC_URI[aarch64_rust-type-map+default-devel.sha256sum] = "ef17e82f5ae6295e71137262c25340cea5756c693986ac71e44b5bbd7bd9dedf"

URI_aarch64_rust-type-map-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-type-map-devel-0.5.1-2.el10_2.noarch.rpm;name=aarch64_rust-type-map-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-type-map-devel}"
SRC_URI[aarch64_rust-type-map-devel.sha256sum] = "28ebfd15e3f8b461a01dbe06180f1b5bac49181a9bbb08f26b1818894df63fb7"

RDEPENDS:rust-type-map+default-devel = " \
 cargo \
 rust-type-map-devel \
 "
RDEPENDS:rust-type-map-devel = " \
 cargo \
 rust-rustc-hash+default-devel \
 "
