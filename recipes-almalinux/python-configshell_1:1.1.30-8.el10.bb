# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-configshell"
PE = "1"
PV = "1.1.30"
PR = "8.el10"
PACKAGES = " \
 python3-configshell \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-configshell-1.1.30-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d6ca8fdf255b188a4a2f462cf521973a43cbcfb99a490c4951affe3b0755724"

URI_x86_64_v2_python3-configshell = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-configshell-1.1.30-8.el10.noarch.rpm;name=x86_64_v2_python3-configshell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-configshell}"
SRC_URI[x86_64_v2_python3-configshell.sha256sum] = "66a0f41a116b4f4cb57cb2fa997926feca1be67494433e9c1485c3460e71d4a5"

URI_aarch64_python3-configshell = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-configshell-1.1.30-8.el10.noarch.rpm;name=aarch64_python3-configshell;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-configshell}"
SRC_URI[aarch64_python3-configshell.sha256sum] = "66a0f41a116b4f4cb57cb2fa997926feca1be67494433e9c1485c3460e71d4a5"

RDEPENDS:python3-configshell = " \
 python3 \
 python3-pyparsing \
 python3-six \
 python3-urwid \
 "
