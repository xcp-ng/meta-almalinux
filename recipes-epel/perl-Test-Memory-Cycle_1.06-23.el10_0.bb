# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Memory-Cycle"
PV = "1.06"
PR = "23.el10_0"
PACKAGES = " \
 perl-Test-Memory-Cycle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-Memory-Cycle-1.06-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41ca66613aa3130f7540ac4c718e2a019c40a1d9131b676a4efa1b9f8235dfeb"

URI_x86_64_v2_perl-Test-Memory-Cycle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Memory-Cycle-1.06-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Memory-Cycle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Memory-Cycle}"
SRC_URI[x86_64_v2_perl-Test-Memory-Cycle.sha256sum] = "cd8ee40657908335e2b532556a000e10534fc9c0dbbe43028ea2115109a00ff7"

URI_aarch64_perl-Test-Memory-Cycle = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Memory-Cycle-1.06-23.el10_0.noarch.rpm;name=aarch64_perl-Test-Memory-Cycle;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Memory-Cycle}"
SRC_URI[aarch64_perl-Test-Memory-Cycle.sha256sum] = "0d6848e9ecd98471c742211a7a4e22b34e439a0536aee023a41293ca1127f100"

RDEPENDS:perl-Test-Memory-Cycle = " \
 perl-Devel-Cycle \
 perl-Test-Simple \
 perl-libs \
 "
