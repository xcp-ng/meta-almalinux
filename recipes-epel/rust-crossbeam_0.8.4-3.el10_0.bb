# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam"
PV = "0.8.4"
PR = "3.el10_0"
PACKAGES = " \
 rust-crossbeam+alloc-devel \
 rust-crossbeam+crossbeam-channel-devel \
 rust-crossbeam+crossbeam-deque-devel \
 rust-crossbeam+crossbeam-epoch-devel \
 rust-crossbeam+crossbeam-queue-devel \
 rust-crossbeam+default-devel \
 rust-crossbeam+nightly-devel \
 rust-crossbeam+std-devel \
 rust-crossbeam-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-0.8.4-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32fd0265c984b4769665ad70084119c8c60b64a860f2781795ac461e8a885e99"

URI_x86_64_v2_rust-crossbeam+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+alloc-devel-0.8.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam+alloc-devel}"
SRC_URI[x86_64_v2_rust-crossbeam+alloc-devel.sha256sum] = "4ffa186dc79b0294557ead03c4e4ac6495cfe01f07449749dbe2745e6a42a77a"

URI_x86_64_v2_rust-crossbeam+crossbeam-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+crossbeam-channel-devel-0.8.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam+crossbeam-channel-devel}"
SRC_URI[x86_64_v2_rust-crossbeam+crossbeam-channel-devel.sha256sum] = "98f503b30322c6a42228ee4836f03621819d9c753e56b569efa2d5f8c5904b9d"

URI_x86_64_v2_rust-crossbeam+crossbeam-deque-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+crossbeam-deque-devel-0.8.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+crossbeam-deque-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam+crossbeam-deque-devel}"
SRC_URI[x86_64_v2_rust-crossbeam+crossbeam-deque-devel.sha256sum] = "ab17e6c08234004f60565bc740664e4c90df230c4ddc7675bbfa6f3f1ef9ce21"

URI_x86_64_v2_rust-crossbeam+crossbeam-epoch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+crossbeam-epoch-devel-0.8.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+crossbeam-epoch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam+crossbeam-epoch-devel}"
SRC_URI[x86_64_v2_rust-crossbeam+crossbeam-epoch-devel.sha256sum] = "83c6c90b3b867e38ca6062a525ad25eb16e22a9db7fd9741545657fc7ca0203f"

URI_x86_64_v2_rust-crossbeam+crossbeam-queue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+crossbeam-queue-devel-0.8.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+crossbeam-queue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam+crossbeam-queue-devel}"
SRC_URI[x86_64_v2_rust-crossbeam+crossbeam-queue-devel.sha256sum] = "994583a7b5b339d7b216f89777836ffaecdebc2959ddfee2dd4ae807e34c1508"

URI_x86_64_v2_rust-crossbeam+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+default-devel-0.8.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam+default-devel.sha256sum] = "ec207a8b1d13c31a159488a3866d0e569ca33c4d87db1cc9f022a0237da3c859"

URI_x86_64_v2_rust-crossbeam+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+nightly-devel-0.8.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam+nightly-devel}"
SRC_URI[x86_64_v2_rust-crossbeam+nightly-devel.sha256sum] = "392cf9bc5c5592a58d01929c978bfe4a930d7caec06f0a5d5ac9dcd4479fccd6"

URI_x86_64_v2_rust-crossbeam+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+std-devel-0.8.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam+std-devel.sha256sum] = "40c1e90b98daec8f0fa20a1576a8eede7aff32906b5e339e5da9cd8205170425"

URI_x86_64_v2_rust-crossbeam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-devel-0.8.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-devel.sha256sum] = "4d4c3abd350e39210c77ef38507b6f82f386f68b54b183e4699b227113206897"

URI_aarch64_rust-crossbeam+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+alloc-devel-0.8.4-3.el10_0.noarch.rpm;name=aarch64_rust-crossbeam+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam+alloc-devel}"
SRC_URI[aarch64_rust-crossbeam+alloc-devel.sha256sum] = "db350226d739d10c4094b2f701bc542c94e7f7709fb9b7108e49cd12bbb92377"

URI_aarch64_rust-crossbeam+crossbeam-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+crossbeam-channel-devel-0.8.4-3.el10_0.noarch.rpm;name=aarch64_rust-crossbeam+crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam+crossbeam-channel-devel}"
SRC_URI[aarch64_rust-crossbeam+crossbeam-channel-devel.sha256sum] = "b616b95c78bff572308fadc24ce10a73e73f9f986e9eb82baabd44f8243bdb3d"

URI_aarch64_rust-crossbeam+crossbeam-deque-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+crossbeam-deque-devel-0.8.4-3.el10_0.noarch.rpm;name=aarch64_rust-crossbeam+crossbeam-deque-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam+crossbeam-deque-devel}"
SRC_URI[aarch64_rust-crossbeam+crossbeam-deque-devel.sha256sum] = "bb3f2a7641a57f6cace086b7db1c3d8f9cd15a5a769bdde99fc23ba5a1659d60"

URI_aarch64_rust-crossbeam+crossbeam-epoch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+crossbeam-epoch-devel-0.8.4-3.el10_0.noarch.rpm;name=aarch64_rust-crossbeam+crossbeam-epoch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam+crossbeam-epoch-devel}"
SRC_URI[aarch64_rust-crossbeam+crossbeam-epoch-devel.sha256sum] = "65dff63825b901216bae95af8c152b843a034173880e6faaad24861a63d41db9"

URI_aarch64_rust-crossbeam+crossbeam-queue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+crossbeam-queue-devel-0.8.4-3.el10_0.noarch.rpm;name=aarch64_rust-crossbeam+crossbeam-queue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam+crossbeam-queue-devel}"
SRC_URI[aarch64_rust-crossbeam+crossbeam-queue-devel.sha256sum] = "924170451b4833091d1b47c5b2850eb2baef1f2764b00857978a04f52e7289c5"

URI_aarch64_rust-crossbeam+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+default-devel-0.8.4-3.el10_0.noarch.rpm;name=aarch64_rust-crossbeam+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam+default-devel}"
SRC_URI[aarch64_rust-crossbeam+default-devel.sha256sum] = "534f5fcb005db23bf6291535afb64b0b49a6a8ca6f08614f7657c860f6cd0f85"

URI_aarch64_rust-crossbeam+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+nightly-devel-0.8.4-3.el10_0.noarch.rpm;name=aarch64_rust-crossbeam+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam+nightly-devel}"
SRC_URI[aarch64_rust-crossbeam+nightly-devel.sha256sum] = "fff404ad23f96a97b0f413272cc285cbcc4374bce277609b47a36aedae14ff3e"

URI_aarch64_rust-crossbeam+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+std-devel-0.8.4-3.el10_0.noarch.rpm;name=aarch64_rust-crossbeam+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam+std-devel}"
SRC_URI[aarch64_rust-crossbeam+std-devel.sha256sum] = "dc519c5164f27a1385fa60310a175ee210097f137627a2daf7402bef81bd6d69"

URI_aarch64_rust-crossbeam-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-devel-0.8.4-3.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-devel}"
SRC_URI[aarch64_rust-crossbeam-devel.sha256sum] = "75d783bb14141bafe229791a4408bbfcc95fa3308076fab89a746ce9cbc4843a"

RDEPENDS:rust-crossbeam+alloc-devel = " \
 cargo \
 rust-crossbeam-devel \
 rust-crossbeam-epoch+alloc-devel \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-queue+alloc-devel \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam+crossbeam-channel-devel = " \
 cargo \
 rust-crossbeam-channel-devel \
 rust-crossbeam-devel \
 "
RDEPENDS:rust-crossbeam+crossbeam-deque-devel = " \
 cargo \
 rust-crossbeam-deque-devel \
 rust-crossbeam-devel \
 "
RDEPENDS:rust-crossbeam+crossbeam-epoch-devel = " \
 cargo \
 rust-crossbeam-devel \
 rust-crossbeam-epoch-devel \
 "
RDEPENDS:rust-crossbeam+crossbeam-queue-devel = " \
 cargo \
 rust-crossbeam-devel \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam+default-devel = " \
 cargo \
 rust-crossbeam+std-devel \
 rust-crossbeam-devel \
 "
RDEPENDS:rust-crossbeam+nightly-devel = " \
 cargo \
 rust-crossbeam-devel \
 rust-crossbeam-epoch+nightly-devel \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-queue+nightly-devel \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+nightly-devel \
 "
RDEPENDS:rust-crossbeam+std-devel = " \
 cargo \
 rust-crossbeam+alloc-devel \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 rust-crossbeam-deque+std-devel \
 rust-crossbeam-deque-devel \
 rust-crossbeam-devel \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-queue+std-devel \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
