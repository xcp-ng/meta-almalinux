# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nmon"
PV = "16q"
PR = "3.el10_1"
PACKAGES = " \
 nmon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nmon-16q-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6545bfd34400341221b1d12455b0c2d1140b39e4cd2e36bbe76a4ed15d422879"

URI_x86_64_v2_nmon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nmon-16q-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nmon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmon}"
SRC_URI[x86_64_v2_nmon.sha256sum] = "e9de3fc2f84952677b30f92591470d05e4c9f098bf19b87f9789792967cbd01d"

URI_aarch64_nmon = "${EPEL_MIRROR}/aarch64/Packages/n/nmon-16q-3.el10_1.aarch64.rpm;name=aarch64_nmon;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmon}"
SRC_URI[aarch64_nmon.sha256sum] = "c6b28c73aeba061fbfd41a953ccf91427e223d78222069f079d0f1ef827e41be"

RDEPENDS:nmon = " \
 glibc \
 ncurses-libs \
 "
