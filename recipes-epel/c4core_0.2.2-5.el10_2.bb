# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c4core"
PV = "0.2.2"
PR = "5.el10_2"
PACKAGES = " \
 c4core \
 c4core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/c4core-0.2.2-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acb6131e6afaf2083e02a409bc6bb102a785c124d244b902fa51c3dbc8dd7eb5"

URI_x86_64_v2_c4core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c4core-0.2.2-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c4core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c4core}"
SRC_URI[x86_64_v2_c4core.sha256sum] = "df93710d4c79dd0a216e6ef15def7e5e658c40ca741ca2639162719760d4f31e"

URI_x86_64_v2_c4core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c4core-devel-0.2.2-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c4core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c4core-devel}"
SRC_URI[x86_64_v2_c4core-devel.sha256sum] = "94ff0234e2ed79030c0e459be43ad44f5361d35a58623f886e999339b5e9de6a"

URI_aarch64_c4core = "${EPEL_MIRROR}/aarch64/Packages/c/c4core-0.2.2-5.el10_2.aarch64.rpm;name=aarch64_c4core;unpack=0"
SRC_URI:append = " ${URI_aarch64_c4core}"
SRC_URI[aarch64_c4core.sha256sum] = "fb745626c5b6202e7ca34aaa22606f6cfc2d69e70c09aac2fa3c4c93c10948f9"

URI_aarch64_c4core-devel = "${EPEL_MIRROR}/aarch64/Packages/c/c4core-devel-0.2.2-5.el10_2.aarch64.rpm;name=aarch64_c4core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_c4core-devel}"
SRC_URI[aarch64_c4core-devel.sha256sum] = "462d62c4a3a0c250eb8b5a633680364189ed82bdad934ae332ddd0b9349c305a"

RDEPENDS:c4core = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:c4core-devel = " \
 c4core \
 cmake-filesystem \
 debugbreak-devel \
 fast_float-devel \
 "
