# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pxz"
PV = "4.999.9"
PR = "33.beta.20260317git.el10_2"
PACKAGES = " \
 pxz \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pxz-4.999.9-33.beta.20260317git.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3856dbeb2443a3a9aa337df7173498458852632752b4ba4714ac6a8118d37fe0"

URI_x86_64_v2_pxz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pxz-4.999.9-33.beta.20260317git.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pxz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pxz}"
SRC_URI[x86_64_v2_pxz.sha256sum] = "f4370006a3ff12de1f877735f11365321c24ccab31c0c00a229e9323ba9ef651"

URI_aarch64_pxz = "${EPEL_MIRROR}/aarch64/Packages/p/pxz-4.999.9-33.beta.20260317git.el10_2.aarch64.rpm;name=aarch64_pxz;unpack=0"
SRC_URI:append = " ${URI_aarch64_pxz}"
SRC_URI[aarch64_pxz.sha256sum] = "6da9421c2347aef1ba79b8d21aa3c1ab08bd6b8352db515727697c0d9183e5ff"

RDEPENDS:pxz = " \
 glibc \
 libgcc \
 libgomp \
 xz \
 xz-libs \
 "
