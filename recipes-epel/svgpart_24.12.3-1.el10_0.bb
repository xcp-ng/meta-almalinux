# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "svgpart"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 svgpart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/svgpart-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c01cc5e10b5ff4b2b220c20576c34e9ce736036d531f26e17e1e6473db0db738"

URI_x86_64_v2_svgpart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/svgpart-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_svgpart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_svgpart}"
SRC_URI[x86_64_v2_svgpart.sha256sum] = "92aca7c0f2605694fb92be05d62f2fb47fd037a40192cfd75c4ce6b21cd214dd"

URI_aarch64_svgpart = "${EPEL_MIRROR}/aarch64/Packages/s/svgpart-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_svgpart;unpack=0"
SRC_URI:append = " ${URI_aarch64_svgpart}"
SRC_URI[aarch64_svgpart.sha256sum] = "97462df93461fe1ac2d3a6f1dc42cc8f5fbbe7fb33c6b1980205f2956bde4dc0"

RDEPENDS:svgpart = " \
 glibc \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kparts \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
