# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-bleach"
PV = "6.2.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-bleach \
 python3-bleach+css \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-bleach-6.2.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33220284601ff4fe0a7842841a14a8134df7b68cd14397062bd31c1e07390b45"

URI_x86_64_v2_python3-bleach = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bleach-6.2.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-bleach;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bleach}"
SRC_URI[x86_64_v2_python3-bleach.sha256sum] = "4c10591b730c9d3d62e92fb738217226c9af6537514018f70f7ce0a1e89a1607"

URI_x86_64_v2_python3-bleach+css = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bleach+css-6.2.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-bleach+css;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bleach+css}"
SRC_URI[x86_64_v2_python3-bleach+css.sha256sum] = "b708eeeeee8bea72e699e9e78e0d3c9bce8c62813f37a8963dc37a43b9e18a74"

URI_aarch64_python3-bleach = "${EPEL_MIRROR}/aarch64/Packages/p/python3-bleach-6.2.0-2.el10_1.noarch.rpm;name=aarch64_python3-bleach;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bleach}"
SRC_URI[aarch64_python3-bleach.sha256sum] = "e7cd64e246e8702a268164370ffeb834391c834dc186a4b790725363a3e0a2e3"

URI_aarch64_python3-bleach+css = "${EPEL_MIRROR}/aarch64/Packages/p/python3-bleach+css-6.2.0-2.el10_1.noarch.rpm;name=aarch64_python3-bleach+css;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bleach+css}"
SRC_URI[aarch64_python3-bleach+css.sha256sum] = "a0038d3e40c4e4cb34ec48da228c775d0b38abc1f31da7953152568a81b4e567"

RDEPENDS:python3-bleach = " \
 python3 \
 python3-html5lib \
 python3-webencodings \
 "
RDEPENDS:python3-bleach+css = " \
 python3 \
 python3-bleach \
 python3-tinycss2 \
 "
