# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-widestring"
PV = "1.2.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-widestring+alloc-devel \
 rust-widestring+default-devel \
 rust-widestring+std-devel \
 rust-widestring-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-widestring-1.2.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd93d7993c509ed67921032630ed0670e03761a2121db953fe129953e0b265ab"

URI_x86_64_v2_rust-widestring+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-widestring+alloc-devel-1.2.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-widestring+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-widestring+alloc-devel}"
SRC_URI[x86_64_v2_rust-widestring+alloc-devel.sha256sum] = "89ea451d6eac700b3f8c222616177a354e421c60c361b545451ae6dfe6e35ec6"

URI_x86_64_v2_rust-widestring+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-widestring+default-devel-1.2.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-widestring+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-widestring+default-devel}"
SRC_URI[x86_64_v2_rust-widestring+default-devel.sha256sum] = "836f46e7250f6bc3a78eb1fa07b9c70822a0d3175d11073a0eca2823ad02cd72"

URI_x86_64_v2_rust-widestring+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-widestring+std-devel-1.2.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-widestring+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-widestring+std-devel}"
SRC_URI[x86_64_v2_rust-widestring+std-devel.sha256sum] = "060cf4533b6ec87bb2d42a70a664a760cbafbdab7cbf9f9a3879dd2793064c6f"

URI_x86_64_v2_rust-widestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-widestring-devel-1.2.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-widestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-widestring-devel}"
SRC_URI[x86_64_v2_rust-widestring-devel.sha256sum] = "b47293d9549a85166bf46c996462705aef9e24263573250daf6cdb23dd3e8c82"

URI_aarch64_rust-widestring+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-widestring+alloc-devel-1.2.1-3.el10_0.noarch.rpm;name=aarch64_rust-widestring+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-widestring+alloc-devel}"
SRC_URI[aarch64_rust-widestring+alloc-devel.sha256sum] = "e1aef0c8f3806e49254c29c8301d1311df89dd7d4281233a64d78407a5c01893"

URI_aarch64_rust-widestring+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-widestring+default-devel-1.2.1-3.el10_0.noarch.rpm;name=aarch64_rust-widestring+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-widestring+default-devel}"
SRC_URI[aarch64_rust-widestring+default-devel.sha256sum] = "26dd2aa09f0790dde9f871de8f179ee35b9b7929b601b9e7abcf8c2c84630ae3"

URI_aarch64_rust-widestring+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-widestring+std-devel-1.2.1-3.el10_0.noarch.rpm;name=aarch64_rust-widestring+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-widestring+std-devel}"
SRC_URI[aarch64_rust-widestring+std-devel.sha256sum] = "3f130f1e1556eb587c0958aa629394e18d0adca013cb86bff0aec2f5b47a3cc1"

URI_aarch64_rust-widestring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-widestring-devel-1.2.1-3.el10_0.noarch.rpm;name=aarch64_rust-widestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-widestring-devel}"
SRC_URI[aarch64_rust-widestring-devel.sha256sum] = "2d44d161cf802782c430c3290bbf116e04b0f3c0d6d61c849216715716eeff2a"

RDEPENDS:rust-widestring+alloc-devel = " \
 cargo \
 rust-widestring-devel \
 "
RDEPENDS:rust-widestring+default-devel = " \
 cargo \
 rust-widestring+std-devel \
 rust-widestring-devel \
 "
RDEPENDS:rust-widestring+std-devel = " \
 cargo \
 rust-widestring+alloc-devel \
 rust-widestring-devel \
 "
RDEPENDS:rust-widestring-devel = " \
 cargo \
 rust \
 "
