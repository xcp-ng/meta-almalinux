# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "movit"
PV = "1.7.1"
PR = "8.el10_2"
PACKAGES = " \
 movit \
 movit-data \
 movit-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/movit-1.7.1-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "287e6659c28b2371270152848545668feab6df1d044c2c887f0cae958573f55d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/movit-1.7.1-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_movit;unpack=0"
SRC_URI[x86_64_v2_movit.sha256sum] = "f223709b1c5c55dacbaebf047da2b19a090a83d805ea4df50f91871de325a1ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/movit-data-1.7.1-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_movit-data;unpack=0"
SRC_URI[x86_64_v2_movit-data.sha256sum] = "db8ba7c39462427f6863e0ece1b7550518112342ea66f38b591a2d1a530881b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/movit-devel-1.7.1-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_movit-devel;unpack=0"
SRC_URI[x86_64_v2_movit-devel.sha256sum] = "d1f862be4053a4637818bfaa2c47da9fb3bef9ab025b5aa797df6514e10d41c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/movit-1.7.1-8.el10_2.aarch64.rpm;name=aarch64_movit;unpack=0"
SRC_URI[aarch64_movit.sha256sum] = "6a031175779c87080c0ec3182d95091eb61630af93f0cd3df4563da88d907029"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/movit-data-1.7.1-8.el10_2.noarch.rpm;name=aarch64_movit-data;unpack=0"
SRC_URI[aarch64_movit-data.sha256sum] = "96e98096f25984492f7ed49ccead29a83a9f4d26aa2af5c0a5243ae4bf301a4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/movit-devel-1.7.1-8.el10_2.aarch64.rpm;name=aarch64_movit-devel;unpack=0"
SRC_URI[aarch64_movit-devel.sha256sum] = "6e2083e44225e51df7259ef6928cd322605b1dba3bb06f21aee74e008b107e2f"

RDEPENDS:movit = " \
 fftw-libs-double \
 glibc \
 libepoxy \
 libgcc \
 libstdc++ \
 movit-data \
 "
RDEPENDS:movit-data = " \
 movit \
 "
RDEPENDS:movit-devel = " \
 eigen3-devel \
 fftw-devel \
 libepoxy-devel \
 movit \
 pkgconf-pkg-config \
 "
