# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cloud-init"
PV = "24.4"
PR = "7.el10.1"
PACKAGES = " \
 cloud-init \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cloud-init-24.4-7.el10.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47e032692c5fa6be1fd214d3035310e6f3b69a46dcc0f30a8e7ab6a9ac3b4d39"

URI_x86_64_v2_cloud-init = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cloud-init-24.4-7.el10.1.noarch.rpm;name=x86_64_v2_cloud-init;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cloud-init}"
SRC_URI[x86_64_v2_cloud-init.sha256sum] = "8b239379b9b095ec56b9e35b9a7c69b2f588697e99c52e087fe3e44104b9e9d9"

URI_aarch64_cloud-init = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cloud-init-24.4-7.el10.1.noarch.rpm;name=aarch64_cloud-init;unpack=0"
SRC_URI:append = " ${URI_aarch64_cloud-init}"
SRC_URI[aarch64_cloud-init.sha256sum] = "8b239379b9b095ec56b9e35b9a7c69b2f588697e99c52e087fe3e44104b9e9d9"

RDEPENDS:cloud-init = " \
 bash \
 dhcpcd \
 e2fsprogs \
 hostname \
 iproute \
 openssl \
 procps-ng \
 python3 \
 python3-configobj \
 python3-jinja2 \
 python3-jsonpatch \
 python3-libselinux \
 python3-oauthlib \
 python3-policycoreutils \
 python3-pyserial \
 python3-pyyaml \
 python3-requests \
 shadow-utils \
 systemd \
 util-linux \
 xfsprogs \
 "
