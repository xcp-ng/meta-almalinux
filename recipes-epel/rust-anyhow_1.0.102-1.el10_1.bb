# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anyhow"
PV = "1.0.102"
PR = "1.el10_1"
PACKAGES = " \
 rust-anyhow+backtrace-devel \
 rust-anyhow+default-devel \
 rust-anyhow+std-devel \
 rust-anyhow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anyhow-1.0.102-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37344b14e967680071ccf8db67ab3da53167ddc6d285940c18ee2b6da058cd32"

URI_x86_64_v2_rust-anyhow+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow+backtrace-devel-1.0.102-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow+backtrace-devel}"
SRC_URI[x86_64_v2_rust-anyhow+backtrace-devel.sha256sum] = "fc0749338d976fa66a632de9527c6c5c6421e346b5d004e4a35bd94fe65ad88d"

URI_x86_64_v2_rust-anyhow+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow+default-devel-1.0.102-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow+default-devel}"
SRC_URI[x86_64_v2_rust-anyhow+default-devel.sha256sum] = "a9134179598a6063546348c4ff8e0485f13e05cf0b2fae6d706d202f26060c34"

URI_x86_64_v2_rust-anyhow+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow+std-devel-1.0.102-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow+std-devel}"
SRC_URI[x86_64_v2_rust-anyhow+std-devel.sha256sum] = "1a132e7fd3e93e7e7741139bef511c8f4613a6afe762b8a75722b4115548ab14"

URI_x86_64_v2_rust-anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow-devel-1.0.102-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow-devel}"
SRC_URI[x86_64_v2_rust-anyhow-devel.sha256sum] = "e9acd6ba2cf12e2bd02d2795d1487eeaf70835d51e3823b8caec112d7949450d"

URI_aarch64_rust-anyhow+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow+backtrace-devel-1.0.102-1.el10_1.noarch.rpm;name=aarch64_rust-anyhow+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow+backtrace-devel}"
SRC_URI[aarch64_rust-anyhow+backtrace-devel.sha256sum] = "2193ef64a9115e33e1f79bf01ddc4e3842988230eebe65c4b4b55f9abb73a14d"

URI_aarch64_rust-anyhow+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow+default-devel-1.0.102-1.el10_1.noarch.rpm;name=aarch64_rust-anyhow+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow+default-devel}"
SRC_URI[aarch64_rust-anyhow+default-devel.sha256sum] = "f8386d5dbd24dee4495e187c3f2f9bbc5b7e154988a496d60eaf55a6b8177a3f"

URI_aarch64_rust-anyhow+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow+std-devel-1.0.102-1.el10_1.noarch.rpm;name=aarch64_rust-anyhow+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow+std-devel}"
SRC_URI[aarch64_rust-anyhow+std-devel.sha256sum] = "a2adf0754a7d6a7b162e1ab8eddd1e3f92aa8775b2d13fe28bf2c0ffefbb64a9"

URI_aarch64_rust-anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow-devel-1.0.102-1.el10_1.noarch.rpm;name=aarch64_rust-anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow-devel}"
SRC_URI[aarch64_rust-anyhow-devel.sha256sum] = "d005bbe6a6e3fd1534ecdb7da855afb794ba928bbc8a18db4b2094e120c56dd5"

RDEPENDS:rust-anyhow+backtrace-devel = " \
 cargo \
 rust-anyhow-devel \
 "
RDEPENDS:rust-anyhow+default-devel = " \
 cargo \
 rust-anyhow+std-devel \
 rust-anyhow-devel \
 "
RDEPENDS:rust-anyhow+std-devel = " \
 cargo \
 rust-anyhow-devel \
 "
RDEPENDS:rust-anyhow-devel = " \
 cargo \
 rust \
 "
