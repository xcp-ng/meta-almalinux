# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ouroboros_macro"
PV = "0.18.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-ouroboros_macro+default-devel \
 rust-ouroboros_macro+std-devel \
 rust-ouroboros_macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ouroboros_macro-0.18.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4b2f430cf83b5cfbb8a7f88066c74b5b7b304da8540bae3a73886812cae840d"

URI_x86_64_v2_rust-ouroboros_macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ouroboros_macro+default-devel-0.18.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ouroboros_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ouroboros_macro+default-devel}"
SRC_URI[x86_64_v2_rust-ouroboros_macro+default-devel.sha256sum] = "339cf6c11bd4b1f1f3d4ee3603f047eeb6693a0cf838b99fb3f05106263d3064"

URI_x86_64_v2_rust-ouroboros_macro+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ouroboros_macro+std-devel-0.18.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ouroboros_macro+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ouroboros_macro+std-devel}"
SRC_URI[x86_64_v2_rust-ouroboros_macro+std-devel.sha256sum] = "3223c7a65ca745eb1f5abb8776bcb004f5fd3b3a9c51a889433f35bfee9fed80"

URI_x86_64_v2_rust-ouroboros_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ouroboros_macro-devel-0.18.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ouroboros_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ouroboros_macro-devel}"
SRC_URI[x86_64_v2_rust-ouroboros_macro-devel.sha256sum] = "d3cd75051cfe8ceac41e73b8788de174e8a6e49186ce0c284db5d51034fcc069"

URI_aarch64_rust-ouroboros_macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ouroboros_macro+default-devel-0.18.5-1.el10_1.noarch.rpm;name=aarch64_rust-ouroboros_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ouroboros_macro+default-devel}"
SRC_URI[aarch64_rust-ouroboros_macro+default-devel.sha256sum] = "18cebb6be5e22b170049b72ea89b960bdf9acaddcc9aade744fe763824ad0d78"

URI_aarch64_rust-ouroboros_macro+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ouroboros_macro+std-devel-0.18.5-1.el10_1.noarch.rpm;name=aarch64_rust-ouroboros_macro+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ouroboros_macro+std-devel}"
SRC_URI[aarch64_rust-ouroboros_macro+std-devel.sha256sum] = "632ae15d85572caae0b98f745d19b43cf00afb48dba77d892c49b658f230004d"

URI_aarch64_rust-ouroboros_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ouroboros_macro-devel-0.18.5-1.el10_1.noarch.rpm;name=aarch64_rust-ouroboros_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ouroboros_macro-devel}"
SRC_URI[aarch64_rust-ouroboros_macro-devel.sha256sum] = "d3963960f85213fdc1181d39042507eeb8da338292484c9d309a3853c62c7f32"

RDEPENDS:rust-ouroboros_macro+default-devel = " \
 cargo \
 rust-ouroboros_macro-devel \
 "
RDEPENDS:rust-ouroboros_macro+std-devel = " \
 cargo \
 rust-ouroboros_macro-devel \
 "
RDEPENDS:rust-ouroboros_macro-devel = " \
 cargo \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-proc-macro2-diagnostics+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 "
