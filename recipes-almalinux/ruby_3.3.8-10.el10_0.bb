# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby"
PV = "3.3.8"
PR = "10.el10_0"
PACKAGES = " \
 ruby \
 ruby-bundled-gems \
 ruby-default-gems \
 ruby-devel \
 ruby-doc \
 ruby-libs \
 rubygem-bigdecimal \
 rubygem-bundler \
 rubygem-io-console \
 rubygem-irb \
 rubygem-json \
 rubygem-minitest \
 rubygem-power_assert \
 rubygem-psych \
 rubygem-racc \
 rubygem-rake \
 rubygem-rbs \
 rubygem-rdoc \
 rubygem-rexml \
 rubygem-rss \
 rubygem-test-unit \
 rubygem-typeprof \
 rubygems \
 rubygems-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ruby-3.3.8-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be2f07b7d9f0cb25488bff82239cddaa67b974cfc2b648fe8ded20bbcd365209"

URI_x86_64_v2_ruby = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-3.3.8-10.el10_0.x86_64_v2.rpm;name=x86_64_v2_ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby}"
SRC_URI[x86_64_v2_ruby.sha256sum] = "6a06b68f4f4744583c4414bbdcc5958a879b89d7b7b2e4d0608fd12aa860b474"

URI_x86_64_v2_ruby-bundled-gems = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-bundled-gems-3.3.8-10.el10_0.x86_64_v2.rpm;name=x86_64_v2_ruby-bundled-gems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-bundled-gems}"
SRC_URI[x86_64_v2_ruby-bundled-gems.sha256sum] = "f899ca719e928081dbbcb3a9811f100f446102fb357c600dd37b48cbe4934ea0"

URI_x86_64_v2_ruby-default-gems = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-default-gems-3.3.8-10.el10_0.noarch.rpm;name=x86_64_v2_ruby-default-gems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-default-gems}"
SRC_URI[x86_64_v2_ruby-default-gems.sha256sum] = "ff56292a0f5dc09dc988fbc7e487c33e1b304f3ddc47b5787a4ef845c45abfd6"

URI_x86_64_v2_ruby-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-devel-3.3.8-10.el10_0.x86_64_v2.rpm;name=x86_64_v2_ruby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-devel}"
SRC_URI[x86_64_v2_ruby-devel.sha256sum] = "1370106e5538475176f83ca816ffdcd128a358f983ebdaaa70b5294e1f2ec66e"

URI_x86_64_v2_ruby-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ruby-doc-3.3.8-10.el10_0.noarch.rpm;name=x86_64_v2_ruby-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-doc}"
SRC_URI[x86_64_v2_ruby-doc.sha256sum] = "1d51af9d9ce63f6f9ce5c086008e0ee96160064dff2ea7fde6da5774cdd48731"

URI_x86_64_v2_ruby-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-libs-3.3.8-10.el10_0.x86_64_v2.rpm;name=x86_64_v2_ruby-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-libs}"
SRC_URI[x86_64_v2_ruby-libs.sha256sum] = "2ab563296cecaba596f64d42700d2440f75e1ad1380b2ec6e964a2aa0355da4d"

URI_x86_64_v2_rubygem-bigdecimal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-bigdecimal-3.1.5-10.el10_0.x86_64_v2.rpm;name=x86_64_v2_rubygem-bigdecimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-bigdecimal}"
SRC_URI[x86_64_v2_rubygem-bigdecimal.sha256sum] = "cc4d80aa16fb6cd93c1af921361f0a9ba0f214cc6749512b126607bf61dcadac"

URI_x86_64_v2_rubygem-bundler = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-bundler-2.5.22-10.el10_0.noarch.rpm;name=x86_64_v2_rubygem-bundler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-bundler}"
SRC_URI[x86_64_v2_rubygem-bundler.sha256sum] = "7dd21d0b71684b061c77df1b5ae31220cc8ba1a7cf822b733ecaf0ef368cccd4"

URI_x86_64_v2_rubygem-io-console = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-io-console-0.7.1-10.el10_0.x86_64_v2.rpm;name=x86_64_v2_rubygem-io-console;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-io-console}"
SRC_URI[x86_64_v2_rubygem-io-console.sha256sum] = "716c6d25841b71ae149d3d7b2cbc94cef23dba3847d48b970b17a95843a46fe5"

URI_x86_64_v2_rubygem-irb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-irb-1.13.1-10.el10_0.noarch.rpm;name=x86_64_v2_rubygem-irb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-irb}"
SRC_URI[x86_64_v2_rubygem-irb.sha256sum] = "78fa8c4a557c809664e24ae265f5e4547745fada84375364357bf58a98608604"

URI_x86_64_v2_rubygem-json = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-json-2.7.2-10.el10_0.x86_64_v2.rpm;name=x86_64_v2_rubygem-json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-json}"
SRC_URI[x86_64_v2_rubygem-json.sha256sum] = "1dc68571d9fbbf72c67feeb03c06b74595fce542564c2b38f93be43753903b14"

URI_x86_64_v2_rubygem-minitest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-minitest-5.20.0-10.el10_0.noarch.rpm;name=x86_64_v2_rubygem-minitest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-minitest}"
SRC_URI[x86_64_v2_rubygem-minitest.sha256sum] = "9d4c545129d46b0e36a7024b0d1ea8071a20bc002b39e2438550ebe2ad5feeb2"

URI_x86_64_v2_rubygem-power_assert = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-power_assert-2.0.3-10.el10_0.noarch.rpm;name=x86_64_v2_rubygem-power_assert;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-power_assert}"
SRC_URI[x86_64_v2_rubygem-power_assert.sha256sum] = "967f3ceb1f03f961ce913304ea4bc74f83a0a5e118bef43b6250d175031c063e"

URI_x86_64_v2_rubygem-psych = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-psych-5.1.2-10.el10_0.x86_64_v2.rpm;name=x86_64_v2_rubygem-psych;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-psych}"
SRC_URI[x86_64_v2_rubygem-psych.sha256sum] = "805fc401dd68667aea1ba0b3e6783c7ae91382595c5c5783f18df8a6f06ce5c8"

URI_x86_64_v2_rubygem-racc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-racc-1.7.3-10.el10_0.x86_64_v2.rpm;name=x86_64_v2_rubygem-racc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-racc}"
SRC_URI[x86_64_v2_rubygem-racc.sha256sum] = "850e30a58052a2ba9fa7db0b98a4804f72b253e213b05847b2a5786b696f3a2e"

URI_x86_64_v2_rubygem-rake = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rake-13.1.0-10.el10_0.noarch.rpm;name=x86_64_v2_rubygem-rake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rake}"
SRC_URI[x86_64_v2_rubygem-rake.sha256sum] = "5bc6f0eab10cc1e6d7dcf548db89906057d6bea53ea80c50c457d9b88d17e534"

URI_x86_64_v2_rubygem-rbs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rbs-3.4.0-10.el10_0.x86_64_v2.rpm;name=x86_64_v2_rubygem-rbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rbs}"
SRC_URI[x86_64_v2_rubygem-rbs.sha256sum] = "fc3c0aefab3798a13f0e4f60be78150fd9fb85ed8c897bacff4e5b0be7bccd8d"

URI_x86_64_v2_rubygem-rdoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rdoc-6.6.3.1-10.el10_0.noarch.rpm;name=x86_64_v2_rubygem-rdoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rdoc}"
SRC_URI[x86_64_v2_rubygem-rdoc.sha256sum] = "000f7ae4b812c2f8b76657ab8a2eb89bac65625b9c16fdabbb066367199be08b"

URI_x86_64_v2_rubygem-rexml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rexml-3.3.9-10.el10_0.noarch.rpm;name=x86_64_v2_rubygem-rexml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rexml}"
SRC_URI[x86_64_v2_rubygem-rexml.sha256sum] = "dada2b54032dd2b68b46e91ca4406c099a2870f48660965b5abee5dccf3a6e81"

URI_x86_64_v2_rubygem-rss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rss-0.3.1-10.el10_0.noarch.rpm;name=x86_64_v2_rubygem-rss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rss}"
SRC_URI[x86_64_v2_rubygem-rss.sha256sum] = "2848b4be77f58301df888353630f1a3c9682a34832454e39630adf91d1aea9dc"

URI_x86_64_v2_rubygem-test-unit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-test-unit-3.6.1-10.el10_0.noarch.rpm;name=x86_64_v2_rubygem-test-unit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-test-unit}"
SRC_URI[x86_64_v2_rubygem-test-unit.sha256sum] = "5302e1d16ea44cbb171ea758e9b5e6ae802e7a8ee31d0d7684e4685e49aefa0f"

URI_x86_64_v2_rubygem-typeprof = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-typeprof-0.21.9-10.el10_0.noarch.rpm;name=x86_64_v2_rubygem-typeprof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-typeprof}"
SRC_URI[x86_64_v2_rubygem-typeprof.sha256sum] = "7731d655f4f2577401b92eb83b124cd72087c6b54e9d856ff37081d2181fa4a5"

URI_x86_64_v2_rubygems = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygems-3.5.22-10.el10_0.noarch.rpm;name=x86_64_v2_rubygems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygems}"
SRC_URI[x86_64_v2_rubygems.sha256sum] = "2535aadd931d6ffe6a62fa72fa20e0f7298f36a9d95f3572576eb3d4cb1b0744"

URI_x86_64_v2_rubygems-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygems-devel-3.5.22-10.el10_0.noarch.rpm;name=x86_64_v2_rubygems-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygems-devel}"
SRC_URI[x86_64_v2_rubygems-devel.sha256sum] = "155cbfad75054d591f4af2bc0623816222795d49f8a9aa13185bae6f5724f4d5"

URI_aarch64_ruby = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-3.3.8-10.el10_0.aarch64.rpm;name=aarch64_ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby}"
SRC_URI[aarch64_ruby.sha256sum] = "21def572781375f44b404a51d67d81a5fc9c49523f8f450f9d29a9b98c2a46fb"

URI_aarch64_ruby-bundled-gems = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-bundled-gems-3.3.8-10.el10_0.aarch64.rpm;name=aarch64_ruby-bundled-gems;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-bundled-gems}"
SRC_URI[aarch64_ruby-bundled-gems.sha256sum] = "4f937acafa5adf982ce6844b4532e1331df1d94cdd1c298b75a80adbbfa03f25"

URI_aarch64_ruby-default-gems = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-default-gems-3.3.8-10.el10_0.noarch.rpm;name=aarch64_ruby-default-gems;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-default-gems}"
SRC_URI[aarch64_ruby-default-gems.sha256sum] = "ff56292a0f5dc09dc988fbc7e487c33e1b304f3ddc47b5787a4ef845c45abfd6"

URI_aarch64_ruby-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-devel-3.3.8-10.el10_0.aarch64.rpm;name=aarch64_ruby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-devel}"
SRC_URI[aarch64_ruby-devel.sha256sum] = "3d8f912902b6123949a4a8b58794aec521cc4605ff43da7e0b2b8d5758a5c502"

URI_aarch64_ruby-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ruby-doc-3.3.8-10.el10_0.noarch.rpm;name=aarch64_ruby-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-doc}"
SRC_URI[aarch64_ruby-doc.sha256sum] = "1d51af9d9ce63f6f9ce5c086008e0ee96160064dff2ea7fde6da5774cdd48731"

URI_aarch64_ruby-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-libs-3.3.8-10.el10_0.aarch64.rpm;name=aarch64_ruby-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-libs}"
SRC_URI[aarch64_ruby-libs.sha256sum] = "a57940d878c01d87c968abee42c0437a62524120b0e22fa0d622d38ae2ee43bd"

URI_aarch64_rubygem-bigdecimal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-bigdecimal-3.1.5-10.el10_0.aarch64.rpm;name=aarch64_rubygem-bigdecimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-bigdecimal}"
SRC_URI[aarch64_rubygem-bigdecimal.sha256sum] = "a4498ebd6acf580a7120001e062e2d4f41b3ff8e8924205926469bb79888d15d"

URI_aarch64_rubygem-bundler = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-bundler-2.5.22-10.el10_0.noarch.rpm;name=aarch64_rubygem-bundler;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-bundler}"
SRC_URI[aarch64_rubygem-bundler.sha256sum] = "7dd21d0b71684b061c77df1b5ae31220cc8ba1a7cf822b733ecaf0ef368cccd4"

URI_aarch64_rubygem-io-console = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-io-console-0.7.1-10.el10_0.aarch64.rpm;name=aarch64_rubygem-io-console;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-io-console}"
SRC_URI[aarch64_rubygem-io-console.sha256sum] = "6f830ead2c486c07ddfee68beced304558c2a5d9d6e1003d2d3f23fa9056b091"

URI_aarch64_rubygem-irb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-irb-1.13.1-10.el10_0.noarch.rpm;name=aarch64_rubygem-irb;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-irb}"
SRC_URI[aarch64_rubygem-irb.sha256sum] = "78fa8c4a557c809664e24ae265f5e4547745fada84375364357bf58a98608604"

URI_aarch64_rubygem-json = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-json-2.7.2-10.el10_0.aarch64.rpm;name=aarch64_rubygem-json;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-json}"
SRC_URI[aarch64_rubygem-json.sha256sum] = "2836655dba4aa4458563edc338c982e035124847126a9d1ec0146acd30e08495"

URI_aarch64_rubygem-minitest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-minitest-5.20.0-10.el10_0.noarch.rpm;name=aarch64_rubygem-minitest;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-minitest}"
SRC_URI[aarch64_rubygem-minitest.sha256sum] = "9d4c545129d46b0e36a7024b0d1ea8071a20bc002b39e2438550ebe2ad5feeb2"

URI_aarch64_rubygem-power_assert = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-power_assert-2.0.3-10.el10_0.noarch.rpm;name=aarch64_rubygem-power_assert;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-power_assert}"
SRC_URI[aarch64_rubygem-power_assert.sha256sum] = "967f3ceb1f03f961ce913304ea4bc74f83a0a5e118bef43b6250d175031c063e"

URI_aarch64_rubygem-psych = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-psych-5.1.2-10.el10_0.aarch64.rpm;name=aarch64_rubygem-psych;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-psych}"
SRC_URI[aarch64_rubygem-psych.sha256sum] = "9ae861179a0b07328a0066d16708956b6e0031ebeb6c68603aa4d0d89d3249eb"

URI_aarch64_rubygem-racc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-racc-1.7.3-10.el10_0.aarch64.rpm;name=aarch64_rubygem-racc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-racc}"
SRC_URI[aarch64_rubygem-racc.sha256sum] = "5262dfc4a7a4733131902e03d32d61d439e9e49a745a52f66ce2fb67c6208203"

URI_aarch64_rubygem-rake = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rake-13.1.0-10.el10_0.noarch.rpm;name=aarch64_rubygem-rake;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rake}"
SRC_URI[aarch64_rubygem-rake.sha256sum] = "5bc6f0eab10cc1e6d7dcf548db89906057d6bea53ea80c50c457d9b88d17e534"

URI_aarch64_rubygem-rbs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rbs-3.4.0-10.el10_0.aarch64.rpm;name=aarch64_rubygem-rbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rbs}"
SRC_URI[aarch64_rubygem-rbs.sha256sum] = "5e98c1820428777a4e8e5aa2463c44033675d4311ea52bee394864ffc807496f"

URI_aarch64_rubygem-rdoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rdoc-6.6.3.1-10.el10_0.noarch.rpm;name=aarch64_rubygem-rdoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rdoc}"
SRC_URI[aarch64_rubygem-rdoc.sha256sum] = "000f7ae4b812c2f8b76657ab8a2eb89bac65625b9c16fdabbb066367199be08b"

URI_aarch64_rubygem-rexml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rexml-3.3.9-10.el10_0.noarch.rpm;name=aarch64_rubygem-rexml;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rexml}"
SRC_URI[aarch64_rubygem-rexml.sha256sum] = "dada2b54032dd2b68b46e91ca4406c099a2870f48660965b5abee5dccf3a6e81"

URI_aarch64_rubygem-rss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rss-0.3.1-10.el10_0.noarch.rpm;name=aarch64_rubygem-rss;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rss}"
SRC_URI[aarch64_rubygem-rss.sha256sum] = "2848b4be77f58301df888353630f1a3c9682a34832454e39630adf91d1aea9dc"

URI_aarch64_rubygem-test-unit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-test-unit-3.6.1-10.el10_0.noarch.rpm;name=aarch64_rubygem-test-unit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-test-unit}"
SRC_URI[aarch64_rubygem-test-unit.sha256sum] = "5302e1d16ea44cbb171ea758e9b5e6ae802e7a8ee31d0d7684e4685e49aefa0f"

URI_aarch64_rubygem-typeprof = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-typeprof-0.21.9-10.el10_0.noarch.rpm;name=aarch64_rubygem-typeprof;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-typeprof}"
SRC_URI[aarch64_rubygem-typeprof.sha256sum] = "7731d655f4f2577401b92eb83b124cd72087c6b54e9d856ff37081d2181fa4a5"

URI_aarch64_rubygems = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygems-3.5.22-10.el10_0.noarch.rpm;name=aarch64_rubygems;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygems}"
SRC_URI[aarch64_rubygems.sha256sum] = "2535aadd931d6ffe6a62fa72fa20e0f7298f36a9d95f3572576eb3d4cb1b0744"

URI_aarch64_rubygems-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygems-devel-3.5.22-10.el10_0.noarch.rpm;name=aarch64_rubygems-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygems-devel}"
SRC_URI[aarch64_rubygems-devel.sha256sum] = "155cbfad75054d591f4af2bc0623816222795d49f8a9aa13185bae6f5724f4d5"

RDEPENDS:ruby = " \
 glibc \
 gmp \
 libxcrypt \
 ruby-libs \
 zlib-ng-compat \
 "
RDEPENDS:ruby-bundled-gems = " \
 glibc \
 ruby \
 ruby-default-gems \
 ruby-libs \
 rubygem-irb \
 rubygems \
 "
RDEPENDS:ruby-default-gems = " \
 ruby \
 ruby-default-gems \
 rubygem-io-console \
 rubygems \
 "
RDEPENDS:ruby-devel = " \
 pkgconf-pkg-config \
 ruby \
 ruby-libs \
 rubygems \
 "
RDEPENDS:ruby-doc = " \
 rubygem-rdoc \
 "
RDEPENDS:ruby-libs = " \
 glibc \
 gmp \
 libffi \
 libgcc \
 libxcrypt \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:rubygem-bigdecimal = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-bundler = " \
 ruby \
 rubygem-io-console \
 rubygems \
 "
RDEPENDS:rubygem-io-console = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-irb = " \
 ruby \
 ruby-default-gems \
 rubygem-rdoc \
 rubygems \
 "
RDEPENDS:rubygem-json = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-minitest = " \
 rubygems \
 "
RDEPENDS:rubygem-power_assert = " \
 rubygems \
 "
RDEPENDS:rubygem-psych = " \
 glibc \
 libyaml \
 ruby-default-gems \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-racc = " \
 glibc \
 ruby \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-rake = " \
 ruby \
 rubygems \
 "
RDEPENDS:rubygem-rbs = " \
 glibc \
 ruby \
 ruby-default-gems \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-rdoc = " \
 ruby \
 rubygem-io-console \
 rubygem-json \
 rubygem-psych \
 rubygems \
 "
RDEPENDS:rubygem-rexml = " \
 rubygems \
 "
RDEPENDS:rubygem-rss = " \
 rubygem-rexml \
 rubygems \
 "
RDEPENDS:rubygem-test-unit = " \
 rubygem-power_assert \
 rubygems \
 "
RDEPENDS:rubygem-typeprof = " \
 ruby \
 rubygem-rbs \
 rubygems \
 "
RDEPENDS:rubygems = " \
 ruby \
 ruby-libs \
 rubygem-psych \
 "
RDEPENDS:rubygems-devel = " \
 ruby \
 rubygem-json \
 rubygem-rdoc \
 rubygems \
 "
