# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest"
PV = "0.12.22"
PR = "1.el10_1"
PACKAGES = " \
 rust-reqwest+__rustls-devel \
 rust-reqwest+__rustls-ring-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+brotli-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+cookies-devel \
 rust-reqwest+default-devel \
 rust-reqwest+default-tls-devel \
 rust-reqwest+deflate-devel \
 rust-reqwest+gzip-devel \
 rust-reqwest+h2-devel \
 rust-reqwest+hickory-dns-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+json-devel \
 rust-reqwest+multipart-devel \
 rust-reqwest+native-tls-alpn-devel \
 rust-reqwest+native-tls-devel \
 rust-reqwest+rustls-tls-devel \
 rust-reqwest+rustls-tls-manual-roots-devel \
 rust-reqwest+rustls-tls-manual-roots-no-provider-devel \
 rust-reqwest+rustls-tls-native-roots-devel \
 rust-reqwest+rustls-tls-native-roots-no-provider-devel \
 rust-reqwest+rustls-tls-no-provider-devel \
 rust-reqwest+rustls-tls-webpki-roots-devel \
 rust-reqwest+rustls-tls-webpki-roots-no-provider-devel \
 rust-reqwest+socks-devel \
 rust-reqwest+stream-devel \
 rust-reqwest+system-proxy-devel \
 rust-reqwest+trust-dns-devel \
 rust-reqwest+zstd-devel \
 rust-reqwest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-0.12.22-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36b961f80ec27812e7fc5d11fda4ba9c271e78383b38eb57a4cce0bd2c1dc36a"

URI_x86_64_v2_rust-reqwest+__rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__rustls-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__rustls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__rustls-devel.sha256sum] = "bfbc787cf1b552848f518d1179e24bec79f1ae3f7ba85c4d8b911451e01f2ba4"

URI_x86_64_v2_rust-reqwest+__rustls-ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__rustls-ring-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__rustls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__rustls-ring-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__rustls-ring-devel.sha256sum] = "ef2922c888da9eb011f5ae33aeb3c40922b06b2c28d2add617c6d752825b8659"

URI_x86_64_v2_rust-reqwest+__tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__tls-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__tls-devel.sha256sum] = "91e69ee9a6e24a7962a96192dac614b585cae7ff5e0dd07d3c0f3ff1b0380696"

URI_x86_64_v2_rust-reqwest+blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+blocking-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+blocking-devel}"
SRC_URI[x86_64_v2_rust-reqwest+blocking-devel.sha256sum] = "4e474112a80edfed430c6e48b705a29b3cf2584ffe53e2893e07184388344e70"

URI_x86_64_v2_rust-reqwest+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+brotli-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+brotli-devel}"
SRC_URI[x86_64_v2_rust-reqwest+brotli-devel.sha256sum] = "3f925f5eae5a41c174d9e3cfc5a0b5dd334bdaa7860c5ef3a3afec6da2066e05"

URI_x86_64_v2_rust-reqwest+charset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+charset-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+charset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+charset-devel}"
SRC_URI[x86_64_v2_rust-reqwest+charset-devel.sha256sum] = "b4fb78fda7a2a9ef8350253b861c8dfa12fa4fd60e422033e193c47d858c6434"

URI_x86_64_v2_rust-reqwest+cookies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+cookies-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+cookies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+cookies-devel}"
SRC_URI[x86_64_v2_rust-reqwest+cookies-devel.sha256sum] = "f575e8e4c35de77c4e5a888cb52abe2fb31096e4cc2e572490b59598a292a98e"

URI_x86_64_v2_rust-reqwest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+default-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest+default-devel.sha256sum] = "afd449fe484cb82e7389905b1bf374226b4f0607f91e20e4e55164f198dffdfd"

URI_x86_64_v2_rust-reqwest+default-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+default-tls-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+default-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+default-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+default-tls-devel.sha256sum] = "b642a71814519b7b893cd36849c11a6007bfe1264ca737cf7e11be2a46e74ead"

URI_x86_64_v2_rust-reqwest+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+deflate-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+deflate-devel}"
SRC_URI[x86_64_v2_rust-reqwest+deflate-devel.sha256sum] = "3b1bf700de237774d9094818d37a820bc777bfff77f0add6914cc47bf9302b12"

URI_x86_64_v2_rust-reqwest+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+gzip-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+gzip-devel}"
SRC_URI[x86_64_v2_rust-reqwest+gzip-devel.sha256sum] = "985876ab511308a9cadc74b6579a7baac35ff09391fba770d5086c6a7f2b1c31"

URI_x86_64_v2_rust-reqwest+h2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+h2-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+h2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+h2-devel}"
SRC_URI[x86_64_v2_rust-reqwest+h2-devel.sha256sum] = "47908bf9fee78bdad71a9287931d0ceeee0c20ada6fbf695499d8808b108f31e"

URI_x86_64_v2_rust-reqwest+hickory-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+hickory-dns-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+hickory-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+hickory-dns-devel}"
SRC_URI[x86_64_v2_rust-reqwest+hickory-dns-devel.sha256sum] = "a3c0523a3d16dbe92de57b48f914e753183f950656b3701a323e4db5b7615820"

URI_x86_64_v2_rust-reqwest+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+http2-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+http2-devel}"
SRC_URI[x86_64_v2_rust-reqwest+http2-devel.sha256sum] = "7cc3aec1fc7f6b27028cbdd48b275c29a2aaf786bf603520eb5a43a1261ed54f"

URI_x86_64_v2_rust-reqwest+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+json-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+json-devel}"
SRC_URI[x86_64_v2_rust-reqwest+json-devel.sha256sum] = "f01f306a46bea9e1099047c45de49820dd913264c797e19dfa254a6f66221eaf"

URI_x86_64_v2_rust-reqwest+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+multipart-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+multipart-devel}"
SRC_URI[x86_64_v2_rust-reqwest+multipart-devel.sha256sum] = "65bfc9a76d9d881d280bed3f139466f5f8e147dfdea293e82489034055de7cc0"

URI_x86_64_v2_rust-reqwest+native-tls-alpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+native-tls-alpn-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+native-tls-alpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+native-tls-alpn-devel}"
SRC_URI[x86_64_v2_rust-reqwest+native-tls-alpn-devel.sha256sum] = "4417e63bffd5e56f42f3b824700be8bf4ee322801381d21befdbcb41b0be5d79"

URI_x86_64_v2_rust-reqwest+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+native-tls-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+native-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+native-tls-devel.sha256sum] = "3ed78690ef0897edd478118a33443f2fea7ddbcdca0b98e943268eb7fda41db5"

URI_x86_64_v2_rust-reqwest+rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-devel.sha256sum] = "0a691a19448645c76a8c0668ff7d1f43535fdbcae34f1abf817f49dff7998dab"

URI_x86_64_v2_rust-reqwest+rustls-tls-manual-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-manual-roots-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-manual-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-manual-roots-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-manual-roots-devel.sha256sum] = "217fe9eafd01e5536ec39759467d68b87f0ca39bb7850023efa52f85da5142bb"

URI_x86_64_v2_rust-reqwest+rustls-tls-manual-roots-no-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-manual-roots-no-provider-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-manual-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-manual-roots-no-provider-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-manual-roots-no-provider-devel.sha256sum] = "4f7c6dbef4c1ea0c429aedaa5bfdbad70cc0638f3b8a7d40cc89866e5f4b7c29"

URI_x86_64_v2_rust-reqwest+rustls-tls-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-native-roots-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-native-roots-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-native-roots-devel.sha256sum] = "0fe5fcefc2488faf98e1aaf6642d26f49ca70b05a8cde30f337620c87df0b52a"

URI_x86_64_v2_rust-reqwest+rustls-tls-native-roots-no-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-native-roots-no-provider-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-native-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-native-roots-no-provider-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-native-roots-no-provider-devel.sha256sum] = "7663b9b554c8a9f9dd25a60b2ac29cf044dd94f59237d56c6dc662786b167ffa"

URI_x86_64_v2_rust-reqwest+rustls-tls-no-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-no-provider-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-no-provider-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-no-provider-devel.sha256sum] = "1f83bf5ddf1fecf1f2807dc5096ee6f1bd4f8c912d4d6caad862aad7da39c812"

URI_x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-webpki-roots-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-devel.sha256sum] = "b04eb7e4477d15e76c4fd7315f698c1d22d1108a6eea3dfc50d5761220eba2e4"

URI_x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-webpki-roots-no-provider-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel.sha256sum] = "3473190c983262617b2cc6fd757d9b15ae770b505b3a081b29daabee1e6bee0e"

URI_x86_64_v2_rust-reqwest+socks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+socks-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+socks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+socks-devel}"
SRC_URI[x86_64_v2_rust-reqwest+socks-devel.sha256sum] = "9a76baa35d6b24b26f37cffa07d8a4f3dd5a22bf90159f797550b29d82b17fb1"

URI_x86_64_v2_rust-reqwest+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+stream-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+stream-devel}"
SRC_URI[x86_64_v2_rust-reqwest+stream-devel.sha256sum] = "eeeab8c55087a25e6b749cdd3342b535139ebe3aad8e315378fcb48a725587f9"

URI_x86_64_v2_rust-reqwest+system-proxy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+system-proxy-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+system-proxy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+system-proxy-devel}"
SRC_URI[x86_64_v2_rust-reqwest+system-proxy-devel.sha256sum] = "a269347ff3e51862823289008e740ff9b36a8334e1ea2840de5ee4164449cb93"

URI_x86_64_v2_rust-reqwest+trust-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+trust-dns-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+trust-dns-devel}"
SRC_URI[x86_64_v2_rust-reqwest+trust-dns-devel.sha256sum] = "8e335eecd445ee9692c7c8817e06e9665504d2b82615874317abcf7bbfcd15b8"

URI_x86_64_v2_rust-reqwest+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+zstd-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+zstd-devel}"
SRC_URI[x86_64_v2_rust-reqwest+zstd-devel.sha256sum] = "e5b86baef7417dfb0a7942fde6a0633ecd6d6d61ea97270fab1b0545e522fb11"

URI_x86_64_v2_rust-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-devel-0.12.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-devel}"
SRC_URI[x86_64_v2_rust-reqwest-devel.sha256sum] = "ccf014acb81129af5eeaa203ee24b60a72f63f0c59c165ab41e3783cac59c532"

URI_aarch64_rust-reqwest+__rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__rustls-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+__rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__rustls-devel}"
SRC_URI[aarch64_rust-reqwest+__rustls-devel.sha256sum] = "3148c88b58ef3090d33ace195d3666d9e770e7620d16e3ce78c32e4456edcad0"

URI_aarch64_rust-reqwest+__rustls-ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__rustls-ring-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+__rustls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__rustls-ring-devel}"
SRC_URI[aarch64_rust-reqwest+__rustls-ring-devel.sha256sum] = "0c7c4acb61ffebe142648d04ca7a7a3d5d8286ff6b045793c879230c4a6f9ef2"

URI_aarch64_rust-reqwest+__tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__tls-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+__tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__tls-devel}"
SRC_URI[aarch64_rust-reqwest+__tls-devel.sha256sum] = "6e2e79297694219ab0e88842d9693ea81fd508350abff6430a6f9e6c93992397"

URI_aarch64_rust-reqwest+blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+blocking-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+blocking-devel}"
SRC_URI[aarch64_rust-reqwest+blocking-devel.sha256sum] = "327c03696aa0e43dd2c494be851f789ced48c365724c0d9d6ef13430c5462122"

URI_aarch64_rust-reqwest+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+brotli-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+brotli-devel}"
SRC_URI[aarch64_rust-reqwest+brotli-devel.sha256sum] = "33ef289bd8a9e7dcb182eed39a2c9b065258c37d2ba0e70c18381e0443d9094f"

URI_aarch64_rust-reqwest+charset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+charset-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+charset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+charset-devel}"
SRC_URI[aarch64_rust-reqwest+charset-devel.sha256sum] = "2eb5de26c9bbb6022df97f57c6b68ff6bfd24ef8d2db34242434542af00f5558"

URI_aarch64_rust-reqwest+cookies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+cookies-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+cookies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+cookies-devel}"
SRC_URI[aarch64_rust-reqwest+cookies-devel.sha256sum] = "ebe16522fa1c682c194484cb63d1d69f0c12d449f4cfaffdbc59faa2cfec0b5b"

URI_aarch64_rust-reqwest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+default-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+default-devel}"
SRC_URI[aarch64_rust-reqwest+default-devel.sha256sum] = "e253e28749eddf6c74e42be4d491fe6ea622067e74397bc3589704aefd7a8d89"

URI_aarch64_rust-reqwest+default-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+default-tls-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+default-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+default-tls-devel}"
SRC_URI[aarch64_rust-reqwest+default-tls-devel.sha256sum] = "3a01a4456d394810ab8bc91205673ce143ed70699e9b7ab2c9d916329c273784"

URI_aarch64_rust-reqwest+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+deflate-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+deflate-devel}"
SRC_URI[aarch64_rust-reqwest+deflate-devel.sha256sum] = "7ddf2c7b28e0cc9fa930fa9e0d2400e45fc9a4ac23ab9feb2bcbbb7486644434"

URI_aarch64_rust-reqwest+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+gzip-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+gzip-devel}"
SRC_URI[aarch64_rust-reqwest+gzip-devel.sha256sum] = "45a64004299f934e7c28ba711541d2ae5cdee0cfce14580a3c460dfbe8845fa0"

URI_aarch64_rust-reqwest+h2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+h2-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+h2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+h2-devel}"
SRC_URI[aarch64_rust-reqwest+h2-devel.sha256sum] = "ebfaeadced649360b11c46cc54e8a784491b7c5db101e941e07620eaa1a51d17"

URI_aarch64_rust-reqwest+hickory-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+hickory-dns-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+hickory-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+hickory-dns-devel}"
SRC_URI[aarch64_rust-reqwest+hickory-dns-devel.sha256sum] = "876f0a18994b3cf6929525c8445ca53d5ab0c86bab35341f1de788f662e50368"

URI_aarch64_rust-reqwest+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+http2-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+http2-devel}"
SRC_URI[aarch64_rust-reqwest+http2-devel.sha256sum] = "066bc9c52ac079ff3d694bda46a4d2a9d9130ff14fa4e483e7cd9dd283ccc2c5"

URI_aarch64_rust-reqwest+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+json-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+json-devel}"
SRC_URI[aarch64_rust-reqwest+json-devel.sha256sum] = "f5a00092b9c3ee45f743a8eaa0baff06f2575a2ee121fd299a60690258f8b6b5"

URI_aarch64_rust-reqwest+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+multipart-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+multipart-devel}"
SRC_URI[aarch64_rust-reqwest+multipart-devel.sha256sum] = "7adf810ddad7bbc014a46b1f88a7e9ae6d9235c3e3e5f82781747f304068b2d2"

URI_aarch64_rust-reqwest+native-tls-alpn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+native-tls-alpn-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+native-tls-alpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+native-tls-alpn-devel}"
SRC_URI[aarch64_rust-reqwest+native-tls-alpn-devel.sha256sum] = "c91d974f05fb4cd40bc9d67a9d890854acdc302ee6c9cea7e9c225d653bd3a05"

URI_aarch64_rust-reqwest+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+native-tls-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+native-tls-devel}"
SRC_URI[aarch64_rust-reqwest+native-tls-devel.sha256sum] = "acf9d8c1277c8de0c9877fd8aacc2ab54f01cdc8b4432073c179c52b656d7c2e"

URI_aarch64_rust-reqwest+rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-devel.sha256sum] = "2fde94ea0bd27d8660613223756a2cc28e3307dbf2bc89ffe174d0359ed41410"

URI_aarch64_rust-reqwest+rustls-tls-manual-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-manual-roots-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-manual-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-manual-roots-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-manual-roots-devel.sha256sum] = "4eb4cf2e53deca274781270c9f057f21a67e00c3291d30abe258bc8e9bc31ea0"

URI_aarch64_rust-reqwest+rustls-tls-manual-roots-no-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-manual-roots-no-provider-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-manual-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-manual-roots-no-provider-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-manual-roots-no-provider-devel.sha256sum] = "9f3cac1bd676ce4a3cc1739483b823e302e57d2071584d08364196f7499f8bb1"

URI_aarch64_rust-reqwest+rustls-tls-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-native-roots-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-native-roots-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-native-roots-devel.sha256sum] = "4b314f985ab2011f6a7549898ccfccf1e68665ea9fcc972da40aa746c72e3832"

URI_aarch64_rust-reqwest+rustls-tls-native-roots-no-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-native-roots-no-provider-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-native-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-native-roots-no-provider-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-native-roots-no-provider-devel.sha256sum] = "7aafece8e76fe3e03c0e2debd10ef8746209bc724975b2708d6267718cfb74c3"

URI_aarch64_rust-reqwest+rustls-tls-no-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-no-provider-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-no-provider-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-no-provider-devel.sha256sum] = "60816cb38a4b062e98744e6de0f1fd58c53d182d20d5750ee206118f201e4dcb"

URI_aarch64_rust-reqwest+rustls-tls-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-webpki-roots-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-webpki-roots-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-webpki-roots-devel.sha256sum] = "6726e46c8f8de55464c7585173078c99d074e77e15f2df0e22310b5a88b22458"

URI_aarch64_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-webpki-roots-no-provider-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel.sha256sum] = "66897741499cdbced992efef6291340e82b5cc7446c62b6767604fa1fedcd90a"

URI_aarch64_rust-reqwest+socks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+socks-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+socks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+socks-devel}"
SRC_URI[aarch64_rust-reqwest+socks-devel.sha256sum] = "3949f8a6e34ba55347c8627ac52f7f981aa4b21844b62a33f91daebfe4bec304"

URI_aarch64_rust-reqwest+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+stream-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+stream-devel}"
SRC_URI[aarch64_rust-reqwest+stream-devel.sha256sum] = "33ecafa46fd8da7477ff17647b63df4a1123bf2bfbcb5f10e256bbb4d761cf9c"

URI_aarch64_rust-reqwest+system-proxy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+system-proxy-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+system-proxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+system-proxy-devel}"
SRC_URI[aarch64_rust-reqwest+system-proxy-devel.sha256sum] = "56b9cdbf913aecd475ab2b2ab6962174988db56f2377edbf0759332e1204d65b"

URI_aarch64_rust-reqwest+trust-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+trust-dns-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+trust-dns-devel}"
SRC_URI[aarch64_rust-reqwest+trust-dns-devel.sha256sum] = "c78f6caf6a643bc905c701d860c3ac6989ccc81e0bfb841d4dbc761539035410"

URI_aarch64_rust-reqwest+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+zstd-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+zstd-devel}"
SRC_URI[aarch64_rust-reqwest+zstd-devel.sha256sum] = "ca543dac29c6ec71bb93322a935c6a1cb472255d669998b33f7c37a7238eb26f"

URI_aarch64_rust-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-devel-0.12.22-1.el10_1.noarch.rpm;name=aarch64_rust-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-devel}"
SRC_URI[aarch64_rust-reqwest-devel.sha256sum] = "dad13a11ff6620b219c4485d76a11a90eabbdc5abd204c7d14dda942bf400db1"

RDEPENDS:rust-reqwest+__rustls-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-reqwest+__rustls-ring-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+ring-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest-devel \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-reqwest+__tls-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-pki-types+std-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-reqwest+blocking-devel = " \
 cargo \
 rust-futures-channel+default-devel \
 rust-futures-channel+sink-devel \
 rust-futures-util+io-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 rust-reqwest-devel \
 rust-tokio+sync-devel \
 "
RDEPENDS:rust-reqwest+brotli-devel = " \
 cargo \
 rust-async-compression+brotli-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression-devel \
 rust-futures-util-devel \
 rust-reqwest-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-reqwest+charset-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-mime+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+cookies-devel = " \
 cargo \
 rust-cookie+default-devel \
 rust-cookie_store+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+default-devel = " \
 cargo \
 rust-reqwest+charset-devel \
 rust-reqwest+default-tls-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+system-proxy-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+default-tls-devel = " \
 cargo \
 rust-hyper-tls+default-devel \
 rust-native-tls+default-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest-devel \
 rust-tokio-native-tls+default-devel \
 "
RDEPENDS:rust-reqwest+deflate-devel = " \
 cargo \
 rust-async-compression+tokio-devel \
 rust-async-compression+zlib-devel \
 rust-async-compression-devel \
 rust-futures-util-devel \
 rust-reqwest-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-reqwest+gzip-devel = " \
 cargo \
 rust-async-compression+gzip-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression-devel \
 rust-futures-util-devel \
 rust-reqwest-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-reqwest+h2-devel = " \
 cargo \
 rust-h2+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+hickory-dns-devel = " \
 cargo \
 rust-hickory-resolver+default-devel \
 rust-hickory-resolver+tokio-runtime-devel \
 rust-once_cell+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+http2-devel = " \
 cargo \
 rust-hyper+http2-devel \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+http2-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-hyper-util+http2-devel \
 rust-reqwest+h2-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+json-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-reqwest+multipart-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-mime_guess-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+native-tls-alpn-devel = " \
 cargo \
 rust-hyper-tls+alpn-devel \
 rust-hyper-tls+default-devel \
 rust-native-tls+alpn-devel \
 rust-native-tls+default-devel \
 rust-reqwest+native-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+native-tls-devel = " \
 cargo \
 rust-reqwest+default-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-devel = " \
 cargo \
 rust-reqwest+rustls-tls-webpki-roots-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-manual-roots-devel = " \
 cargo \
 rust-reqwest+__rustls-ring-devel \
 rust-reqwest+rustls-tls-manual-roots-no-provider-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-manual-roots-no-provider-devel = " \
 cargo \
 rust-reqwest+__rustls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-native-roots-devel = " \
 cargo \
 rust-reqwest+__rustls-ring-devel \
 rust-reqwest+rustls-tls-native-roots-no-provider-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-native-roots-no-provider-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+native-tokio-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest+__rustls-devel \
 rust-reqwest-devel \
 rust-rustls-native-certs+default-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-no-provider-devel = " \
 cargo \
 rust-reqwest+rustls-tls-manual-roots-no-provider-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-webpki-roots-devel = " \
 cargo \
 rust-reqwest+__rustls-ring-devel \
 rust-reqwest+rustls-tls-webpki-roots-no-provider-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-webpki-roots-no-provider-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls+webpki-tokio-devel \
 rust-hyper-rustls-devel \
 rust-reqwest+__rustls-devel \
 rust-reqwest-devel \
 rust-webpki-roots+default-devel \
 "
RDEPENDS:rust-reqwest+socks-devel = " \
 cargo \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+stream-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-reqwest-devel \
 rust-tokio+fs-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-reqwest+system-proxy-devel = " \
 cargo \
 rust-hyper-util+client-proxy-system-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+trust-dns-devel = " \
 cargo \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+zstd-devel = " \
 cargo \
 rust-async-compression+tokio-devel \
 rust-async-compression+zstd-devel \
 rust-async-compression-devel \
 rust-futures-util-devel \
 rust-reqwest-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-reqwest-devel = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-bytes+default-devel \
 rust-futures-core-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-hyper+client-devel \
 rust-hyper+default-devel \
 rust-hyper+http1-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+client-proxy-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+tokio-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-pin-project-lite+default-devel \
 rust-serde+default-devel \
 rust-serde_urlencoded+default-devel \
 rust-sync_wrapper+default-devel \
 rust-sync_wrapper+futures-devel \
 rust-tokio+net-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tower+timeout-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http-devel \
 rust-tower-service+default-devel \
 rust-url+default-devel \
 "
