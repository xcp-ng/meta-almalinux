# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf"
PV = "4.20.0"
PR = "26.el10.alma.1"
PACKAGES = " \
 dnf \
 dnf-automatic \
 dnf-bootc \
 dnf-data \
 python3-dnf \
 yum \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dnf-4.20.0-26.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "956c34b73c0f64e1ef1bd4d0e75b3699a89b836891b012802db4cd15686b7e21"

URI_x86_64_v2_dnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-4.20.0-26.el10.alma.1.noarch.rpm;name=x86_64_v2_dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf}"
SRC_URI[x86_64_v2_dnf.sha256sum] = "41c259e370348f9cc2ff98f745fa7182a8f639ee2c9c6a1ce7cbd9ad40b0ba44"

URI_x86_64_v2_dnf-automatic = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-automatic-4.20.0-26.el10.alma.1.noarch.rpm;name=x86_64_v2_dnf-automatic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-automatic}"
SRC_URI[x86_64_v2_dnf-automatic.sha256sum] = "cb12ae5242339834f076415877a4b13024d3d861ced655413e97d4f94b6d3969"

URI_x86_64_v2_dnf-bootc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnf-bootc-4.20.0-26.el10.alma.1.noarch.rpm;name=x86_64_v2_dnf-bootc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-bootc}"
SRC_URI[x86_64_v2_dnf-bootc.sha256sum] = "7039943f3e8364901769096b96bf2df300d6f7a6514f24c75d175c2e828772f5"

URI_x86_64_v2_dnf-data = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-data-4.20.0-26.el10.alma.1.noarch.rpm;name=x86_64_v2_dnf-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-data}"
SRC_URI[x86_64_v2_dnf-data.sha256sum] = "970923ffd0ce2323cedd0eba917a53bae0eddff6378d26be01621be649578c1d"

URI_x86_64_v2_python3-dnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-4.20.0-26.el10.alma.1.noarch.rpm;name=x86_64_v2_python3-dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf}"
SRC_URI[x86_64_v2_python3-dnf.sha256sum] = "e76e163ad6a9d24b844d6c6bbc2d53a4ea4c452b49b76fb83a88fb3c5b056a03"
RPROVIDES:python3-dnf:x86_64_v2 = "virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_"

URI_x86_64_v2_yum = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/yum-4.20.0-26.el10.alma.1.noarch.rpm;name=x86_64_v2_yum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yum}"
SRC_URI[x86_64_v2_yum.sha256sum] = "782f67205e35b4e55726711e2ee19dd85cd9c58ed6816d656da5563cc7771722"

URI_aarch64_dnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-4.20.0-26.el10.alma.1.noarch.rpm;name=aarch64_dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf}"
SRC_URI[aarch64_dnf.sha256sum] = "41c259e370348f9cc2ff98f745fa7182a8f639ee2c9c6a1ce7cbd9ad40b0ba44"

URI_aarch64_dnf-automatic = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-automatic-4.20.0-26.el10.alma.1.noarch.rpm;name=aarch64_dnf-automatic;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-automatic}"
SRC_URI[aarch64_dnf-automatic.sha256sum] = "cb12ae5242339834f076415877a4b13024d3d861ced655413e97d4f94b6d3969"

URI_aarch64_dnf-bootc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnf-bootc-4.20.0-26.el10.alma.1.noarch.rpm;name=aarch64_dnf-bootc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-bootc}"
SRC_URI[aarch64_dnf-bootc.sha256sum] = "7039943f3e8364901769096b96bf2df300d6f7a6514f24c75d175c2e828772f5"

URI_aarch64_dnf-data = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-data-4.20.0-26.el10.alma.1.noarch.rpm;name=aarch64_dnf-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-data}"
SRC_URI[aarch64_dnf-data.sha256sum] = "970923ffd0ce2323cedd0eba917a53bae0eddff6378d26be01621be649578c1d"

URI_aarch64_python3-dnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-4.20.0-26.el10.alma.1.noarch.rpm;name=aarch64_python3-dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf}"
SRC_URI[aarch64_python3-dnf.sha256sum] = "e76e163ad6a9d24b844d6c6bbc2d53a4ea4c452b49b76fb83a88fb3c5b056a03"
RPROVIDES:python3-dnf:aarch64 = "virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_"

URI_aarch64_yum = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/yum-4.20.0-26.el10.alma.1.noarch.rpm;name=aarch64_yum;unpack=0"
SRC_URI:append = " ${URI_aarch64_yum}"
SRC_URI[aarch64_yum.sha256sum] = "782f67205e35b4e55726711e2ee19dd85cd9c58ed6816d656da5563cc7771722"

RDEPENDS:dnf = " \
 bash \
 python3-dnf \
 virtual/coreutils \
 "
RDEPENDS:dnf-automatic = " \
 bash \
 python3 \
 python3-dnf \
 systemd \
 "
RDEPENDS:dnf-bootc = " \
 ostree \
 ostree-libs \
 python3-dnf \
 python3-gobject-base \
 util-linux-core \
 "
RDEPENDS:dnf-data = " \
 "
RDEPENDS:python3-dnf = " \
 dnf-data \
 libmodulemd \
 python3 \
 python3-hawkey \
 python3-libcomps \
 python3-libdnf \
 python3-rpm \
 "
RDEPENDS:yum = " \
 dnf \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_"

PROVIDES:append:aarch64 = " rpm/virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_"
