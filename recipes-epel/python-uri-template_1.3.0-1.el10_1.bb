# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-uri-template"
PV = "1.3.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-uri-template \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-uri-template-1.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "408d52beb532bb3450f9632b3a7d038653011b27dfb9df5a77f22d561eca8760"

URI_x86_64_v2_python3-uri-template = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-uri-template-1.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-uri-template;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-uri-template}"
SRC_URI[x86_64_v2_python3-uri-template.sha256sum] = "23406dd53887d809cb43d5215f654560902725bcafd0ef456b12918be1b5ac60"

URI_aarch64_python3-uri-template = "${EPEL_MIRROR}/aarch64/Packages/p/python3-uri-template-1.3.0-1.el10_1.noarch.rpm;name=aarch64_python3-uri-template;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-uri-template}"
SRC_URI[aarch64_python3-uri-template.sha256sum] = "c40c77a4d9c7056d6fe037c8142ae2a17187dd50ef1804efa57c28f1124735a4"

RDEPENDS:python3-uri-template = " \
 python3 \
 "
