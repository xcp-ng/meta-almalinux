# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xrootd-s3-http"
PV = "0.6.9"
PR = "1.el10_2"
PACKAGES = " \
 xrootd-s3-http \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xrootd-s3-http-0.6.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a45ec4981f3dd6c4d07b2b6cf02f2fd75a7abe9b7fef7cd7accf864ea4cdbe9"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - xrootd-s3-http: libXrdServer.so.6()(64bit)
# - xrootd-s3-http: libXrdUtils.so.6()(64bit)
# - xrootd-s3-http: xrootd-server

URI_x86_64_v2_xrootd-s3-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-s3-http-0.6.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-s3-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-s3-http}"
SRC_URI[x86_64_v2_xrootd-s3-http.sha256sum] = "6cfffc9accad03c8e5089f9ef846684cd9ac6cf3e78bc8719732f7d20b1ccd5d"

URI_aarch64_xrootd-s3-http = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-s3-http-0.6.9-1.el10_2.aarch64.rpm;name=aarch64_xrootd-s3-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-s3-http}"
SRC_URI[aarch64_xrootd-s3-http.sha256sum] = "7b9da5132a18b60348419c3e1f0193064cdcf4885bb2bb42e20435b54219d064"

RDEPENDS:xrootd-s3-http:x86_64_v2 = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 tinyxml2 \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:xrootd-s3-http:aarch64 = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 tinyxml2 \
 virtual/libcurl.so.4___64bit_ \
 xrootd-libs \
 xrootd-server \
 xrootd-server-libs \
"
