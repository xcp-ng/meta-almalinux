# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgcrypt"
PV = "1.11.0"
PR = "5.el10"
PACKAGES = " \
 libgcrypt \
 libgcrypt-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libgcrypt-1.11.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5407c9b8588af38361184d5530cfdc3c5582d0e6bdffa7759def5781bb0134f3"

URI_x86_64_v2_libgcrypt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgcrypt-1.11.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_libgcrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgcrypt}"
SRC_URI[x86_64_v2_libgcrypt.sha256sum] = "2b627d3edc5fe080bcd8c3947f452b0d1e2b894646a131e59899843f7e867dd0"

URI_x86_64_v2_libgcrypt-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgcrypt-devel-1.11.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_libgcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgcrypt-devel}"
SRC_URI[x86_64_v2_libgcrypt-devel.sha256sum] = "c2251aefa389c9072baef649b557f84de7a4c98dda8db9547e219079e73e1f71"

URI_aarch64_libgcrypt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgcrypt-1.11.0-5.el10.aarch64.rpm;name=aarch64_libgcrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgcrypt}"
SRC_URI[aarch64_libgcrypt.sha256sum] = "4220bacfc28dc6c197a804d1323103093bf32e5216f0c36ec7c6dc7ad9db6d97"

URI_aarch64_libgcrypt-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgcrypt-devel-1.11.0-5.el10.aarch64.rpm;name=aarch64_libgcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgcrypt-devel}"
SRC_URI[aarch64_libgcrypt-devel.sha256sum] = "2cf99c51269a73a92e1bb4140451f3a3b392fe143c99032de2db1eb592f27ad4"

RDEPENDS:libgcrypt = " \
 glibc \
 libgpg-error \
 "
RDEPENDS:libgcrypt-devel = " \
 bash \
 glibc \
 libgcrypt \
 libgpg-error \
 libgpg-error-devel \
 pkgconf-pkg-config \
 "
