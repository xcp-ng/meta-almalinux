# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yakuake"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 yakuake \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yakuake-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0caee699c70af25c2b6e6b123edfdc88aecbb43b0773a9f791a1fc2cc6bca004"

URI_x86_64_v2_yakuake = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yakuake-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yakuake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yakuake}"
SRC_URI[x86_64_v2_yakuake.sha256sum] = "b9749c79fa107097b77a3d3c9b6d98df70cc0da3b65a68bd85e25fd1aa15c59a"

URI_aarch64_yakuake = "${EPEL_MIRROR}/aarch64/Packages/y/yakuake-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_yakuake;unpack=0"
SRC_URI:append = " ${URI_aarch64_yakuake}"
SRC_URI[aarch64_yakuake.sha256sum] = "e5118c52bc672d22519e1579e3662869f5c6d2c776264278935c148ef9211de6"

RDEPENDS:yakuake = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 konsole-part \
 kwayland \
 libX11 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
