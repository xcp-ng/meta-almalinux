# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-CharWidth"
PV = "0.04"
PR = "57.el10"
PACKAGES = " \
 perl-Text-CharWidth \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Text-CharWidth-0.04-57.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34781d0c24f7326efe082d9f38c49410e52253c941b8fbcf96706e46d694e3e7"

URI_x86_64_v2_perl-Text-CharWidth = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Text-CharWidth-0.04-57.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Text-CharWidth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-CharWidth}"
SRC_URI[x86_64_v2_perl-Text-CharWidth.sha256sum] = "39688d285dae1a390d330a42fa4562bd56673ec5f791cc0b4b69d00ba4553500"

URI_aarch64_perl-Text-CharWidth = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Text-CharWidth-0.04-57.el10.aarch64.rpm;name=aarch64_perl-Text-CharWidth;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-CharWidth}"
SRC_URI[aarch64_perl-Text-CharWidth.sha256sum] = "16c0bd378924b016e9bbf61b739f322f5b19dbe50c2e826b3814758caf731235"

RDEPENDS:perl-Text-CharWidth = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
