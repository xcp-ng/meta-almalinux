# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skopeo"
PE = "2"
PV = "1.22.2"
PR = "2.el10_2"
PACKAGES = " \
 skopeo \
 skopeo-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/skopeo-1.22.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "836e497d2d902752639e12147e229a410ba22ad75c5cb4fc8a2a5c2180bb4024"

URI_x86_64_v2_skopeo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/skopeo-1.22.2-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_skopeo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skopeo}"
SRC_URI[x86_64_v2_skopeo.sha256sum] = "1fafaf114e5871acc504165258d14248e11072d251f61dd3f64c2e414192a0e4"

URI_x86_64_v2_skopeo-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/skopeo-tests-1.22.2-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_skopeo-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skopeo-tests}"
SRC_URI[x86_64_v2_skopeo-tests.sha256sum] = "b045497ca0091ea144e214a47842febf59a23734f1b69370e32594f976e5e86b"

URI_aarch64_skopeo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/skopeo-1.22.2-2.el10_2.aarch64.rpm;name=aarch64_skopeo;unpack=0"
SRC_URI:append = " ${URI_aarch64_skopeo}"
SRC_URI[aarch64_skopeo.sha256sum] = "e2d3b913c0389fec54adf2f0772cf99bff38a6ad1ef1c3d31fbf88a0770e9066"

URI_aarch64_skopeo-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/skopeo-tests-1.22.2-2.el10_2.aarch64.rpm;name=aarch64_skopeo-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_skopeo-tests}"
SRC_URI[aarch64_skopeo-tests.sha256sum] = "6dcca7d7bc11abdd81ebfbe3888e946307d322cb593df412c6286de41ad683b1"

RDEPENDS:skopeo = " \
 containers-common \
 glibc \
 gpgme \
 podman-sequoia \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:skopeo-tests = " \
 crun \
 gnupg2 \
 golang \
 httpd-tools \
 jq \
 openssl \
 podman \
 skopeo \
 squashfs-tools \
 "
