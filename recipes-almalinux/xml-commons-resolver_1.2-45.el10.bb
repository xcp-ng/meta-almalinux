# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xml-commons-resolver"
PV = "1.2"
PR = "45.el10"
PACKAGES = " \
 xml-commons-resolver \
 xml-commons-resolver-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xml-commons-resolver-1.2-45.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e944511155728b7eeef15df98a1191f4120edcf21d562f7b91b27ba479a0771f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xml-commons-resolver-1.2-45.el10.noarch.rpm;name=x86_64_v2_xml-commons-resolver;unpack=0"
SRC_URI[x86_64_v2_xml-commons-resolver.sha256sum] = "c86597ee0dde746146895241c421dca6c7eec24b1b3de920bf35619c54410189"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xml-commons-resolver-javadoc-1.2-45.el10.noarch.rpm;name=x86_64_v2_xml-commons-resolver-javadoc;unpack=0"
SRC_URI[x86_64_v2_xml-commons-resolver-javadoc.sha256sum] = "19c560506178df1394cb46961c00e66f3605c761ae77d69e59db703249a55213"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xml-commons-resolver-1.2-45.el10.noarch.rpm;name=aarch64_xml-commons-resolver;unpack=0"
SRC_URI[aarch64_xml-commons-resolver.sha256sum] = "c86597ee0dde746146895241c421dca6c7eec24b1b3de920bf35619c54410189"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xml-commons-resolver-javadoc-1.2-45.el10.noarch.rpm;name=aarch64_xml-commons-resolver-javadoc;unpack=0"
SRC_URI[aarch64_xml-commons-resolver-javadoc.sha256sum] = "19c560506178df1394cb46961c00e66f3605c761ae77d69e59db703249a55213"

RDEPENDS:xml-commons-resolver = " \
 bash \
 javapackages-filesystem \
 javapackages-tools \
 "
RDEPENDS:xml-commons-resolver-javadoc = " \
 javapackages-filesystem \
 "
