# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cdparanoia"
PV = "10.2"
PR = "46.el10_0"
PACKAGES = " \
 cdparanoia \
 cdparanoia-devel \
 cdparanoia-libs \
 cdparanoia-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cdparanoia-10.2-46.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "655cfcf83f07c3d8703ac8f1545c5620b1fad908e2323e728181cd084d3e7b24"

URI_x86_64_v2_cdparanoia = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cdparanoia-10.2-46.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cdparanoia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cdparanoia}"
SRC_URI[x86_64_v2_cdparanoia.sha256sum] = "42a8dd62de10c1495747e95f991967f3070bf597586fb39e170d3a93024f7a54"

URI_x86_64_v2_cdparanoia-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cdparanoia-devel-10.2-46.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cdparanoia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cdparanoia-devel}"
SRC_URI[x86_64_v2_cdparanoia-devel.sha256sum] = "24c18348ecff5887413e6d644e0d3fe2f9db352b85b0bf33a725c33a19e78b36"

URI_x86_64_v2_cdparanoia-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cdparanoia-libs-10.2-46.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cdparanoia-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cdparanoia-libs}"
SRC_URI[x86_64_v2_cdparanoia-libs.sha256sum] = "eb25e9bb1b7c5fe18e4418f50362877bb48b0d96cbf48e006812001a95193e5b"

URI_x86_64_v2_cdparanoia-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cdparanoia-static-10.2-46.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cdparanoia-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cdparanoia-static}"
SRC_URI[x86_64_v2_cdparanoia-static.sha256sum] = "b17a33a489a55e0e8be6cd4644b55026e56530e3f39e4f406b4284d7d3bbc507"

URI_aarch64_cdparanoia = "${EPEL_MIRROR}/aarch64/Packages/c/cdparanoia-10.2-46.el10_0.aarch64.rpm;name=aarch64_cdparanoia;unpack=0"
SRC_URI:append = " ${URI_aarch64_cdparanoia}"
SRC_URI[aarch64_cdparanoia.sha256sum] = "21cb085a6f93c0a3f6da07c4d43ead831e40fb88880809f05617cd9bbb7aea24"

URI_aarch64_cdparanoia-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cdparanoia-devel-10.2-46.el10_0.aarch64.rpm;name=aarch64_cdparanoia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cdparanoia-devel}"
SRC_URI[aarch64_cdparanoia-devel.sha256sum] = "7cc2acd3977d4c6789397c6b8cc5b74ec3d27de76a2f86a57a73059697788056"

URI_aarch64_cdparanoia-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cdparanoia-libs-10.2-46.el10_0.aarch64.rpm;name=aarch64_cdparanoia-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cdparanoia-libs}"
SRC_URI[aarch64_cdparanoia-libs.sha256sum] = "fdd986e7ff0f4ef28acf6622cc1359378f1e60da7f62ea414f44832808058a3f"

URI_aarch64_cdparanoia-static = "${EPEL_MIRROR}/aarch64/Packages/c/cdparanoia-static-10.2-46.el10_0.aarch64.rpm;name=aarch64_cdparanoia-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_cdparanoia-static}"
SRC_URI[aarch64_cdparanoia-static.sha256sum] = "c662e938f3ab83579b3ffb55cb6fd5d7c47df87b87fc9a327aee8988b331c234"

RDEPENDS:cdparanoia = " \
 cdparanoia-libs \
 glibc \
 "
RDEPENDS:cdparanoia-devel = " \
 cdparanoia-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:cdparanoia-libs = " \
 glibc \
 "
RDEPENDS:cdparanoia-static = " \
 cdparanoia-devel \
 "
