# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cpufeatures"
PV = "0.2.17"
PR = "1.el10_0"
PACKAGES = " \
 rust-cpufeatures+default-devel \
 rust-cpufeatures-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cpufeatures-0.2.17-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cadeafc917d4cb13de1b3d21ffec66eeb51fb3db57db471309d9355e4f112e04"

URI_x86_64_v2_rust-cpufeatures+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpufeatures+default-devel-0.2.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpufeatures+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpufeatures+default-devel}"
SRC_URI[x86_64_v2_rust-cpufeatures+default-devel.sha256sum] = "5561fc3725e6e07c2ad3d73960705085e516bc12801337a2f777082ca84047f7"

URI_x86_64_v2_rust-cpufeatures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpufeatures-devel-0.2.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpufeatures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpufeatures-devel}"
SRC_URI[x86_64_v2_rust-cpufeatures-devel.sha256sum] = "5dd1908ba9934801e4ced08d68ec61ff8606db3cf0c5286030fb328f1cb0b88f"

URI_aarch64_rust-cpufeatures+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpufeatures+default-devel-0.2.17-1.el10_0.noarch.rpm;name=aarch64_rust-cpufeatures+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpufeatures+default-devel}"
SRC_URI[aarch64_rust-cpufeatures+default-devel.sha256sum] = "dee24d427e61d9653caa951ae17df93bbd02fba16722864395cdb8ca1212168a"

URI_aarch64_rust-cpufeatures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpufeatures-devel-0.2.17-1.el10_0.noarch.rpm;name=aarch64_rust-cpufeatures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpufeatures-devel}"
SRC_URI[aarch64_rust-cpufeatures-devel.sha256sum] = "94e1b50c4a2ac4696a94f74298d3b09d67f035beccf593f39f2f345a42900626"

RDEPENDS:rust-cpufeatures+default-devel = " \
 cargo \
 rust-cpufeatures-devel \
 "
RDEPENDS:rust-cpufeatures-devel = " \
 cargo \
 rust-libc-devel \
 "
