# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sysv_ipc"
PV = "1.2.0"
PR = "2.el10_3"
PACKAGES = " \
 python-sysv_ipc-examples \
 python3-sysv_ipc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sysv_ipc-1.2.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c827df7dc91d05610ab3951affd03f951d3f631b001cf5b5b60ec5a0ac91212"

URI_x86_64_v2_python-sysv_ipc-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-sysv_ipc-examples-1.2.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python-sysv_ipc-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-sysv_ipc-examples}"
SRC_URI[x86_64_v2_python-sysv_ipc-examples.sha256sum] = "fbf4dac1c34213f9ae5b77d0d3309533095326da00b964daeedd20491381aecf"

URI_x86_64_v2_python3-sysv_ipc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sysv_ipc-1.2.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-sysv_ipc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sysv_ipc}"
SRC_URI[x86_64_v2_python3-sysv_ipc.sha256sum] = "d46d33c9fc8b4014dcc66b0fb737661a9339ab74cb300d852b5d9636da42b1a0"

URI_aarch64_python-sysv_ipc-examples = "${EPEL_MIRROR}/aarch64/Packages/p/python-sysv_ipc-examples-1.2.0-2.el10_3.aarch64.rpm;name=aarch64_python-sysv_ipc-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-sysv_ipc-examples}"
SRC_URI[aarch64_python-sysv_ipc-examples.sha256sum] = "432abe14677aa396096535cebbcd70a900d87e00b326448f71a9c8cdeb2a57d7"

URI_aarch64_python3-sysv_ipc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sysv_ipc-1.2.0-2.el10_3.aarch64.rpm;name=aarch64_python3-sysv_ipc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sysv_ipc}"
SRC_URI[aarch64_python3-sysv_ipc.sha256sum] = "544093975685504ed4efb3ab7b1cd24ee8b0376148aae3215c120be46efd8a4c"

RDEPENDS:python-sysv_ipc-examples = " \
 "
RDEPENDS:python3-sysv_ipc = " \
 glibc \
 python3 \
 "
