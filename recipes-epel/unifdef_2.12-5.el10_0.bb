# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unifdef"
PV = "2.12"
PR = "5.el10_0"
PACKAGES = " \
 unifdef \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/u/unifdef-2.12-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "80d1bc8b887d63a22dbb2b1e82b338a1911e4ff48db445216fa2e879484f38f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unifdef-2.12-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unifdef;unpack=0"
SRC_URI[x86_64_v2_unifdef.sha256sum] = "f9afc8a8aa1a77578b52c1f391530379404158987236435649b6d324dc0ee3e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/unifdef-2.12-5.el10_0.aarch64.rpm;name=aarch64_unifdef;unpack=0"
SRC_URI[aarch64_unifdef.sha256sum] = "19fe9bccbe287afbc38fa2b715a824002f2b67cfb0d3596c32be2526ae27cac6"

RDEPENDS:unifdef = " \
 bash \
 glibc \
 "
