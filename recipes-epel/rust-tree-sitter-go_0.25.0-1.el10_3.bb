# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-go"
PV = "0.25.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-go+default-devel \
 rust-tree-sitter-go-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-go-0.25.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3db1cdcd022985caf50f5972cffdb88ed3c5e361fee3d151bf22c077fba7f1e9"

URI_x86_64_v2_rust-tree-sitter-go+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-go+default-devel-0.25.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-go+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-go+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-go+default-devel.sha256sum] = "72c3d7d1bd429ed94be75240e32a97643cc2f604c6dbbea8d3b49adefacdf65e"

URI_x86_64_v2_rust-tree-sitter-go-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-go-devel-0.25.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-go-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-go-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-go-devel.sha256sum] = "2c82980a733be69127611051d316417fd3960a1f3c271a323a308f0a43cbb915"

URI_aarch64_rust-tree-sitter-go+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-go+default-devel-0.25.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-go+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-go+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-go+default-devel.sha256sum] = "521785bde9dde51b1d186c9f6522131faf812636fc69cfca08588657502cc6d3"

URI_aarch64_rust-tree-sitter-go-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-go-devel-0.25.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-go-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-go-devel}"
SRC_URI[aarch64_rust-tree-sitter-go-devel.sha256sum] = "93b86d1ab7925066bff300caedbf7daf87a949999356c738e832c99a90a71070"

RDEPENDS:rust-tree-sitter-go+default-devel = " \
 cargo \
 rust-tree-sitter-go-devel \
 "
RDEPENDS:rust-tree-sitter-go-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
