# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_calendar"
PV = "2.2.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_calendar+alloc-devel \
 rust-icu_calendar+compiled_data-devel \
 rust-icu_calendar+datagen-devel \
 rust-icu_calendar+default-devel \
 rust-icu_calendar+ixdtf-devel \
 rust-icu_calendar+logging-devel \
 rust-icu_calendar+serde-devel \
 rust-icu_calendar+unstable-devel \
 rust-icu_calendar+unstable_chrono_0_4-devel \
 rust-icu_calendar+unstable_jiff_0_2-devel \
 rust-icu_calendar+unstable_time_0_3-devel \
 rust-icu_calendar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_calendar-2.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32a62fdae08986fc8f376ba0ae3a6f96412cf3f891a383f17828cd9538fe8ce3"

URI_x86_64_v2_rust-icu_calendar+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+alloc-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+alloc-devel.sha256sum] = "d84295b1f38d44fb5fd8b68b86d3670e19fadf416b0ab12c3c643ee6c3935c50"

URI_x86_64_v2_rust-icu_calendar+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+compiled_data-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+compiled_data-devel.sha256sum] = "508d085b8028a655fad49f87ca91c4530b6ce24dc74d7814e1a8626f2ac8a25b"

URI_x86_64_v2_rust-icu_calendar+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+datagen-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+datagen-devel.sha256sum] = "33e35fba05eaff00e6d00f5669a823b638f22116413f3301a54d7afc11cb8ff4"

URI_x86_64_v2_rust-icu_calendar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+default-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+default-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+default-devel.sha256sum] = "b10fc45dd277ddb4a2d4d07354784aa4741976242d1a6432b12fb32ed436788e"

URI_x86_64_v2_rust-icu_calendar+ixdtf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+ixdtf-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+ixdtf-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+ixdtf-devel.sha256sum] = "afdb66fc0156517348dda109918b2818880ef7d34b02e9f2d4cd5cd14ebaedb2"

URI_x86_64_v2_rust-icu_calendar+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+logging-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+logging-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+logging-devel.sha256sum] = "c2df0ac143e5bb65efb904f6bcfd7514303f7b445ec30a9a1f8f54717d5e5881"

URI_x86_64_v2_rust-icu_calendar+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+serde-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+serde-devel.sha256sum] = "5bc9d6baf36d73d79fc431ec4929a5fe2aa882ecc28cc861b79100d6e06722b6"

URI_x86_64_v2_rust-icu_calendar+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+unstable-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+unstable-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+unstable-devel.sha256sum] = "837b5df26ef18d4187bb41dba03d9c499b51ef2d447a632d01c2052307064316"

URI_x86_64_v2_rust-icu_calendar+unstable_chrono_0_4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+unstable_chrono_0_4-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+unstable_chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+unstable_chrono_0_4-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+unstable_chrono_0_4-devel.sha256sum] = "ba7f75fd02901d9642bf658664fbd9b8962c3ba6c70064599c34d36c477e6cac"

URI_x86_64_v2_rust-icu_calendar+unstable_jiff_0_2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+unstable_jiff_0_2-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+unstable_jiff_0_2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+unstable_jiff_0_2-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+unstable_jiff_0_2-devel.sha256sum] = "ddee8ab7f18bec7f1ddf4e30be64eaaaf511660ec4c0668c1500a57ce63025bb"

URI_x86_64_v2_rust-icu_calendar+unstable_time_0_3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+unstable_time_0_3-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+unstable_time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+unstable_time_0_3-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+unstable_time_0_3-devel.sha256sum] = "d98b68ee3de5628c96ad0e86dfb19e8cf005b227b8931b683be5c09f72f1f931"

URI_x86_64_v2_rust-icu_calendar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar-devel.sha256sum] = "986c7d2de97bf19a3730162703f4a07106e3ad733f763adfad4cabfd8c45e323"

URI_aarch64_rust-icu_calendar+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+alloc-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_calendar+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+alloc-devel}"
SRC_URI[aarch64_rust-icu_calendar+alloc-devel.sha256sum] = "1c1b68d362d5c68c72f5f8a9aedb7835fc35c2c61b8ab552e6c8db2f8bbd8191"

URI_aarch64_rust-icu_calendar+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+compiled_data-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_calendar+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_calendar+compiled_data-devel.sha256sum] = "158f771ae8005affe5c9aff59109d8c62e3ab10a57d9a848ae0e5d2d92a28863"

URI_aarch64_rust-icu_calendar+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+datagen-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_calendar+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+datagen-devel}"
SRC_URI[aarch64_rust-icu_calendar+datagen-devel.sha256sum] = "2203fabeb7df7193d5bf34c431ddb09698517ec9491fc9f62fea2cb076d3b1cb"

URI_aarch64_rust-icu_calendar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+default-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_calendar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+default-devel}"
SRC_URI[aarch64_rust-icu_calendar+default-devel.sha256sum] = "31c9a0d12b62bbd48748c0d67198f00e011c3adc3b231a0718a8ec1035599d2f"

URI_aarch64_rust-icu_calendar+ixdtf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+ixdtf-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_calendar+ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+ixdtf-devel}"
SRC_URI[aarch64_rust-icu_calendar+ixdtf-devel.sha256sum] = "607ab71a1c8a96025bdedb671cd6aa96b85dd8503cd29fea02fac647884a2226"

URI_aarch64_rust-icu_calendar+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+logging-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_calendar+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+logging-devel}"
SRC_URI[aarch64_rust-icu_calendar+logging-devel.sha256sum] = "f362dfed4c3c909fafeec771194731d52ec3dbee6026172ae3b5973f3cf7f252"

URI_aarch64_rust-icu_calendar+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+serde-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_calendar+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+serde-devel}"
SRC_URI[aarch64_rust-icu_calendar+serde-devel.sha256sum] = "e52d64b6999c8f2faafb04ebf9f67ece878c2c070e07a0ff9a44cf08547e8610"

URI_aarch64_rust-icu_calendar+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+unstable-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_calendar+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+unstable-devel}"
SRC_URI[aarch64_rust-icu_calendar+unstable-devel.sha256sum] = "d73dbe9170943d171d89b83bf87f46d3095514f6abfe0b6a53af24adca51ce1f"

URI_aarch64_rust-icu_calendar+unstable_chrono_0_4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+unstable_chrono_0_4-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_calendar+unstable_chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+unstable_chrono_0_4-devel}"
SRC_URI[aarch64_rust-icu_calendar+unstable_chrono_0_4-devel.sha256sum] = "fd833450afe3b126224b5937091ce4bb9f81b3058a445e38586d63c2da73e4dd"

URI_aarch64_rust-icu_calendar+unstable_jiff_0_2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+unstable_jiff_0_2-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_calendar+unstable_jiff_0_2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+unstable_jiff_0_2-devel}"
SRC_URI[aarch64_rust-icu_calendar+unstable_jiff_0_2-devel.sha256sum] = "7f88910a4108cc7c382182379a2c264b0d7bcff070afe700948553bef77f8a76"

URI_aarch64_rust-icu_calendar+unstable_time_0_3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+unstable_time_0_3-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_calendar+unstable_time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+unstable_time_0_3-devel}"
SRC_URI[aarch64_rust-icu_calendar+unstable_time_0_3-devel.sha256sum] = "927b922b94f5d1f608b620c3ccff385837decf0e5a3aac1b737ea3c229588067"

URI_aarch64_rust-icu_calendar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_calendar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar-devel}"
SRC_URI[aarch64_rust-icu_calendar-devel.sha256sum] = "d61faccadd8a4da7ab03a62203bb47905c477cd1fd7ffd7fbe3d72b9f712a95c"

RDEPENDS:rust-icu_calendar+alloc-devel = " \
 cargo \
 rust-icu_calendar-devel \
 rust-icu_locale_core+alloc-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-tinystr+alloc-devel \
 "
RDEPENDS:rust-icu_calendar+compiled_data-devel = " \
 cargo \
 rust-icu_calendar-devel \
 rust-icu_calendar_data-devel \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_calendar+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_calendar+alloc-devel \
 rust-icu_calendar+serde-devel \
 rust-icu_calendar-devel \
 rust-icu_provider+export-devel \
 rust-tinystr+databake-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_calendar+default-devel = " \
 cargo \
 rust-icu_calendar+compiled_data-devel \
 rust-icu_calendar+ixdtf-devel \
 rust-icu_calendar-devel \
 "
RDEPENDS:rust-icu_calendar+ixdtf-devel = " \
 cargo \
 rust-icu_calendar-devel \
 rust-ixdtf-devel \
 "
RDEPENDS:rust-icu_calendar+logging-devel = " \
 cargo \
 rust-calendrical_calculations+logging-devel \
 rust-icu_calendar-devel \
 "
RDEPENDS:rust-icu_calendar+serde-devel = " \
 cargo \
 rust-icu_calendar-devel \
 rust-icu_provider+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-tinystr+serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_calendar+unstable-devel = " \
 cargo \
 rust-icu_calendar-devel \
 "
RDEPENDS:rust-icu_calendar+unstable_chrono_0_4-devel = " \
 cargo \
 rust-chrono-devel \
 rust-icu_calendar-devel \
 "
RDEPENDS:rust-icu_calendar+unstable_jiff_0_2-devel = " \
 cargo \
 rust-icu_calendar-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-icu_calendar+unstable_time_0_3-devel = " \
 cargo \
 rust-icu_calendar-devel \
 rust-time-devel \
 "
RDEPENDS:rust-icu_calendar-devel = " \
 cargo \
 rust \
 rust-calendrical_calculations-devel \
 rust-displaydoc-devel \
 rust-icu_locale_core-devel \
 rust-icu_provider-devel \
 rust-tinystr+zerovec-devel \
 rust-tinystr-devel \
 rust-zerovec+derive-devel \
 rust-zerovec-devel \
 "
