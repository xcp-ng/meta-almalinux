# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-borrow-or-share"
PV = "0.2.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-borrow-or-share+alloc-devel \
 rust-borrow-or-share+default-devel \
 rust-borrow-or-share+std-devel \
 rust-borrow-or-share-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-borrow-or-share-0.2.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b5c7089c23f712879142adb6177517d411c2ac1be49cf258ac44cbbf6471c94"

URI_x86_64_v2_rust-borrow-or-share+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-borrow-or-share+alloc-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-borrow-or-share+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-borrow-or-share+alloc-devel}"
SRC_URI[x86_64_v2_rust-borrow-or-share+alloc-devel.sha256sum] = "86cbcc345e229ccb0bbdfeb73540a752bc0a6fa5ac594509eff7bae2f10cca72"

URI_x86_64_v2_rust-borrow-or-share+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-borrow-or-share+default-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-borrow-or-share+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-borrow-or-share+default-devel}"
SRC_URI[x86_64_v2_rust-borrow-or-share+default-devel.sha256sum] = "1ce01c102d94df0b3161a8b7bb1ffc5b1d1ecc8b6da4c2ae98f80c7f4ff13789"

URI_x86_64_v2_rust-borrow-or-share+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-borrow-or-share+std-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-borrow-or-share+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-borrow-or-share+std-devel}"
SRC_URI[x86_64_v2_rust-borrow-or-share+std-devel.sha256sum] = "774a54c2579cf982a4c5d1a0a4499fdb051a1cb07d44038fbb9e528cbaa43767"

URI_x86_64_v2_rust-borrow-or-share-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-borrow-or-share-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-borrow-or-share-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-borrow-or-share-devel}"
SRC_URI[x86_64_v2_rust-borrow-or-share-devel.sha256sum] = "effa38465e7e418b4ca3d2ee5ffd9643e1f630904c3a70fdb03ded9c7690f60c"

URI_aarch64_rust-borrow-or-share+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-borrow-or-share+alloc-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-borrow-or-share+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-borrow-or-share+alloc-devel}"
SRC_URI[aarch64_rust-borrow-or-share+alloc-devel.sha256sum] = "f18f4099df9445c5b3f9a4a7f1acee6ca126fe46689b12e39aa49e205ecf29fd"

URI_aarch64_rust-borrow-or-share+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-borrow-or-share+default-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-borrow-or-share+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-borrow-or-share+default-devel}"
SRC_URI[aarch64_rust-borrow-or-share+default-devel.sha256sum] = "eab4cc4770b4827c4d7bab47a2b205dace6436719b52592f92a4bbf506028a30"

URI_aarch64_rust-borrow-or-share+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-borrow-or-share+std-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-borrow-or-share+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-borrow-or-share+std-devel}"
SRC_URI[aarch64_rust-borrow-or-share+std-devel.sha256sum] = "ccdef5eea0824a3d567c03926984fdca30d72e6a62b6d456bac074e2454d3475"

URI_aarch64_rust-borrow-or-share-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-borrow-or-share-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-borrow-or-share-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-borrow-or-share-devel}"
SRC_URI[aarch64_rust-borrow-or-share-devel.sha256sum] = "30ac9c3397509f23493a9abf47978acbc30b651a620360663409ea784579eca6"

RDEPENDS:rust-borrow-or-share+alloc-devel = " \
 cargo \
 rust-borrow-or-share-devel \
 "
RDEPENDS:rust-borrow-or-share+default-devel = " \
 cargo \
 rust-borrow-or-share+alloc-devel \
 rust-borrow-or-share-devel \
 "
RDEPENDS:rust-borrow-or-share+std-devel = " \
 cargo \
 rust-borrow-or-share+alloc-devel \
 rust-borrow-or-share-devel \
 "
RDEPENDS:rust-borrow-or-share-devel = " \
 cargo \
 rust \
 "
