# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-deriving-compat"
PV = "0.6.6"
PR = "1.el10_0"
PACKAGES = " \
 ghc-deriving-compat \
 ghc-deriving-compat-devel \
 ghc-deriving-compat-doc \
 ghc-deriving-compat-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-deriving-compat-0.6.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5acad524a1c49419b473c197791a97bd0bcd73d7cadf5160af61c278f950d21c"

URI_x86_64_v2_ghc-deriving-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deriving-compat-0.6.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-deriving-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deriving-compat}"
SRC_URI[x86_64_v2_ghc-deriving-compat.sha256sum] = "f840ab6e86b34059df19f62e42e1cbc661d418be15894d26954940e9b034046f"

URI_x86_64_v2_ghc-deriving-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deriving-compat-devel-0.6.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-deriving-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deriving-compat-devel}"
SRC_URI[x86_64_v2_ghc-deriving-compat-devel.sha256sum] = "378c7273992493a481eb0b94e28e4a024785d778f0ae6fe65bf16615afa4470e"

URI_x86_64_v2_ghc-deriving-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deriving-compat-doc-0.6.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-deriving-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deriving-compat-doc}"
SRC_URI[x86_64_v2_ghc-deriving-compat-doc.sha256sum] = "358157e596ca46879e2dc1549bd397ad963486c7a19575723b24f1d84edad948"

URI_x86_64_v2_ghc-deriving-compat-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deriving-compat-prof-0.6.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-deriving-compat-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deriving-compat-prof}"
SRC_URI[x86_64_v2_ghc-deriving-compat-prof.sha256sum] = "9e90e3e238e45fa0635cea28d757dd2f5089ba62b7c8ae6545e603f64209a8f8"

URI_aarch64_ghc-deriving-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deriving-compat-0.6.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-deriving-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deriving-compat}"
SRC_URI[aarch64_ghc-deriving-compat.sha256sum] = "31b389d7d01cf6519b554d918d7bb9790bbba30ca2c2277216c196d18c321039"

URI_aarch64_ghc-deriving-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deriving-compat-devel-0.6.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-deriving-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deriving-compat-devel}"
SRC_URI[aarch64_ghc-deriving-compat-devel.sha256sum] = "163402af1280716be1b1150ea3074b7cfd2feb8a70f2bd26b5536b174ebfb0e0"

URI_aarch64_ghc-deriving-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deriving-compat-doc-0.6.6-1.el10_0.noarch.rpm;name=aarch64_ghc-deriving-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deriving-compat-doc}"
SRC_URI[aarch64_ghc-deriving-compat-doc.sha256sum] = "947a1dcc79bfda5100bbc67c91bdc9c971eb28f7e8cfe381b4dee24091dfd4bf"

URI_aarch64_ghc-deriving-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deriving-compat-prof-0.6.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-deriving-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deriving-compat-prof}"
SRC_URI[aarch64_ghc-deriving-compat-prof.sha256sum] = "a3f6c9e9c488fd4d0d4b41587bca27494b1ed4e1a8336f457616958bce19f9e1"

RDEPENDS:ghc-deriving-compat = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-th-abstraction \
 ghc-transformers \
 ghc-transformers-compat \
 glibc \
 gmp \
 "
RDEPENDS:ghc-deriving-compat-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deriving-compat \
 ghc-ghc-boot-th-devel \
 ghc-template-haskell-devel \
 ghc-th-abstraction-devel \
 ghc-transformers-compat-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-deriving-compat-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-deriving-compat-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-deriving-compat-devel \
 ghc-ghc-boot-th-prof \
 ghc-template-haskell-prof \
 ghc-th-abstraction-prof \
 ghc-transformers-compat-prof \
 ghc-transformers-prof \
 "
