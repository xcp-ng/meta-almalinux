# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libbpf"
PE = "2"
PV = "1.5.0"
PR = "4.el10"
PACKAGES = " \
 libbpf \
 libbpf-devel \
 libbpf-static \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libbpf-1.5.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4524d4653929cf0ae3f66f5d19f4050dd30ac7db2b07ed1a97d72ab750bca573"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libbpf-1.5.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_libbpf;unpack=0"
SRC_URI[x86_64_v2_libbpf.sha256sum] = "6cca1a44206ad1d63a707728aa82ca9b11aa467f7b9fb7e922bcf05024bd379c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libbpf-devel-1.5.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_libbpf-devel;unpack=0"
SRC_URI[x86_64_v2_libbpf-devel.sha256sum] = "f86c7e76d59436b2a8d850584444e333014b5304d76c980af7300dd8bdc4298c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libbpf-static-1.5.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_libbpf-static;unpack=0"
SRC_URI[x86_64_v2_libbpf-static.sha256sum] = "2d8ecb386780081fe5d5076da9c953de4c493ea177c628bdbc4eea3bc347685b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libbpf-1.5.0-4.el10.aarch64.rpm;name=aarch64_libbpf;unpack=0"
SRC_URI[aarch64_libbpf.sha256sum] = "13d0cf37a7f8a89ac77fc3d1f1c18e22c25d622a5e42e067faac538ef603019b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libbpf-devel-1.5.0-4.el10.aarch64.rpm;name=aarch64_libbpf-devel;unpack=0"
SRC_URI[aarch64_libbpf-devel.sha256sum] = "ff4b1af2314be83359e52eb1a90752e151f5673c78156ed68570a3877d77b86e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libbpf-static-1.5.0-4.el10.aarch64.rpm;name=aarch64_libbpf-static;unpack=0"
SRC_URI[aarch64_libbpf-static.sha256sum] = "d38b1b2db90fda5d65b86f5ef5a6df6f3c35881f684953f5b668ea95b68a35ec"

RDEPENDS:libbpf = " \
 elfutils-libelf \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:libbpf-devel = " \
 elfutils-libelf-devel \
 kernel-headers \
 libbpf \
 pkgconf-pkg-config \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:libbpf-static = " \
 libbpf-devel \
 "
