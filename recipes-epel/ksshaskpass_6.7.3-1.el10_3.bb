# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksshaskpass"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 ksshaskpass \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksshaskpass-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fda7390a00e2c3f5ef40b87b6a4466373a66911dd686eced03a4542cc8e56732"

URI_x86_64_v2_ksshaskpass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksshaskpass-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksshaskpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksshaskpass}"
SRC_URI[x86_64_v2_ksshaskpass.sha256sum] = "40bb97ad472a3f3abe20ffd17a8d2d31813ebc14ab2c31a465df1222917df3a0"

URI_aarch64_ksshaskpass = "${EPEL_MIRROR}/aarch64/Packages/k/ksshaskpass-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_ksshaskpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksshaskpass}"
SRC_URI[aarch64_ksshaskpass.sha256sum] = "bd6d24d650895d6a66137956b2d58a48856aac3d261c3e4fce89758fb361df6e"

RDEPENDS:ksshaskpass = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
