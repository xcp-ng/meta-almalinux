# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xcb-util-keysyms"
PV = "0.4.1"
PR = "7.el10"
PACKAGES = " \
 xcb-util-keysyms \
 xcb-util-keysyms-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xcb-util-keysyms-0.4.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7bce79015d2e540e10f7297a303173a454b4274709f3439d73b48e33fa02d9d"

URI_x86_64_v2_xcb-util-keysyms = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xcb-util-keysyms-0.4.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_xcb-util-keysyms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xcb-util-keysyms}"
SRC_URI[x86_64_v2_xcb-util-keysyms.sha256sum] = "a10e993d1076830e0efa006cd704c72e3728f9ef028c124f627b46a06a58f8ab"

URI_x86_64_v2_xcb-util-keysyms-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xcb-util-keysyms-devel-0.4.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_xcb-util-keysyms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xcb-util-keysyms-devel}"
SRC_URI[x86_64_v2_xcb-util-keysyms-devel.sha256sum] = "ef075c6b81bc28bdc22301fc39777642c77bf751178f2f80d6559b8dba91ce52"

URI_aarch64_xcb-util-keysyms = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xcb-util-keysyms-0.4.1-7.el10.aarch64.rpm;name=aarch64_xcb-util-keysyms;unpack=0"
SRC_URI:append = " ${URI_aarch64_xcb-util-keysyms}"
SRC_URI[aarch64_xcb-util-keysyms.sha256sum] = "8ae502feeea2260077696b0822d01c83fe411e91a73dcbdab8973a621b05b10d"

URI_aarch64_xcb-util-keysyms-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xcb-util-keysyms-devel-0.4.1-7.el10.aarch64.rpm;name=aarch64_xcb-util-keysyms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xcb-util-keysyms-devel}"
SRC_URI[aarch64_xcb-util-keysyms-devel.sha256sum] = "12a2cb97ba3ee099937fa4d368df8c129197a2d5fe502eaa2eb6f130cfe2f4fb"

RDEPENDS:xcb-util-keysyms = " \
 glibc \
 libxcb \
 "
RDEPENDS:xcb-util-keysyms-devel = " \
 libxcb-devel \
 pkgconf-pkg-config \
 xcb-util-keysyms \
 "
