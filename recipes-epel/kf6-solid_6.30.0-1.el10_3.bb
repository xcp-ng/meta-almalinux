# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-solid"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-solid \
 kf6-solid-devel \
 kf6-solid-doc \
 kf6-solid-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-solid-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "76fdc023060de211cc46156a2f6b8067890871a374a799c40a1676d5f45a1014"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-solid;unpack=0"
SRC_URI[x86_64_v2_kf6-solid.sha256sum] = "12dc87720dedcaf24fcde013fb12cb7bd9c2a1ad3220d3c38d40967b6b1520d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-solid-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-solid-devel.sha256sum] = "4191e96f5f191738eeefd58927001fc2139b8f50d72f096eec129f648ab2860b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-solid-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-solid-doc.sha256sum] = "7b357d0f4b7ae323740b3adbb507c8b210015e8f852d25cf7aaccc66d71b51e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-solid-html;unpack=0"
SRC_URI[x86_64_v2_kf6-solid-html.sha256sum] = "638e0e71de6f46a96d027038abec56cfab5b227cbc2b6636b5826c75a94d651f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-solid;unpack=0"
SRC_URI[aarch64_kf6-solid.sha256sum] = "46d6d183f52bbe297d6e6922f4b7d7a61f5c5402c95c6d31c2765151008c0515"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-solid-devel;unpack=0"
SRC_URI[aarch64_kf6-solid-devel.sha256sum] = "a7f20760060a6a26b5e4c10c8beeceebf5d146ccd7c70a2bc9b41f86910ca393"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-solid-doc;unpack=0"
SRC_URI[aarch64_kf6-solid-doc.sha256sum] = "202e28e86e6f3405026498e7e770de44526e5d713e738cbf8df9a5f2a8de58df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-solid-html;unpack=0"
SRC_URI[aarch64_kf6-solid-html.sha256sum] = "5dc634e71b8d341ac4b5f48e74d18093c8a66ea1a0befcfdb1f51a08d922e601"

RDEPENDS:kf6-solid = " \
 glibc \
 kf6-filesystem \
 libimobiledevice \
 libmount \
 libplist \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 systemd-libs \
 "
RDEPENDS:kf6-solid-devel = " \
 cmake-filesystem \
 kf6-solid \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-solid-doc = " \
 "
RDEPENDS:kf6-solid-html = " \
 "
