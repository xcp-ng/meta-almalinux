# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libspf2"
PV = "1.2.11"
PR = "16.20210922git4915c308.el10_0"
PACKAGES = " \
 libspf2 \
 libspf2-apidocs \
 libspf2-devel \
 libspf2-progs \
 perl-Mail-SPF_XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libspf2-1.2.11-16.20210922git4915c308.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3670e649502f79bc87d3cd84a2cbc9839102fba373f49e53874c707d6bf598a"

URI_x86_64_v2_libspf2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libspf2-1.2.11-16.20210922git4915c308.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libspf2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libspf2}"
SRC_URI[x86_64_v2_libspf2.sha256sum] = "6aa50a1c3851db8d974e8b0caf5f52c902eb9a91bc6e084c728fd0f45ee27425"

URI_x86_64_v2_libspf2-apidocs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libspf2-apidocs-1.2.11-16.20210922git4915c308.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libspf2-apidocs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libspf2-apidocs}"
SRC_URI[x86_64_v2_libspf2-apidocs.sha256sum] = "73b98034d094213e89d1fbd451dd4f6f6e08c05f153684f8b554785caa54eb17"

URI_x86_64_v2_libspf2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libspf2-devel-1.2.11-16.20210922git4915c308.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libspf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libspf2-devel}"
SRC_URI[x86_64_v2_libspf2-devel.sha256sum] = "2260faa544bd6ad51a1205b54a8cc1f96ab98db9290e2c6b4b8a5335140e7d0a"

URI_x86_64_v2_libspf2-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libspf2-progs-1.2.11-16.20210922git4915c308.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libspf2-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libspf2-progs}"
SRC_URI[x86_64_v2_libspf2-progs.sha256sum] = "0611ceb74182f340f95fe47a3736f887cfd610dc06f6f0e55035f9ec5a5ad686"

URI_x86_64_v2_perl-Mail-SPF_XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Mail-SPF_XS-1.2.11-16.20210922git4915c308.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Mail-SPF_XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Mail-SPF_XS}"
SRC_URI[x86_64_v2_perl-Mail-SPF_XS.sha256sum] = "c6435675b0e700842a61a97465a702348dbcc15b362886e8ab9114d0339d07f8"

URI_aarch64_libspf2 = "${EPEL_MIRROR}/aarch64/Packages/l/libspf2-1.2.11-16.20210922git4915c308.el10_0.aarch64.rpm;name=aarch64_libspf2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libspf2}"
SRC_URI[aarch64_libspf2.sha256sum] = "78a2686ab59362db2a549ed18f9a57de7489a7a91374ad7e97e3c288035ce769"

URI_aarch64_libspf2-apidocs = "${EPEL_MIRROR}/aarch64/Packages/l/libspf2-apidocs-1.2.11-16.20210922git4915c308.el10_0.noarch.rpm;name=aarch64_libspf2-apidocs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libspf2-apidocs}"
SRC_URI[aarch64_libspf2-apidocs.sha256sum] = "c82b91263c84d30a367e21fd51962f8c8b6db12bb4d366df1b0071933d65dbeb"

URI_aarch64_libspf2-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libspf2-devel-1.2.11-16.20210922git4915c308.el10_0.aarch64.rpm;name=aarch64_libspf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libspf2-devel}"
SRC_URI[aarch64_libspf2-devel.sha256sum] = "4b32f43ffbe9d99e9d658ebd372ea6cd5b98a593830600c9f297e0de0a330300"

URI_aarch64_libspf2-progs = "${EPEL_MIRROR}/aarch64/Packages/l/libspf2-progs-1.2.11-16.20210922git4915c308.el10_0.aarch64.rpm;name=aarch64_libspf2-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libspf2-progs}"
SRC_URI[aarch64_libspf2-progs.sha256sum] = "a55610356498ad96f10cb659559021962898becce6caaddc175f68f9b6747b17"

URI_aarch64_perl-Mail-SPF_XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Mail-SPF_XS-1.2.11-16.20210922git4915c308.el10_0.aarch64.rpm;name=aarch64_perl-Mail-SPF_XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Mail-SPF_XS}"
SRC_URI[aarch64_perl-Mail-SPF_XS.sha256sum] = "22ea6dbfeffb1eb092104c1adab0d6ffa4c0b791f6bbe2d25a0cb5c21d686b01"

RDEPENDS:libspf2 = " \
 glibc \
 "
RDEPENDS:libspf2-apidocs = " \
 libspf2 \
 "
RDEPENDS:libspf2-devel = " \
 libspf2 \
 "
RDEPENDS:libspf2-progs = " \
 alternatives \
 bash \
 glibc \
 libspf2 \
 virtual//usr/bin/readlink \
 "
RDEPENDS:perl-Mail-SPF_XS = " \
 glibc \
 libspf2 \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
