# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cinderclient"
PV = "9.9.0"
PR = "2.el10_3"
PACKAGES = " \
 python-cinderclient-doc \
 python3-cinderclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cinderclient-9.9.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a4b4c54ca63b4a9c13c50abf8d6da19e3225210cf48ab39a602816223a3ec07"

URI_x86_64_v2_python-cinderclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-cinderclient-doc-9.9.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-cinderclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-cinderclient-doc}"
SRC_URI[x86_64_v2_python-cinderclient-doc.sha256sum] = "ab8c35538520060194192ba8e4e609276141f05d4c1bf2df57c0b069b974a5c6"

URI_x86_64_v2_python3-cinderclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cinderclient-9.9.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cinderclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cinderclient}"
SRC_URI[x86_64_v2_python3-cinderclient.sha256sum] = "eb546e54fcf98def194d63a1951d30c07e5b7c607707419d67586cc3804ca7a0"

URI_aarch64_python-cinderclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-cinderclient-doc-9.9.0-2.el10_3.noarch.rpm;name=aarch64_python-cinderclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-cinderclient-doc}"
SRC_URI[aarch64_python-cinderclient-doc.sha256sum] = "70ecaebbd992192727c5559820eebdac8571500344959b44348242f1f6b0bdfe"

URI_aarch64_python3-cinderclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cinderclient-9.9.0-2.el10_3.noarch.rpm;name=aarch64_python3-cinderclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cinderclient}"
SRC_URI[aarch64_python3-cinderclient.sha256sum] = "2e11a2c1a096bb6848adb7b90a41d5c54c59b6d39c310f86e67e3db603e58d38"

RDEPENDS:python-cinderclient-doc = " \
 "
RDEPENDS:python3-cinderclient = " \
 python3 \
 python3-keystoneauth1 \
 python3-oslo-i18n \
 python3-oslo-utils \
 python3-pbr \
 python3-prettytable \
 python3-requests \
 python3-stevedore \
 "
