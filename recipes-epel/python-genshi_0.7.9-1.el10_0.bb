# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-genshi"
PV = "0.7.9"
PR = "1.el10_0"
PACKAGES = " \
 python3-genshi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-genshi-0.7.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49a2b0cc43a02e7184c935c09399906178e02f94058a090a79af3db3e7f47b7f"

URI_x86_64_v2_python3-genshi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-genshi-0.7.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-genshi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-genshi}"
SRC_URI[x86_64_v2_python3-genshi.sha256sum] = "274fb81e448ece1719a5f670b08ea2f0eb94312a28ad94554ea2dcec5a0d4cae"

URI_aarch64_python3-genshi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-genshi-0.7.9-1.el10_0.aarch64.rpm;name=aarch64_python3-genshi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-genshi}"
SRC_URI[aarch64_python3-genshi.sha256sum] = "c0d46f22b81261903b99a68fae04f8646a802139ea8381c5f29f54aa3e61b46c"

RDEPENDS:python3-genshi = " \
 glibc \
 python3 \
 python3-six \
 "
