# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-influxdb-client"
PV = "1.50.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-influxdb-client \
 python3-influxdb-client+async \
 python3-influxdb-client+extra \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-influxdb-client-1.50.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb9caca78d59160d4795655f3dff0e4833807341962ac72c27427a76e3147ae5"

URI_x86_64_v2_python3-influxdb-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-influxdb-client-1.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-influxdb-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-influxdb-client}"
SRC_URI[x86_64_v2_python3-influxdb-client.sha256sum] = "aa262aad47e162d02d7385c3dd6bb72d466af5b61bbcbcfd561e8ed99b79fb55"

URI_x86_64_v2_python3-influxdb-client+async = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-influxdb-client+async-1.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-influxdb-client+async;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-influxdb-client+async}"
SRC_URI[x86_64_v2_python3-influxdb-client+async.sha256sum] = "c3032699d6c65eec6886ad08e0b94ab981af0270918b845a1c6016ee77aa0118"

URI_x86_64_v2_python3-influxdb-client+extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-influxdb-client+extra-1.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-influxdb-client+extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-influxdb-client+extra}"
SRC_URI[x86_64_v2_python3-influxdb-client+extra.sha256sum] = "4ce13f0939c01203b2fe624c075aedf5fca03d7c2fd7941359d7f560618e5842"

URI_aarch64_python3-influxdb-client = "${EPEL_MIRROR}/aarch64/Packages/p/python3-influxdb-client-1.50.0-1.el10_2.noarch.rpm;name=aarch64_python3-influxdb-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-influxdb-client}"
SRC_URI[aarch64_python3-influxdb-client.sha256sum] = "e74ebead046dc705271fa2aee6af7d8180f9d65ebcae226b5e00cc1875cc4458"

URI_aarch64_python3-influxdb-client+async = "${EPEL_MIRROR}/aarch64/Packages/p/python3-influxdb-client+async-1.50.0-1.el10_2.noarch.rpm;name=aarch64_python3-influxdb-client+async;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-influxdb-client+async}"
SRC_URI[aarch64_python3-influxdb-client+async.sha256sum] = "3ec85cd90baf759c781cee3e8d13b58660dcea3a20a89cc83af9af291785a9e7"

URI_aarch64_python3-influxdb-client+extra = "${EPEL_MIRROR}/aarch64/Packages/p/python3-influxdb-client+extra-1.50.0-1.el10_2.noarch.rpm;name=aarch64_python3-influxdb-client+extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-influxdb-client+extra}"
SRC_URI[aarch64_python3-influxdb-client+extra.sha256sum] = "20fe1a95d4a20731e00ac5c032519f5cb8d070fafe5cbd0bc60398da056b7eec"

RDEPENDS:python3-influxdb-client = " \
 python3 \
 python3-certifi \
 python3-dateutil \
 python3-rx \
 python3-urllib3 \
 "
RDEPENDS:python3-influxdb-client+async = " \
 python3 \
 python3-aiohttp \
 python3-influxdb-client \
 "
RDEPENDS:python3-influxdb-client+extra = " \
 python3 \
 python3-influxdb-client \
 python3-numpy \
 python3-pandas \
 "
