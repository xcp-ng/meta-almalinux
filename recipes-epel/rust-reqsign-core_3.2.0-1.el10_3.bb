# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-core"
PV = "3.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-core+default-devel \
 rust-reqsign-core+jwt-devel \
 rust-reqsign-core-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-core-3.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "42fc8d3786d64b35457150153aa35af261dbaf4e00625d0f79d248d20dbae059"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-core+default-devel-3.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-core+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-core+default-devel.sha256sum] = "b70fff3384ad647a8670c632bcbcaa4ebb7612479eaaa24b0592b4ab18b44250"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-core+jwt-devel-3.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-core+jwt-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-core+jwt-devel.sha256sum] = "49bff6ee5356f8d07232bf5579f5843caae96af62260d18167424c3ff32738fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-core-devel-3.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-core-devel.sha256sum] = "d89de395cf385723bd3ac81fdda75d598daf972262366692650ed3c8bc1a21c2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-core+default-devel-3.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-core+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-core+default-devel.sha256sum] = "81c3ac58cfb3f044e231525ca22db6ca6b74794107e309131bff175201128ddd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-core+jwt-devel-3.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-core+jwt-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-core+jwt-devel.sha256sum] = "68e1dd461cb38419e76f88ddea76e672ccfca4dcc79c345a8183ad5224405eee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-core-devel-3.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-core-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-core-devel.sha256sum] = "786ac4b8d5e7b1efc73f3d5d4d3ae6a1d9561e04a2d8bc51e990e0377d0eb4da"

RDEPENDS:rust-reqsign-core+default-devel = " \
 cargo \
 rust-reqsign-core-devel \
 "
RDEPENDS:rust-reqsign-core+jwt-devel = " \
 cargo \
 rust-reqsign-core-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-reqsign-core-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-base64_0.22+default-devel \
 rust-bytes+default-devel \
 rust-futures+default-devel \
 rust-hex+default-devel \
 rust-hmac+default-devel \
 rust-http+default-devel \
 rust-jiff+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-sha1+default-devel \
 rust-sha2+default-devel \
 rust-sha2+oid-devel \
 "
