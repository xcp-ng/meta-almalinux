# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "adwaita-fonts"
PV = "49.0"
PR = "6.el10_2"
PACKAGES = " \
 adwaita-fonts-all \
 adwaita-mono-fonts \
 adwaita-sans-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/adwaita-fonts-49.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81fcabc78b26858cb919ab687be8cddde60cf7248550882bcc842dd84484e07f"

URI_x86_64_v2_adwaita-fonts-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/adwaita-fonts-all-49.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_adwaita-fonts-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adwaita-fonts-all}"
SRC_URI[x86_64_v2_adwaita-fonts-all.sha256sum] = "93042804e8146e28d72fb3c178b4032cc37018d8736806428a29db469f2868a8"

URI_x86_64_v2_adwaita-mono-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/adwaita-mono-fonts-49.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_adwaita-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adwaita-mono-fonts}"
SRC_URI[x86_64_v2_adwaita-mono-fonts.sha256sum] = "282491426f0fd8d85cfae7919df3e96f21b1561f873c3cd2c5b494760c96b988"

URI_x86_64_v2_adwaita-sans-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/adwaita-sans-fonts-49.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_adwaita-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adwaita-sans-fonts}"
SRC_URI[x86_64_v2_adwaita-sans-fonts.sha256sum] = "de163bafd908bda386f101218486f3d06c5749856c5b5b8964a549b666ecc6e7"

URI_aarch64_adwaita-fonts-all = "${EPEL_MIRROR}/aarch64/Packages/a/adwaita-fonts-all-49.0-6.el10_2.noarch.rpm;name=aarch64_adwaita-fonts-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_adwaita-fonts-all}"
SRC_URI[aarch64_adwaita-fonts-all.sha256sum] = "6b0b0fdc4285c5d98a4a4b9f0adccd40099718b4bcc6e97fb25f383e2ca54217"

URI_aarch64_adwaita-mono-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/adwaita-mono-fonts-49.0-6.el10_2.noarch.rpm;name=aarch64_adwaita-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_adwaita-mono-fonts}"
SRC_URI[aarch64_adwaita-mono-fonts.sha256sum] = "b2f9239d371b6e202499ac6811906e4e71f246b6edcb78b82a02429db887ae9f"

URI_aarch64_adwaita-sans-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/adwaita-sans-fonts-49.0-6.el10_2.noarch.rpm;name=aarch64_adwaita-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_adwaita-sans-fonts}"
SRC_URI[aarch64_adwaita-sans-fonts.sha256sum] = "20a8105fe3395d741e59231d9d2a5fe22f5b09baf68d99c7e85d7d8df94752a1"

RDEPENDS:adwaita-fonts-all = " \
 adwaita-mono-fonts \
 adwaita-sans-fonts \
 "
RDEPENDS:adwaita-mono-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:adwaita-sans-fonts = " \
 fonts-filesystem \
 "
