# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kitty"
PV = "0.43.1"
PR = "1.el10_2"
PACKAGES = " \
 kitty \
 kitty-doc \
 kitty-kitten \
 kitty-shell-integration \
 kitty-terminfo \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kitty-0.43.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e3c77eb2e23e8ea5a3852f13bf9713dda4074944551711a13bfcce08c94c400c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-0.43.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitty;unpack=0"
SRC_URI[x86_64_v2_kitty.sha256sum] = "13ae8fc70ec0eed6aff124002dc23bfa014a53d8201329845bcd34936c2f3d4a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-doc-0.43.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kitty-doc;unpack=0"
SRC_URI[x86_64_v2_kitty-doc.sha256sum] = "bf0c38f36550d3cc493689a7b773ce6fa5031f7e1fc48261d39effeb698dd672"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-kitten-0.43.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitty-kitten;unpack=0"
SRC_URI[x86_64_v2_kitty-kitten.sha256sum] = "ac39110413e02bd6ef75241c28fb1c14734c229461edf1d68037426f9f846607"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-shell-integration-0.43.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kitty-shell-integration;unpack=0"
SRC_URI[x86_64_v2_kitty-shell-integration.sha256sum] = "13b5a70630621577ec23fd16369a713e302c61343e333fa3a1b7d901ea8c329a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-terminfo-0.43.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kitty-terminfo;unpack=0"
SRC_URI[x86_64_v2_kitty-terminfo.sha256sum] = "4c86624b84b91367eac9c6b1156077b965ef5df154193f8009a17d2543fb8388"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kitty-0.43.1-1.el10_2.aarch64.rpm;name=aarch64_kitty;unpack=0"
SRC_URI[aarch64_kitty.sha256sum] = "9d597fe910269ae665f30ac77cccc9cc9c52ecd7b63326e233dc0620c17adeb2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kitty-doc-0.43.1-1.el10_2.noarch.rpm;name=aarch64_kitty-doc;unpack=0"
SRC_URI[aarch64_kitty-doc.sha256sum] = "da1d1452fd797594df25e97299084b75d32d0173a809872c05df8f4cb182deff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kitty-kitten-0.43.1-1.el10_2.aarch64.rpm;name=aarch64_kitty-kitten;unpack=0"
SRC_URI[aarch64_kitty-kitten.sha256sum] = "5550e4aa5c2ee028e3c1d3900258d5bd6051a478dae933dbf994827bc6e7f3bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kitty-shell-integration-0.43.1-1.el10_2.noarch.rpm;name=aarch64_kitty-shell-integration;unpack=0"
SRC_URI[aarch64_kitty-shell-integration.sha256sum] = "2a2ba795d7c6c967daeda2343ee68ba75d5dbb3f8f0f83d3e56bb43a07778c02"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kitty-terminfo-0.43.1-1.el10_2.noarch.rpm;name=aarch64_kitty-terminfo;unpack=0"
SRC_URI[aarch64_kitty-terminfo.sha256sum] = "8136ff0bc40f35575b1698332d450c5ec9743fd1275a999ba7c96b3f9a62a4b0"

RDEPENDS:kitty = " \
 cairo \
 dbus-libs \
 freetype \
 glibc \
 harfbuzz \
 hicolor-icon-theme \
 kitty-kitten \
 kitty-shell-integration \
 kitty-terminfo \
 lcms2 \
 libX11 \
 libX11-xcb \
 libXcursor \
 libgcc \
 libpng \
 libwayland-client \
 libxkbcommon \
 libxkbcommon-x11 \
 openssl-libs \
 python3 \
 python3-libs \
 xxhash-libs \
 zlib-ng-compat \
 "
RDEPENDS:kitty-doc = " \
 "
RDEPENDS:kitty-kitten = " \
 glibc \
 "
RDEPENDS:kitty-shell-integration = " \
 bash \
 "
RDEPENDS:kitty-terminfo = " \
 ncurses-base \
 "
