# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crypto-policies"
PV = "20250905"
PR = "2.gitc7eb7b2.el10_1.1"
PACKAGES = " \
 crypto-policies \
 crypto-policies-pq-preview \
 crypto-policies-scripts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/crypto-policies-20250905-2.gitc7eb7b2.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be3f15630e390c98d86171954ad99da06a65558e7220bfc06844f1b96358984f"

URI_x86_64_v2_crypto-policies = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/crypto-policies-20250905-2.gitc7eb7b2.el10_1.1.noarch.rpm;name=x86_64_v2_crypto-policies;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crypto-policies}"
SRC_URI[x86_64_v2_crypto-policies.sha256sum] = "66ea1fdb27bf84ae6a8e008fe009b114bc13628fdaf1aa92dc7eaab01fa7e9be"

URI_x86_64_v2_crypto-policies-pq-preview = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crypto-policies-pq-preview-20250905-2.gitc7eb7b2.el10_1.1.noarch.rpm;name=x86_64_v2_crypto-policies-pq-preview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crypto-policies-pq-preview}"
SRC_URI[x86_64_v2_crypto-policies-pq-preview.sha256sum] = "262acaaab33e6d511c020c3971df2a6bbc774acfa90a565cf22f008adcbd218f"

URI_x86_64_v2_crypto-policies-scripts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/crypto-policies-scripts-20250905-2.gitc7eb7b2.el10_1.1.noarch.rpm;name=x86_64_v2_crypto-policies-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crypto-policies-scripts}"
SRC_URI[x86_64_v2_crypto-policies-scripts.sha256sum] = "392905cee4351207d724da389fab8f84d6175169bafab2bbf4de484ffa97609f"

URI_aarch64_crypto-policies = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/crypto-policies-20250905-2.gitc7eb7b2.el10_1.1.noarch.rpm;name=aarch64_crypto-policies;unpack=0"
SRC_URI:append = " ${URI_aarch64_crypto-policies}"
SRC_URI[aarch64_crypto-policies.sha256sum] = "66ea1fdb27bf84ae6a8e008fe009b114bc13628fdaf1aa92dc7eaab01fa7e9be"

URI_aarch64_crypto-policies-pq-preview = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crypto-policies-pq-preview-20250905-2.gitc7eb7b2.el10_1.1.noarch.rpm;name=aarch64_crypto-policies-pq-preview;unpack=0"
SRC_URI:append = " ${URI_aarch64_crypto-policies-pq-preview}"
SRC_URI[aarch64_crypto-policies-pq-preview.sha256sum] = "262acaaab33e6d511c020c3971df2a6bbc774acfa90a565cf22f008adcbd218f"

URI_aarch64_crypto-policies-scripts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/crypto-policies-scripts-20250905-2.gitc7eb7b2.el10_1.1.noarch.rpm;name=aarch64_crypto-policies-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_crypto-policies-scripts}"
SRC_URI[aarch64_crypto-policies-scripts.sha256sum] = "392905cee4351207d724da389fab8f84d6175169bafab2bbf4de484ffa97609f"

RDEPENDS:crypto-policies = " \
 bash \
 "
RDEPENDS:crypto-policies-pq-preview = " \
 crypto-policies \
 "
RDEPENDS:crypto-policies-scripts = " \
 bash \
 crypto-policies \
 python3 \
 "
