# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpsd"
PE = "1"
PV = "3.25"
PR = "17.el10"
PACKAGES = " \
 gpsd \
 gpsd-clients \
 python3-gpsd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gpsd-3.25-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4d7e5df2b297a2bfb26135be1a5c4a56011a3275f968082e415316730cf9236"

URI_x86_64_v2_gpsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gpsd-3.25-17.el10.x86_64_v2.rpm;name=x86_64_v2_gpsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsd}"
SRC_URI[x86_64_v2_gpsd.sha256sum] = "ab3f41063c738beb00509ef08e5c8dd300ecfd8cc85e1b27f106c13f8ba309ba"

URI_x86_64_v2_gpsd-clients = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gpsd-clients-3.25-17.el10.x86_64_v2.rpm;name=x86_64_v2_gpsd-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsd-clients}"
SRC_URI[x86_64_v2_gpsd-clients.sha256sum] = "432d2e4cd8eb412a55a555feffb78c0da1fec95c807aa526f4d0f77aecfcc55e"

URI_x86_64_v2_python3-gpsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-gpsd-3.25-17.el10.x86_64_v2.rpm;name=x86_64_v2_python3-gpsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gpsd}"
SRC_URI[x86_64_v2_python3-gpsd.sha256sum] = "629a67b2cdbc993ddc1240fcc2a0f69d2f3ffaee33d6141a40bf6d43b7160c64"

URI_aarch64_gpsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gpsd-3.25-17.el10.aarch64.rpm;name=aarch64_gpsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd}"
SRC_URI[aarch64_gpsd.sha256sum] = "c02f03f5f6a218b298c5b49b6869bed9d031ca9912ccd14a0331c892dd9cff1d"

URI_aarch64_gpsd-clients = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gpsd-clients-3.25-17.el10.aarch64.rpm;name=aarch64_gpsd-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd-clients}"
SRC_URI[aarch64_gpsd-clients.sha256sum] = "97c40373bdc172a37745e5405700caa2625d428dbc2ed034b5f67f02c8c97af0"

URI_aarch64_python3-gpsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-gpsd-3.25-17.el10.aarch64.rpm;name=aarch64_python3-gpsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gpsd}"
SRC_URI[aarch64_python3-gpsd.sha256sum] = "aa1eeb3dea335aca983bcf3b10ac00967b64f403c4936d4a9d80f4141abe299c"

RDEPENDS:gpsd = " \
 bash \
 bluez-libs \
 dbus-libs \
 glibc \
 libusb1 \
 ncurses-libs \
 systemd \
 systemd-udev \
 "
RDEPENDS:gpsd-clients = " \
 bash \
 bluez-libs \
 dbus-libs \
 glibc \
 libusb1 \
 ncurses-libs \
 python3 \
 python3-gpsd \
 "
RDEPENDS:python3-gpsd = " \
 glibc \
 python3 \
 python3-pyserial \
 "
