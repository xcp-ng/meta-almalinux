# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-zmq"
PV = "26.3.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-pyzmq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-zmq-26.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15f45f5d9892c4b311e7637f67e098c53f4bd26b70d00b9a93b0019a27c32b97"

URI_x86_64_v2_python3-pyzmq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyzmq-26.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyzmq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyzmq}"
SRC_URI[x86_64_v2_python3-pyzmq.sha256sum] = "d27cdfe0ea99ff27132584345cc672a3302c41c2ed2f7b3d3be7f3da7eb373d0"

URI_aarch64_python3-pyzmq = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyzmq-26.3.0-1.el10_0.aarch64.rpm;name=aarch64_python3-pyzmq;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyzmq}"
SRC_URI[aarch64_python3-pyzmq.sha256sum] = "305a92f637628a3097257d186eabd5a7620d13eb66707e500ba6524c7c2fe71e"

RDEPENDS:python3-pyzmq = " \
 glibc \
 python3 \
 zeromq \
 "
