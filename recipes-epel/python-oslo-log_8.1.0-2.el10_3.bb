# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslo-log"
PV = "8.1.0"
PR = "2.el10_3"
PACKAGES = " \
 python-oslo-log-doc \
 python-oslo-log-lang \
 python3-oslo-log \
 python3-oslo-log-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-oslo-log-8.1.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c873d2cd78ebef94616592a701a52e51d9172cda0e7a35969d6bfd27a4a5e1d"

URI_x86_64_v2_python-oslo-log-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-log-doc-8.1.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-log-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-log-doc}"
SRC_URI[x86_64_v2_python-oslo-log-doc.sha256sum] = "bcdb68a1234b3dd245400e3894ececc0875ffddb31685f918ba577149a0aeee0"

URI_x86_64_v2_python-oslo-log-lang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-log-lang-8.1.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-log-lang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-log-lang}"
SRC_URI[x86_64_v2_python-oslo-log-lang.sha256sum] = "6afe88da2272a8614d87a30a888b959c49e88754664551189bbe999fd0a2e78f"

URI_x86_64_v2_python3-oslo-log = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-log-8.1.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-log}"
SRC_URI[x86_64_v2_python3-oslo-log.sha256sum] = "bff98ae5d98faab6966a1e6a5a23feab0a20c97269416da772ec57bcfc52b103"

URI_x86_64_v2_python3-oslo-log-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-log-tests-8.1.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-log-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-log-tests}"
SRC_URI[x86_64_v2_python3-oslo-log-tests.sha256sum] = "32334bf89f671ff0a1c6b9888175498198ce06b364bed85a1ea042c9780d59b8"

URI_aarch64_python-oslo-log-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-log-doc-8.1.0-2.el10_3.noarch.rpm;name=aarch64_python-oslo-log-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-log-doc}"
SRC_URI[aarch64_python-oslo-log-doc.sha256sum] = "cef3376d990e437e8d447c9099108e96c3ca431033c4db287dd0ccf99da174cb"

URI_aarch64_python-oslo-log-lang = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-log-lang-8.1.0-2.el10_3.noarch.rpm;name=aarch64_python-oslo-log-lang;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-log-lang}"
SRC_URI[aarch64_python-oslo-log-lang.sha256sum] = "d850672e949478a4c8f7d7bee186e562e0b1e2e21a392b9c2919a4a514d2287c"

URI_aarch64_python3-oslo-log = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-log-8.1.0-2.el10_3.noarch.rpm;name=aarch64_python3-oslo-log;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-log}"
SRC_URI[aarch64_python3-oslo-log.sha256sum] = "91a0e2c64fb79996938d473bd2a362716e74b88dfbd89ad50b46be5ad2f495fb"

URI_aarch64_python3-oslo-log-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-log-tests-8.1.0-2.el10_3.noarch.rpm;name=aarch64_python3-oslo-log-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-log-tests}"
SRC_URI[aarch64_python3-oslo-log-tests.sha256sum] = "1ef5982c1ffaa8fb1401b40ebb8e3b921fae7cf834a9ac4dcd5f29b8529af8e3"

RDEPENDS:python-oslo-log-doc = " \
 "
RDEPENDS:python-oslo-log-lang = " \
 "
RDEPENDS:python3-oslo-log = " \
 python-oslo-log-lang \
 python3 \
 python3-dateutil \
 python3-debtcollector \
 python3-oslo-config \
 python3-oslo-context \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 "
RDEPENDS:python3-oslo-log-tests = " \
 python3 \
 python3-oslo-log \
 "
