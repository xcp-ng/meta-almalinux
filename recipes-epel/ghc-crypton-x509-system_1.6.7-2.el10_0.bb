# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-crypton-x509-system"
PV = "1.6.7"
PR = "2.el10_0"
PACKAGES = " \
 ghc-crypton-x509-system \
 ghc-crypton-x509-system-devel \
 ghc-crypton-x509-system-doc \
 ghc-crypton-x509-system-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-crypton-x509-system-1.6.7-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43f215258de4b075d2d5edc955ef1648f3d6635c8e9153ced47d42ff2e97562d"

URI_x86_64_v2_ghc-crypton-x509-system = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-x509-system-1.6.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypton-x509-system;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-x509-system}"
SRC_URI[x86_64_v2_ghc-crypton-x509-system.sha256sum] = "6eaf518145a532e9f6f6b95c08cfd3d496404be75dac2caebe01e8a74395f189"

URI_x86_64_v2_ghc-crypton-x509-system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-x509-system-devel-1.6.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypton-x509-system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-x509-system-devel}"
SRC_URI[x86_64_v2_ghc-crypton-x509-system-devel.sha256sum] = "93bb3ac92baf2299bbeb1a5c4e183ba3917eebe321c0b0e3c41ecc89e1d1c621"

URI_x86_64_v2_ghc-crypton-x509-system-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-x509-system-doc-1.6.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-crypton-x509-system-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-x509-system-doc}"
SRC_URI[x86_64_v2_ghc-crypton-x509-system-doc.sha256sum] = "432c122ed247bdc26cdb0bb5d0661cfdd0c123a17afd922f489848791e77367e"

URI_x86_64_v2_ghc-crypton-x509-system-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-x509-system-prof-1.6.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypton-x509-system-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-x509-system-prof}"
SRC_URI[x86_64_v2_ghc-crypton-x509-system-prof.sha256sum] = "e3a9d228970c653233091f5325bccdc9d664cad913d4ac978fd4ab04d1afd53e"

URI_aarch64_ghc-crypton-x509-system = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-x509-system-1.6.7-2.el10_0.aarch64.rpm;name=aarch64_ghc-crypton-x509-system;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-x509-system}"
SRC_URI[aarch64_ghc-crypton-x509-system.sha256sum] = "e101baff1d50b7466b74b7a3e0175eb7f73eb7f1d5acd138f86ce80871c6cfeb"

URI_aarch64_ghc-crypton-x509-system-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-x509-system-devel-1.6.7-2.el10_0.aarch64.rpm;name=aarch64_ghc-crypton-x509-system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-x509-system-devel}"
SRC_URI[aarch64_ghc-crypton-x509-system-devel.sha256sum] = "abb359ecda610075b4a74388edaa043053e0e03189f27dfb4e849cd76c5a4773"

URI_aarch64_ghc-crypton-x509-system-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-x509-system-doc-1.6.7-2.el10_0.noarch.rpm;name=aarch64_ghc-crypton-x509-system-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-x509-system-doc}"
SRC_URI[aarch64_ghc-crypton-x509-system-doc.sha256sum] = "d723bff2291fc378d2863129ec5bca554247e33bf2fbe8f9012871e124fcb7d4"

URI_aarch64_ghc-crypton-x509-system-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-x509-system-prof-1.6.7-2.el10_0.aarch64.rpm;name=aarch64_ghc-crypton-x509-system-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-x509-system-prof}"
SRC_URI[aarch64_ghc-crypton-x509-system-prof.sha256sum] = "1a6bda3a8c088f2d130327269b5e41108eeaaac6ce073ef10cfa03a1d6bb1509"

RDEPENDS:ghc-crypton-x509-system = " \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-base \
 ghc-basement \
 ghc-bytestring \
 ghc-containers \
 ghc-crypton \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hourglass \
 ghc-memory \
 ghc-mtl \
 ghc-pem \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-crypton-x509-system-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-crypton-x509-devel \
 ghc-crypton-x509-store-devel \
 ghc-crypton-x509-system \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-mtl-devel \
 ghc-pem-devel \
 ghc-process-devel \
 "
RDEPENDS:ghc-crypton-x509-system-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-crypton-x509-system-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-crypton-x509-prof \
 ghc-crypton-x509-store-prof \
 ghc-crypton-x509-system-devel \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-mtl-prof \
 ghc-pem-prof \
 ghc-process-prof \
 "
