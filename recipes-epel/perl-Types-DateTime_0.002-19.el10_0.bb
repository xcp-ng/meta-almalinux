# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Types-DateTime"
PV = "0.002"
PR = "19.el10_0"
PACKAGES = " \
 perl-Types-DateTime \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Types-DateTime-0.002-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a242bfb2897c58aaec882d715d689870a138344109b92b75b848805dd3d0d0d0"

URI_x86_64_v2_perl-Types-DateTime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Types-DateTime-0.002-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Types-DateTime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Types-DateTime}"
SRC_URI[x86_64_v2_perl-Types-DateTime.sha256sum] = "5e27e9be2350f6055364e91ef6671ddda9faeacace51381b3dc1276dfbd3c0e7"

URI_aarch64_perl-Types-DateTime = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Types-DateTime-0.002-19.el10_0.noarch.rpm;name=aarch64_perl-Types-DateTime;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Types-DateTime}"
SRC_URI[aarch64_perl-Types-DateTime.sha256sum] = "8c01fc61bbbd13baf3923cea7c119811495cad848501b15ad1c20942df3560a5"

RDEPENDS:perl-Types-DateTime = " \
 perl-DateTime \
 perl-DateTime-Locale \
 perl-DateTime-TimeZone \
 perl-Module-Runtime \
 perl-Type-Tiny \
 perl-libs \
 "
