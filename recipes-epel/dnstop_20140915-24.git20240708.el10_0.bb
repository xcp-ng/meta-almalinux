# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnstop"
PV = "20140915"
PR = "24.git20240708.el10_0"
PACKAGES = " \
 dnstop \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dnstop-20140915-24.git20240708.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "050ed9f547e80ef07a23be796c8d6b604d73332a493b946cb1d6fc1998b8f226"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnstop-20140915-24.git20240708.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dnstop;unpack=0"
SRC_URI[x86_64_v2_dnstop.sha256sum] = "6715d32cb5a03677576cee57a46d802ab2342302ed86dfd2cce65b24484dca97"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dnstop-20140915-24.git20240708.el10_0.aarch64.rpm;name=aarch64_dnstop;unpack=0"
SRC_URI[aarch64_dnstop.sha256sum] = "b07cb07d65d5295d72eba0069bd4dfc3176f2eab525f6c9fc46cdd1cc33c38a0"

RDEPENDS:dnstop = " \
 glibc \
 libpcap \
 ncurses-libs \
 "
