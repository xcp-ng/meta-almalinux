# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Finance-Quote"
PV = "1.7000"
PR = "1.el10_2"
PACKAGES = " \
 perl-Finance-Quote \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Finance-Quote-1.7000-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b286c1203173979db2fb74a8cc9122bb8c5bd63e915759094fe9fc2535742851"

URI_x86_64_v2_perl-Finance-Quote = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Finance-Quote-1.7000-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Finance-Quote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Finance-Quote}"
SRC_URI[x86_64_v2_perl-Finance-Quote.sha256sum] = "f7ab92b15b792254ebf68e288224de7174c5481d0055e46a1c76625adee919fe"

URI_aarch64_perl-Finance-Quote = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Finance-Quote-1.7000-1.el10_2.noarch.rpm;name=aarch64_perl-Finance-Quote;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Finance-Quote}"
SRC_URI[aarch64_perl-Finance-Quote.sha256sum] = "80af08a981fd980b3cc6596faf9cb18f0cf0ffe8ab971d6f46d3c601f1be89a5"

RDEPENDS:perl-Finance-Quote = " \
 perl-Carp \
 perl-DateTime-Format-Strptime \
 perl-Encode \
 perl-Exporter \
 perl-Finance-Quote \
 perl-HTML-Parser \
 perl-HTML-TableExtract \
 perl-HTML-Tree \
 perl-HTML-TreeBuilder-XPath \
 perl-HTTP-CookieJar \
 perl-HTTP-Cookies \
 perl-HTTP-Message \
 perl-IO-Compress \
 perl-IO-String \
 perl-JSON \
 perl-LWP-Protocol-https \
 perl-Module-Load \
 perl-POSIX \
 perl-Readonly \
 perl-Scalar-List-Utils \
 perl-String-Util \
 perl-Text-Template \
 perl-Time-Piece \
 perl-TimeDate \
 perl-URI \
 perl-Web-Scraper \
 perl-XML-LibXML \
 perl-base \
 perl-constant \
 perl-if \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 "
