# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-wai-app-static"
PV = "3.1.9"
PR = "1.el10_0"
PACKAGES = " \
 ghc-wai-app-static \
 ghc-wai-app-static-devel \
 ghc-wai-app-static-doc \
 ghc-wai-app-static-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-wai-app-static-3.1.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f85a6c9a513199ec9507a4a898e9704b70fd1f780e25f98bbbf6e3cbc64a1893"

URI_x86_64_v2_ghc-wai-app-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-app-static-3.1.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wai-app-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-app-static}"
SRC_URI[x86_64_v2_ghc-wai-app-static.sha256sum] = "16967830d5655857b28c5a464e907c6f2e3c47ca681491224105e558c5b03bf5"

URI_x86_64_v2_ghc-wai-app-static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-app-static-devel-3.1.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wai-app-static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-app-static-devel}"
SRC_URI[x86_64_v2_ghc-wai-app-static-devel.sha256sum] = "b648ac4024c338f9271aee75f5eafb43201aeb3e78e955fd8d3dff354570abe0"

URI_x86_64_v2_ghc-wai-app-static-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-app-static-doc-3.1.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-wai-app-static-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-app-static-doc}"
SRC_URI[x86_64_v2_ghc-wai-app-static-doc.sha256sum] = "4288a04da8453de94bb6d688f54a263b8f5c7f4ad022509595d649780afaa50f"

URI_x86_64_v2_ghc-wai-app-static-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-app-static-prof-3.1.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wai-app-static-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-app-static-prof}"
SRC_URI[x86_64_v2_ghc-wai-app-static-prof.sha256sum] = "01b5145f99fd468b54ed0ba48517e9ccf35bfa7841ca762873eaccafcd75dd70"

URI_aarch64_ghc-wai-app-static = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-app-static-3.1.9-1.el10_0.aarch64.rpm;name=aarch64_ghc-wai-app-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-app-static}"
SRC_URI[aarch64_ghc-wai-app-static.sha256sum] = "2ba34dab2aa7a96d5519c756133a9fb34871e9c6df93970f423fabb1d63921b0"

URI_aarch64_ghc-wai-app-static-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-app-static-devel-3.1.9-1.el10_0.aarch64.rpm;name=aarch64_ghc-wai-app-static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-app-static-devel}"
SRC_URI[aarch64_ghc-wai-app-static-devel.sha256sum] = "527d45c0bb5ccd48856e0caec8078824596b575c86b8862ba5fe5efa7f220b45"

URI_aarch64_ghc-wai-app-static-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-app-static-doc-3.1.9-1.el10_0.noarch.rpm;name=aarch64_ghc-wai-app-static-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-app-static-doc}"
SRC_URI[aarch64_ghc-wai-app-static-doc.sha256sum] = "052a9b30829869f1965f1e33050002ec084c033472787000c12ae290f1cd0a6e"

URI_aarch64_ghc-wai-app-static-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-app-static-prof-3.1.9-1.el10_0.aarch64.rpm;name=aarch64_ghc-wai-app-static-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-app-static-prof}"
SRC_URI[aarch64_ghc-wai-app-static-prof.sha256sum] = "35f2bc89a0d31988be79dbbc618f671ca696d47142265f8f8a63f22658509e69"

RDEPENDS:ghc-wai-app-static = " \
 ghc-HUnit \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-auto-update \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bsb-http-chunked \
 ghc-byteorder \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-colour \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-x509 \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-easy-file \
 ghc-exceptions \
 ghc-fast-logger \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-date \
 ghc-http-types \
 ghc-http2 \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-memory \
 ghc-mime-types \
 ghc-mtl \
 ghc-network \
 ghc-network-byte-order \
 ghc-network-control \
 ghc-old-locale \
 ghc-old-time \
 ghc-optparse-applicative \
 ghc-os-string \
 ghc-pem \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-primitive \
 ghc-process \
 ghc-psqueues \
 ghc-random \
 ghc-recv \
 ghc-resourcet \
 ghc-safe-exceptions \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-simple-sendfile \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-time-manager \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vault \
 ghc-vector \
 ghc-vector-stream \
 ghc-wai \
 ghc-wai-extra \
 ghc-wai-logger \
 ghc-warp \
 ghc-witherable \
 ghc-word8 \
 ghc-zlib \
 glibc \
 gmp \
 libffi \
 zlib-ng-compat \
 "
RDEPENDS:ghc-wai-app-static-devel = " \
 ghc-base-devel \
 ghc-blaze-html-devel \
 ghc-blaze-markup-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-crypton-devel \
 ghc-directory-devel \
 ghc-file-embed-devel \
 ghc-filepath-devel \
 ghc-http-date-devel \
 ghc-http-types-devel \
 ghc-memory-devel \
 ghc-mime-types-devel \
 ghc-old-locale-devel \
 ghc-optparse-applicative-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unix-compat-devel \
 ghc-unordered-containers-devel \
 ghc-wai-app-static \
 ghc-wai-devel \
 ghc-wai-extra-devel \
 ghc-warp-devel \
 ghc-zlib-devel \
 "
RDEPENDS:ghc-wai-app-static-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-wai-app-static-prof = " \
 ghc-base-prof \
 ghc-blaze-html-prof \
 ghc-blaze-markup-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-crypton-prof \
 ghc-directory-prof \
 ghc-file-embed-prof \
 ghc-filepath-prof \
 ghc-http-date-prof \
 ghc-http-types-prof \
 ghc-memory-prof \
 ghc-mime-types-prof \
 ghc-old-locale-prof \
 ghc-optparse-applicative-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unix-compat-prof \
 ghc-unordered-containers-prof \
 ghc-wai-app-static-devel \
 ghc-wai-extra-prof \
 ghc-wai-prof \
 ghc-warp-prof \
 ghc-zlib-prof \
 "
