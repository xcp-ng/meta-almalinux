# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-MQTT-Simple"
PV = "1.33"
PR = "1.el10_1"
PACKAGES = " \
 perl-Net-MQTT-Simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-MQTT-Simple-1.33-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8669a77b0d40b4b146176a1469d6f28ab701dc7ad9a7eb02ea118546cbd0454"

URI_x86_64_v2_perl-Net-MQTT-Simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-MQTT-Simple-1.33-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-MQTT-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-MQTT-Simple}"
SRC_URI[x86_64_v2_perl-Net-MQTT-Simple.sha256sum] = "30f30f23d241a58272f249b9d0191ee526e288a95e6558da9bd13596d8aac6f5"

URI_aarch64_perl-Net-MQTT-Simple = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-MQTT-Simple-1.33-1.el10_1.noarch.rpm;name=aarch64_perl-Net-MQTT-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-MQTT-Simple}"
SRC_URI[aarch64_perl-Net-MQTT-Simple.sha256sum] = "5ad6afbffa15789436bce088859af49b669b40739276952d7b60f7f6af0a8075"

RDEPENDS:perl-Net-MQTT-Simple = " \
 perl-Getopt-Long \
 perl-IO-Socket-IP \
 perl-IO-Socket-SSL \
 perl-Net-MQTT-Simple \
 perl-Socket \
 perl-base \
 perl-interpreter \
 perl-libs \
 "
