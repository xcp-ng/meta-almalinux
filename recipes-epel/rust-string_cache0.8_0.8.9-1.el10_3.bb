# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-string_cache0.8"
PV = "0.8.9"
PR = "1.el10_3"
PACKAGES = " \
 rust-string_cache0.8+default-devel \
 rust-string_cache0.8+serde-devel \
 rust-string_cache0.8+serde_support-devel \
 rust-string_cache0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-string_cache0.8-0.8.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e13a158bb44cfaeab13296ec7ec2454293d62acc17b203a32e45322c2093a2d"

URI_x86_64_v2_rust-string_cache0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache0.8+default-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache0.8+default-devel}"
SRC_URI[x86_64_v2_rust-string_cache0.8+default-devel.sha256sum] = "030b322050c42353265943e133ad5a16ba7f3fb3f8d15165cdfc750a012c1632"

URI_x86_64_v2_rust-string_cache0.8+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache0.8+serde-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache0.8+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache0.8+serde-devel}"
SRC_URI[x86_64_v2_rust-string_cache0.8+serde-devel.sha256sum] = "2818d4dc00c3aa753d983ce5be37b4b0f8924214f40abd03fedd410db7f1c013"

URI_x86_64_v2_rust-string_cache0.8+serde_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache0.8+serde_support-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache0.8+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache0.8+serde_support-devel}"
SRC_URI[x86_64_v2_rust-string_cache0.8+serde_support-devel.sha256sum] = "9c2d79e5fcacb0ed82bc9d9d5346fe898f53d283506017977cd45e0289fe434e"

URI_x86_64_v2_rust-string_cache0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache0.8-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache0.8-devel}"
SRC_URI[x86_64_v2_rust-string_cache0.8-devel.sha256sum] = "8a4a26fff4996cbee25b20a210b253f3762d1e641cecb7555876e0604918b725"

URI_aarch64_rust-string_cache0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache0.8+default-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-string_cache0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache0.8+default-devel}"
SRC_URI[aarch64_rust-string_cache0.8+default-devel.sha256sum] = "433129f637f0bae4a15151b484b3e7cf28a919e6fbab9b66d585e36dcafdd391"

URI_aarch64_rust-string_cache0.8+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache0.8+serde-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-string_cache0.8+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache0.8+serde-devel}"
SRC_URI[aarch64_rust-string_cache0.8+serde-devel.sha256sum] = "819ec70e21a723bc494d7cf8d78811cab1e2e1bc572c15b603c9a6e297451301"

URI_aarch64_rust-string_cache0.8+serde_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache0.8+serde_support-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-string_cache0.8+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache0.8+serde_support-devel}"
SRC_URI[aarch64_rust-string_cache0.8+serde_support-devel.sha256sum] = "53f3108f3ce40efcfe7d3330b4ae1daaa03bf8e27766f78922aafa7ecf6aa0b3"

URI_aarch64_rust-string_cache0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache0.8-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-string_cache0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache0.8-devel}"
SRC_URI[aarch64_rust-string_cache0.8-devel.sha256sum] = "16bc8e5f7a86e4c98dcae9a7b10d8cee64b9d05c8bc76baf229fbaee346c7b00"

RDEPENDS:rust-string_cache0.8+default-devel = " \
 cargo \
 rust-string_cache0.8+serde_support-devel \
 rust-string_cache0.8-devel \
 "
RDEPENDS:rust-string_cache0.8+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-string_cache0.8-devel \
 "
RDEPENDS:rust-string_cache0.8+serde_support-devel = " \
 cargo \
 rust-string_cache0.8+serde-devel \
 rust-string_cache0.8-devel \
 "
RDEPENDS:rust-string_cache0.8-devel = " \
 cargo \
 rust \
 rust-new_debug_unreachable+default-devel \
 rust-parking_lot+default-devel \
 rust-phf_shared0.11+default-devel \
 rust-precomputed-hash+default-devel \
 "
