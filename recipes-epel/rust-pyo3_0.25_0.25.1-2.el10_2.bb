# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3_0.25"
PV = "0.25.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-pyo3_0.25+abi3-devel \
 rust-pyo3_0.25+abi3-py310-devel \
 rust-pyo3_0.25+abi3-py311-devel \
 rust-pyo3_0.25+abi3-py312-devel \
 rust-pyo3_0.25+abi3-py313-devel \
 rust-pyo3_0.25+abi3-py314-devel \
 rust-pyo3_0.25+abi3-py37-devel \
 rust-pyo3_0.25+abi3-py38-devel \
 rust-pyo3_0.25+abi3-py39-devel \
 rust-pyo3_0.25+anyhow-devel \
 rust-pyo3_0.25+arc_lock-devel \
 rust-pyo3_0.25+auto-initialize-devel \
 rust-pyo3_0.25+bigdecimal-devel \
 rust-pyo3_0.25+chrono-devel \
 rust-pyo3_0.25+chrono-local-devel \
 rust-pyo3_0.25+chrono-tz-devel \
 rust-pyo3_0.25+default-devel \
 rust-pyo3_0.25+either-devel \
 rust-pyo3_0.25+experimental-async-devel \
 rust-pyo3_0.25+experimental-inspect-devel \
 rust-pyo3_0.25+extension-module-devel \
 rust-pyo3_0.25+eyre-devel \
 rust-pyo3_0.25+full-devel \
 rust-pyo3_0.25+hashbrown-devel \
 rust-pyo3_0.25+indexmap-devel \
 rust-pyo3_0.25+indoc-devel \
 rust-pyo3_0.25+inventory-devel \
 rust-pyo3_0.25+jiff-02-devel \
 rust-pyo3_0.25+lock_api-devel \
 rust-pyo3_0.25+macros-devel \
 rust-pyo3_0.25+multiple-pymethods-devel \
 rust-pyo3_0.25+nightly-devel \
 rust-pyo3_0.25+num-bigint-devel \
 rust-pyo3_0.25+num-complex-devel \
 rust-pyo3_0.25+num-rational-devel \
 rust-pyo3_0.25+ordered-float-devel \
 rust-pyo3_0.25+parking_lot-devel \
 rust-pyo3_0.25+py-clone-devel \
 rust-pyo3_0.25+pyo3-macros-devel \
 rust-pyo3_0.25+rust_decimal-devel \
 rust-pyo3_0.25+serde-devel \
 rust-pyo3_0.25+smallvec-devel \
 rust-pyo3_0.25+time-devel \
 rust-pyo3_0.25+unindent-devel \
 rust-pyo3_0.25+uuid-devel \
 rust-pyo3_0.25-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3_0.25-0.25.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a0804e2558c3e5b29e0fe83d7b8dea35cb6ed68b49a03d64159b4bcaa4a05c0"

URI_x86_64_v2_rust-pyo3_0.25+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+abi3-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+abi3-devel.sha256sum] = "f262cd801d68c8db284ce2f8af699fd293ff2ba98ad29c8b314f8ade7cd39601"

URI_x86_64_v2_rust-pyo3_0.25+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+abi3-py310-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+abi3-py310-devel.sha256sum] = "861915dcf9bae4b7377db18d1616cc714175406a6b0b6edccff26df2293335f1"

URI_x86_64_v2_rust-pyo3_0.25+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+abi3-py311-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+abi3-py311-devel.sha256sum] = "c255fecab5b37dbb4d041be63cc14e9940cbb2eaff74554d9157008d33169c46"

URI_x86_64_v2_rust-pyo3_0.25+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+abi3-py312-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+abi3-py312-devel.sha256sum] = "ec0dc60dd24969a1742c2ffeda30de360c4220d100c24176df84cedef3555764"

URI_x86_64_v2_rust-pyo3_0.25+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+abi3-py313-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+abi3-py313-devel.sha256sum] = "f576d95124105b139b0a0f160cb4105ef69dba7faa9162d33dfad3b210e348c0"

URI_x86_64_v2_rust-pyo3_0.25+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+abi3-py314-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+abi3-py314-devel.sha256sum] = "af312f381f30f69aa249880def0b3cbf6b213d3974323f4894d0520f11736032"

URI_x86_64_v2_rust-pyo3_0.25+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+abi3-py37-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+abi3-py37-devel.sha256sum] = "5127639c368ab41c459fff661999d015ccf8784e29f1f2f30b83c521720f6f5d"

URI_x86_64_v2_rust-pyo3_0.25+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+abi3-py38-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+abi3-py38-devel.sha256sum] = "569b02796a224a6d82e89753b4635840458a66e87281c2980e58d45c7fd4712b"

URI_x86_64_v2_rust-pyo3_0.25+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+abi3-py39-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+abi3-py39-devel.sha256sum] = "72b9209914aec12d234e89bfbc397f618fc6ae48751294a270f881a2eddeadfc"

URI_x86_64_v2_rust-pyo3_0.25+anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+anyhow-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+anyhow-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+anyhow-devel.sha256sum] = "af4f4f756b7732cbe5963318836b48c1ff469bcd1e8288c2a501b21b8d1a409b"

URI_x86_64_v2_rust-pyo3_0.25+arc_lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+arc_lock-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+arc_lock-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+arc_lock-devel.sha256sum] = "3a83280786f8bc2d67e75b21fb5c236faaf885d5564ac97bec0cf9fabb846adb"

URI_x86_64_v2_rust-pyo3_0.25+auto-initialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+auto-initialize-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+auto-initialize-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+auto-initialize-devel.sha256sum] = "24250da45b100dd4fe9ca4e086c30faec906c7a1ba00f4fb53d1fb8e2dd41450"

URI_x86_64_v2_rust-pyo3_0.25+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+bigdecimal-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+bigdecimal-devel.sha256sum] = "a700c1eec4ad1cb39f5b0beef1eb78b4921d82935675a3a8c8f66a205983e030"

URI_x86_64_v2_rust-pyo3_0.25+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+chrono-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+chrono-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+chrono-devel.sha256sum] = "c928705d57db299cd3c8fd6c1f914ffa2082cb7531645cc7ad76ce72675ca9d3"

URI_x86_64_v2_rust-pyo3_0.25+chrono-local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+chrono-local-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+chrono-local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+chrono-local-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+chrono-local-devel.sha256sum] = "8528ab22f277c7c7c6d291644b5069c77e710f75aedb0cb5000afcb0ebff52a8"

URI_x86_64_v2_rust-pyo3_0.25+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+chrono-tz-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+chrono-tz-devel.sha256sum] = "c96318148e525d563b1ccfdfa34daf8d8e78d86a4fd528139cce18b88c9736ed"

URI_x86_64_v2_rust-pyo3_0.25+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+default-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+default-devel.sha256sum] = "0da6331e0345b79145eca4ed578e7c3d255a1e116b9062530c37d4566fda2bed"

URI_x86_64_v2_rust-pyo3_0.25+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+either-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+either-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+either-devel.sha256sum] = "4e7056b7e0aafd24b6c2540bffd0b0d416928d1e3beba580ec85ad4a97e3dc9e"

URI_x86_64_v2_rust-pyo3_0.25+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+experimental-async-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+experimental-async-devel.sha256sum] = "74e79c8a188054a1ea8290cd993042ed8c8d0b6aa6ee52c34e3d4d28485aff72"

URI_x86_64_v2_rust-pyo3_0.25+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+experimental-inspect-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+experimental-inspect-devel.sha256sum] = "9e5c8f70e0ab373d8033ffe76e1eec887059b81c0e62b5693b0da107207be609"

URI_x86_64_v2_rust-pyo3_0.25+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+extension-module-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+extension-module-devel.sha256sum] = "013e83c8a59fb42d6f982ba0f89092896fc7f85ee5d4990af69bcadaf4946fa8"

URI_x86_64_v2_rust-pyo3_0.25+eyre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+eyre-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+eyre-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+eyre-devel.sha256sum] = "6b17aac0015b7a28e9cf867eabfb0746369280397da08b029538e7f46d7dd839"

URI_x86_64_v2_rust-pyo3_0.25+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+full-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+full-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+full-devel.sha256sum] = "a647bfb2dd5330580d0282b22892d6062cab6919c33b6eb4451d8ef43e37bd80"

URI_x86_64_v2_rust-pyo3_0.25+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+hashbrown-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+hashbrown-devel.sha256sum] = "b61309d9dd5d2bb3e92a4efea32ed92b8d6bf412bb3ac506aecf59ab9ed62e7e"

URI_x86_64_v2_rust-pyo3_0.25+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+indexmap-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+indexmap-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+indexmap-devel.sha256sum] = "d362203e77b83b03d67c30c998e1bd94e451889059ee4c5710c943c63e54100f"

URI_x86_64_v2_rust-pyo3_0.25+indoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+indoc-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+indoc-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+indoc-devel.sha256sum] = "98454992f2d8178082ec677b70c9d5c20e91c5ed4bae5dd57f45be7b3cbc5fba"

URI_x86_64_v2_rust-pyo3_0.25+inventory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+inventory-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+inventory-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+inventory-devel.sha256sum] = "53c4462d563538b7294ea772b93d64042b5cb3e9c34471a7609c84faf69fbb05"

URI_x86_64_v2_rust-pyo3_0.25+jiff-02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+jiff-02-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+jiff-02-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+jiff-02-devel.sha256sum] = "21e81ace61a2253df80be79c1cc5ede2bd7d35bee768ce87bf5a44e2a3d951d3"

URI_x86_64_v2_rust-pyo3_0.25+lock_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+lock_api-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+lock_api-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+lock_api-devel.sha256sum] = "b6961ed54707518c929b6ccfe468e07db3b82b7df3f5e8d99c5ec853f110a1c6"

URI_x86_64_v2_rust-pyo3_0.25+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+macros-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+macros-devel.sha256sum] = "c757fe416e92d0426ee7fd7ee20d99e474b047f17e7c2904f70fb4917aea4774"

URI_x86_64_v2_rust-pyo3_0.25+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+multiple-pymethods-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+multiple-pymethods-devel.sha256sum] = "846efb49c106f85c67c07b7aa276d6f864bce9f3f6b3823a25953318338f1db6"

URI_x86_64_v2_rust-pyo3_0.25+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+nightly-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+nightly-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+nightly-devel.sha256sum] = "604f47618b63625a19ff1c4d86666c9775632ee236aacbab5ae762bdb0edd051"

URI_x86_64_v2_rust-pyo3_0.25+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+num-bigint-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+num-bigint-devel.sha256sum] = "62e798e44c0b51c28c81a4fb86f76271afaa2e82e968c2942c2f98cb13b07e94"

URI_x86_64_v2_rust-pyo3_0.25+num-complex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+num-complex-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+num-complex-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+num-complex-devel.sha256sum] = "5907a5feccb6a2692527539d65da4b9665efceb10e88fc321a518e45df0a8209"

URI_x86_64_v2_rust-pyo3_0.25+num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+num-rational-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+num-rational-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+num-rational-devel.sha256sum] = "869b2b7dbb6f3be1e11f38bbd7763867994fbb2119f1de9d1eb03b38b39c9444"

URI_x86_64_v2_rust-pyo3_0.25+ordered-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+ordered-float-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+ordered-float-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+ordered-float-devel.sha256sum] = "d4831ac2a04ac5948ef408dbdf6257adaaaba6817889fc35e9783c94b922914d"

URI_x86_64_v2_rust-pyo3_0.25+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+parking_lot-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+parking_lot-devel.sha256sum] = "2c8927cb6d648f50d35c6076e72066f1bb46a4e66ad66be780b183535e64347d"

URI_x86_64_v2_rust-pyo3_0.25+py-clone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+py-clone-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+py-clone-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+py-clone-devel.sha256sum] = "8cc11c132d8fdb359d4fe3acd6944dc5f14ea26cde4a455f2dedf37d6c992109"

URI_x86_64_v2_rust-pyo3_0.25+pyo3-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+pyo3-macros-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+pyo3-macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+pyo3-macros-devel.sha256sum] = "fb7c57ac564da5701e9e16389466eb649abf5541220a864f7b169013ff9e6446"

URI_x86_64_v2_rust-pyo3_0.25+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+rust_decimal-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+rust_decimal-devel.sha256sum] = "5060f8a628877959374c69530a8a83dfe2062c4ceed75f0cee7c08377cd567f6"

URI_x86_64_v2_rust-pyo3_0.25+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+serde-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+serde-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+serde-devel.sha256sum] = "fbfbf75027868884f53da7c68189eeafc8c9150b60cfa2cc43ad7e3aa3816652"

URI_x86_64_v2_rust-pyo3_0.25+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+smallvec-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+smallvec-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+smallvec-devel.sha256sum] = "e0aead978169570c3793646685f77386e62c7886a314dcbc7bdcef4337475428"

URI_x86_64_v2_rust-pyo3_0.25+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+time-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+time-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+time-devel.sha256sum] = "ab30e4f2cf085e3361da7439263bed40a94d62f139346eb369546d5735a2e5ec"

URI_x86_64_v2_rust-pyo3_0.25+unindent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+unindent-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+unindent-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+unindent-devel.sha256sum] = "0d888ee705d61829d23b87d5a7c62c0a9c515de445ff9120a03f3abf89c6aef8"

URI_x86_64_v2_rust-pyo3_0.25+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25+uuid-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25+uuid-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25+uuid-devel.sha256sum] = "b27063fa4df2a682dd28d0c6925000ad5bf761e6de2070017ced5b13320267d4"

URI_x86_64_v2_rust-pyo3_0.25-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.25-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.25-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.25-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.25-devel.sha256sum] = "e3b1ec61af21f3fdfb1000ea854c9fceaf818a4588918df783710275aee4f80a"

URI_aarch64_rust-pyo3_0.25+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+abi3-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+abi3-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+abi3-devel.sha256sum] = "4dd673a362469761ad4f77824160d456db19b7553d1a70c3a8a423fbc5f5900f"

URI_aarch64_rust-pyo3_0.25+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+abi3-py310-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+abi3-py310-devel.sha256sum] = "31bd135689e21dec3ffe96d2029d783d38d97230cb895e1d7179d92931c0a390"

URI_aarch64_rust-pyo3_0.25+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+abi3-py311-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+abi3-py311-devel.sha256sum] = "d19790a7fd1adfd289a8435eeefbb3ef98d1c27f9e91dacf82d38cc1694f76ce"

URI_aarch64_rust-pyo3_0.25+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+abi3-py312-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+abi3-py312-devel.sha256sum] = "f23f5109ffabcd2d9e9ba21d9e2e5aec4cb9731d9b724825704204e0459f8e83"

URI_aarch64_rust-pyo3_0.25+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+abi3-py313-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+abi3-py313-devel.sha256sum] = "7723978b89cde4229db98225195590ad1f3054ee97dbcb3050591dc9f90de1b5"

URI_aarch64_rust-pyo3_0.25+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+abi3-py314-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+abi3-py314-devel.sha256sum] = "34624bc62b044aeb564e3077bbee1b652504dc409d0afdc494aa2ee3d8e22899"

URI_aarch64_rust-pyo3_0.25+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+abi3-py37-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+abi3-py37-devel.sha256sum] = "064969cc06b009d00e3d51f7bf85b425b12911355d39ea858a9d108a51eb9d82"

URI_aarch64_rust-pyo3_0.25+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+abi3-py38-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+abi3-py38-devel.sha256sum] = "005aca24710e3c8cfc981fb2995f066c8d1ae3c13e1037ff7fdfc993c077bae0"

URI_aarch64_rust-pyo3_0.25+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+abi3-py39-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+abi3-py39-devel.sha256sum] = "737e98c648d14b6226e93343f06c6d0d733f71662c57aa4942b57c2db637298d"

URI_aarch64_rust-pyo3_0.25+anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+anyhow-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+anyhow-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+anyhow-devel.sha256sum] = "63188f3723e886e16bca3a8e103de1dcc1ee374211714e4eea067de01a123160"

URI_aarch64_rust-pyo3_0.25+arc_lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+arc_lock-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+arc_lock-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+arc_lock-devel.sha256sum] = "fe4581f96e81579ae16917cf6f554e3224a30e5fb547dd09be05973e023dd830"

URI_aarch64_rust-pyo3_0.25+auto-initialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+auto-initialize-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+auto-initialize-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+auto-initialize-devel.sha256sum] = "ef23576f0e607a4a258906fb80e12f848c9887e6fd2975db3333cb0aecb245ce"

URI_aarch64_rust-pyo3_0.25+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+bigdecimal-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+bigdecimal-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+bigdecimal-devel.sha256sum] = "eddd09681b87e3aefd76a1e9ab32e883a7c220c8ee7723c70c1fc9b0344f4e09"

URI_aarch64_rust-pyo3_0.25+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+chrono-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+chrono-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+chrono-devel.sha256sum] = "64e89030d51a65aa19574133b30e36fbb9a2c7324d77a282e320fd2f1aafbb92"

URI_aarch64_rust-pyo3_0.25+chrono-local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+chrono-local-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+chrono-local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+chrono-local-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+chrono-local-devel.sha256sum] = "41006db09afb9922c56e768e92f3c1a82f15ad0da6626a775cca32537f50bf55"

URI_aarch64_rust-pyo3_0.25+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+chrono-tz-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+chrono-tz-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+chrono-tz-devel.sha256sum] = "6326bdb8cc2ef4197697fe29bb98412caecc81f635318f757ca04e39ff4b0632"

URI_aarch64_rust-pyo3_0.25+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+default-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+default-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+default-devel.sha256sum] = "6d55536fb0e24ac3f5932795fbb76b1b4cec7946cb82a0f1ceed1ca7edf62804"

URI_aarch64_rust-pyo3_0.25+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+either-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+either-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+either-devel.sha256sum] = "5d3d5fee0ccaf680e7f8145128c7c9483576981d0d052e3ff393a0ea551d8015"

URI_aarch64_rust-pyo3_0.25+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+experimental-async-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+experimental-async-devel.sha256sum] = "243e2050e2434cbc17f86f20ab190b0bc592225f3476209a46f229944a043357"

URI_aarch64_rust-pyo3_0.25+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+experimental-inspect-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+experimental-inspect-devel.sha256sum] = "fa35f8e2b7b2e57a6ba038fe12443bd37da45cd392cf00aed75038f66c6c284e"

URI_aarch64_rust-pyo3_0.25+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+extension-module-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+extension-module-devel.sha256sum] = "749433b6f55052764da5c7f6dd855733148710035f439b4ee27adbc2109637a8"

URI_aarch64_rust-pyo3_0.25+eyre-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+eyre-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+eyre-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+eyre-devel.sha256sum] = "e8f019bd9f8f393ac228ef8b327dfbcefbe20574f65ec5d263176d3e8556e50e"

URI_aarch64_rust-pyo3_0.25+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+full-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+full-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+full-devel.sha256sum] = "cd50734e07a89df489db46e41cf422333e223d88fbebe98e587f2d1a50060558"

URI_aarch64_rust-pyo3_0.25+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+hashbrown-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+hashbrown-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+hashbrown-devel.sha256sum] = "b697b90cf9d08739207b30ea6b91009b2f388a82f56e423627bc4d2cc53bd46c"

URI_aarch64_rust-pyo3_0.25+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+indexmap-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+indexmap-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+indexmap-devel.sha256sum] = "b324c3ff123130e9525b64c790e26da56117b69f206adbec13a7bec9133dc29e"

URI_aarch64_rust-pyo3_0.25+indoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+indoc-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+indoc-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+indoc-devel.sha256sum] = "a237137d2337654ec5d5e5a8211cc551c88edf31878c893afa9362cc82d1dfaa"

URI_aarch64_rust-pyo3_0.25+inventory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+inventory-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+inventory-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+inventory-devel.sha256sum] = "474af4d3e9a738f0dab1972cc81156b3f954f599e537fd278ef6e1112b7a3535"

URI_aarch64_rust-pyo3_0.25+jiff-02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+jiff-02-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+jiff-02-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+jiff-02-devel.sha256sum] = "20a53ac451489f203b0b335f7ec8c8f517fa21c2c2f4bd8f791f398b845f43a1"

URI_aarch64_rust-pyo3_0.25+lock_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+lock_api-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+lock_api-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+lock_api-devel.sha256sum] = "0383b43863b8b9e8665905c8034782306defeb601d08c037c8118383eb3bf00b"

URI_aarch64_rust-pyo3_0.25+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+macros-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+macros-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+macros-devel.sha256sum] = "f2f224212bb4021641c54d21b95228ddb6a2533f329bddaa672f9fa78074266b"

URI_aarch64_rust-pyo3_0.25+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+multiple-pymethods-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+multiple-pymethods-devel.sha256sum] = "19358672c8b300bce4df98ddc125a29bde3d0380379feb3e3fe8191d9e8f8d6c"

URI_aarch64_rust-pyo3_0.25+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+nightly-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+nightly-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+nightly-devel.sha256sum] = "7abd8e221774313d2b17a721ccf267a2c1446655bd82250014f2aa9de2ff0180"

URI_aarch64_rust-pyo3_0.25+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+num-bigint-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+num-bigint-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+num-bigint-devel.sha256sum] = "c3ca24182f1f6c1fbad455c22c29047b34b6edec3b9af56bd7e626e8dce519dd"

URI_aarch64_rust-pyo3_0.25+num-complex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+num-complex-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+num-complex-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+num-complex-devel.sha256sum] = "adcd0cce3d496d2c8e0e2508a95d4cb88035c2a621a659b0cb42b1f8fa6c14bb"

URI_aarch64_rust-pyo3_0.25+num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+num-rational-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+num-rational-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+num-rational-devel.sha256sum] = "e3b6526349ade8207154bea111bb79cf3ee270aefc6ddf5fb0230c5f61aef6a3"

URI_aarch64_rust-pyo3_0.25+ordered-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+ordered-float-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+ordered-float-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+ordered-float-devel.sha256sum] = "2fe0222f8ad85f0676bae67e6751aaa3ef452029246069acb452455c57b83482"

URI_aarch64_rust-pyo3_0.25+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+parking_lot-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+parking_lot-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+parking_lot-devel.sha256sum] = "9cce269295955a21f5e41e306cb30eb0c23dfa63554deb68951332cecce61845"

URI_aarch64_rust-pyo3_0.25+py-clone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+py-clone-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+py-clone-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+py-clone-devel.sha256sum] = "c76279e1d163f6c7aad125b1f262147536773a12ac7e3c82cfadc3d6f8d8b7c1"

URI_aarch64_rust-pyo3_0.25+pyo3-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+pyo3-macros-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+pyo3-macros-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+pyo3-macros-devel.sha256sum] = "a739ec0ce330d64b4b4dcd3a44189107316dbf066a7e151af47879d7e6bbd2f7"

URI_aarch64_rust-pyo3_0.25+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+rust_decimal-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+rust_decimal-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+rust_decimal-devel.sha256sum] = "f649b49e1123fab7c59bbf5842c2d4664a333f88d861d0a47d7f0dd8397d3bd6"

URI_aarch64_rust-pyo3_0.25+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+serde-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+serde-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+serde-devel.sha256sum] = "7f4e49d1e2c029055e1e35f58a984db54e4b675dda87c355ebc50fe5d69ef4ac"

URI_aarch64_rust-pyo3_0.25+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+smallvec-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+smallvec-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+smallvec-devel.sha256sum] = "448d4c6af090d0d288d71a41452a6c8a6751c9971b7c6d585732f948547f86b1"

URI_aarch64_rust-pyo3_0.25+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+time-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+time-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+time-devel.sha256sum] = "276fc047af0563de6c31f57b9ee2b91c74b8b6f5b708e2cc0eb487e20103d1ae"

URI_aarch64_rust-pyo3_0.25+unindent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+unindent-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+unindent-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+unindent-devel.sha256sum] = "d40fd414a00c8330956d93434a4f0136a324ea21c4a0769a1ebd53aa6810761e"

URI_aarch64_rust-pyo3_0.25+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25+uuid-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25+uuid-devel}"
SRC_URI[aarch64_rust-pyo3_0.25+uuid-devel.sha256sum] = "62ee8b6493aa94739a0a715ff65fc349c890efd0f33ad57e308ae88603c913e0"

URI_aarch64_rust-pyo3_0.25-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.25-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.25-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.25-devel}"
SRC_URI[aarch64_rust-pyo3_0.25-devel.sha256sum] = "da4cb9b92df070de3ab25c2061889e4bf95ba701be22c5da15b48ec9f471b51b"

RDEPENDS:rust-pyo3_0.25+abi3-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py310-devel \
 rust-pyo3_0.25+abi3-py311-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py311-devel \
 rust-pyo3_0.25+abi3-py312-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py312-devel \
 rust-pyo3_0.25+abi3-py313-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+abi3-py313-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py313-devel \
 rust-pyo3_0.25+abi3-py314-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+abi3-py314-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py314-devel \
 rust-pyo3_0.25+abi3-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py37-devel \
 rust-pyo3_0.25+abi3-py38-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py38-devel \
 rust-pyo3_0.25+abi3-py39-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py39-devel \
 rust-pyo3_0.25+abi3-py310-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+anyhow-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+arc_lock-devel = " \
 cargo \
 rust-lock_api+arc_lock-devel \
 rust-lock_api+default-devel \
 rust-parking_lot+arc_lock-devel \
 rust-parking_lot+default-devel \
 rust-pyo3_0.25+lock_api-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+auto-initialize-devel = " \
 cargo \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+bigdecimal-devel = " \
 cargo \
 rust-bigdecimal+default-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+chrono-local-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-iana-time-zone+default-devel \
 rust-iana-time-zone+fallback-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+default-devel = " \
 cargo \
 rust-pyo3_0.25+macros-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+either-devel = " \
 cargo \
 rust-either+default-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros0.25+default-devel \
 rust-pyo3-macros0.25+experimental-async-devel \
 rust-pyo3_0.25+macros-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros0.25+default-devel \
 rust-pyo3-macros0.25+experimental-inspect-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi0.25+extension-module-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+eyre-devel = " \
 cargo \
 rust-eyre+default-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+full-devel = " \
 cargo \
 rust-pyo3_0.25+anyhow-devel \
 rust-pyo3_0.25+arc_lock-devel \
 rust-pyo3_0.25+bigdecimal-devel \
 rust-pyo3_0.25+chrono-devel \
 rust-pyo3_0.25+chrono-local-devel \
 rust-pyo3_0.25+chrono-tz-devel \
 rust-pyo3_0.25+either-devel \
 rust-pyo3_0.25+experimental-async-devel \
 rust-pyo3_0.25+experimental-inspect-devel \
 rust-pyo3_0.25+eyre-devel \
 rust-pyo3_0.25+hashbrown-devel \
 rust-pyo3_0.25+indexmap-devel \
 rust-pyo3_0.25+lock_api-devel \
 rust-pyo3_0.25+macros-devel \
 rust-pyo3_0.25+num-bigint-devel \
 rust-pyo3_0.25+num-complex-devel \
 rust-pyo3_0.25+num-rational-devel \
 rust-pyo3_0.25+ordered-float-devel \
 rust-pyo3_0.25+parking_lot-devel \
 rust-pyo3_0.25+py-clone-devel \
 rust-pyo3_0.25+rust_decimal-devel \
 rust-pyo3_0.25+serde-devel \
 rust-pyo3_0.25+smallvec-devel \
 rust-pyo3_0.25+uuid-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+hashbrown-devel = " \
 cargo \
 rust-pyo3_0.25-devel \
 virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~ \
 "
RDEPENDS:rust-pyo3_0.25+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+indoc-devel = " \
 cargo \
 rust-indoc+default-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+inventory-devel = " \
 cargo \
 rust-inventory+default-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+jiff-02-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+lock_api-devel = " \
 cargo \
 rust-lock_api+default-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+macros-devel = " \
 cargo \
 rust-pyo3_0.25+indoc-devel \
 rust-pyo3_0.25+pyo3-macros-devel \
 rust-pyo3_0.25+unindent-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros0.25+default-devel \
 rust-pyo3-macros0.25+multiple-pymethods-devel \
 rust-pyo3_0.25+inventory-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+nightly-devel = " \
 cargo \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+num-complex-devel = " \
 cargo \
 rust-num-complex+default-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+num-rational-devel = " \
 cargo \
 rust-num-rational+default-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+ordered-float-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-pyo3_0.25+lock_api-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+py-clone-devel = " \
 cargo \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+pyo3-macros-devel = " \
 cargo \
 rust-pyo3-macros0.25+default-devel \
 rust-pyo3_0.25-devel \
 "
RDEPENDS:rust-pyo3_0.25+rust_decimal-devel = " \
 cargo \
 rust-pyo3_0.25-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-pyo3_0.25+serde-devel = " \
 cargo \
 rust-pyo3_0.25-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-pyo3_0.25+smallvec-devel = " \
 cargo \
 rust-pyo3_0.25-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-pyo3_0.25+time-devel = " \
 cargo \
 rust-pyo3_0.25-devel \
 rust-time-devel \
 "
RDEPENDS:rust-pyo3_0.25+unindent-devel = " \
 cargo \
 rust-pyo3_0.25-devel \
 rust-unindent+default-devel \
 "
RDEPENDS:rust-pyo3_0.25+uuid-devel = " \
 cargo \
 rust-pyo3_0.25-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-pyo3_0.25-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 rust-memoffset+default-devel \
 rust-once_cell+default-devel \
 rust-pyo3-build-config0.25+default-devel \
 rust-pyo3-build-config0.25+resolve-config-devel \
 rust-pyo3-ffi0.25+default-devel \
 "
