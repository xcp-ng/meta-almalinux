# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcerf"
PV = "2.4"
PR = "2.el10_1"
PACKAGES = " \
 libcerf \
 libcerf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcerf-2.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1aa6c803fc48b521320861c5bec869ffa7d5a61ea04d38b70be4e311a2d16614"

URI_x86_64_v2_libcerf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcerf-2.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcerf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcerf}"
SRC_URI[x86_64_v2_libcerf.sha256sum] = "1153a728701c6aff173867aac2f7936be10dc79c797a93f9688bdb75fee307a1"

URI_x86_64_v2_libcerf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcerf-devel-2.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcerf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcerf-devel}"
SRC_URI[x86_64_v2_libcerf-devel.sha256sum] = "442bf96d698239e7626043143f7b7d3857460e9a10eca6593324e28d66d8a21a"

URI_aarch64_libcerf = "${EPEL_MIRROR}/aarch64/Packages/l/libcerf-2.4-2.el10_1.aarch64.rpm;name=aarch64_libcerf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcerf}"
SRC_URI[aarch64_libcerf.sha256sum] = "44806e5d7eaf74ed83bc001746fb4935567950b37cbc581c5b44d8c720702444"

URI_aarch64_libcerf-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcerf-devel-2.4-2.el10_1.aarch64.rpm;name=aarch64_libcerf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcerf-devel}"
SRC_URI[aarch64_libcerf-devel.sha256sum] = "a50fa14bd9b6e6580ab0b4bbf813389de6604b7ea035d2ffd5a11e978069644e"

RDEPENDS:libcerf = " \
 glibc \
 "
RDEPENDS:libcerf-devel = " \
 cmake-filesystem \
 libcerf \
 pkgconf-pkg-config \
 "
