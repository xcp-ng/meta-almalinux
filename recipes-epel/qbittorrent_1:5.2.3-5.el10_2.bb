# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qbittorrent"
PE = "1"
PV = "5.2.3"
PR = "5.el10_2"
PACKAGES = " \
 qbittorrent \
 qbittorrent-nox \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qbittorrent-5.2.3-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3af10ff90394bb11df75cea1c9e3c98f026479bb95d5f23f2a2c469057c9572"

URI_x86_64_v2_qbittorrent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qbittorrent-5.2.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qbittorrent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qbittorrent}"
SRC_URI[x86_64_v2_qbittorrent.sha256sum] = "100b5065760c5f25498c6405b7e23c5244557ceb3a65dd96aa838d3dbd80f999"

URI_x86_64_v2_qbittorrent-nox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qbittorrent-nox-5.2.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qbittorrent-nox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qbittorrent-nox}"
SRC_URI[x86_64_v2_qbittorrent-nox.sha256sum] = "a7738a5ec28ce936a1ec39ba688ad2760c7a915cb728a8094bfd6ad8abb97fe0"

URI_aarch64_qbittorrent = "${EPEL_MIRROR}/aarch64/Packages/q/qbittorrent-5.2.3-5.el10_2.aarch64.rpm;name=aarch64_qbittorrent;unpack=0"
SRC_URI:append = " ${URI_aarch64_qbittorrent}"
SRC_URI[aarch64_qbittorrent.sha256sum] = "01a8c1eba6040c8ae9021a746a97070ba5e95d13bfcb4ef6d92c72b0aa2d4986"

URI_aarch64_qbittorrent-nox = "${EPEL_MIRROR}/aarch64/Packages/q/qbittorrent-nox-5.2.3-5.el10_2.aarch64.rpm;name=aarch64_qbittorrent-nox;unpack=0"
SRC_URI:append = " ${URI_aarch64_qbittorrent-nox}"
SRC_URI[aarch64_qbittorrent-nox.sha256sum] = "1fac91891c3057dd4e100eb52172c8f29f6e6c19b0a48b1c0dee8e115fae4306"

RDEPENDS:qbittorrent = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 rb_libtorrent \
 zlib-ng-compat \
 "
RDEPENDS:qbittorrent-nox = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 rb_libtorrent \
 zlib-ng-compat \
 "
