# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dyninst"
PV = "13.0.0"
PR = "1.el10"
PACKAGES = " \
 dyninst \
 dyninst-devel \
 dyninst-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dyninst-13.0.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d053c0b25b7cc90780faec14380ef48a1b47e5a706be07cce8ab29ff61ba05a4"

URI_x86_64_v2_dyninst = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dyninst-13.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_dyninst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dyninst}"
SRC_URI[x86_64_v2_dyninst.sha256sum] = "fed724aae838affcdb6f9aa310915f40d30b15d327519ff2331b3058b35f1e1c"

URI_x86_64_v2_dyninst-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dyninst-devel-13.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_dyninst-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dyninst-devel}"
SRC_URI[x86_64_v2_dyninst-devel.sha256sum] = "c44d09fa281874d4296a84e01e6cde80a723d3c11c08a4d97272d36d443807ad"

URI_x86_64_v2_dyninst-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dyninst-doc-13.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_dyninst-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dyninst-doc}"
SRC_URI[x86_64_v2_dyninst-doc.sha256sum] = "bbfeb688460a5649634087b078a7ea6875d52e50b8261e9eb70237a81e25c8df"

URI_aarch64_dyninst = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dyninst-13.0.0-1.el10.aarch64.rpm;name=aarch64_dyninst;unpack=0"
SRC_URI:append = " ${URI_aarch64_dyninst}"
SRC_URI[aarch64_dyninst.sha256sum] = "23d9ccc16ff479b641a0918211b6453d6008e328642db9696206a7290362452b"

URI_aarch64_dyninst-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dyninst-devel-13.0.0-1.el10.aarch64.rpm;name=aarch64_dyninst-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dyninst-devel}"
SRC_URI[aarch64_dyninst-devel.sha256sum] = "2fa35927158a6cdc3d98681bb1f2c4fbb1e344841be35e7b7d9d177b36c3e45a"

URI_aarch64_dyninst-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dyninst-doc-13.0.0-1.el10.aarch64.rpm;name=aarch64_dyninst-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dyninst-doc}"
SRC_URI[aarch64_dyninst-doc.sha256sum] = "6890374d5223977e62360c7308f25e470631fa25a46a4dcd8cd1538ee9afdaef"

RDEPENDS:dyninst = " \
 boost-filesystem \
 boost-thread \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 tbb \
 "
RDEPENDS:dyninst-devel = " \
 boost-devel \
 cmake-filesystem \
 dyninst \
 tbb-devel \
 "
RDEPENDS:dyninst-doc = " \
 "
