# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pycdlib"
PV = "1.16.0"
PR = "2.el10_2"
PACKAGES = " \
 pycdlib-tools \
 python3-pycdlib \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-pycdlib-1.16.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "be4859ce993f315f2ea7e142a404e08bc12f659a568662b7f043898a35bddf7a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pycdlib-tools-1.16.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pycdlib-tools;unpack=0"
SRC_URI[x86_64_v2_pycdlib-tools.sha256sum] = "a6bc75094c68e0a364fbb94aa8ed32a4eb8a367b52704b680cefd6e2fd6068cc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pycdlib-1.16.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pycdlib;unpack=0"
SRC_URI[x86_64_v2_python3-pycdlib.sha256sum] = "26dda9806360eaa2ff31f171a9fbcd55421708dc46afa622307202c00f67e409"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pycdlib-tools-1.16.0-2.el10_2.noarch.rpm;name=aarch64_pycdlib-tools;unpack=0"
SRC_URI[aarch64_pycdlib-tools.sha256sum] = "d1682a632e631728d753410c02e8c6cb1f21c8057e2ba1bc5f3afef33f74ccdc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pycdlib-1.16.0-2.el10_2.noarch.rpm;name=aarch64_python3-pycdlib;unpack=0"
SRC_URI[aarch64_python3-pycdlib.sha256sum] = "5de9672699b95efe71e23ab9ad827679055eee9e78596dd4c8a895311ec6b511"

RDEPENDS:pycdlib-tools = " \
 python3 \
 python3-pycdlib \
 "
RDEPENDS:python3-pycdlib = " \
 python3 \
 "
