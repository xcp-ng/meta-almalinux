# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nettle"
PV = "7.5.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-nettle+default-devel \
 rust-nettle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nettle-7.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ccf5d28eb9f1f72879bb1a89fe03c1d548a650d7db00cb6e09c812197a75e333"

URI_x86_64_v2_rust-nettle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nettle+default-devel-7.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nettle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nettle+default-devel}"
SRC_URI[x86_64_v2_rust-nettle+default-devel.sha256sum] = "1318f2c0764cac892bd3f5afecdc9f2282da53ff2a41554694d4e69676597b0a"

URI_x86_64_v2_rust-nettle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nettle-devel-7.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nettle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nettle-devel}"
SRC_URI[x86_64_v2_rust-nettle-devel.sha256sum] = "ac7b64863b7043785355ff19e16cd2b50f46ffa727d650a9c099735841b717d5"

URI_aarch64_rust-nettle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nettle+default-devel-7.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-nettle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nettle+default-devel}"
SRC_URI[aarch64_rust-nettle+default-devel.sha256sum] = "9a1a0c287b1f18bd58b67531221e1dc2f838201de144c47b18e1e0102d0068c5"

URI_aarch64_rust-nettle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nettle-devel-7.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-nettle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nettle-devel}"
SRC_URI[aarch64_rust-nettle-devel.sha256sum] = "c98e1bd7f5bd54dd98a5e9178905474e544c26f72899f83a8230b3713287f5ec"

RDEPENDS:rust-nettle+default-devel = " \
 cargo \
 rust-nettle-devel \
 "
RDEPENDS:rust-nettle-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 rust-nettle-sys+default-devel \
 rust-typenum+default-devel \
 virtual/crate_getrandom/default__ge_0.3.0_with_crate_getrandom/default__lt_0.5.0~ \
 virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~ \
 "
