# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knights"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 knights \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knights-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddc5104908eb796d8d5305d0ece34ce11752527e5e03cc28e6fddc85bc194e88"

URI_x86_64_v2_knights = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knights-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knights;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knights}"
SRC_URI[x86_64_v2_knights.sha256sum] = "beb7b34baad2a27089324bb06b5dc73e96f6d28db493501431457f7424be0ea0"

URI_aarch64_knights = "${EPEL_MIRROR}/aarch64/Packages/k/knights-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_knights;unpack=0"
SRC_URI:append = " ${URI_aarch64_knights}"
SRC_URI[aarch64_knights.sha256sum] = "3738889891b33cccf8c4ecac676b9c10c52b50084739ad35f3c1417d9c40b1cf"

RDEPENDS:knights = " \
 glibc \
 gnuchess \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kplotting \
 kf6-ksvg \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
