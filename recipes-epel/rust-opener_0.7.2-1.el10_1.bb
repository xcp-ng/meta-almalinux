# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-opener"
PV = "0.7.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-opener+default-devel \
 rust-opener-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-opener-0.7.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "decc18d23073653578c566221e3b011f415ece961e61817c4ce5b2baa2815553"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-opener+default-devel-0.7.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-opener+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-opener+default-devel.sha256sum] = "27ac5d2a99efd0a7a727d95ff3dc3df7465ad2adfb00bad2e3960638b70446cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-opener-devel-0.7.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-opener-devel;unpack=0"
SRC_URI[x86_64_v2_rust-opener-devel.sha256sum] = "79a9589f11ec491576558526463c113a5f21dbc7b93291664f17f34dc08d95ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-opener+default-devel-0.7.2-1.el10_1.noarch.rpm;name=aarch64_rust-opener+default-devel;unpack=0"
SRC_URI[aarch64_rust-opener+default-devel.sha256sum] = "72934a30b767686ab58366fea7472f4e8813fcd20eade7909c60514a1c7a7204"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-opener-devel-0.7.2-1.el10_1.noarch.rpm;name=aarch64_rust-opener-devel;unpack=0"
SRC_URI[aarch64_rust-opener-devel.sha256sum] = "2d7168283f5df5f588a442761fb7c59a1bd9d5b72983ba7d066e0ec20245c5fa"

RDEPENDS:rust-opener+default-devel = " \
 cargo \
 rust-opener-devel \
 "
RDEPENDS:rust-opener-devel = " \
 cargo \
 rust-bstr+default-devel \
 "
