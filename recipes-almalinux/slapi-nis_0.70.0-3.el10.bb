# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "slapi-nis"
PV = "0.70.0"
PR = "3.el10"
PACKAGES = " \
 slapi-nis \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/slapi-nis-0.70.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a73e18fae4c4cd8f28bb31eeec4a78d05cb68b3ab57067e1c2a29f07880232ba"

URI_x86_64_v2_slapi-nis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/slapi-nis-0.70.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_slapi-nis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slapi-nis}"
SRC_URI[x86_64_v2_slapi-nis.sha256sum] = "6685f0442063f92d7babc2119a561a9db0a3512999be69a1a1a4568815352b29"

URI_aarch64_slapi-nis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/slapi-nis-0.70.0-3.el10.aarch64.rpm;name=aarch64_slapi-nis;unpack=0"
SRC_URI:append = " ${URI_aarch64_slapi-nis}"
SRC_URI[aarch64_slapi-nis.sha256sum] = "026e9e17de7760120e54d6ed778018d271354bc9e52910f63a28fd671bbc55e5"

RDEPENDS:slapi-nis = " \
 389-ds-base \
 bash \
 glibc \
 libsss_nss_idmap \
 nspr \
 nss \
 nss-util \
 openldap \
 pam-libs \
 "
