# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kontrast"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kontrast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kontrast-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2666f67011966aa28d6ee20c4c038a4de0cb10a78243ea65c1f4015243e8ec5d"

URI_x86_64_v2_kontrast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontrast-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontrast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontrast}"
SRC_URI[x86_64_v2_kontrast.sha256sum] = "b522d3d9ab520ef46ce3822c7418800b990147415b85084e888aadcceb4e327b"

URI_aarch64_kontrast = "${EPEL_MIRROR}/aarch64/Packages/k/kontrast-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kontrast;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontrast}"
SRC_URI[aarch64_kontrast.sha256sum] = "4e274d0dd2bd25b942c0affbf12cb0871a26689e4bc44da7eb73bf3b95a430e6"

RDEPENDS:kontrast = " \
 futuresql-qt6 \
 glibc \
 hicolor-icon-theme \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
