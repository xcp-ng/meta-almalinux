# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "CGSI-gSOAP"
PV = "1.3.13"
PR = "1.el10_1"
PACKAGES = " \
 CGSI-gSOAP \
 CGSI-gSOAP-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/CGSI-gSOAP-1.3.13-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b8c869b08a7a9f553916d1db353c211fc4b520dd7852b2ff8a374938e5b8827"

URI_x86_64_v2_CGSI-gSOAP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CGSI-gSOAP-1.3.13-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CGSI-gSOAP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CGSI-gSOAP}"
SRC_URI[x86_64_v2_CGSI-gSOAP.sha256sum] = "a4ef3d4652cf1b237ea3d3a1b52f0d50830ec5ea6b97cd08d21ee2b2cdb16dd5"

URI_x86_64_v2_CGSI-gSOAP-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CGSI-gSOAP-devel-1.3.13-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CGSI-gSOAP-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CGSI-gSOAP-devel}"
SRC_URI[x86_64_v2_CGSI-gSOAP-devel.sha256sum] = "4c2d9427650e296c47944322f99fedfd3902962e6499295750a9a425f6921314"

URI_aarch64_CGSI-gSOAP = "${EPEL_MIRROR}/aarch64/Packages/c/CGSI-gSOAP-1.3.13-1.el10_1.aarch64.rpm;name=aarch64_CGSI-gSOAP;unpack=0"
SRC_URI:append = " ${URI_aarch64_CGSI-gSOAP}"
SRC_URI[aarch64_CGSI-gSOAP.sha256sum] = "96ff01e86ec133640e646ace5866c10fff9adcbbd13bfb9215efa41f39aba37e"

URI_aarch64_CGSI-gSOAP-devel = "${EPEL_MIRROR}/aarch64/Packages/c/CGSI-gSOAP-devel-1.3.13-1.el10_1.aarch64.rpm;name=aarch64_CGSI-gSOAP-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_CGSI-gSOAP-devel}"
SRC_URI[aarch64_CGSI-gSOAP-devel.sha256sum] = "ba604168fdff2a9756548aa20ff7b090e70cb5c1a7f8f9641619902b73d1116f"

RDEPENDS:CGSI-gSOAP = " \
 glibc \
 globus-common \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-openssl-module \
 libstdc++ \
 openssl-libs \
 voms \
 "
RDEPENDS:CGSI-gSOAP-devel = " \
 CGSI-gSOAP \
 gsoap-devel \
 "
