# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Time-Moment"
PV = "0.46"
PR = "1.el10_2"
PACKAGES = " \
 perl-Time-Moment \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Time-Moment-0.46-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c78b2285456758638bbe52f34f4504fecb0c327fd8b56543a63d79033691868c"

URI_x86_64_v2_perl-Time-Moment = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Time-Moment-0.46-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Time-Moment;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Time-Moment}"
SRC_URI[x86_64_v2_perl-Time-Moment.sha256sum] = "59a06973bbd1dd7b39ad3a036a29be794e5825b296df66c1ceff4279e6d8d56b"

URI_aarch64_perl-Time-Moment = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Time-Moment-0.46-1.el10_2.aarch64.rpm;name=aarch64_perl-Time-Moment;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Time-Moment}"
SRC_URI[aarch64_perl-Time-Moment.sha256sum] = "1b21152a457d61f2cc0160b69a1ce0efbfed5f2f7f90b4c138262683e12873bc"

RDEPENDS:perl-Time-Moment = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
