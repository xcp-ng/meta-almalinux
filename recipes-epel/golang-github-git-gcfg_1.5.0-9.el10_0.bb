# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-git-gcfg"
PV = "1.5.0"
PR = "9.el10_0"
PACKAGES = " \
 golang-github-git-gcfg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-git-gcfg-1.5.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69c76f9fb15b28469ac03d2ac9cf857b2f525e6df8ce3aaae69fdc0e98f38c9b"

URI_x86_64_v2_golang-github-git-gcfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-git-gcfg-devel-1.5.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-git-gcfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-git-gcfg-devel}"
SRC_URI[x86_64_v2_golang-github-git-gcfg-devel.sha256sum] = "ccb7d77942a2e6564c7df72b0906830c21da80734543a0270f3342be8acaf257"

URI_aarch64_golang-github-git-gcfg-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-git-gcfg-devel-1.5.0-9.el10_0.noarch.rpm;name=aarch64_golang-github-git-gcfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-git-gcfg-devel}"
SRC_URI[aarch64_golang-github-git-gcfg-devel.sha256sum] = "284229fc60d2eda1c959c73b4e4669e0114c348b57f8d47f038bf1ba2d9df852"

RDEPENDS:golang-github-git-gcfg-devel = " \
 go-filesystem \
 golang-gopkg-warnings-0-devel \
 "
