# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-sergi-diff"
PV = "1.3.1"
PR = "5.el10_0"
PACKAGES = " \
 golang-github-sergi-diff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-sergi-diff-1.3.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb97b1fe93718f701dcf948fd10eba7f2604d6f0631b85905d34a0ef6b8474e2"

URI_x86_64_v2_golang-github-sergi-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-sergi-diff-devel-1.3.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-sergi-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-sergi-diff-devel}"
SRC_URI[x86_64_v2_golang-github-sergi-diff-devel.sha256sum] = "ef4b9966f24202f5f1d1b8bcadccf6de99b288db05a8497ea0c89d27d093ee74"

URI_aarch64_golang-github-sergi-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-sergi-diff-devel-1.3.1-5.el10_0.noarch.rpm;name=aarch64_golang-github-sergi-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-sergi-diff-devel}"
SRC_URI[aarch64_golang-github-sergi-diff-devel.sha256sum] = "1c61f74d00f4411c13d4b9685ef3fb3e654093ff839b360273a0eac379f83eb9"

RDEPENDS:golang-github-sergi-diff-devel = " \
 go-filesystem \
 "
