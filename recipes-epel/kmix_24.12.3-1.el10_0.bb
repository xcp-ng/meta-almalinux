# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmix"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kmix \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmix-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "58a4c3281e735627aea134c32f7ccd418e3820ad288d1227b7bf5501cc1265f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmix-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmix;unpack=0"
SRC_URI[x86_64_v2_kmix.sha256sum] = "81fd5071a622e3cc824f08824d6be228894df9201c730c2ad661e3afb20e78c4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmix-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmix;unpack=0"
SRC_URI[aarch64_kmix.sha256sum] = "db8f35a0395db456708e712732b01c22edc5a6d2854e137ba7bdf2f0cfe4655f"

RDEPENDS:kmix = " \
 alsa-lib \
 bash \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 libcanberra \
 libstdc++ \
 pulseaudio-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
