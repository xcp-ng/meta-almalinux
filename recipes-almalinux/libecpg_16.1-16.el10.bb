# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libecpg"
PV = "16.1"
PR = "16.el10"
PACKAGES = " \
 libecpg \
 libecpg-devel \
 libpgtypes \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libecpg-16.1-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e959a1cdb00c05f681af8f6d0b19d5034c409da9ed0266f2d65e4405309133ff"

URI_x86_64_v2_libecpg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libecpg-16.1-16.el10.x86_64_v2.rpm;name=x86_64_v2_libecpg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libecpg}"
SRC_URI[x86_64_v2_libecpg.sha256sum] = "b327719cba1c68e7c864d048a2de17b78166716d263f934f3a6cac5c84c6834e"

URI_x86_64_v2_libecpg-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libecpg-devel-16.1-16.el10.x86_64_v2.rpm;name=x86_64_v2_libecpg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libecpg-devel}"
SRC_URI[x86_64_v2_libecpg-devel.sha256sum] = "4d80545e70584a66ee38610315c7564fc3bfc986c5f25895fb66c47dc116e7e3"

URI_x86_64_v2_libpgtypes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpgtypes-16.1-16.el10.x86_64_v2.rpm;name=x86_64_v2_libpgtypes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpgtypes}"
SRC_URI[x86_64_v2_libpgtypes.sha256sum] = "7ebdebdaac13f47639e62ab46bbf9627be51af7029362daa77369df5ff9b61dd"

URI_aarch64_libecpg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libecpg-16.1-16.el10.aarch64.rpm;name=aarch64_libecpg;unpack=0"
SRC_URI:append = " ${URI_aarch64_libecpg}"
SRC_URI[aarch64_libecpg.sha256sum] = "fc291f185f1af0e6bab9d2d767111fb023db370ce40f354797308e54d55705d0"

URI_aarch64_libecpg-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libecpg-devel-16.1-16.el10.aarch64.rpm;name=aarch64_libecpg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libecpg-devel}"
SRC_URI[aarch64_libecpg-devel.sha256sum] = "73e353a641a2f285d0e5d6715413b480236a0c39a95c8d101f97e028f3bd5605"

URI_aarch64_libpgtypes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpgtypes-16.1-16.el10.aarch64.rpm;name=aarch64_libpgtypes;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpgtypes}"
SRC_URI[aarch64_libpgtypes.sha256sum] = "c757eddef3580fbd49bf425948486ba19bc3d2b1d86871e5936708b302eb2739"

RDEPENDS:libecpg = " \
 glibc \
 libpgtypes \
 libpq \
 "
RDEPENDS:libecpg-devel = " \
 glibc \
 libecpg \
 libecpg-devel \
 libpgtypes \
 libpq-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libpgtypes = " \
 glibc \
 "
