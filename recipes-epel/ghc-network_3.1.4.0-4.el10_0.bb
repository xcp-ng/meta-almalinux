# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-network"
PV = "3.1.4.0"
PR = "4.el10_0"
PACKAGES = " \
 ghc-network \
 ghc-network-devel \
 ghc-network-doc \
 ghc-network-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-network-3.1.4.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2342cf37ed24ddadbcd2361446d8094810790938ad25082f67b188e3a6b8f05e"

URI_x86_64_v2_ghc-network = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-3.1.4.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network}"
SRC_URI[x86_64_v2_ghc-network.sha256sum] = "73c5ad2a9d5b5a9276e395aa477941ab3112b7e447919ac29b2c0cbc455f154b"

URI_x86_64_v2_ghc-network-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-devel-3.1.4.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-devel}"
SRC_URI[x86_64_v2_ghc-network-devel.sha256sum] = "99c790106c9b19add7ecee57dfa50df34537eb70f7cfa8b59efa136ab4f1484e"

URI_x86_64_v2_ghc-network-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-doc-3.1.4.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-network-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-doc}"
SRC_URI[x86_64_v2_ghc-network-doc.sha256sum] = "38864cd68b7303c43f2555d5087762f64d544b75fe168f9ba7659f1c5d6de537"

URI_x86_64_v2_ghc-network-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-prof-3.1.4.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-prof}"
SRC_URI[x86_64_v2_ghc-network-prof.sha256sum] = "e0245b6e155a56c26cf571425ed56b383722eb760a71f98f342995ac44c1b656"

URI_aarch64_ghc-network = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-3.1.4.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-network;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network}"
SRC_URI[aarch64_ghc-network.sha256sum] = "3adf96968d032db9fb3bb0d44e7398c1841fe13617cdb6864c8610730e08ce69"

URI_aarch64_ghc-network-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-devel-3.1.4.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-network-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-devel}"
SRC_URI[aarch64_ghc-network-devel.sha256sum] = "78eee0dac0e46c281a54e3d6bd05472a4ecbd6b04febb8f1e686d20d75bd84da"

URI_aarch64_ghc-network-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-doc-3.1.4.0-4.el10_0.noarch.rpm;name=aarch64_ghc-network-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-doc}"
SRC_URI[aarch64_ghc-network-doc.sha256sum] = "f8d3e4b5e0df7144c482233d41c2668b79b7c0875e869859d390ba2403125e17"

URI_aarch64_ghc-network-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-prof-3.1.4.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-network-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-prof}"
SRC_URI[aarch64_ghc-network-prof.sha256sum] = "de7cc2d498f3927eede694556908eda89cd4ef686454f4c5beee1c7615c90757"

RDEPENDS:ghc-network = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-network-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-network \
 "
RDEPENDS:ghc-network-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-network-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-network-devel \
 "
