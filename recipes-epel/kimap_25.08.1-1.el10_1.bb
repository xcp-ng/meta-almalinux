# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kimap"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kimap \
 kimap-devel \
 kimap-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kimap-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ba57204144552c94f1c45909fdabccd33adbacef64121e9b09b95be76522ea6"

URI_x86_64_v2_kimap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimap}"
SRC_URI[x86_64_v2_kimap.sha256sum] = "9b7dedf1d148118c38fb95af89b4a547de5b48a3015bc240476c26c844822807"

URI_x86_64_v2_kimap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimap-devel}"
SRC_URI[x86_64_v2_kimap-devel.sha256sum] = "9765b3d35ff34287d28dcbc8b3b5c9f28aa9e71f98a3836a5d23ff9a0701accc"

URI_x86_64_v2_kimap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kimap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimap-doc}"
SRC_URI[x86_64_v2_kimap-doc.sha256sum] = "e7018efd974f30098df14950dcfaa39b83d05711de802888d7f98af2e1dd7ee7"

URI_aarch64_kimap = "${EPEL_MIRROR}/aarch64/Packages/k/kimap-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kimap;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimap}"
SRC_URI[aarch64_kimap.sha256sum] = "e610310a53c5015fa9dfa5379188cb75124c2cc910a82e56799fcf09e1baa91b"

URI_aarch64_kimap-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kimap-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kimap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimap-devel}"
SRC_URI[aarch64_kimap-devel.sha256sum] = "08ddfa460013a8c895b9b87da07014e638fe1320e48e3763b950689fead2b7a3"

URI_aarch64_kimap-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kimap-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kimap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimap-doc}"
SRC_URI[aarch64_kimap-doc.sha256sum] = "dd8b4bbe5a39f61283578ceae2594a42cd9eb66875c2351a2a4927c8daee2a90"

RDEPENDS:kimap = " \
 cyrus-sasl-lib \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kimap-devel = " \
 boost-devel \
 cmake-filesystem \
 cyrus-sasl-devel \
 kf6-kcoreaddons-devel \
 kimap \
 "
RDEPENDS:kimap-doc = " \
 "
