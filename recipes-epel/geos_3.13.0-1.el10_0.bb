# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "geos"
PV = "3.13.0"
PR = "1.el10_0"
PACKAGES = " \
 geos \
 geos-devel \
 mingw32-geos \
 mingw64-geos \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/geos-3.13.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "945c2909017fa250d9c04af9b82361f0913b39305495030b62db4bf458d28b3f"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - mingw32-geos: mingw32(libstdc++-6.dll)
# - mingw64-geos: mingw64(libstdc++-6.dll)

URI_x86_64_v2_geos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/geos-3.13.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_geos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_geos}"
SRC_URI[x86_64_v2_geos.sha256sum] = "9ee7d0672a919492b3bf007a9c1f2176cd268fe7fc910f7e5dc8dba2ceb56f92"

URI_x86_64_v2_geos-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/geos-devel-3.13.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_geos-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_geos-devel}"
SRC_URI[x86_64_v2_geos-devel.sha256sum] = "99c3a46b882c8004d00453195c4736e8880c8265991bf2999353fa5b6a678396"

URI_x86_64_v2_mingw32-geos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-geos-3.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-geos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-geos}"
SRC_URI[x86_64_v2_mingw32-geos.sha256sum] = "5b3797c2e55e024a9e29ef30e21a9a7889cda7e2e711a1436130ed61ebea8d62"

URI_x86_64_v2_mingw64-geos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-geos-3.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-geos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-geos}"
SRC_URI[x86_64_v2_mingw64-geos.sha256sum] = "c0c47dab62aabfbfa5b9ecdd4261c1e6b75cb6b0048c60bbad1119fbc9e93f3f"

URI_aarch64_geos = "${EPEL_MIRROR}/aarch64/Packages/g/geos-3.13.0-1.el10_0.aarch64.rpm;name=aarch64_geos;unpack=0"
SRC_URI:append = " ${URI_aarch64_geos}"
SRC_URI[aarch64_geos.sha256sum] = "46eb3f5743903ca9094e57601caf9debe5a2a0ac6d9807c1a7932715cede7ed8"

URI_aarch64_geos-devel = "${EPEL_MIRROR}/aarch64/Packages/g/geos-devel-3.13.0-1.el10_0.aarch64.rpm;name=aarch64_geos-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_geos-devel}"
SRC_URI[aarch64_geos-devel.sha256sum] = "238022a699db5788ae7fbdad5f55e7f29646adfc9b3a53ccaaebff68b55f171d"

URI_aarch64_mingw32-geos = "${EPEL_MIRROR}/aarch64/Packages/m/mingw32-geos-3.13.0-1.el10_0.noarch.rpm;name=aarch64_mingw32-geos;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-geos}"
SRC_URI[aarch64_mingw32-geos.sha256sum] = "fc74b7cd35c8ceb9e90daf2ed8791ef2c5226ddcd1cdb46356416d1fb2b3fa20"

URI_aarch64_mingw64-geos = "${EPEL_MIRROR}/aarch64/Packages/m/mingw64-geos-3.13.0-1.el10_0.noarch.rpm;name=aarch64_mingw64-geos;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-geos}"
SRC_URI[aarch64_mingw64-geos.sha256sum] = "e34984313e793d29de859224142a24d73908c659de4f0b44a98580ef7eb6e654"

RDEPENDS:geos = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:geos-devel = " \
 bash \
 cmake-filesystem \
 geos \
 pkgconf-pkg-config \
 "
RDEPENDS:mingw32-geos:x86_64_v2 = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
 mingw32-libstdc++ \
 mingw32-winpthreads \
"
RDEPENDS:mingw32-geos:aarch64 = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
 mingw32-winpthreads \
"
RDEPENDS:mingw64-geos:x86_64_v2 = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-libgcc \
 mingw64-libstdc++ \
 mingw64-winpthreads \
"
RDEPENDS:mingw64-geos:aarch64 = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-libgcc \
 mingw64-winpthreads \
"
