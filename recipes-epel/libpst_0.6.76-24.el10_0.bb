# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpst"
PV = "0.6.76"
PR = "24.el10_0"
PACKAGES = " \
 libpst \
 libpst-devel \
 libpst-devel-doc \
 libpst-doc \
 libpst-libs \
 python3-libpst \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libpst-0.6.76-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fd6e37a935ab4450ef0c040edfd5a3af0c6a851cfa3f7b90ff58a1f233529a1"

URI_x86_64_v2_libpst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpst-0.6.76-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpst}"
SRC_URI[x86_64_v2_libpst.sha256sum] = "d478c3fb1849bac6c1b0b1e297f003ff9a43ae075b7174f424e46356c2737ba3"

URI_x86_64_v2_libpst-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpst-devel-0.6.76-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpst-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpst-devel}"
SRC_URI[x86_64_v2_libpst-devel.sha256sum] = "201b76ab235c8f876aca6b49f886701e7235cd4a5a90bcf5a523a7fdfe672025"

URI_x86_64_v2_libpst-devel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpst-devel-doc-0.6.76-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpst-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpst-devel-doc}"
SRC_URI[x86_64_v2_libpst-devel-doc.sha256sum] = "12b0f330b87742004a322d39286e4cc09b5241976643af81f6ffd9c697fa02a0"

URI_x86_64_v2_libpst-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpst-doc-0.6.76-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpst-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpst-doc}"
SRC_URI[x86_64_v2_libpst-doc.sha256sum] = "4e150d1f343ecb7f9577c462b5b24fb35fafd2abdf2400f6deb3e8c03912cbf0"

URI_x86_64_v2_libpst-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpst-libs-0.6.76-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpst-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpst-libs}"
SRC_URI[x86_64_v2_libpst-libs.sha256sum] = "f985fe7d0d5f9ea82b903052605ac92f7543965157b3b24ef1cd9e215d1e13f8"

URI_x86_64_v2_python3-libpst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libpst-0.6.76-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-libpst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libpst}"
SRC_URI[x86_64_v2_python3-libpst.sha256sum] = "56df6d719cf4b1ef4c0b444f633d50edce7dd3ce101309c8ce2176a7bf00e008"

URI_aarch64_libpst = "${EPEL_MIRROR}/aarch64/Packages/l/libpst-0.6.76-24.el10_0.aarch64.rpm;name=aarch64_libpst;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpst}"
SRC_URI[aarch64_libpst.sha256sum] = "eeae8e46abac5e29383029fb010ca98216354a10b3d60fe6c2509445fa98a43b"

URI_aarch64_libpst-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libpst-devel-0.6.76-24.el10_0.aarch64.rpm;name=aarch64_libpst-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpst-devel}"
SRC_URI[aarch64_libpst-devel.sha256sum] = "a3c7ec2c50f15fc70d39f654e1cca7bcb8388d023ecef21598dfc5d2bf1d99a6"

URI_aarch64_libpst-devel-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libpst-devel-doc-0.6.76-24.el10_0.aarch64.rpm;name=aarch64_libpst-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpst-devel-doc}"
SRC_URI[aarch64_libpst-devel-doc.sha256sum] = "0368c4a7b1a2a9e182643f6386ac2495f548625fbddb641b302905ea615ec659"

URI_aarch64_libpst-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libpst-doc-0.6.76-24.el10_0.aarch64.rpm;name=aarch64_libpst-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpst-doc}"
SRC_URI[aarch64_libpst-doc.sha256sum] = "9feeb63c7e3c9d79d7c9ea8c29b1c1a104b94bd93959c5ce34835d0815fa3798"

URI_aarch64_libpst-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libpst-libs-0.6.76-24.el10_0.aarch64.rpm;name=aarch64_libpst-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpst-libs}"
SRC_URI[aarch64_libpst-libs.sha256sum] = "aadac5446f05a7a4b20d96d01af1a3bacd018e3413524708da5e5b22a5a31974"

URI_aarch64_python3-libpst = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libpst-0.6.76-24.el10_0.aarch64.rpm;name=aarch64_python3-libpst;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libpst}"
SRC_URI[aarch64_python3-libpst.sha256sum] = "1932ee4d8059629c187f6cd7eea78a86a56eb3d59d8cb074747354a29f5c1af2"

RDEPENDS:libpst = " \
 boost-python3 \
 glib2 \
 glibc \
 libgcc \
 libgsf \
 libpst-libs \
 libstdc++ \
 "
RDEPENDS:libpst-devel = " \
 libpst-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:libpst-devel-doc = " \
 libpst-doc \
 "
RDEPENDS:libpst-doc = " \
 "
RDEPENDS:libpst-libs = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:python3-libpst = " \
 boost-python3 \
 glibc \
 libgcc \
 libpst-libs \
 libstdc++ \
 python3 \
 zlib-ng-compat \
 "
