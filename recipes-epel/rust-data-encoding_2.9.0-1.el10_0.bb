# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-data-encoding"
PV = "2.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-data-encoding+alloc-devel \
 rust-data-encoding+default-devel \
 rust-data-encoding+std-devel \
 rust-data-encoding-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-data-encoding-2.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ccce8dd4698d5f16a8e44e6a652eae638e186697885101a5c4663521311a6075"

URI_x86_64_v2_rust-data-encoding+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding+alloc-devel-2.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-data-encoding+alloc-devel}"
SRC_URI[x86_64_v2_rust-data-encoding+alloc-devel.sha256sum] = "568e76637ddc228eda79f65b002d9ecb27d47e17e32b542892da3b3ec8694229"

URI_x86_64_v2_rust-data-encoding+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding+default-devel-2.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-data-encoding+default-devel}"
SRC_URI[x86_64_v2_rust-data-encoding+default-devel.sha256sum] = "ab5a187ec932ddee4601d33c12fc1516492f7f1353cfeb469485aa48d108c8db"

URI_x86_64_v2_rust-data-encoding+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding+std-devel-2.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-data-encoding+std-devel}"
SRC_URI[x86_64_v2_rust-data-encoding+std-devel.sha256sum] = "e1ff47e987516f5701fe8e120d115c4226584296b336a4ee0091c3813ffd9c41"

URI_x86_64_v2_rust-data-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding-devel-2.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-data-encoding-devel}"
SRC_URI[x86_64_v2_rust-data-encoding-devel.sha256sum] = "be4a6438a8bf981c1cd034c58376e3689bceeff5b20c9c8b6803411a8924250f"

URI_aarch64_rust-data-encoding+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding+alloc-devel-2.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-data-encoding+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-data-encoding+alloc-devel}"
SRC_URI[aarch64_rust-data-encoding+alloc-devel.sha256sum] = "32b8f8fedb6f2d6e4d81fc60ec31e9edee6ccf54aac96439d93014d488769db1"

URI_aarch64_rust-data-encoding+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding+default-devel-2.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-data-encoding+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-data-encoding+default-devel}"
SRC_URI[aarch64_rust-data-encoding+default-devel.sha256sum] = "36a0fb416ef9a247a4df0c3b410c7e8e7d5c242b55a81afe15714418abe1fbbf"

URI_aarch64_rust-data-encoding+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding+std-devel-2.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-data-encoding+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-data-encoding+std-devel}"
SRC_URI[aarch64_rust-data-encoding+std-devel.sha256sum] = "10127ec4e377eb807fab96ad113fddd83d94aedd06077f9b28e365882ffeda43"

URI_aarch64_rust-data-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding-devel-2.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-data-encoding-devel}"
SRC_URI[aarch64_rust-data-encoding-devel.sha256sum] = "3ee0c13eee84a2faba08f90c84fbbfe459f33a3546b0d5c5a5e72d701970594f"

RDEPENDS:rust-data-encoding+alloc-devel = " \
 cargo \
 rust-data-encoding-devel \
 "
RDEPENDS:rust-data-encoding+default-devel = " \
 cargo \
 rust-data-encoding+std-devel \
 rust-data-encoding-devel \
 "
RDEPENDS:rust-data-encoding+std-devel = " \
 cargo \
 rust-data-encoding+alloc-devel \
 rust-data-encoding-devel \
 "
RDEPENDS:rust-data-encoding-devel = " \
 cargo \
 rust \
 "
