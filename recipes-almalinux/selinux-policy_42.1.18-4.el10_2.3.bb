# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "selinux-policy"
PV = "42.1.18"
PR = "4.el10_2.3"
PACKAGES = " \
 selinux-policy \
 selinux-policy-devel \
 selinux-policy-doc \
 selinux-policy-extra \
 selinux-policy-mls \
 selinux-policy-mls-extra \
 selinux-policy-sandbox \
 selinux-policy-targeted \
 selinux-policy-targeted-extra \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/selinux-policy-42.1.18-4.el10_2.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62ec2b5f0faba882524a5998f48e6cf6b50ceb63ba3532a9a559263e2ed89dc2"

URI_x86_64_v2_selinux-policy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-42.1.18-4.el10_2.3.noarch.rpm;name=x86_64_v2_selinux-policy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy}"
SRC_URI[x86_64_v2_selinux-policy.sha256sum] = "fcf32c8b8a9d26c944b2c513857cbd9b0f872764a1988bf10c0cac45ba0a798f"

URI_x86_64_v2_selinux-policy-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/selinux-policy-devel-42.1.18-4.el10_2.3.noarch.rpm;name=x86_64_v2_selinux-policy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-devel}"
SRC_URI[x86_64_v2_selinux-policy-devel.sha256sum] = "df8f0b6ae8db2fc26acb15f652e86275378c8908cd931d90fe468f79aa293234"

URI_x86_64_v2_selinux-policy-doc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-doc-42.1.18-4.el10_2.3.noarch.rpm;name=x86_64_v2_selinux-policy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-doc}"
SRC_URI[x86_64_v2_selinux-policy-doc.sha256sum] = "4ee823144dc9a3723d6f5bd5e1f9315f05d98ed3aada23f64980cf15e64390a1"

URI_x86_64_v2_selinux-policy-extra = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-extra-42.1.18-4.el10_2.3.noarch.rpm;name=x86_64_v2_selinux-policy-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-extra}"
SRC_URI[x86_64_v2_selinux-policy-extra.sha256sum] = "6af5d8b5473e8c7c1aad9628f895012698a07cf17072191cc2afaa7125c206c9"

URI_x86_64_v2_selinux-policy-mls = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-mls-42.1.18-4.el10_2.3.noarch.rpm;name=x86_64_v2_selinux-policy-mls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-mls}"
SRC_URI[x86_64_v2_selinux-policy-mls.sha256sum] = "858fa9c4c59bcca88c360c8807f04cfce1e261dd68a0e4db9ecce84a33ac5bd3"
RPROVIDES:selinux-policy-mls:x86_64_v2 = "virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.18-4.el10_2.3 virtual/selinux-policy-any_ge_42.1.13 virtual/selinux-policy-any_ge_42.1.15 virtual/selinux-policy-any_ge_42.1.17 virtual/selinux-policy-any_ge_42.1.9"

URI_x86_64_v2_selinux-policy-mls-extra = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-mls-extra-42.1.18-4.el10_2.3.noarch.rpm;name=x86_64_v2_selinux-policy-mls-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-mls-extra}"
SRC_URI[x86_64_v2_selinux-policy-mls-extra.sha256sum] = "5dfda8a7bf48b96c919b62ead3d069982382eda371b5d156f417fd027df6a7ca"

URI_x86_64_v2_selinux-policy-sandbox = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-sandbox-42.1.18-4.el10_2.3.noarch.rpm;name=x86_64_v2_selinux-policy-sandbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-sandbox}"
SRC_URI[x86_64_v2_selinux-policy-sandbox.sha256sum] = "b839f5569c7973dd4ee0774e96766b90c0961af2c4918f3d585b55d44f5a51c6"

URI_x86_64_v2_selinux-policy-targeted = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-targeted-42.1.18-4.el10_2.3.noarch.rpm;name=x86_64_v2_selinux-policy-targeted;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-targeted}"
SRC_URI[x86_64_v2_selinux-policy-targeted.sha256sum] = "9e66510a62a0522797e42759d9e93ccfc00ecdfc947ede230a31c07e06612c16"
RPROVIDES:selinux-policy-targeted:x86_64_v2 = "virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.18-4.el10_2.3 virtual/selinux-policy-any_ge_42.1.13 virtual/selinux-policy-any_ge_42.1.15 virtual/selinux-policy-any_ge_42.1.17 virtual/selinux-policy-any_ge_42.1.9"

URI_x86_64_v2_selinux-policy-targeted-extra = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-targeted-extra-42.1.18-4.el10_2.3.noarch.rpm;name=x86_64_v2_selinux-policy-targeted-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-targeted-extra}"
SRC_URI[x86_64_v2_selinux-policy-targeted-extra.sha256sum] = "a93bf51cd0fe5b299fbe4f822687b09fd7f8eee00d16be79b0ef6ea4b76689b6"

URI_aarch64_selinux-policy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-42.1.18-4.el10_2.3.noarch.rpm;name=aarch64_selinux-policy;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy}"
SRC_URI[aarch64_selinux-policy.sha256sum] = "fcf32c8b8a9d26c944b2c513857cbd9b0f872764a1988bf10c0cac45ba0a798f"

URI_aarch64_selinux-policy-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/selinux-policy-devel-42.1.18-4.el10_2.3.noarch.rpm;name=aarch64_selinux-policy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-devel}"
SRC_URI[aarch64_selinux-policy-devel.sha256sum] = "df8f0b6ae8db2fc26acb15f652e86275378c8908cd931d90fe468f79aa293234"

URI_aarch64_selinux-policy-doc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-doc-42.1.18-4.el10_2.3.noarch.rpm;name=aarch64_selinux-policy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-doc}"
SRC_URI[aarch64_selinux-policy-doc.sha256sum] = "4ee823144dc9a3723d6f5bd5e1f9315f05d98ed3aada23f64980cf15e64390a1"

URI_aarch64_selinux-policy-extra = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-extra-42.1.18-4.el10_2.3.noarch.rpm;name=aarch64_selinux-policy-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-extra}"
SRC_URI[aarch64_selinux-policy-extra.sha256sum] = "6af5d8b5473e8c7c1aad9628f895012698a07cf17072191cc2afaa7125c206c9"

URI_aarch64_selinux-policy-mls = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-mls-42.1.18-4.el10_2.3.noarch.rpm;name=aarch64_selinux-policy-mls;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-mls}"
SRC_URI[aarch64_selinux-policy-mls.sha256sum] = "858fa9c4c59bcca88c360c8807f04cfce1e261dd68a0e4db9ecce84a33ac5bd3"
RPROVIDES:selinux-policy-mls:aarch64 = "virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.18-4.el10_2.3 virtual/selinux-policy-any_ge_42.1.12 virtual/selinux-policy-any_ge_42.1.15 virtual/selinux-policy-any_ge_42.1.17 virtual/selinux-policy-any_ge_42.1.9"

URI_aarch64_selinux-policy-mls-extra = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-mls-extra-42.1.18-4.el10_2.3.noarch.rpm;name=aarch64_selinux-policy-mls-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-mls-extra}"
SRC_URI[aarch64_selinux-policy-mls-extra.sha256sum] = "5dfda8a7bf48b96c919b62ead3d069982382eda371b5d156f417fd027df6a7ca"

URI_aarch64_selinux-policy-sandbox = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-sandbox-42.1.18-4.el10_2.3.noarch.rpm;name=aarch64_selinux-policy-sandbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-sandbox}"
SRC_URI[aarch64_selinux-policy-sandbox.sha256sum] = "b839f5569c7973dd4ee0774e96766b90c0961af2c4918f3d585b55d44f5a51c6"

URI_aarch64_selinux-policy-targeted = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-targeted-42.1.18-4.el10_2.3.noarch.rpm;name=aarch64_selinux-policy-targeted;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-targeted}"
SRC_URI[aarch64_selinux-policy-targeted.sha256sum] = "9e66510a62a0522797e42759d9e93ccfc00ecdfc947ede230a31c07e06612c16"
RPROVIDES:selinux-policy-targeted:aarch64 = "virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.18-4.el10_2.3 virtual/selinux-policy-any_ge_42.1.12 virtual/selinux-policy-any_ge_42.1.15 virtual/selinux-policy-any_ge_42.1.17 virtual/selinux-policy-any_ge_42.1.9"

URI_aarch64_selinux-policy-targeted-extra = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-targeted-extra-42.1.18-4.el10_2.3.noarch.rpm;name=aarch64_selinux-policy-targeted-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-targeted-extra}"
SRC_URI[aarch64_selinux-policy-targeted-extra.sha256sum] = "a93bf51cd0fe5b299fbe4f822687b09fd7f8eee00d16be79b0ef6ea4b76689b6"

RDEPENDS:selinux-policy = " \
 bash \
 gawk \
 policycoreutils \
 rpm-plugin-selinux \
 virtual//usr/bin/sha512sum \
 virtual/selinux-policy-any_eq_42.1.18-4.el10_2.3 \
 "
RDEPENDS:selinux-policy-devel = " \
 bash \
 checkpolicy \
 m4 \
 make \
 policycoreutils-devel \
 selinux-policy \
 "
RDEPENDS:selinux-policy-doc = " \
 selinux-policy \
 "
RDEPENDS:selinux-policy-extra = " \
 selinux-policy-mls-extra \
 selinux-policy-targeted-extra \
 "
RDEPENDS:selinux-policy-mls = " \
 bash \
 mcstrans \
 policycoreutils \
 policycoreutils-newrole \
 selinux-policy \
 virtual/coreutils \
 "
RDEPENDS:selinux-policy-mls-extra = " \
 bash \
 selinux-policy-mls \
 "
RDEPENDS:selinux-policy-sandbox = " \
 bash \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:selinux-policy-targeted = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/coreutils \
 "
RDEPENDS:selinux-policy-targeted-extra = " \
 bash \
 selinux-policy-targeted \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/selinux-policy-any rpm/virtual/selinux-policy-any_eq_42.1.18-4.el10_2.3 rpm/virtual/selinux-policy-any_ge_42.1.13 rpm/virtual/selinux-policy-any_ge_42.1.15 rpm/virtual/selinux-policy-any_ge_42.1.17 rpm/virtual/selinux-policy-any_ge_42.1.9"

PROVIDES:append:aarch64 = " rpm/virtual/selinux-policy-any rpm/virtual/selinux-policy-any_eq_42.1.18-4.el10_2.3 rpm/virtual/selinux-policy-any_ge_42.1.12 rpm/virtual/selinux-policy-any_ge_42.1.15 rpm/virtual/selinux-policy-any_ge_42.1.17 rpm/virtual/selinux-policy-any_ge_42.1.9"
