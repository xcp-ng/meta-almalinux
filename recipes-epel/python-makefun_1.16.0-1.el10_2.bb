# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-makefun"
PV = "1.16.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-makefun \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-makefun-1.16.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dbbf401de1004887aab90719ef1eab806b47c90a6de06484b9a3f949449d597"

URI_x86_64_v2_python3-makefun = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-makefun-1.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-makefun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-makefun}"
SRC_URI[x86_64_v2_python3-makefun.sha256sum] = "57a220122f0eb53119a8ab6638ac9c069055c33efdd73329c30ce6bf5de679a6"

URI_aarch64_python3-makefun = "${EPEL_MIRROR}/aarch64/Packages/p/python3-makefun-1.16.0-1.el10_2.noarch.rpm;name=aarch64_python3-makefun;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-makefun}"
SRC_URI[aarch64_python3-makefun.sha256sum] = "9eaa2a07ce1e58dd95f096e4edaa35a36be41f10145f9f52ddbf675f15bf1ade"

RDEPENDS:python3-makefun = " \
 python3 \
 "
