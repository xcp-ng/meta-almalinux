# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ki18n"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-ki18n \
 kf6-ki18n-devel \
 kf6-ki18n-doc \
 kf6-ki18n-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-ki18n-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ffb2f782b9f78f1e09ad482031c77f4e09b0a9d53bad62775317418b8a47fbd9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ki18n;unpack=0"
SRC_URI[x86_64_v2_kf6-ki18n.sha256sum] = "fd2a33368adb09d91961559a061288f5c02f612f5cfa8f0d8dedfd4388ad889b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ki18n-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-ki18n-devel.sha256sum] = "c5a7177691d3c57a2062ea2555df97fad365d12b3d27bbae73705e66ddb69171"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ki18n-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-ki18n-doc.sha256sum] = "70c6b1d22ba64cdd52e8c9339b2be5f0ade95f5b3b84ea1b7f87974529a38901"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ki18n-html;unpack=0"
SRC_URI[x86_64_v2_kf6-ki18n-html.sha256sum] = "6a7cc32b01fa1062e53588f4075ccbaa25d86c7d716d22bf208d406864656299"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ki18n;unpack=0"
SRC_URI[aarch64_kf6-ki18n.sha256sum] = "cea5f693793b406a7c27ff5b4444a6d72b724fd5fd24acaf6fa205473fba8c63"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ki18n-devel;unpack=0"
SRC_URI[aarch64_kf6-ki18n-devel.sha256sum] = "7934ee4ca396686452a2daee5989d9e3f3b91e94586eec1d3e2d7cff0f33a6a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ki18n-doc;unpack=0"
SRC_URI[aarch64_kf6-ki18n-doc.sha256sum] = "1308a20111a926bf3401783989a323e5f43d7ce94e663d23530abd6b204f21b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ki18n-html;unpack=0"
SRC_URI[aarch64_kf6-ki18n-html.sha256sum] = "38f3e44a506c5efa6fa143ee9b322cf68b02ceda48dac63e41376cc6d89633c3"

RDEPENDS:kf6-ki18n = " \
 glibc \
 iso-codes \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-ki18n-devel = " \
 cmake-filesystem \
 gettext \
 kf6-ki18n \
 python3 \
 "
RDEPENDS:kf6-ki18n-doc = " \
 "
RDEPENDS:kf6-ki18n-html = " \
 "
