# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Perl-Destruct-Level"
PV = "0.02"
PR = "35.el10_0"
PACKAGES = " \
 perl-Perl-Destruct-Level \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Perl-Destruct-Level-0.02-35.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c8f56b2905d1d4c88d780329b2ac2239e6efa922ccf6893f90dff6af3c42a8c"

URI_x86_64_v2_perl-Perl-Destruct-Level = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Perl-Destruct-Level-0.02-35.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Perl-Destruct-Level;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Perl-Destruct-Level}"
SRC_URI[x86_64_v2_perl-Perl-Destruct-Level.sha256sum] = "8aaad4d3254182681a92ac8192b266c4a11ef6cd9219d973df8237a40ceb1622"

URI_aarch64_perl-Perl-Destruct-Level = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Perl-Destruct-Level-0.02-35.el10_0.aarch64.rpm;name=aarch64_perl-Perl-Destruct-Level;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Perl-Destruct-Level}"
SRC_URI[aarch64_perl-Perl-Destruct-Level.sha256sum] = "f46ef7df74885d2d7a74f0b583ce75610b868c2199d0da78a1074ce1bf67e042"

RDEPENDS:perl-Perl-Destruct-Level = " \
 glibc \
 perl-libs \
 "
