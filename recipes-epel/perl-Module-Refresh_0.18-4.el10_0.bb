# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Refresh"
PV = "0.18"
PR = "4.el10_0"
PACKAGES = " \
 perl-Module-Refresh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Refresh-0.18-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea6ae27d6b70a60043be265f50e369908841e4bc54df4c27a0c81e7d24bebf3c"

URI_x86_64_v2_perl-Module-Refresh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Refresh-0.18-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Refresh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Refresh}"
SRC_URI[x86_64_v2_perl-Module-Refresh.sha256sum] = "39b4caa297e6d25b7b592bfc32b6113472fd8e8a9f461e9564def0f026f2312d"

URI_aarch64_perl-Module-Refresh = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Refresh-0.18-4.el10_0.noarch.rpm;name=aarch64_perl-Module-Refresh;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Refresh}"
SRC_URI[aarch64_perl-Module-Refresh.sha256sum] = "399afba7ecbb01f7773b3a61dcfe96ca1492b57615dd5b838e70b52cd09b70c7"

RDEPENDS:perl-Module-Refresh = " \
 perl-libs \
 perl-vars \
 "
