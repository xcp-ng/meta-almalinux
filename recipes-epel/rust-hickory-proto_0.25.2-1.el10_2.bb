# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-proto"
PV = "0.25.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-hickory-proto+backtrace-devel \
 rust-hickory-proto+default-devel \
 rust-hickory-proto+futures-io-devel \
 rust-hickory-proto+mdns-devel \
 rust-hickory-proto+no-std-rand-devel \
 rust-hickory-proto+rustls-platform-verifier-devel \
 rust-hickory-proto+serde-devel \
 rust-hickory-proto+socket2-devel \
 rust-hickory-proto+std-devel \
 rust-hickory-proto+testing-devel \
 rust-hickory-proto+text-parsing-devel \
 rust-hickory-proto+tokio-devel \
 rust-hickory-proto+webpki-roots-devel \
 rust-hickory-proto-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-proto-0.25.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87bde175b9cdb2bb189214f40203900e4e41fbd8e8104bb2f6de12ef416f55e0"

URI_x86_64_v2_rust-hickory-proto+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+backtrace-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+backtrace-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+backtrace-devel.sha256sum] = "d46afdb4846fe1d823442192def864923480942d94d5d5ccd29b85a4fa8c1310"

URI_x86_64_v2_rust-hickory-proto+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+default-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+default-devel.sha256sum] = "55e1cb9bc9107c97e41237fe5830dff8dbe97afaea5ca5613fbdde62fdab1c4d"

URI_x86_64_v2_rust-hickory-proto+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+futures-io-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+futures-io-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+futures-io-devel.sha256sum] = "dd74aa9860d14a0b64f03d674409d576e9c95910d03d59372a257267b173367b"

URI_x86_64_v2_rust-hickory-proto+mdns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+mdns-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+mdns-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+mdns-devel.sha256sum] = "7e08dd045c0f5c55919b4f5ea895e3c8bbad3a256a7381e9e4c431acd22e0ec0"

URI_x86_64_v2_rust-hickory-proto+no-std-rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+no-std-rand-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+no-std-rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+no-std-rand-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+no-std-rand-devel.sha256sum] = "deb39a08ff1bf2a5ab149f91e3b00534c97a745c5cb0c64521f9774129b3efb0"

URI_x86_64_v2_rust-hickory-proto+rustls-platform-verifier-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+rustls-platform-verifier-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+rustls-platform-verifier-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+rustls-platform-verifier-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+rustls-platform-verifier-devel.sha256sum] = "7e72b6f9f9993c91358f71c8a4cf46c3f7eafdbade8d4ba7713cdc06337f36bb"

URI_x86_64_v2_rust-hickory-proto+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+serde-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+serde-devel.sha256sum] = "eed464e622ca5e20d630590f060802e487d6a5f9ed08e30ba963b9420377d581"

URI_x86_64_v2_rust-hickory-proto+socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+socket2-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+socket2-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+socket2-devel.sha256sum] = "fa178e83e20db5fb673e8a5910cc74ab2d1a9afa5591b88dd1692bb1a7529491"

URI_x86_64_v2_rust-hickory-proto+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+std-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+std-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+std-devel.sha256sum] = "460de385ffc9f8ad578adaa26b6af52935f5d0468d88adba8137a21206ec8fc5"

URI_x86_64_v2_rust-hickory-proto+testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+testing-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+testing-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+testing-devel.sha256sum] = "dd92cd5c4a84941d46207c9d027667144dded523c7489aac9cc44d5ecfc660d7"

URI_x86_64_v2_rust-hickory-proto+text-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+text-parsing-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+text-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+text-parsing-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+text-parsing-devel.sha256sum] = "c111e32f3e5f740b2c9a9f8b9bfa869399b5bef690953b73a6e59e95d5ea1d75"

URI_x86_64_v2_rust-hickory-proto+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+tokio-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+tokio-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+tokio-devel.sha256sum] = "3b84aee715502d5d0a4f25cc9f1cad0f0385a5bc35349410c0be860e0e9abab7"

URI_x86_64_v2_rust-hickory-proto+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+webpki-roots-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+webpki-roots-devel.sha256sum] = "8f89a4aac6b865fc8cfc1582251a082a8330bc56a720fd9588dfdfad405135d1"

URI_x86_64_v2_rust-hickory-proto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto-devel.sha256sum] = "26ad15ee77c7673512f02cfab1012500fb48bd06d41b66b3093030c4c80906b6"

URI_aarch64_rust-hickory-proto+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+backtrace-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+backtrace-devel}"
SRC_URI[aarch64_rust-hickory-proto+backtrace-devel.sha256sum] = "a163b7755747d6078652c7a046161bc5e681f09384acbe1327d0cf2143e0e751"

URI_aarch64_rust-hickory-proto+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+default-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+default-devel}"
SRC_URI[aarch64_rust-hickory-proto+default-devel.sha256sum] = "d49db3eb65c6d05579816830ee168a8dd1803f79d47b14fecfe78cd6759aa004"

URI_aarch64_rust-hickory-proto+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+futures-io-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+futures-io-devel}"
SRC_URI[aarch64_rust-hickory-proto+futures-io-devel.sha256sum] = "b6e016ba7ac1aa38c3268b1aee10039a91c6eb7d267ce4d8676e0f32874fccb4"

URI_aarch64_rust-hickory-proto+mdns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+mdns-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+mdns-devel}"
SRC_URI[aarch64_rust-hickory-proto+mdns-devel.sha256sum] = "4a471b9c6300361a4448fff2d27b4a271161cc1d0cdd1569ab714ddf20ea6b19"

URI_aarch64_rust-hickory-proto+no-std-rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+no-std-rand-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto+no-std-rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+no-std-rand-devel}"
SRC_URI[aarch64_rust-hickory-proto+no-std-rand-devel.sha256sum] = "ffbf1f21eba380fef972ec61492d08464d7eae1862b498c80c013c6f6be699d6"

URI_aarch64_rust-hickory-proto+rustls-platform-verifier-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+rustls-platform-verifier-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto+rustls-platform-verifier-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+rustls-platform-verifier-devel}"
SRC_URI[aarch64_rust-hickory-proto+rustls-platform-verifier-devel.sha256sum] = "d8b9d4120d66dc9714ac0585cc386dd65e0d275678d365f30215a2be3a04d723"

URI_aarch64_rust-hickory-proto+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+serde-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+serde-devel}"
SRC_URI[aarch64_rust-hickory-proto+serde-devel.sha256sum] = "e5721fe2de697b6ecc1a97a705481909536bfe4797de15124b1022485b399d44"

URI_aarch64_rust-hickory-proto+socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+socket2-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+socket2-devel}"
SRC_URI[aarch64_rust-hickory-proto+socket2-devel.sha256sum] = "8d561ec1479b4128177b0485ac4a8d6628d8cb9c77b9a6fa3c555281d681778d"

URI_aarch64_rust-hickory-proto+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+std-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+std-devel}"
SRC_URI[aarch64_rust-hickory-proto+std-devel.sha256sum] = "ce1afdc07bed88bc5a00621d68635a313966fb7bd57dbd2794ef7d2036794725"

URI_aarch64_rust-hickory-proto+testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+testing-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto+testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+testing-devel}"
SRC_URI[aarch64_rust-hickory-proto+testing-devel.sha256sum] = "6f3c6d8da6ee7189406d6934fc028161d6438a78d272b2c07e22ab479baaad39"

URI_aarch64_rust-hickory-proto+text-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+text-parsing-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto+text-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+text-parsing-devel}"
SRC_URI[aarch64_rust-hickory-proto+text-parsing-devel.sha256sum] = "84b68c3654e8002216586f1cdc73d14c775313e1ba45c23768b3568f381cfe98"

URI_aarch64_rust-hickory-proto+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+tokio-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+tokio-devel}"
SRC_URI[aarch64_rust-hickory-proto+tokio-devel.sha256sum] = "7e73ff26bcf3fd77609b83d79d51f4cc0c10e078ed920738818cd7b3ffce44c1"

URI_aarch64_rust-hickory-proto+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+webpki-roots-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+webpki-roots-devel}"
SRC_URI[aarch64_rust-hickory-proto+webpki-roots-devel.sha256sum] = "234aaa08d7499c115f5a68b745e22b61fbed13acce0147ec1839026024e56385"

URI_aarch64_rust-hickory-proto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto-devel}"
SRC_URI[aarch64_rust-hickory-proto-devel.sha256sum] = "c31fc52792baeacbf1550e8a3bc12221c9fc5c4e905bccfe043478874ed240a6"

RDEPENDS:rust-hickory-proto+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+default-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto+tokio-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+futures-io-devel = " \
 cargo \
 rust-futures-io-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+mdns-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 rust-socket2_0.5+all-devel \
 rust-socket2_0.5+default-devel \
 "
RDEPENDS:rust-hickory-proto+no-std-rand-devel = " \
 cargo \
 rust-critical-section+default-devel \
 rust-hickory-proto-devel \
 rust-once_cell+critical-section-devel \
 "
RDEPENDS:rust-hickory-proto+rustls-platform-verifier-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 rust-rustls-platform-verifier0.5+default-devel \
 "
RDEPENDS:rust-hickory-proto+serde-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-url+serde-devel \
 "
RDEPENDS:rust-hickory-proto+socket2-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-socket2_0.5+default-devel \
 "
RDEPENDS:rust-hickory-proto+std-devel = " \
 cargo \
 rust-data-encoding+std-devel \
 rust-futures-channel+std-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-util+std-devel \
 rust-hickory-proto-devel \
 rust-ipnet+std-devel \
 rust-rand0.9+std-devel \
 rust-rand0.9+thread_rng-devel \
 rust-ring+default-devel \
 rust-ring+std-devel \
 rust-thiserror+std-devel \
 rust-tracing+std-devel \
 rust-url+std-devel \
 "
RDEPENDS:rust-hickory-proto+testing-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+text-parsing-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+tokio-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-hickory-proto+webpki-roots-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-webpki-roots0.26+default-devel \
 "
RDEPENDS:rust-hickory-proto-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-cfg-if+default-devel \
 rust-data-encoding+alloc-devel \
 rust-data-encoding-devel \
 rust-enum-as-inner+default-devel \
 rust-futures-channel+alloc-devel \
 rust-futures-channel-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-idna+alloc-devel \
 rust-idna+compiled_data-devel \
 rust-idna-devel \
 rust-ipnet-devel \
 rust-once_cell+critical-section-devel \
 rust-once_cell-devel \
 rust-rand0.9+alloc-devel \
 rust-rand0.9+std_rng-devel \
 rust-rand0.9-devel \
 rust-thiserror-devel \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+default-devel \
 rust-tracing-devel \
 rust-url-devel \
 "
