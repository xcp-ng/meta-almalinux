# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Date-Range"
PV = "1.41"
PR = "6.el10_0"
PACKAGES = " \
 perl-Date-Range \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Date-Range-1.41-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7f2cd1527fbc329c3adc4502478f5ba748075ba221e712dcabd48401e2967d25"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Date-Range-1.41-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Date-Range;unpack=0"
SRC_URI[x86_64_v2_perl-Date-Range.sha256sum] = "fee5570a9f368c49734be74f9b200eec42ad11caedc4249cc11645af6b4c459e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Date-Range-1.41-6.el10_0.noarch.rpm;name=aarch64_perl-Date-Range;unpack=0"
SRC_URI[aarch64_perl-Date-Range.sha256sum] = "ce9cb62f98582e6f5b292279b77e94216b3dfd6e2608cfc21ca1c4e481e08ef2"

RDEPENDS:perl-Date-Range = " \
 perl-Carp \
 perl-Date-Simple \
 perl-libs \
 "
