# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-maybe-owned"
PV = "0.3.4"
PR = "9.el10_3"
PACKAGES = " \
 rust-maybe-owned+default-devel \
 rust-maybe-owned+serde-devel \
 rust-maybe-owned-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-maybe-owned-0.3.4-9.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "900fd826710ba98a7345baa5abcd2601a6323f3d632800c76825d1a43e8674f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maybe-owned+default-devel-0.3.4-9.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maybe-owned+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-maybe-owned+default-devel.sha256sum] = "1e9e69653579bf0b441b0e08db2c860b9a0ad94c00b9c4eeb0f168d42e259dbd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maybe-owned+serde-devel-0.3.4-9.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maybe-owned+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-maybe-owned+serde-devel.sha256sum] = "17319c28041484af43eaf5ba0ebebab26c34621efc9178349422b9baece7fd13"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maybe-owned-devel-0.3.4-9.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maybe-owned-devel;unpack=0"
SRC_URI[x86_64_v2_rust-maybe-owned-devel.sha256sum] = "f1293dbe889e8b5a0c4883dcdf6b494dd7604d27b86daa80df39c552def7920d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-maybe-owned+default-devel-0.3.4-9.el10_3.noarch.rpm;name=aarch64_rust-maybe-owned+default-devel;unpack=0"
SRC_URI[aarch64_rust-maybe-owned+default-devel.sha256sum] = "f31168d176bccabca1263336cbb54c9bcabe9b52e33d4545fe3116cc0b06ab93"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-maybe-owned+serde-devel-0.3.4-9.el10_3.noarch.rpm;name=aarch64_rust-maybe-owned+serde-devel;unpack=0"
SRC_URI[aarch64_rust-maybe-owned+serde-devel.sha256sum] = "307e7659805a62b691c267eefb7ac7c910272b721661430d4f3db577c83cb29d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-maybe-owned-devel-0.3.4-9.el10_3.noarch.rpm;name=aarch64_rust-maybe-owned-devel;unpack=0"
SRC_URI[aarch64_rust-maybe-owned-devel.sha256sum] = "cf025617151ec98e90dffb5a7ff510078254be50b9f7f57eb22a3f8906f52adc"

RDEPENDS:rust-maybe-owned+default-devel = " \
 cargo \
 rust-maybe-owned-devel \
 "
RDEPENDS:rust-maybe-owned+serde-devel = " \
 cargo \
 rust-maybe-owned-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-maybe-owned-devel = " \
 cargo \
 "
