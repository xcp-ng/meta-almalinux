# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ring"
PV = "0.17.14"
PR = "1.el10_0"
PACKAGES = " \
 rust-ring+alloc-devel \
 rust-ring+default-devel \
 rust-ring+dev_urandom_fallback-devel \
 rust-ring+less-safe-getrandom-custom-or-rdrand-devel \
 rust-ring+less-safe-getrandom-espidf-devel \
 rust-ring+slow_tests-devel \
 rust-ring+std-devel \
 rust-ring+test_logging-devel \
 rust-ring-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ring-0.17.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "797bf3c3900253e66d227df24506eb68651b6d6361791abb58c65eb4e83e6a5e"

URI_x86_64_v2_rust-ring+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+alloc-devel-0.17.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+alloc-devel}"
SRC_URI[x86_64_v2_rust-ring+alloc-devel.sha256sum] = "06b0e641c1edd331ff8a3b5b3d12736f0f1eecd96302db5dddf68ed12925804d"

URI_x86_64_v2_rust-ring+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+default-devel-0.17.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+default-devel}"
SRC_URI[x86_64_v2_rust-ring+default-devel.sha256sum] = "c1df0d2c92424e43e436098d49d991fe510e2de04cd1604108d03eadffd7a61b"

URI_x86_64_v2_rust-ring+dev_urandom_fallback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+dev_urandom_fallback-devel-0.17.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+dev_urandom_fallback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+dev_urandom_fallback-devel}"
SRC_URI[x86_64_v2_rust-ring+dev_urandom_fallback-devel.sha256sum] = "b218bec98ee121faec92f184d4c7ddf6c5d3db530721cb4c75e8b6ff648ce418"

URI_x86_64_v2_rust-ring+less-safe-getrandom-custom-or-rdrand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+less-safe-getrandom-custom-or-rdrand-devel-0.17.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+less-safe-getrandom-custom-or-rdrand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+less-safe-getrandom-custom-or-rdrand-devel}"
SRC_URI[x86_64_v2_rust-ring+less-safe-getrandom-custom-or-rdrand-devel.sha256sum] = "e6ad997bb8e90c393614791336cdf509d2bed7168ab6c77d9ab8ca374d9839b3"

URI_x86_64_v2_rust-ring+less-safe-getrandom-espidf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+less-safe-getrandom-espidf-devel-0.17.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+less-safe-getrandom-espidf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+less-safe-getrandom-espidf-devel}"
SRC_URI[x86_64_v2_rust-ring+less-safe-getrandom-espidf-devel.sha256sum] = "d1e080423790ef76b6e73c0ce1810f9141652cd8489458af6d58f5ef58c2b8d1"

URI_x86_64_v2_rust-ring+slow_tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+slow_tests-devel-0.17.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+slow_tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+slow_tests-devel}"
SRC_URI[x86_64_v2_rust-ring+slow_tests-devel.sha256sum] = "a3dd0d7e6dcf1342b4f32d26b4c12cc142710451a93c9d8fd5e114543c26a65c"

URI_x86_64_v2_rust-ring+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+std-devel-0.17.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+std-devel}"
SRC_URI[x86_64_v2_rust-ring+std-devel.sha256sum] = "0e240aa20486b0cff522c211177aba714f1a2557e30dac17c336796dd304a40b"

URI_x86_64_v2_rust-ring+test_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+test_logging-devel-0.17.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+test_logging-devel}"
SRC_URI[x86_64_v2_rust-ring+test_logging-devel.sha256sum] = "38604254b18ef7071ed49d38e785eeb048e31b7d93e95b00dd9cd8f47d83362d"

URI_x86_64_v2_rust-ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring-devel-0.17.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring-devel}"
SRC_URI[x86_64_v2_rust-ring-devel.sha256sum] = "f77ef25e699d153fd369549b37053eca93882ae591c04a86b30acc7bdc88881a"

URI_aarch64_rust-ring+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+alloc-devel-0.17.14-1.el10_0.noarch.rpm;name=aarch64_rust-ring+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+alloc-devel}"
SRC_URI[aarch64_rust-ring+alloc-devel.sha256sum] = "45af4eaded2fa1f57f5c9b1cef27b0038a6ed98acb85dc8d4305247411361ed6"

URI_aarch64_rust-ring+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+default-devel-0.17.14-1.el10_0.noarch.rpm;name=aarch64_rust-ring+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+default-devel}"
SRC_URI[aarch64_rust-ring+default-devel.sha256sum] = "93be82d2816a40fced0371639f904ad213fc46601a152212e4130301485a17b3"

URI_aarch64_rust-ring+dev_urandom_fallback-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+dev_urandom_fallback-devel-0.17.14-1.el10_0.noarch.rpm;name=aarch64_rust-ring+dev_urandom_fallback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+dev_urandom_fallback-devel}"
SRC_URI[aarch64_rust-ring+dev_urandom_fallback-devel.sha256sum] = "37076fe2ee171c3c22287e17a7aa26a4b560cfd6f7e970d67e68ccb088e686d1"

URI_aarch64_rust-ring+less-safe-getrandom-custom-or-rdrand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+less-safe-getrandom-custom-or-rdrand-devel-0.17.14-1.el10_0.noarch.rpm;name=aarch64_rust-ring+less-safe-getrandom-custom-or-rdrand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+less-safe-getrandom-custom-or-rdrand-devel}"
SRC_URI[aarch64_rust-ring+less-safe-getrandom-custom-or-rdrand-devel.sha256sum] = "c704db253ae2d7c0dd8c00e7539ae6722e878fa74c8efd3f81ab476227795db9"

URI_aarch64_rust-ring+less-safe-getrandom-espidf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+less-safe-getrandom-espidf-devel-0.17.14-1.el10_0.noarch.rpm;name=aarch64_rust-ring+less-safe-getrandom-espidf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+less-safe-getrandom-espidf-devel}"
SRC_URI[aarch64_rust-ring+less-safe-getrandom-espidf-devel.sha256sum] = "de1ac527d7ba411fa544a9e8058d44073224da97719d9dcd8a842255b7463c49"

URI_aarch64_rust-ring+slow_tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+slow_tests-devel-0.17.14-1.el10_0.noarch.rpm;name=aarch64_rust-ring+slow_tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+slow_tests-devel}"
SRC_URI[aarch64_rust-ring+slow_tests-devel.sha256sum] = "3a16d742ed2f598a84c78070fb55ff3b4f0193139b09ee7f90c03b391bd6a382"

URI_aarch64_rust-ring+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+std-devel-0.17.14-1.el10_0.noarch.rpm;name=aarch64_rust-ring+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+std-devel}"
SRC_URI[aarch64_rust-ring+std-devel.sha256sum] = "6403a022b1a85f88fd9435340d5c15b4b6ae4f247c4b1bbfee96d3b504bb24e8"

URI_aarch64_rust-ring+test_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+test_logging-devel-0.17.14-1.el10_0.noarch.rpm;name=aarch64_rust-ring+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+test_logging-devel}"
SRC_URI[aarch64_rust-ring+test_logging-devel.sha256sum] = "0af3ac51945cf176882a353c7ff36530d4e9d5a35382260e997e76cb5608ee3d"

URI_aarch64_rust-ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring-devel-0.17.14-1.el10_0.noarch.rpm;name=aarch64_rust-ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring-devel}"
SRC_URI[aarch64_rust-ring-devel.sha256sum] = "20334f83ec9143d81696032f04d332f8ac1e076c390fdc5c4b30f718f236be7a"

RDEPENDS:rust-ring+alloc-devel = " \
 cargo \
 rust-ring-devel \
 "
RDEPENDS:rust-ring+default-devel = " \
 cargo \
 rust-ring+alloc-devel \
 rust-ring+dev_urandom_fallback-devel \
 rust-ring-devel \
 "
RDEPENDS:rust-ring+dev_urandom_fallback-devel = " \
 cargo \
 rust-ring-devel \
 "
RDEPENDS:rust-ring+less-safe-getrandom-custom-or-rdrand-devel = " \
 cargo \
 rust-ring-devel \
 "
RDEPENDS:rust-ring+less-safe-getrandom-espidf-devel = " \
 cargo \
 rust-ring-devel \
 "
RDEPENDS:rust-ring+slow_tests-devel = " \
 cargo \
 rust-ring-devel \
 "
RDEPENDS:rust-ring+std-devel = " \
 cargo \
 rust-ring+alloc-devel \
 rust-ring-devel \
 "
RDEPENDS:rust-ring+test_logging-devel = " \
 cargo \
 rust-ring-devel \
 "
RDEPENDS:rust-ring-devel = " \
 cargo \
 gcc \
 perl-interpreter \
 rust \
 rust-cc-devel \
 rust-cfg-if-devel \
 rust-getrandom0.2+default-devel \
 rust-libc-devel \
 rust-untrusted+default-devel \
 "
