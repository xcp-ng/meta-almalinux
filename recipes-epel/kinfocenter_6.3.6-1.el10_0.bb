# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kinfocenter"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kinfocenter \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kinfocenter-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "91b3bb02c1ede7e35404212410fd04c4e1fed196387b8d73adfe6e23d4b18283"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kinfocenter-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kinfocenter;unpack=0"
SRC_URI[x86_64_v2_kinfocenter.sha256sum] = "4d06cc9af9471824e673aa7f624ad303cf151dc33c4a9b792355fc93be12c2a4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kinfocenter-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kinfocenter;unpack=0"
SRC_URI[aarch64_kinfocenter.sha256sum] = "e4aba7f6fca052c8e33752725ab0f4de822dec5231019195d5213becc55940af"

RDEPENDS:kinfocenter = " \
 aha \
 clinfo \
 dmidecode \
 egl-utils \
 fwupd \
 glibc \
 hwdata \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kservice \
 kf6-solid \
 libdisplay-info-tools \
 libdrm \
 libstdc++ \
 libusb1 \
 plasma-systemsettings \
 pulseaudio-utils \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 vulkan-tools \
 wayland-utils \
 "
