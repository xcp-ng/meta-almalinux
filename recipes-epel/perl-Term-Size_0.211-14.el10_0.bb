# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Term-Size"
PV = "0.211"
PR = "14.el10_0"
PACKAGES = " \
 perl-Term-Size \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Term-Size-0.211-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "018ba07feceb4aabd8a6c87ab594a38753685d462b011650161a2bc9bb511c28"

URI_x86_64_v2_perl-Term-Size = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Term-Size-0.211-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Term-Size;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Term-Size}"
SRC_URI[x86_64_v2_perl-Term-Size.sha256sum] = "f67b23c1551d16d32ce9105b0935e806880e8ec0eb7ac532715093debb5f621c"

URI_aarch64_perl-Term-Size = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Term-Size-0.211-14.el10_0.aarch64.rpm;name=aarch64_perl-Term-Size;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Term-Size}"
SRC_URI[aarch64_perl-Term-Size.sha256sum] = "ca09cec56765f55becc3da7426bddd599f677d661b661f9acf70704de25159a2"

RDEPENDS:perl-Term-Size = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
