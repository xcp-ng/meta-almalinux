# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-actor"
PV = "0.41.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-actor+default-devel \
 rust-gix-actor+document-features-devel \
 rust-gix-actor+serde-devel \
 rust-gix-actor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-actor-0.41.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "926c69b575b860257a296523a26123b3d16cc3ba92010e156f812505f41aa910"

URI_x86_64_v2_rust-gix-actor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor+default-devel-0.41.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor+default-devel}"
SRC_URI[x86_64_v2_rust-gix-actor+default-devel.sha256sum] = "caf36d6bddcb117a8f56d2ce5dce61f4b17941151f0c7b1341a71e3a65376de8"

URI_x86_64_v2_rust-gix-actor+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor+document-features-devel-0.41.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-actor+document-features-devel.sha256sum] = "795a2113738243a6b003bc11a740ecbda4535bb80a6d9be56ccc9f12578820d1"

URI_x86_64_v2_rust-gix-actor+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor+serde-devel-0.41.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-actor+serde-devel.sha256sum] = "ef7224105a92a90b7af2761f8027ae1e94c9cd91ee8df456662c25c20964ed42"

URI_x86_64_v2_rust-gix-actor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor-devel-0.41.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor-devel}"
SRC_URI[x86_64_v2_rust-gix-actor-devel.sha256sum] = "aa32713d1b64b37007aabe6447401da400be373160cdd01a8f180a0da6b11333"

URI_aarch64_rust-gix-actor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor+default-devel-0.41.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-actor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor+default-devel}"
SRC_URI[aarch64_rust-gix-actor+default-devel.sha256sum] = "702454f8dc7a95d5e472547aa043bf8313e765bda96863c4743d9c57d64f554f"

URI_aarch64_rust-gix-actor+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor+document-features-devel-0.41.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-actor+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor+document-features-devel}"
SRC_URI[aarch64_rust-gix-actor+document-features-devel.sha256sum] = "d7fb5bac5c8b461d741fbb2ffbe60c756eb5660abb3c5663cad740526cf4df3d"

URI_aarch64_rust-gix-actor+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor+serde-devel-0.41.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-actor+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor+serde-devel}"
SRC_URI[aarch64_rust-gix-actor+serde-devel.sha256sum] = "74da07c8105b85ec8fa1f8ef29e1101388fd2a98a574efc17a9d6e509446bdf9"

URI_aarch64_rust-gix-actor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor-devel-0.41.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-actor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor-devel}"
SRC_URI[aarch64_rust-gix-actor-devel.sha256sum] = "81c48a01627868afced2f11891aca888cf87131b9141b5524d942d7225aebbbe"

RDEPENDS:rust-gix-actor+default-devel = " \
 cargo \
 rust-gix-actor-devel \
 "
RDEPENDS:rust-gix-actor+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-actor-devel \
 "
RDEPENDS:rust-gix-actor+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-actor-devel \
 rust-gix-date+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-actor-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-date+default-devel \
 rust-gix-error+default-devel \
 "
