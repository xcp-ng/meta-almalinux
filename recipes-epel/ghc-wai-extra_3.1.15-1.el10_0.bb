# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-wai-extra"
PV = "3.1.15"
PR = "1.el10_0"
PACKAGES = " \
 ghc-wai-extra \
 ghc-wai-extra-devel \
 ghc-wai-extra-doc \
 ghc-wai-extra-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-wai-extra-3.1.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a78e96b761ec420b3ffdb130f33bf34e48dfc7cdf5c2fe86ee24f968eb6f4e5b"

URI_x86_64_v2_ghc-wai-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-extra-3.1.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wai-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-extra}"
SRC_URI[x86_64_v2_ghc-wai-extra.sha256sum] = "99f1dc9d044d8d4cf9c60dc2124fe6f71acc32a64684980b442f0241eb231f7d"

URI_x86_64_v2_ghc-wai-extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-extra-devel-3.1.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wai-extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-extra-devel}"
SRC_URI[x86_64_v2_ghc-wai-extra-devel.sha256sum] = "4b0189ae1be846b7c83fbc7f035ddd4375cb538113131db050c4a12bf3b1721a"

URI_x86_64_v2_ghc-wai-extra-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-extra-doc-3.1.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-wai-extra-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-extra-doc}"
SRC_URI[x86_64_v2_ghc-wai-extra-doc.sha256sum] = "dd70f2bc18d807f8884fc0c6264ebebf1b216fbdeffb09a34fabe78201363f55"

URI_x86_64_v2_ghc-wai-extra-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-extra-prof-3.1.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wai-extra-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-extra-prof}"
SRC_URI[x86_64_v2_ghc-wai-extra-prof.sha256sum] = "20357e2460953ebfd0914236da0c3f3c77e64c18cd32a73404e0f2d93ac4f2f2"

URI_aarch64_ghc-wai-extra = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-extra-3.1.15-1.el10_0.aarch64.rpm;name=aarch64_ghc-wai-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-extra}"
SRC_URI[aarch64_ghc-wai-extra.sha256sum] = "8a1df7be3007c95315f65612073907162484fde0df733e1d51f1567c9d1e719f"

URI_aarch64_ghc-wai-extra-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-extra-devel-3.1.15-1.el10_0.aarch64.rpm;name=aarch64_ghc-wai-extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-extra-devel}"
SRC_URI[aarch64_ghc-wai-extra-devel.sha256sum] = "06e6a67d7a02f89c94b2371b20360ca7e1bc6d2818ac751174f01f96fdd1fb2d"

URI_aarch64_ghc-wai-extra-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-extra-doc-3.1.15-1.el10_0.noarch.rpm;name=aarch64_ghc-wai-extra-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-extra-doc}"
SRC_URI[aarch64_ghc-wai-extra-doc.sha256sum] = "02f49d40e3d9f654cc91beee8e74e350bf44f478cddb129c91bc6c854f577bd0"

URI_aarch64_ghc-wai-extra-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-extra-prof-3.1.15-1.el10_0.aarch64.rpm;name=aarch64_ghc-wai-extra-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-extra-prof}"
SRC_URI[aarch64_ghc-wai-extra-prof.sha256sum] = "8c76815c7336ed8b25c887fd9193e7a54a0672609892c49cb009241896925029"

RDEPENDS:ghc-wai-extra = " \
 ghc-HUnit \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-auto-update \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bsb-http-chunked \
 ghc-byteorder \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-colour \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-x509 \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-easy-file \
 ghc-exceptions \
 ghc-fast-logger \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-date \
 ghc-http-types \
 ghc-http2 \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-memory \
 ghc-mtl \
 ghc-network \
 ghc-network-byte-order \
 ghc-network-control \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-psqueues \
 ghc-random \
 ghc-recv \
 ghc-resourcet \
 ghc-safe-exceptions \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-simple-sendfile \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-time-manager \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vault \
 ghc-vector \
 ghc-vector-stream \
 ghc-wai \
 ghc-wai-logger \
 ghc-warp \
 ghc-witherable \
 ghc-word8 \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-wai-extra-devel = " \
 ghc-HUnit-devel \
 ghc-aeson-devel \
 ghc-ansi-terminal-devel \
 ghc-base-devel \
 ghc-base64-bytestring-devel \
 ghc-bytestring-devel \
 ghc-call-stack-devel \
 ghc-case-insensitive-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-cookie-devel \
 ghc-data-default-class-devel \
 ghc-directory-devel \
 ghc-fast-logger-devel \
 ghc-http-types-devel \
 ghc-iproute-devel \
 ghc-network-devel \
 ghc-resourcet-devel \
 ghc-streaming-commons-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unix-devel \
 ghc-vault-devel \
 ghc-wai-devel \
 ghc-wai-extra \
 ghc-wai-logger-devel \
 ghc-warp-devel \
 ghc-word8-devel \
 "
RDEPENDS:ghc-wai-extra-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-wai-extra-prof = " \
 ghc-HUnit-prof \
 ghc-aeson-prof \
 ghc-ansi-terminal-prof \
 ghc-base-prof \
 ghc-base64-bytestring-prof \
 ghc-bytestring-prof \
 ghc-call-stack-prof \
 ghc-case-insensitive-prof \
 ghc-containers-prof \
 ghc-cookie-prof \
 ghc-data-default-class-prof \
 ghc-directory-prof \
 ghc-fast-logger-prof \
 ghc-http-types-prof \
 ghc-iproute-prof \
 ghc-network-prof \
 ghc-resourcet-prof \
 ghc-streaming-commons-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unix-prof \
 ghc-vault-prof \
 ghc-wai-extra-devel \
 ghc-wai-logger-prof \
 ghc-wai-prof \
 ghc-warp-prof \
 ghc-word8-prof \
 "
