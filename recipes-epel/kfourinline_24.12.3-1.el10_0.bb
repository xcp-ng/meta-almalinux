# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kfourinline"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kfourinline \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kfourinline-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6475ccebb99dc1a4be9994f776a98427ac233ca06ee7eff68ad9355e9229a04"

URI_x86_64_v2_kfourinline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kfourinline-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kfourinline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kfourinline}"
SRC_URI[x86_64_v2_kfourinline.sha256sum] = "96bc4c20610555f2222206f8806eb844ecd78b6d8af476fe6fe031687fbf2456"

URI_aarch64_kfourinline = "${EPEL_MIRROR}/aarch64/Packages/k/kfourinline-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kfourinline;unpack=0"
SRC_URI:append = " ${URI_aarch64_kfourinline}"
SRC_URI[aarch64_kfourinline.sha256sum] = "2e8fc9ccbe361baae6275ea0bf2eea31cbacb965373b8d5432cd9736f5d2819a"

RDEPENDS:kfourinline = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
