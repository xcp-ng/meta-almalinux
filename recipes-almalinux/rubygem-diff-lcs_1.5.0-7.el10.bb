# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-diff-lcs"
PV = "1.5.0"
PR = "7.el10"
PACKAGES = " \
 rubygem-diff-lcs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/rubygem-diff-lcs-1.5.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51e99df6e08a72db91ef260c5ea08d928e53d6a834dcf77381c471835d8572bb"

URI_x86_64_v2_rubygem-diff-lcs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rubygem-diff-lcs-1.5.0-7.el10.noarch.rpm;name=x86_64_v2_rubygem-diff-lcs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-diff-lcs}"
SRC_URI[x86_64_v2_rubygem-diff-lcs.sha256sum] = "49cc2ce2d1976f88f23aa57130e624221fede91aff8f163986d1e378f9005d79"

URI_aarch64_rubygem-diff-lcs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rubygem-diff-lcs-1.5.0-7.el10.noarch.rpm;name=aarch64_rubygem-diff-lcs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-diff-lcs}"
SRC_URI[aarch64_rubygem-diff-lcs.sha256sum] = "49cc2ce2d1976f88f23aa57130e624221fede91aff8f163986d1e378f9005d79"

RDEPENDS:rubygem-diff-lcs = " \
 ruby \
 rubygems \
 "
