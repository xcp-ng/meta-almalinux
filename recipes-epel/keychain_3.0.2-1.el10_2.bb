# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keychain"
PV = "3.0.2"
PR = "1.el10_2"
PACKAGES = " \
 keychain \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keychain-3.0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e40b1d463104a7e23cf35d030c5df31155b9d88f502f59190273c5ee86f50b7d"

URI_x86_64_v2_keychain = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keychain-3.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_keychain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keychain}"
SRC_URI[x86_64_v2_keychain.sha256sum] = "26de7770be4920b7f594a98ccb7ce6b1fe5f9bbc9ed5656221f4c9af4aecccde"

URI_aarch64_keychain = "${EPEL_MIRROR}/aarch64/Packages/k/keychain-3.0.2-1.el10_2.noarch.rpm;name=aarch64_keychain;unpack=0"
SRC_URI:append = " ${URI_aarch64_keychain}"
SRC_URI[aarch64_keychain.sha256sum] = "1cabe80426e84439744ffa05393e988e516df5bf3a60746a914721e0c1f049d7"

RDEPENDS:keychain = " \
 python3 \
 "
