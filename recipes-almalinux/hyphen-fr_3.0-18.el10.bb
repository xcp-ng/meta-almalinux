# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-fr"
PV = "3.0"
PR = "18.el10"
PACKAGES = " \
 hyphen-fr \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-fr-3.0-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4d47ab95dc65ca5f1b18384d873cf2fbe7126d5716208e2b6a15af969688499"

URI_x86_64_v2_hyphen-fr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-fr-3.0-18.el10.noarch.rpm;name=x86_64_v2_hyphen-fr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-fr}"
SRC_URI[x86_64_v2_hyphen-fr.sha256sum] = "9b757cc5c9fb414f2569d44cfbba16c5ae5ca027b9e0899a6ae997457114aa29"

URI_aarch64_hyphen-fr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-fr-3.0-18.el10.noarch.rpm;name=aarch64_hyphen-fr;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-fr}"
SRC_URI[aarch64_hyphen-fr.sha256sum] = "9b757cc5c9fb414f2569d44cfbba16c5ae5ca027b9e0899a6ae997457114aa29"

RDEPENDS:hyphen-fr = " \
 hyphen \
 "
