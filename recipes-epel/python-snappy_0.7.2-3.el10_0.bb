# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-snappy"
PV = "0.7.2"
PR = "3.el10_0"
PACKAGES = " \
 python3-snappy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-snappy-0.7.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de04596448adca1f48347b28c35006816030f31a0e244d3e751d3d14889838f4"

URI_x86_64_v2_python3-snappy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-snappy-0.7.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-snappy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-snappy}"
SRC_URI[x86_64_v2_python3-snappy.sha256sum] = "4dc57801e7a234ca68550cf651a796e15d6d1e54f5862e97683217c9a0af5563"

URI_aarch64_python3-snappy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-snappy-0.7.2-3.el10_0.noarch.rpm;name=aarch64_python3-snappy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-snappy}"
SRC_URI[aarch64_python3-snappy.sha256sum] = "48ae3b930260960a665abf3b2304b7da219f8b01c2314bbf6ba83310a55296cc"

RDEPENDS:python3-snappy = " \
 python3 \
 python3-cffi \
 python3-cramjam \
 snappy \
 "
