# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rbw"
PV = "1.13.2"
PR = "5.el10_2"
PACKAGES = " \
 rbw \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rbw-1.13.2-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac7038a06d5d493b49659c58f9b331de46aefbd11a420867f776c9c6593d165c"

URI_x86_64_v2_rbw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rbw-1.13.2-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rbw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rbw}"
SRC_URI[x86_64_v2_rbw.sha256sum] = "005b717a976ee351685d3cdba771d6715f8a2e6af3783d45285f5e563a7552ef"

URI_aarch64_rbw = "${EPEL_MIRROR}/aarch64/Packages/r/rbw-1.13.2-5.el10_2.aarch64.rpm;name=aarch64_rbw;unpack=0"
SRC_URI:append = " ${URI_aarch64_rbw}"
SRC_URI[aarch64_rbw.sha256sum] = "f3efa2cf49d1b7cf157dd953398d8461e0bb4aeb5b6279a2cb6774a347fc4f12"

RDEPENDS:rbw = " \
 glibc \
 libgcc \
 "
