# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "analitza"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 analitza \
 analitza-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/analitza-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5eca4f0e04e376bf6b609ee1919c636ca2537f80674ed2c4308cb98441389f4d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/analitza-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_analitza;unpack=0"
SRC_URI[x86_64_v2_analitza.sha256sum] = "54fd3e7b5eb37220f0d212e6b0d105e247614d3c6bd34a15c1550f7aca85a313"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/analitza-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_analitza-devel;unpack=0"
SRC_URI[x86_64_v2_analitza-devel.sha256sum] = "30c5c1a8239bd32266d30803c45d6f417ba03202a7a4ed7276a80efdb58ac5a2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/analitza-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_analitza;unpack=0"
SRC_URI[aarch64_analitza.sha256sum] = "aa18b5ff78133f490906537a97d7fff2750c73d09f60692e6610a2726204d02b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/analitza-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_analitza-devel;unpack=0"
SRC_URI[aarch64_analitza-devel.sha256sum] = "f8384d22ff9a7d7ca910b5c5ddddae5df73568b731d0df62a2804bb03ca60f65"

RDEPENDS:analitza = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:analitza-devel = " \
 analitza \
 cmake-filesystem \
 "
