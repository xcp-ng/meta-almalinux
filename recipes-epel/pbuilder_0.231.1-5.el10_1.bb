# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pbuilder"
PV = "0.231.1"
PR = "5.el10_1"
PACKAGES = " \
 pbuilder \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pbuilder-0.231.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "058752d34a69378beac0b814b6bd57aeb76c22a856158c04f891d339c2aa80c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pbuilder-0.231.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pbuilder;unpack=0"
SRC_URI[x86_64_v2_pbuilder.sha256sum] = "c60a0664f120e49267c87eb5d34f56321183f89ae12ba250a25b7413017d3daa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pbuilder-0.231.1-5.el10_1.noarch.rpm;name=aarch64_pbuilder;unpack=0"
SRC_URI[aarch64_pbuilder.sha256sum] = "cce24eae7446a942182d75fd438a9981d31ffb1415978670ccd5b820822b2802"

RDEPENDS:pbuilder = " \
 bash \
 debconf \
 debhelper \
 debian-keyring \
 debootstrap \
 dpkg-dev \
 gcc \
 gnupg2 \
 ubu-keyring \
 util-linux-core \
 wget \
 "
