# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-eyre"
PV = "0.6.14"
PR = "1.el10_3"
PACKAGES = " \
 rust-eyre+auto-install-devel \
 rust-eyre+default-devel \
 rust-eyre+track-caller-devel \
 rust-eyre-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-eyre-0.6.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a71ce6125e7fd815821bc7815d47d9e30c15fddab8ebd0b16d13a719b6c981a3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eyre+auto-install-devel-0.6.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eyre+auto-install-devel;unpack=0"
SRC_URI[x86_64_v2_rust-eyre+auto-install-devel.sha256sum] = "167dc28418de11573c1d1b5aa28312ad60ecbf2563ab4c02fa8dfb27b0cdc2c3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eyre+default-devel-0.6.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eyre+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-eyre+default-devel.sha256sum] = "64ee684b3bfbd2a840fd0a7074f6bcc78b0098a630084aea6cb4ecea4346af0a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eyre+track-caller-devel-0.6.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eyre+track-caller-devel;unpack=0"
SRC_URI[x86_64_v2_rust-eyre+track-caller-devel.sha256sum] = "667affd0a19b12187b6a6c233484fc6e8057fba7d1cd0c8ed5d9eddc8bd8fabf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eyre-devel-0.6.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eyre-devel;unpack=0"
SRC_URI[x86_64_v2_rust-eyre-devel.sha256sum] = "e65fbf3d3be1ae467bb4a385b09b226a4ad2cdb1df28d04382cab6cd76e16fc6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-eyre+auto-install-devel-0.6.14-1.el10_3.noarch.rpm;name=aarch64_rust-eyre+auto-install-devel;unpack=0"
SRC_URI[aarch64_rust-eyre+auto-install-devel.sha256sum] = "08a0f45b054f991f4abb268504a625ff55262077b96743fc76270fd331f27c0e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-eyre+default-devel-0.6.14-1.el10_3.noarch.rpm;name=aarch64_rust-eyre+default-devel;unpack=0"
SRC_URI[aarch64_rust-eyre+default-devel.sha256sum] = "7ce8c718258beda0c3a3a3cb3971ddc3a51bb83b7682df01a5928511335baac9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-eyre+track-caller-devel-0.6.14-1.el10_3.noarch.rpm;name=aarch64_rust-eyre+track-caller-devel;unpack=0"
SRC_URI[aarch64_rust-eyre+track-caller-devel.sha256sum] = "f8cade79099a4a4969259893456c74d016004b2a1e5eb67bd59455f423617ee8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-eyre-devel-0.6.14-1.el10_3.noarch.rpm;name=aarch64_rust-eyre-devel;unpack=0"
SRC_URI[aarch64_rust-eyre-devel.sha256sum] = "2a532e8fee4d948b5e9cb72d446ea064259aa0ca51a89ab9764849fb1dee3840"

RDEPENDS:rust-eyre+auto-install-devel = " \
 cargo \
 rust-eyre-devel \
 "
RDEPENDS:rust-eyre+default-devel = " \
 cargo \
 rust-eyre+auto-install-devel \
 rust-eyre+track-caller-devel \
 rust-eyre-devel \
 "
RDEPENDS:rust-eyre+track-caller-devel = " \
 cargo \
 rust-eyre-devel \
 "
RDEPENDS:rust-eyre-devel = " \
 cargo \
 rust \
 rust-autocfg+default-devel \
 rust-indenter+default-devel \
 rust-once_cell+default-devel \
 "
