# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "latexmk"
PV = "4.88"
PR = "1.el10_2"
PACKAGES = " \
 latexmk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/latexmk-4.88-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9e9b935814e5bc8a6a03f3ab030822c9410642f292c0a32c52556c4d0122ead"

URI_x86_64_v2_latexmk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/latexmk-4.88-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_latexmk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_latexmk}"
SRC_URI[x86_64_v2_latexmk.sha256sum] = "52258c8a9c2ce0f71c79f30b22906c0a7d74f9cede3644305de6fea57d984d1e"

URI_aarch64_latexmk = "${EPEL_MIRROR}/aarch64/Packages/l/latexmk-4.88-1.el10_2.noarch.rpm;name=aarch64_latexmk;unpack=0"
SRC_URI:append = " ${URI_aarch64_latexmk}"
SRC_URI[aarch64_latexmk.sha256sum] = "8c30f2af876d41d14e7b46a751db1b77d24c00d3bb9b3ce20b1b1c354969e056"

RDEPENDS:latexmk = " \
 ghostscript-tools-dvipdf \
 perl-Digest-MD5 \
 perl-Encode \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-FileHandle \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Time-HiRes \
 perl-Unicode-Normalize \
 perl-interpreter \
 perl-libs \
 perl-sigtrap \
 texlive-latex \
 xdg-utils \
 "
