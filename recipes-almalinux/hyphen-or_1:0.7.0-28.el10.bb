# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-or"
PE = "1"
PV = "0.7.0"
PR = "28.el10"
PACKAGES = " \
 hyphen-or \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-or-0.7.0-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7821e31ca0cf72b23a483fd60fffc9524e2a79bbf8240ceb5d58c1e4d5502705"

URI_x86_64_v2_hyphen-or = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-or-0.7.0-28.el10.noarch.rpm;name=x86_64_v2_hyphen-or;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-or}"
SRC_URI[x86_64_v2_hyphen-or.sha256sum] = "ad35f67267b2712117ad38384cc71b441d211848dda39aa0b9508faf412e782e"

URI_aarch64_hyphen-or = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-or-0.7.0-28.el10.noarch.rpm;name=aarch64_hyphen-or;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-or}"
SRC_URI[aarch64_hyphen-or.sha256sum] = "ad35f67267b2712117ad38384cc71b441d211848dda39aa0b9508faf412e782e"

RDEPENDS:hyphen-or = " \
 hyphen \
 "
