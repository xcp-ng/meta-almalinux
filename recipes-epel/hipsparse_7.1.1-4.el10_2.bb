# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipsparse"
PV = "7.1.1"
PR = "4.el10_2"
PACKAGES:x86_64_v2 = " \
 hipsparse \
 hipsparse-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipsparse-7.1.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6cc7adf875f7aec34c62d39016edf330a7d0d6959a471c2c55643fab79175158"

URI_x86_64_v2_hipsparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsparse-7.1.1-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsparse}"
SRC_URI[x86_64_v2_hipsparse.sha256sum] = "0db53ec9b1824550f1243867d955b3525a8448ae8bfd5070e0933e6f0a89f06b"

URI_x86_64_v2_hipsparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsparse-devel-7.1.1-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsparse-devel}"
SRC_URI[x86_64_v2_hipsparse-devel.sha256sum] = "10aaa64f1a71b2a50b821ac39de22b519f0964016567d9cf088fe10e5124f1ef"

RDEPENDS:hipsparse = " \
 glibc \
 libstdc++ \
 rocm-hip \
 rocsparse \
 "
RDEPENDS:hipsparse-devel = " \
 cmake-filesystem \
 hipsparse \
 "
