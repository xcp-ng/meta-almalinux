# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fpc"
PV = "3.2.2"
PR = "20.el10_0"
PACKAGES:x86_64_v2 = " \
 fpc \
 fpc-doc \
 fpc-ide \
 fpc-src \
 fpc-units-x86_64-linux \
"
PACKAGES:aarch64 = " \
 fpc \
 fpc-doc \
 fpc-ide \
 fpc-src \
 fpc-units-aarch64-linux \
"

URI_src = "${EPELSRC_MIRROR}/Packages/f/fpc-3.2.2-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a224fb04e02e03f87166b55ad163beace001095e6bf2a3bfe7081276c341c9e0"

URI_x86_64_v2_fpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpc-3.2.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fpc}"
SRC_URI[x86_64_v2_fpc.sha256sum] = "29f8df4b71cca6534864c9b3afbaf944cf4cf6d63b957d3366e8b4e203b9e09b"

URI_x86_64_v2_fpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpc-doc-3.2.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fpc-doc}"
SRC_URI[x86_64_v2_fpc-doc.sha256sum] = "969bf53d4ad44a9a46760bf1c1b9f24bc681767b95a6bd79cda80ad2be06ded3"

URI_x86_64_v2_fpc-ide = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpc-ide-3.2.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fpc-ide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fpc-ide}"
SRC_URI[x86_64_v2_fpc-ide.sha256sum] = "26a77b6daccddb68efb348fe903b971f9970e55e030e491c286d43b7f1d81976"

URI_x86_64_v2_fpc-src = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpc-src-3.2.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fpc-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fpc-src}"
SRC_URI[x86_64_v2_fpc-src.sha256sum] = "4b3bf06869fbe0d88dff3bb71d3974f0c147bc191ae1f45de31c18c88d807496"

URI_x86_64_v2_fpc-units-x86_64-linux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpc-units-x86_64-linux-3.2.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fpc-units-x86_64-linux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fpc-units-x86_64-linux}"
SRC_URI[x86_64_v2_fpc-units-x86_64-linux.sha256sum] = "811e52e4e3daa6b4797582715d7527030ff029cea81e9b7f491c8678171b8d62"

URI_aarch64_fpc = "${EPEL_MIRROR}/aarch64/Packages/f/fpc-3.2.2-20.el10_0.aarch64.rpm;name=aarch64_fpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fpc}"
SRC_URI[aarch64_fpc.sha256sum] = "51c701d6a2866c3efaa032b52e7bc50ebf87b1033c864aef73460823e2cd283d"

URI_aarch64_fpc-doc = "${EPEL_MIRROR}/aarch64/Packages/f/fpc-doc-3.2.2-20.el10_0.aarch64.rpm;name=aarch64_fpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fpc-doc}"
SRC_URI[aarch64_fpc-doc.sha256sum] = "482cd37ac24b27d724c53cd33246eb6350132baff98f2cc46d07d6cb8d589445"

URI_aarch64_fpc-ide = "${EPEL_MIRROR}/aarch64/Packages/f/fpc-ide-3.2.2-20.el10_0.aarch64.rpm;name=aarch64_fpc-ide;unpack=0"
SRC_URI:append = " ${URI_aarch64_fpc-ide}"
SRC_URI[aarch64_fpc-ide.sha256sum] = "40830ac3203cdb3154fee4e1a653a923ccdccff450bc232b7ba8708b0cab864a"

URI_aarch64_fpc-src = "${EPEL_MIRROR}/aarch64/Packages/f/fpc-src-3.2.2-20.el10_0.noarch.rpm;name=aarch64_fpc-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_fpc-src}"
SRC_URI[aarch64_fpc-src.sha256sum] = "72cd42a56cd3777e65c7249d6b7f4b216879d2789ac293329961289d3ee604d7"

URI_aarch64_fpc-units-aarch64-linux = "${EPEL_MIRROR}/aarch64/Packages/f/fpc-units-aarch64-linux-3.2.2-20.el10_0.aarch64.rpm;name=aarch64_fpc-units-aarch64-linux;unpack=0"
SRC_URI:append = " ${URI_aarch64_fpc-units-aarch64-linux}"
SRC_URI[aarch64_fpc-units-aarch64-linux.sha256sum] = "7224fd909a21a30bbe8f9befde01f6eb4c16948a217bb64a9cb8a8859b368818"

RDEPENDS:fpc:x86_64_v2 = " \
 bash \
 binutils \
 fpc-units-x86_64-linux \
 glibc \
"
RDEPENDS:fpc:aarch64 = " \
 bash \
 binutils \
 fpc-units-aarch64-linux \
 glibc \
"
RDEPENDS:fpc-doc = " \
 "
RDEPENDS:fpc-ide:x86_64_v2 = " \
 fpc-units-x86_64-linux \
 gpm \
 ncurses \
"
RDEPENDS:fpc-ide:aarch64 = " \
 fpc-units-aarch64-linux \
 gpm \
 ncurses \
"
RDEPENDS:fpc-src = " \
 bash \
 "
RDEPENDS:fpc-units-x86_64-linux = " \
 "
RDEPENDS:fpc-units-aarch64-linux = " \
 "
