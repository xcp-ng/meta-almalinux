# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stix-fonts"
PV = "2.13b171"
PR = "8.el10"
PACKAGES = " \
 stix-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/stix-fonts-2.13b171-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99e229d6a4a02e87fd11a6dffb318d4f13796f4b6d5d8334c7050363ed13899b"

URI_x86_64_v2_stix-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stix-fonts-2.13b171-8.el10.noarch.rpm;name=x86_64_v2_stix-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stix-fonts}"
SRC_URI[x86_64_v2_stix-fonts.sha256sum] = "061476ac526ba605bcf920265a3e64ea42011db467bd8c1841b7d26011406c5c"

URI_aarch64_stix-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stix-fonts-2.13b171-8.el10.noarch.rpm;name=aarch64_stix-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_stix-fonts}"
SRC_URI[aarch64_stix-fonts.sha256sum] = "061476ac526ba605bcf920265a3e64ea42011db467bd8c1841b7d26011406c5c"

RDEPENDS:stix-fonts = " \
 fonts-filesystem \
 "
