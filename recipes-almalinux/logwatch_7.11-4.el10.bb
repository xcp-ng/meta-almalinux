# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "logwatch"
PV = "7.11"
PR = "4.el10"
PACKAGES = " \
 logwatch \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/logwatch-7.11-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13f17ddb3e49cc4296cd544cb2746b0798b02d5fd334ddae43b295787710e67d"

URI_x86_64_v2_logwatch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/logwatch-7.11-4.el10.noarch.rpm;name=x86_64_v2_logwatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_logwatch}"
SRC_URI[x86_64_v2_logwatch.sha256sum] = "e25e29e504d954ae2775d9dae3cae0c8a661732437d3c19900e518cec3f53df2"

URI_aarch64_logwatch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/logwatch-7.11-4.el10.noarch.rpm;name=aarch64_logwatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_logwatch}"
SRC_URI[aarch64_logwatch.sha256sum] = "e25e29e504d954ae2775d9dae3cae0c8a661732437d3c19900e518cec3f53df2"

RDEPENDS:logwatch = " \
 bash \
 crontabs \
 grep \
 perl-Date-Manip \
 perl-Errno \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-HTML-Parser \
 perl-POSIX \
 perl-PathTools \
 perl-Socket \
 perl-Time-Local \
 perl-URI \
 perl-diagnostics \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-subs \
 perl-vars \
 "
