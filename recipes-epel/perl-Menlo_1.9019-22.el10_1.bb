# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Menlo"
PV = "1.9019"
PR = "22.el10_1"
PACKAGES = " \
 perl-Menlo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Menlo-1.9019-22.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff53708804f2d8b865455fe3de74bf428720222c546e6376732e7791b44f24f8"

URI_x86_64_v2_perl-Menlo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Menlo-1.9019-22.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Menlo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Menlo}"
SRC_URI[x86_64_v2_perl-Menlo.sha256sum] = "68459de377c50723ff3aeb9d28162a8004d773b850850bbe7aa8980856ea8bc0"

URI_aarch64_perl-Menlo = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Menlo-1.9019-22.el10_1.noarch.rpm;name=aarch64_perl-Menlo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Menlo}"
SRC_URI[aarch64_perl-Menlo.sha256sum] = "b158d5e35e2beb3f2a4bc06bbb83e67857d0d853271c10b2ed59f38a3b7e6587"

RDEPENDS:perl-Menlo = " \
 git \
 perl-CPAN-Common-Index \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-CPAN-Meta-YAML \
 perl-Carp \
 perl-Class-Tiny \
 perl-Exporter \
 perl-ExtUtils-Config \
 perl-ExtUtils-Helpers \
 perl-ExtUtils-Install \
 perl-ExtUtils-InstallPaths \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-pushd \
 perl-Getopt-Long \
 perl-HTTP-Tiny \
 perl-HTTP-Tinyish \
 perl-JSON-PP \
 perl-PathTools \
 perl-String-ShellQuote \
 perl-Test-Harness \
 perl-Time-Local \
 perl-URI \
 perl-constant \
 perl-libs \
 perl-parent \
 perl-podlators \
 "
