# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgsasl"
PV = "1.10.0"
PR = "12.el10_0"
PACKAGES = " \
 libgsasl \
 libgsasl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgsasl-1.10.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b9ad6436ba02261a327b3858bbbcfc64d0adcb33d5fea36674a5818f945754b"

URI_x86_64_v2_libgsasl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgsasl-1.10.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgsasl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgsasl}"
SRC_URI[x86_64_v2_libgsasl.sha256sum] = "98c968121b7a59e695db36c62f4da308f1c696cb5481de2d47d7903080f7dd80"

URI_x86_64_v2_libgsasl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgsasl-devel-1.10.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgsasl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgsasl-devel}"
SRC_URI[x86_64_v2_libgsasl-devel.sha256sum] = "8e63c56a143a007b20dc9f9606eb4a40ea542c6810b457666b952b7006b4380b"

URI_aarch64_libgsasl = "${EPEL_MIRROR}/aarch64/Packages/l/libgsasl-1.10.0-12.el10_0.aarch64.rpm;name=aarch64_libgsasl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgsasl}"
SRC_URI[aarch64_libgsasl.sha256sum] = "4e9fde23dafd1e4e42c73af30f6985592183f1747d4d3580bba57686e716f5e2"

URI_aarch64_libgsasl-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgsasl-devel-1.10.0-12.el10_0.aarch64.rpm;name=aarch64_libgsasl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgsasl-devel}"
SRC_URI[aarch64_libgsasl-devel.sha256sum] = "36973d3fc2968bbfa45575fe0527405364ca9f7aa59936001f50ca29f521645f"

RDEPENDS:libgsasl = " \
 glibc \
 krb5-libs \
 libcom_err \
 libidn \
 libntlm \
 "
RDEPENDS:libgsasl-devel = " \
 libgsasl \
 pkgconf-pkg-config \
 "
