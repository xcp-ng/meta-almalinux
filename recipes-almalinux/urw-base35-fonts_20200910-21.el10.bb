# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "urw-base35-fonts"
PV = "20200910"
PR = "21.el10"
PACKAGES = " \
 urw-base35-bookman-fonts \
 urw-base35-c059-fonts \
 urw-base35-d050000l-fonts \
 urw-base35-fonts \
 urw-base35-fonts-common \
 urw-base35-fonts-devel \
 urw-base35-gothic-fonts \
 urw-base35-nimbus-mono-ps-fonts \
 urw-base35-nimbus-roman-fonts \
 urw-base35-nimbus-sans-fonts \
 urw-base35-p052-fonts \
 urw-base35-standard-symbols-ps-fonts \
 urw-base35-z003-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/urw-base35-fonts-20200910-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0acd7b03bb821de2903548aa43e636ae4e7c9f5fbff349eac50a1e5d36bdf67c"

URI_x86_64_v2_urw-base35-bookman-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/urw-base35-bookman-fonts-20200910-21.el10.noarch.rpm;name=x86_64_v2_urw-base35-bookman-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_urw-base35-bookman-fonts}"
SRC_URI[x86_64_v2_urw-base35-bookman-fonts.sha256sum] = "4a15b9b0a8530272b402e85464188b84805699f72d56c41904010a6cbfbaf19e"

URI_x86_64_v2_urw-base35-c059-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/urw-base35-c059-fonts-20200910-21.el10.noarch.rpm;name=x86_64_v2_urw-base35-c059-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_urw-base35-c059-fonts}"
SRC_URI[x86_64_v2_urw-base35-c059-fonts.sha256sum] = "6686d8ea3830578a646d846c4e0604a0665b420609dd2d5472114c5a08e9a795"

URI_x86_64_v2_urw-base35-d050000l-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/urw-base35-d050000l-fonts-20200910-21.el10.noarch.rpm;name=x86_64_v2_urw-base35-d050000l-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_urw-base35-d050000l-fonts}"
SRC_URI[x86_64_v2_urw-base35-d050000l-fonts.sha256sum] = "79a15e6de44db624923a5c2fc9cb63c9511675b54d8d7f820269fdeccdbebe08"

URI_x86_64_v2_urw-base35-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/urw-base35-fonts-20200910-21.el10.noarch.rpm;name=x86_64_v2_urw-base35-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_urw-base35-fonts}"
SRC_URI[x86_64_v2_urw-base35-fonts.sha256sum] = "95f7b5e1ca9dd91137da9cd6072fc17a38f181417f27c7f5e661f5c7c1fa984b"

URI_x86_64_v2_urw-base35-fonts-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/urw-base35-fonts-common-20200910-21.el10.noarch.rpm;name=x86_64_v2_urw-base35-fonts-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_urw-base35-fonts-common}"
SRC_URI[x86_64_v2_urw-base35-fonts-common.sha256sum] = "001b43f796db1cd935ed072d28db09f6498edb0d7e8d328059c4408121cbb6c5"

URI_x86_64_v2_urw-base35-fonts-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/urw-base35-fonts-devel-20200910-21.el10.noarch.rpm;name=x86_64_v2_urw-base35-fonts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_urw-base35-fonts-devel}"
SRC_URI[x86_64_v2_urw-base35-fonts-devel.sha256sum] = "b41795909b93d24fd560d775cf734cc4ad0964ebe235933fabf27b9ac3c7495f"

URI_x86_64_v2_urw-base35-gothic-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/urw-base35-gothic-fonts-20200910-21.el10.noarch.rpm;name=x86_64_v2_urw-base35-gothic-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_urw-base35-gothic-fonts}"
SRC_URI[x86_64_v2_urw-base35-gothic-fonts.sha256sum] = "b47ff8f0a085fecc62ee3ff4e0c896a883f5bd2a551a97bdb08f82b932b1b042"

URI_x86_64_v2_urw-base35-nimbus-mono-ps-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/urw-base35-nimbus-mono-ps-fonts-20200910-21.el10.noarch.rpm;name=x86_64_v2_urw-base35-nimbus-mono-ps-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_urw-base35-nimbus-mono-ps-fonts}"
SRC_URI[x86_64_v2_urw-base35-nimbus-mono-ps-fonts.sha256sum] = "669fe8dd99594db53075d9d6a372339fb5da11f49b14949a4f0fecee504e86aa"

URI_x86_64_v2_urw-base35-nimbus-roman-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/urw-base35-nimbus-roman-fonts-20200910-21.el10.noarch.rpm;name=x86_64_v2_urw-base35-nimbus-roman-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_urw-base35-nimbus-roman-fonts}"
SRC_URI[x86_64_v2_urw-base35-nimbus-roman-fonts.sha256sum] = "7fe8f043211936772ea82c3d4016ae49fdaf3e1274f05bd532de41a09536c96a"

URI_x86_64_v2_urw-base35-nimbus-sans-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/urw-base35-nimbus-sans-fonts-20200910-21.el10.noarch.rpm;name=x86_64_v2_urw-base35-nimbus-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_urw-base35-nimbus-sans-fonts}"
SRC_URI[x86_64_v2_urw-base35-nimbus-sans-fonts.sha256sum] = "445c396b63de4f3870d30770b5de5d7228e55c5cc3a2729705cc4d3b0a46948e"

URI_x86_64_v2_urw-base35-p052-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/urw-base35-p052-fonts-20200910-21.el10.noarch.rpm;name=x86_64_v2_urw-base35-p052-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_urw-base35-p052-fonts}"
SRC_URI[x86_64_v2_urw-base35-p052-fonts.sha256sum] = "25c84d671664336daf4c43b4b3edd50a7d1f140749cd3d4f7d4e20f140a2fb97"

URI_x86_64_v2_urw-base35-standard-symbols-ps-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/urw-base35-standard-symbols-ps-fonts-20200910-21.el10.noarch.rpm;name=x86_64_v2_urw-base35-standard-symbols-ps-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_urw-base35-standard-symbols-ps-fonts}"
SRC_URI[x86_64_v2_urw-base35-standard-symbols-ps-fonts.sha256sum] = "79fb51899353e10ceca1f48a6f5d26eb773fdd83b890701c6e4a4fdc2cfe0691"

URI_x86_64_v2_urw-base35-z003-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/urw-base35-z003-fonts-20200910-21.el10.noarch.rpm;name=x86_64_v2_urw-base35-z003-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_urw-base35-z003-fonts}"
SRC_URI[x86_64_v2_urw-base35-z003-fonts.sha256sum] = "413b1d2b38931b98b866cacf486f1a69f0a33f0b6f89be0d51fd0652cb09bc67"

URI_aarch64_urw-base35-bookman-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/urw-base35-bookman-fonts-20200910-21.el10.noarch.rpm;name=aarch64_urw-base35-bookman-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_urw-base35-bookman-fonts}"
SRC_URI[aarch64_urw-base35-bookman-fonts.sha256sum] = "4a15b9b0a8530272b402e85464188b84805699f72d56c41904010a6cbfbaf19e"

URI_aarch64_urw-base35-c059-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/urw-base35-c059-fonts-20200910-21.el10.noarch.rpm;name=aarch64_urw-base35-c059-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_urw-base35-c059-fonts}"
SRC_URI[aarch64_urw-base35-c059-fonts.sha256sum] = "6686d8ea3830578a646d846c4e0604a0665b420609dd2d5472114c5a08e9a795"

URI_aarch64_urw-base35-d050000l-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/urw-base35-d050000l-fonts-20200910-21.el10.noarch.rpm;name=aarch64_urw-base35-d050000l-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_urw-base35-d050000l-fonts}"
SRC_URI[aarch64_urw-base35-d050000l-fonts.sha256sum] = "79a15e6de44db624923a5c2fc9cb63c9511675b54d8d7f820269fdeccdbebe08"

URI_aarch64_urw-base35-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/urw-base35-fonts-20200910-21.el10.noarch.rpm;name=aarch64_urw-base35-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_urw-base35-fonts}"
SRC_URI[aarch64_urw-base35-fonts.sha256sum] = "95f7b5e1ca9dd91137da9cd6072fc17a38f181417f27c7f5e661f5c7c1fa984b"

URI_aarch64_urw-base35-fonts-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/urw-base35-fonts-common-20200910-21.el10.noarch.rpm;name=aarch64_urw-base35-fonts-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_urw-base35-fonts-common}"
SRC_URI[aarch64_urw-base35-fonts-common.sha256sum] = "001b43f796db1cd935ed072d28db09f6498edb0d7e8d328059c4408121cbb6c5"

URI_aarch64_urw-base35-fonts-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/urw-base35-fonts-devel-20200910-21.el10.noarch.rpm;name=aarch64_urw-base35-fonts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_urw-base35-fonts-devel}"
SRC_URI[aarch64_urw-base35-fonts-devel.sha256sum] = "b41795909b93d24fd560d775cf734cc4ad0964ebe235933fabf27b9ac3c7495f"

URI_aarch64_urw-base35-gothic-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/urw-base35-gothic-fonts-20200910-21.el10.noarch.rpm;name=aarch64_urw-base35-gothic-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_urw-base35-gothic-fonts}"
SRC_URI[aarch64_urw-base35-gothic-fonts.sha256sum] = "b47ff8f0a085fecc62ee3ff4e0c896a883f5bd2a551a97bdb08f82b932b1b042"

URI_aarch64_urw-base35-nimbus-mono-ps-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/urw-base35-nimbus-mono-ps-fonts-20200910-21.el10.noarch.rpm;name=aarch64_urw-base35-nimbus-mono-ps-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_urw-base35-nimbus-mono-ps-fonts}"
SRC_URI[aarch64_urw-base35-nimbus-mono-ps-fonts.sha256sum] = "669fe8dd99594db53075d9d6a372339fb5da11f49b14949a4f0fecee504e86aa"

URI_aarch64_urw-base35-nimbus-roman-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/urw-base35-nimbus-roman-fonts-20200910-21.el10.noarch.rpm;name=aarch64_urw-base35-nimbus-roman-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_urw-base35-nimbus-roman-fonts}"
SRC_URI[aarch64_urw-base35-nimbus-roman-fonts.sha256sum] = "7fe8f043211936772ea82c3d4016ae49fdaf3e1274f05bd532de41a09536c96a"

URI_aarch64_urw-base35-nimbus-sans-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/urw-base35-nimbus-sans-fonts-20200910-21.el10.noarch.rpm;name=aarch64_urw-base35-nimbus-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_urw-base35-nimbus-sans-fonts}"
SRC_URI[aarch64_urw-base35-nimbus-sans-fonts.sha256sum] = "445c396b63de4f3870d30770b5de5d7228e55c5cc3a2729705cc4d3b0a46948e"

URI_aarch64_urw-base35-p052-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/urw-base35-p052-fonts-20200910-21.el10.noarch.rpm;name=aarch64_urw-base35-p052-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_urw-base35-p052-fonts}"
SRC_URI[aarch64_urw-base35-p052-fonts.sha256sum] = "25c84d671664336daf4c43b4b3edd50a7d1f140749cd3d4f7d4e20f140a2fb97"

URI_aarch64_urw-base35-standard-symbols-ps-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/urw-base35-standard-symbols-ps-fonts-20200910-21.el10.noarch.rpm;name=aarch64_urw-base35-standard-symbols-ps-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_urw-base35-standard-symbols-ps-fonts}"
SRC_URI[aarch64_urw-base35-standard-symbols-ps-fonts.sha256sum] = "79fb51899353e10ceca1f48a6f5d26eb773fdd83b890701c6e4a4fdc2cfe0691"

URI_aarch64_urw-base35-z003-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/urw-base35-z003-fonts-20200910-21.el10.noarch.rpm;name=aarch64_urw-base35-z003-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_urw-base35-z003-fonts}"
SRC_URI[aarch64_urw-base35-z003-fonts.sha256sum] = "413b1d2b38931b98b866cacf486f1a69f0a33f0b6f89be0d51fd0652cb09bc67"

RDEPENDS:urw-base35-bookman-fonts = " \
 bash \
 urw-base35-fonts-common \
 virtual/coreutils \
 "
RDEPENDS:urw-base35-c059-fonts = " \
 bash \
 urw-base35-fonts-common \
 virtual/coreutils \
 "
RDEPENDS:urw-base35-d050000l-fonts = " \
 bash \
 urw-base35-fonts-common \
 virtual/coreutils \
 "
RDEPENDS:urw-base35-fonts = " \
 urw-base35-bookman-fonts \
 urw-base35-c059-fonts \
 urw-base35-d050000l-fonts \
 urw-base35-fonts-common \
 urw-base35-gothic-fonts \
 urw-base35-nimbus-mono-ps-fonts \
 urw-base35-nimbus-roman-fonts \
 urw-base35-nimbus-sans-fonts \
 urw-base35-p052-fonts \
 urw-base35-standard-symbols-ps-fonts \
 urw-base35-z003-fonts \
 "
RDEPENDS:urw-base35-fonts-common = " \
 filesystem \
 fonts-filesystem \
 "
RDEPENDS:urw-base35-fonts-devel = " \
 urw-base35-fonts \
 "
RDEPENDS:urw-base35-gothic-fonts = " \
 bash \
 urw-base35-fonts-common \
 virtual/coreutils \
 "
RDEPENDS:urw-base35-nimbus-mono-ps-fonts = " \
 bash \
 urw-base35-fonts-common \
 virtual/coreutils \
 "
RDEPENDS:urw-base35-nimbus-roman-fonts = " \
 bash \
 urw-base35-fonts-common \
 virtual/coreutils \
 "
RDEPENDS:urw-base35-nimbus-sans-fonts = " \
 bash \
 urw-base35-fonts-common \
 virtual/coreutils \
 "
RDEPENDS:urw-base35-p052-fonts = " \
 bash \
 urw-base35-fonts-common \
 virtual/coreutils \
 "
RDEPENDS:urw-base35-standard-symbols-ps-fonts = " \
 bash \
 urw-base35-fonts-common \
 virtual/coreutils \
 "
RDEPENDS:urw-base35-z003-fonts = " \
 bash \
 urw-base35-fonts-common \
 virtual/coreutils \
 "
