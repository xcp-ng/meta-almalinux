# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skopeo"
PE = "2"
PV = "1.22.2"
PR = "5.el10_2"
PACKAGES = " \
 skopeo \
 skopeo-tests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/skopeo-1.22.2-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3cf565e1a865faa3e35fb30a58c8e3f4dd70efef52e36aee72f70303c15bb3d6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/skopeo-1.22.2-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_skopeo;unpack=0"
SRC_URI[x86_64_v2_skopeo.sha256sum] = "aa1f85886dd417bad304e944ca2a8ae1f3f34230a073af4369081ef36ca3a00a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/skopeo-tests-1.22.2-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_skopeo-tests;unpack=0"
SRC_URI[x86_64_v2_skopeo-tests.sha256sum] = "03d48bf2756486e1cf42e82908167bdb50c705e7a56a0e3427371494afa3d448"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/skopeo-1.22.2-5.el10_2.aarch64.rpm;name=aarch64_skopeo;unpack=0"
SRC_URI[aarch64_skopeo.sha256sum] = "a1b34bdc63a82584e642f77b0db420f60ca51171406cd4116974593ada3c52d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/skopeo-tests-1.22.2-5.el10_2.aarch64.rpm;name=aarch64_skopeo-tests;unpack=0"
SRC_URI[aarch64_skopeo-tests.sha256sum] = "5d6729d99ffd6a18ca2308ce09c7ed55a91a1c93ebb5d873e87a55095bafe165"

RDEPENDS:skopeo = " \
 containers-common \
 glibc \
 gpgme \
 podman-sequoia \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:skopeo-tests = " \
 bash \
 crun \
 gnupg2 \
 golang \
 httpd-tools \
 jq \
 openssl \
 podman \
 skopeo \
 squashfs-tools \
 virtual//usr/bin/env \
 "
