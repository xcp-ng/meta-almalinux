# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MIME-Types"
PV = "2.26"
PR = "1.el10_0"
PACKAGES = " \
 perl-MIME-Types \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MIME-Types-2.26-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5340b0b8370854cca105f909998f8add03e35a7950032f684e789e9c5e60614e"

URI_x86_64_v2_perl-MIME-Types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MIME-Types-2.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MIME-Types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MIME-Types}"
SRC_URI[x86_64_v2_perl-MIME-Types.sha256sum] = "1dbd605793fd16a054eff988dc3b159b5fa583327c1686fa6a7c224fba201385"

URI_aarch64_perl-MIME-Types = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MIME-Types-2.26-1.el10_0.noarch.rpm;name=aarch64_perl-MIME-Types;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MIME-Types}"
SRC_URI[aarch64_perl-MIME-Types.sha256sum] = "9f37d6dff4dd76f1d0364f2de744588064a1953b285026c6f2617da7d7c6d401"

RDEPENDS:perl-MIME-Types = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-MIME-Types \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-base \
 perl-libs \
 perl-overload \
 perl-vars \
 "
