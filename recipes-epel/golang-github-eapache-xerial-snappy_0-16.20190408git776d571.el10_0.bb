# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-eapache-xerial-snappy"
PV = "0"
PR = "16.20190408git776d571.el10_0"
PACKAGES = " \
 golang-github-eapache-xerial-snappy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-eapache-xerial-snappy-0-16.20190408git776d571.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "217506562799e170fe385612aba8e9974329f181f6fb72eaf5c67de2b8305cfa"

URI_aarch64_golang-github-eapache-xerial-snappy-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-eapache-xerial-snappy-devel-0-16.20190408git776d571.el10_0.noarch.rpm;name=aarch64_golang-github-eapache-xerial-snappy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-eapache-xerial-snappy-devel}"
SRC_URI[aarch64_golang-github-eapache-xerial-snappy-devel.sha256sum] = "e72d251b4e4f4c50a8c7a667a378822417be0da9c1d6c4b15d3e33cc13eb771f"

RDEPENDS:golang-github-eapache-xerial-snappy-devel = " \
 go-filesystem \
 golang-github-snappy-devel \
 "
