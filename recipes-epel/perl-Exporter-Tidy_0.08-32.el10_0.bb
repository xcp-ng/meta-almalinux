# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Exporter-Tidy"
PV = "0.08"
PR = "32.el10_0"
PACKAGES = " \
 perl-Exporter-Tidy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Exporter-Tidy-0.08-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "356eedf54701fea4628ca97079a065b96d312bf12d5de5523a02ea5d631f5f22"

URI_x86_64_v2_perl-Exporter-Tidy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Exporter-Tidy-0.08-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Exporter-Tidy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Exporter-Tidy}"
SRC_URI[x86_64_v2_perl-Exporter-Tidy.sha256sum] = "db137231b329262edb1593b4739c3aec1d23d90bd9de5e2b5faabc9ad158e482"

URI_aarch64_perl-Exporter-Tidy = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Exporter-Tidy-0.08-32.el10_0.noarch.rpm;name=aarch64_perl-Exporter-Tidy;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Exporter-Tidy}"
SRC_URI[aarch64_perl-Exporter-Tidy.sha256sum] = "163f0def934b705c74af2409b900c452af1022b0ac6803237d082284e1b53b2e"

RDEPENDS:perl-Exporter-Tidy = " \
 perl-Carp \
 perl-libs \
 "
