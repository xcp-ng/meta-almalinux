# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-hatch-jupyter-builder"
PV = "0.9.0"
PR = "4.el10_1"
PACKAGES = " \
 python3-hatch-jupyter-builder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-hatch-jupyter-builder-0.9.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c85cdeb988ad617b871b86c27597060b0dfc454743679bcb59b5cb6689635fd8"

URI_x86_64_v2_python3-hatch-jupyter-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hatch-jupyter-builder-0.9.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hatch-jupyter-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hatch-jupyter-builder}"
SRC_URI[x86_64_v2_python3-hatch-jupyter-builder.sha256sum] = "86330ae31d4973d38636eb75fc650e3b625622ca0ce04b3639f67599876cafd1"

URI_aarch64_python3-hatch-jupyter-builder = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hatch-jupyter-builder-0.9.0-4.el10_1.noarch.rpm;name=aarch64_python3-hatch-jupyter-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hatch-jupyter-builder}"
SRC_URI[aarch64_python3-hatch-jupyter-builder.sha256sum] = "aa4d29b6e8d1bc7a40deb7474ac08ef27d9d41b76bc90fd557afef7904e7041f"

RDEPENDS:python3-hatch-jupyter-builder = " \
 python3 \
 python3-hatchling \
 "
