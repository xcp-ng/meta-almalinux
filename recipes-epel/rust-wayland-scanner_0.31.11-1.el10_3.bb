# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-scanner"
PV = "0.31.11"
PR = "1.el10_3"
PACKAGES = " \
 rust-wayland-scanner+default-devel \
 rust-wayland-scanner-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-scanner-0.31.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "176abe5ad30a79a968df06306764805910bbf0d05b52af5acb2821d15d325089"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-scanner+default-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-scanner+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-scanner+default-devel.sha256sum] = "7c15060e7be7d3d0cae79b25c98b8ce6cf886fb85d55b000e721e8d70b533bd8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-scanner-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-scanner-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-scanner-devel.sha256sum] = "66c4761eb5c7bf808f75234b21de212ade3b3ecece32edb1c7a1a0a8166968d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-scanner+default-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-scanner+default-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-scanner+default-devel.sha256sum] = "4997f7ff0bf94487f8022c60e25e99a93b08a8363489fb9a5ee718c777d44950"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-scanner-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-scanner-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-scanner-devel.sha256sum] = "76c68af3c27f5941464a783ca84e0876dd2b70665817b3052fdf024294d81245"

RDEPENDS:rust-wayland-scanner+default-devel = " \
 cargo \
 rust-wayland-scanner-devel \
 "
RDEPENDS:rust-wayland-scanner-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quick-xml+default-devel \
 rust-quote+default-devel \
 "
