# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyxattr"
PV = "0.7.2"
PR = "14.el10"
PACKAGES = " \
 python3-pyxattr \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/pyxattr-0.7.2-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0d167cdae9667c4eaa5053c98774b84b9fa008e561ab1a9fcef8f79d12a6b46"

URI_x86_64_v2_python3-pyxattr = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-pyxattr-0.7.2-14.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyxattr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyxattr}"
SRC_URI[x86_64_v2_python3-pyxattr.sha256sum] = "f84aa7bfc879d414d4876b493e5217d8b60aedef9d5b9d5fc7bfc1b9bb721593"

URI_aarch64_python3-pyxattr = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-pyxattr-0.7.2-14.el10.aarch64.rpm;name=aarch64_python3-pyxattr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyxattr}"
SRC_URI[aarch64_python3-pyxattr.sha256sum] = "53952147dea1f595add50157a95459210e0e3651c60f4429cd7b44656b2204aa"

RDEPENDS:python3-pyxattr = " \
 glibc \
 python3 \
 "
