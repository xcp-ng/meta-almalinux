# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-vte"
PV = "0.13.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-vte+ansi-devel \
 rust-vte+arrayvec-devel \
 rust-vte+bitflags-devel \
 rust-vte+cursor-icon-devel \
 rust-vte+default-devel \
 rust-vte+log-devel \
 rust-vte+nightly-devel \
 rust-vte+no_std-devel \
 rust-vte+serde-devel \
 rust-vte-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-vte-0.13.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31d0fb117b23ae20b2b5ee948a99f5ffc042f47816b983cabaf91135cb44e3cf"

URI_x86_64_v2_rust-vte+ansi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+ansi-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+ansi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+ansi-devel}"
SRC_URI[x86_64_v2_rust-vte+ansi-devel.sha256sum] = "e9b7e4b2a18c6a77f4e9d4d14e027d6c78b83e7d8e8410c97b33fd58b60a2d61"

URI_x86_64_v2_rust-vte+arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+arrayvec-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+arrayvec-devel}"
SRC_URI[x86_64_v2_rust-vte+arrayvec-devel.sha256sum] = "c79039f54d7f462575484158904c0c04fc6c1fe5c222e687c8d19802d811845f"

URI_x86_64_v2_rust-vte+bitflags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+bitflags-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+bitflags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+bitflags-devel}"
SRC_URI[x86_64_v2_rust-vte+bitflags-devel.sha256sum] = "b70b7d351aa50729d03bdbf1eb5a2f688ed17fdb06928fce0f08b04d8f5720ec"

URI_x86_64_v2_rust-vte+cursor-icon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+cursor-icon-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+cursor-icon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+cursor-icon-devel}"
SRC_URI[x86_64_v2_rust-vte+cursor-icon-devel.sha256sum] = "84ebbd137b7d0c69b500d9e898bd3696b276c5dc32008bd8c964bb668f0964f1"

URI_x86_64_v2_rust-vte+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+default-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+default-devel}"
SRC_URI[x86_64_v2_rust-vte+default-devel.sha256sum] = "e2a6a8a1601e720a2b3e4a4d337af7703f24e1d4c19e444a210db9d8545644c2"

URI_x86_64_v2_rust-vte+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+log-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+log-devel}"
SRC_URI[x86_64_v2_rust-vte+log-devel.sha256sum] = "7464c8ad8e2e2870da0555d5d5c98ad1af4233275a819204db9cde1fcc81af99"

URI_x86_64_v2_rust-vte+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+nightly-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+nightly-devel}"
SRC_URI[x86_64_v2_rust-vte+nightly-devel.sha256sum] = "a885a97bd3e9aea89bab087567a85c4b114e1034d8bf1839905278b5942aeed7"

URI_x86_64_v2_rust-vte+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+no_std-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+no_std-devel}"
SRC_URI[x86_64_v2_rust-vte+no_std-devel.sha256sum] = "2a8290da5583296577bb5866e8894ce8316097f919316d291310329cfd223c62"

URI_x86_64_v2_rust-vte+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+serde-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+serde-devel}"
SRC_URI[x86_64_v2_rust-vte+serde-devel.sha256sum] = "ef3299310bdb8fc551584107057d79013f0c0666c4943be353c347c6bce798b5"

URI_x86_64_v2_rust-vte-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte-devel}"
SRC_URI[x86_64_v2_rust-vte-devel.sha256sum] = "e37bd662478acb4e6fafa5efa4ea92869744c48d7cb9c7e1b5df7997a0c6d5eb"

URI_aarch64_rust-vte+ansi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+ansi-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-vte+ansi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+ansi-devel}"
SRC_URI[aarch64_rust-vte+ansi-devel.sha256sum] = "3d4ae917b203d0737650873cf596391b5a0bc4de5487c90c80de804721521e91"

URI_aarch64_rust-vte+arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+arrayvec-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-vte+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+arrayvec-devel}"
SRC_URI[aarch64_rust-vte+arrayvec-devel.sha256sum] = "5babe2a0e623c16e7b8c661d341745443b5792a51abe6c81839d9684a0c31d57"

URI_aarch64_rust-vte+bitflags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+bitflags-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-vte+bitflags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+bitflags-devel}"
SRC_URI[aarch64_rust-vte+bitflags-devel.sha256sum] = "5c783d4129973917b0c0b32c035376ba564478d32230cec37630177121f7deba"

URI_aarch64_rust-vte+cursor-icon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+cursor-icon-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-vte+cursor-icon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+cursor-icon-devel}"
SRC_URI[aarch64_rust-vte+cursor-icon-devel.sha256sum] = "b9795091395e99edae1798e88bf2349449875a3cbaf970302b717c77e298ea36"

URI_aarch64_rust-vte+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+default-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-vte+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+default-devel}"
SRC_URI[aarch64_rust-vte+default-devel.sha256sum] = "5845be6ef4245295750b273fedcbbda99f8fc2021e09144d131916e240e2d31a"

URI_aarch64_rust-vte+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+log-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-vte+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+log-devel}"
SRC_URI[aarch64_rust-vte+log-devel.sha256sum] = "9c4c3ab8e4b7e58fcc66214ed7193367f0a65faf901a620a96de1fba1a2a03a0"

URI_aarch64_rust-vte+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+nightly-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-vte+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+nightly-devel}"
SRC_URI[aarch64_rust-vte+nightly-devel.sha256sum] = "f832da7a856b53cc0989eff576a513196c2c82548883d539c2b605ff40f5f0c8"

URI_aarch64_rust-vte+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+no_std-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-vte+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+no_std-devel}"
SRC_URI[aarch64_rust-vte+no_std-devel.sha256sum] = "fa4d2e4a83db883a7de71393ce7c071665207ce89d51c4f443ab61a9efaf628a"

URI_aarch64_rust-vte+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+serde-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-vte+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+serde-devel}"
SRC_URI[aarch64_rust-vte+serde-devel.sha256sum] = "74432877363bd4e96df96d1b197a37e280ee561e340932b6d2581911c650173f"

URI_aarch64_rust-vte-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-vte-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte-devel}"
SRC_URI[aarch64_rust-vte-devel.sha256sum] = "ae74972202584752a9654314df47bb918313c50a4b430e512e0249f1822c2e47"

RDEPENDS:rust-vte+ansi-devel = " \
 cargo \
 rust-vte+bitflags-devel \
 rust-vte+cursor-icon-devel \
 rust-vte+log-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte+arrayvec-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte+bitflags-devel = " \
 cargo \
 rust-bitflags-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte+cursor-icon-devel = " \
 cargo \
 rust-cursor-icon-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte+default-devel = " \
 cargo \
 rust-vte+no_std-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte+nightly-devel = " \
 cargo \
 rust-utf8parse+nightly-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte+no_std-devel = " \
 cargo \
 rust-vte+arrayvec-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte-devel = " \
 cargo \
 rust \
 rust-utf8parse+default-devel \
 rust-vte_generate_state_changes+default-devel \
 "
