# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-half"
PV = "2.7.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-half+alloc-devel \
 rust-half+arbitrary-devel \
 rust-half+bytemuck-devel \
 rust-half+default-devel \
 rust-half+num-traits-devel \
 rust-half+rand_distr-devel \
 rust-half+rkyv-devel \
 rust-half+serde-devel \
 rust-half+std-devel \
 rust-half+use-intrinsics-devel \
 rust-half+zerocopy-devel \
 rust-half-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-half-2.7.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ccc32ca62d6b50fd0d9347ef4b8697b9331af13c16d1bf4e73851fbbebaa574"

URI_x86_64_v2_rust-half+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+alloc-devel-2.7.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+alloc-devel}"
SRC_URI[x86_64_v2_rust-half+alloc-devel.sha256sum] = "3aeb5c4f6826eafb749959d69a1335ee4a04b7efeb6f5161c2db5cabed231289"

URI_x86_64_v2_rust-half+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+arbitrary-devel-2.7.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-half+arbitrary-devel.sha256sum] = "55a86dfc4348a56a3dd3a73018528f0a45beef38ca5115efaf35441ab9cb8bda"

URI_x86_64_v2_rust-half+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+bytemuck-devel-2.7.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-half+bytemuck-devel.sha256sum] = "1675604b9c4faa6cd678adfbaea6960c9af2c997cb2ff319ef857fdb232a8336"

URI_x86_64_v2_rust-half+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+default-devel-2.7.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+default-devel}"
SRC_URI[x86_64_v2_rust-half+default-devel.sha256sum] = "67765aaefda212cdd472be75590105b32088ea01bf5a30b7c647e8e4c67a9f5e"

URI_x86_64_v2_rust-half+num-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+num-traits-devel-2.7.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+num-traits-devel}"
SRC_URI[x86_64_v2_rust-half+num-traits-devel.sha256sum] = "d9abc5dfc83132a0e2ac4c6972dcc563f7923aebd261d6e1d02ae79632c93d90"

URI_x86_64_v2_rust-half+rand_distr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+rand_distr-devel-2.7.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+rand_distr-devel}"
SRC_URI[x86_64_v2_rust-half+rand_distr-devel.sha256sum] = "8261bdc92542e0cf48884f1fa2d275bf932702b0d10e29be0cd94482a4f4ae7b"

URI_x86_64_v2_rust-half+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+rkyv-devel-2.7.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+rkyv-devel}"
SRC_URI[x86_64_v2_rust-half+rkyv-devel.sha256sum] = "ed8a733267d62023895f35a256938e47028f97a2c11c2b1adea66ae6d152ff0f"

URI_x86_64_v2_rust-half+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+serde-devel-2.7.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+serde-devel}"
SRC_URI[x86_64_v2_rust-half+serde-devel.sha256sum] = "dd8cbcae1250ee0990817f31c1edc36aa114bddd4552b7fe3f67068cc6688964"

URI_x86_64_v2_rust-half+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+std-devel-2.7.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+std-devel}"
SRC_URI[x86_64_v2_rust-half+std-devel.sha256sum] = "a6be4b12e7f02a4058c290a1215a9885faf8c499df2fe7c19f64ad1425360c8b"

URI_x86_64_v2_rust-half+use-intrinsics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+use-intrinsics-devel-2.7.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+use-intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+use-intrinsics-devel}"
SRC_URI[x86_64_v2_rust-half+use-intrinsics-devel.sha256sum] = "8641dbc7ed709656a592bc98508ca0e8e0ffc636bab5932ae92f66283c057fdf"

URI_x86_64_v2_rust-half+zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+zerocopy-devel-2.7.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+zerocopy-devel}"
SRC_URI[x86_64_v2_rust-half+zerocopy-devel.sha256sum] = "3412b76c01d2eb3914148ed1ea1e5983bf46672432c5b4cd07212fa9392a35e8"

URI_x86_64_v2_rust-half-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half-devel-2.7.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half-devel}"
SRC_URI[x86_64_v2_rust-half-devel.sha256sum] = "c40c90e50183df9a909d48b22b34ebd5069126fe7e34f1c180b6c63a39b73ee6"
RPROVIDES:rust-half-devel:x86_64_v2 = "virtual/crate_half__ge_1.8.0_with_crate_half__lt_3.0.0~"

URI_aarch64_rust-half+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+alloc-devel-2.7.1-2.el10_2.noarch.rpm;name=aarch64_rust-half+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+alloc-devel}"
SRC_URI[aarch64_rust-half+alloc-devel.sha256sum] = "56a266bdf51ba16286943b517d9dca0d7e2d9a7ec81ac25b9e85e98107dd6487"

URI_aarch64_rust-half+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+arbitrary-devel-2.7.1-2.el10_2.noarch.rpm;name=aarch64_rust-half+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+arbitrary-devel}"
SRC_URI[aarch64_rust-half+arbitrary-devel.sha256sum] = "f9a5bc5fb1f07e1466da81c84f14c291f966d3f194277b5c4d47f88afec043c5"

URI_aarch64_rust-half+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+bytemuck-devel-2.7.1-2.el10_2.noarch.rpm;name=aarch64_rust-half+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+bytemuck-devel}"
SRC_URI[aarch64_rust-half+bytemuck-devel.sha256sum] = "d7b3f9a698c59adde611f5eec8783f0fa86c8309434d73957f54c84d0408740e"

URI_aarch64_rust-half+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+default-devel-2.7.1-2.el10_2.noarch.rpm;name=aarch64_rust-half+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+default-devel}"
SRC_URI[aarch64_rust-half+default-devel.sha256sum] = "f05ca1e1ba12f53f4c70a4b4dd25b934ace4f9a6c9d5cbdae6e4cfc2db3c9a99"

URI_aarch64_rust-half+num-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+num-traits-devel-2.7.1-2.el10_2.noarch.rpm;name=aarch64_rust-half+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+num-traits-devel}"
SRC_URI[aarch64_rust-half+num-traits-devel.sha256sum] = "99d63dd2251046dae976508768ae5c1adf30c3cabffa2f69344c5d019754e23f"

URI_aarch64_rust-half+rand_distr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+rand_distr-devel-2.7.1-2.el10_2.noarch.rpm;name=aarch64_rust-half+rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+rand_distr-devel}"
SRC_URI[aarch64_rust-half+rand_distr-devel.sha256sum] = "96d676d6b1c9cb0fc70c4e6007bdee4e00bf69cd923fad31d96b43f7767eb16e"

URI_aarch64_rust-half+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+rkyv-devel-2.7.1-2.el10_2.noarch.rpm;name=aarch64_rust-half+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+rkyv-devel}"
SRC_URI[aarch64_rust-half+rkyv-devel.sha256sum] = "da5b647b0c60f9217e836da4f7656f1ba740e02e76760104adcf07e98466ca24"

URI_aarch64_rust-half+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+serde-devel-2.7.1-2.el10_2.noarch.rpm;name=aarch64_rust-half+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+serde-devel}"
SRC_URI[aarch64_rust-half+serde-devel.sha256sum] = "f93ac823afcdfc62fd0acff07a3c2efec4a58afe963c7497cc17c0249a6195fe"

URI_aarch64_rust-half+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+std-devel-2.7.1-2.el10_2.noarch.rpm;name=aarch64_rust-half+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+std-devel}"
SRC_URI[aarch64_rust-half+std-devel.sha256sum] = "23c1be15fdcbb81cb366615bcab410bc60cd5a699726b6a3ae1201526f0423ec"

URI_aarch64_rust-half+use-intrinsics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+use-intrinsics-devel-2.7.1-2.el10_2.noarch.rpm;name=aarch64_rust-half+use-intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+use-intrinsics-devel}"
SRC_URI[aarch64_rust-half+use-intrinsics-devel.sha256sum] = "d3073821d1f42e645e3bfae16033f0af685721294cc1437d30344023f6ebb83e"

URI_aarch64_rust-half+zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+zerocopy-devel-2.7.1-2.el10_2.noarch.rpm;name=aarch64_rust-half+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+zerocopy-devel}"
SRC_URI[aarch64_rust-half+zerocopy-devel.sha256sum] = "fb48eaebfdcba6d10b51b3dc5b4ec0824442f3664f5b08c4d65a68ea8d954986"

URI_aarch64_rust-half-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half-devel-2.7.1-2.el10_2.noarch.rpm;name=aarch64_rust-half-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half-devel}"
SRC_URI[aarch64_rust-half-devel.sha256sum] = "c10b2fd64e109786d0e867977ee0901ff6b9e0c32306d3bcd835dfd170d8db8d"
RPROVIDES:rust-half-devel:aarch64 = "virtual/crate_half__ge_1.8.0_with_crate_half__lt_3.0.0~"

RDEPENDS:rust-half+alloc-devel = " \
 cargo \
 rust-half-devel \
 "
RDEPENDS:rust-half+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-half-devel \
 "
RDEPENDS:rust-half+bytemuck-devel = " \
 cargo \
 rust-bytemuck+derive-devel \
 rust-bytemuck-devel \
 rust-half-devel \
 "
RDEPENDS:rust-half+default-devel = " \
 cargo \
 rust-half+std-devel \
 rust-half-devel \
 "
RDEPENDS:rust-half+num-traits-devel = " \
 cargo \
 rust-half-devel \
 rust-num-traits+libm-devel \
 rust-num-traits-devel \
 "
RDEPENDS:rust-half+rand_distr-devel = " \
 cargo \
 rust-half-devel \
 rust-rand0.9+thread_rng-devel \
 rust-rand0.9-devel \
 rust-rand_distr0.5-devel \
 "
RDEPENDS:rust-half+rkyv-devel = " \
 cargo \
 rust-half-devel \
 rust-rkyv+default-devel \
 "
RDEPENDS:rust-half+serde-devel = " \
 cargo \
 rust-half-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-half+std-devel = " \
 cargo \
 rust-half+alloc-devel \
 rust-half-devel \
 "
RDEPENDS:rust-half+use-intrinsics-devel = " \
 cargo \
 rust-half-devel \
 "
RDEPENDS:rust-half+zerocopy-devel = " \
 cargo \
 rust-half-devel \
 "
RDEPENDS:rust-half-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_half__ge_1.8.0_with_crate_half__lt_3.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_half__ge_1.8.0_with_crate_half__lt_3.0.0~"
