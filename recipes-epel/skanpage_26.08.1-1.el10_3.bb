# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skanpage"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 skanpage \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/skanpage-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d6cadee5a9910312b997e770d59b3cbeaf753b50f424fba086669b290ec6d9e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/skanpage-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_skanpage;unpack=0"
SRC_URI[x86_64_v2_skanpage.sha256sum] = "b0a1dee0a887edba439dbd9b4b199fa96288db78e53b2344cf8cdce6f9b5c178"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/skanpage-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_skanpage;unpack=0"
SRC_URI[aarch64_skanpage.sha256sum] = "e9a361149ca739473447b3553d36fc56712ecfb07072a743707efe3009cd0357"

RDEPENDS:skanpage = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kirigami \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kquickimageeditor-qt6 \
 ksanecore \
 leptonica \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpdf \
 tesseract \
 "
