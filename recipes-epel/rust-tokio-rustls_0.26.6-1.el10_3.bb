# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-rustls"
PV = "0.26.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-tokio-rustls+brotli-devel \
 rust-tokio-rustls+default-devel \
 rust-tokio-rustls+early-data-devel \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls+zlib-devel \
 rust-tokio-rustls-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-rustls-0.26.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "effcb814b0677a91cdb508b0446f96b066c010ab13ae104b26334f4bc3239d41"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+brotli-devel-0.26.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+brotli-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+brotli-devel.sha256sum] = "951c04cec18e50fe51836a34a327714d9cd8c361582a073888807578ff0a4e77"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+default-devel-0.26.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+default-devel.sha256sum] = "9c6683d8ac541f0f4858eb619d23543a668588a1055d1b7771cd34b01ba778e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+early-data-devel-0.26.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+early-data-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+early-data-devel.sha256sum] = "110300a00917d8573c981ff1240f3bc675c2b96a5b37a79ea522c097687ee1ad"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+logging-devel-0.26.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+logging-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+logging-devel.sha256sum] = "d49ac918b5401023f6e3589075cb2edb8203a11c892344098916642ea58cfb76"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+ring-devel-0.26.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+ring-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+ring-devel.sha256sum] = "221397e574856965b66f5d38e67551807f8bd4ca89e46e9af58a7575c1e8ef97"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+tls12-devel-0.26.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+tls12-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+tls12-devel.sha256sum] = "156c6dc28d9b64c39c35b8d54eae165212284344f7c966ba5a26dca32d6189bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+zlib-devel-0.26.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+zlib-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+zlib-devel.sha256sum] = "26f7f4756afa520289f937672d556d3a98a3ec8955e39a5507118c41f82253e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls-devel-0.26.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls-devel.sha256sum] = "6f7c7c1f9956200486d18ee9bcf0e2433a9f84e0849afbc2e267d57a25d46c74"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+brotli-devel-0.26.6-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls+brotli-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+brotli-devel.sha256sum] = "744efd08e0a09d11a1ff7dedbfb808e5fb0a2cdd01354523bd4c81a5dd25206c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+default-devel-0.26.6-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls+default-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+default-devel.sha256sum] = "63b6548adf18ad89d57cb428e4d05db992c2211464ea279e0173b452a768de3c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+early-data-devel-0.26.6-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls+early-data-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+early-data-devel.sha256sum] = "276e241829690021d6aa72f2d1e64f772912921f2474ef1d85cc0e93bf888531"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+logging-devel-0.26.6-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls+logging-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+logging-devel.sha256sum] = "d44bba6220c3d5070c073f4cf078144d130394cb659287eb21f98b4c18c18fa5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+ring-devel-0.26.6-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls+ring-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+ring-devel.sha256sum] = "66c5b89ceaa6b16f02c81cfaa58c76e6cfaf883b6e2725ae0a84b4ac25d2a00d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+tls12-devel-0.26.6-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls+tls12-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+tls12-devel.sha256sum] = "eb7bd574b69dedcc6b82e885a9072206a954d956bef4174a2ee5c731e36649ea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+zlib-devel-0.26.6-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls+zlib-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+zlib-devel.sha256sum] = "38c9609cc3587551f37a96ea5dbf3d6f603e5af7f534c5920bf6f9265a645be9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls-devel-0.26.6-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls-devel.sha256sum] = "c8e5bcdaf09b337eeae9c2d2529991d56ce57879a2dfd4ba6abf898e16db989d"

RDEPENDS:rust-tokio-rustls+brotli-devel = " \
 cargo \
 rust-rustls+brotli-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+default-devel = " \
 cargo \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+early-data-devel = " \
 cargo \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+logging-devel = " \
 cargo \
 rust-rustls+logging-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+ring-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+tls12-devel = " \
 cargo \
 rust-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+zlib-devel = " \
 cargo \
 rust-rustls+zlib-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls-devel = " \
 cargo \
 rust \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-tokio+default-devel \
 "
