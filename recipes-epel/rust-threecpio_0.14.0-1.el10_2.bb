# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-threecpio"
PV = "0.14.0"
PR = "1.el10_2"
PACKAGES = " \
 3cpio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-threecpio-0.14.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8033c3d277d2741df43c4ae85ef5559baed0a7ddcc98d56fcf776ea5fd2864c1"

URI_x86_64_v2_3cpio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/3cpio-0.14.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_3cpio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_3cpio}"
SRC_URI[x86_64_v2_3cpio.sha256sum] = "9d7338bcc4ab36baa672b2bd667216186c7e06b4bb1c66a51eb2e0d9a2705fe3"

URI_aarch64_3cpio = "${EPEL_MIRROR}/aarch64/Packages/3/3cpio-0.14.0-1.el10_2.aarch64.rpm;name=aarch64_3cpio;unpack=0"
SRC_URI:append = " ${URI_aarch64_3cpio}"
SRC_URI[aarch64_3cpio.sha256sum] = "fd9c4b256ca8d0426ce1002dacbcc54417b72e3a12d1075e92130fc0069116a5"

RDEPENDS:3cpio = " \
 glibc \
 libgcc \
 "
