# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aioitertools"
PV = "0.12.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-aioitertools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aioitertools-0.12.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4810d6a58a138e43d53ad071f93331f624a774b4c24d2e4f39b4651ccaa8e2ed"

URI_x86_64_v2_python3-aioitertools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aioitertools-0.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aioitertools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aioitertools}"
SRC_URI[x86_64_v2_python3-aioitertools.sha256sum] = "20cfe63a25506c46ff79fde35e73879570088a043b641f9e986efc3377a565e0"

URI_aarch64_python3-aioitertools = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aioitertools-0.12.0-1.el10_2.noarch.rpm;name=aarch64_python3-aioitertools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aioitertools}"
SRC_URI[aarch64_python3-aioitertools.sha256sum] = "8659a4bdcd9aaf497360d4a39f976e4d2dd870458f013767f661d6a73782bc1b"

RDEPENDS:python3-aioitertools = " \
 python3 \
 "
