# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-shared_child"
PV = "1.0.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-shared_child+default-devel \
 rust-shared_child-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-shared_child-1.0.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b35b33f314c04e03425cf80651a2fc1b73f52c25ef442039e17d3545a3e7ef4d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shared_child+default-devel-1.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shared_child+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-shared_child+default-devel.sha256sum] = "d9a2b83944348940d674a0c4bcf55d8abee44ed85e40e96fb2f97d4a1ae08da8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shared_child-devel-1.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shared_child-devel;unpack=0"
SRC_URI[x86_64_v2_rust-shared_child-devel.sha256sum] = "2c461e3acbd936eff5d129751fd90a9d43b1dd6538c7b9770790ba2a5537986f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-shared_child+default-devel-1.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-shared_child+default-devel;unpack=0"
SRC_URI[aarch64_rust-shared_child+default-devel.sha256sum] = "f68522b639c2c40fc893cb1b8b106568113a8db3a114984b2e2bfceed4fddec7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-shared_child-devel-1.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-shared_child-devel;unpack=0"
SRC_URI[aarch64_rust-shared_child-devel.sha256sum] = "6957e00bb94c9d07c97bfdbca7fb44ecb01a906e968b290f54a64790ac0aa20c"

RDEPENDS:rust-shared_child+default-devel = " \
 cargo \
 rust-shared_child-devel \
 "
RDEPENDS:rust-shared_child-devel = " \
 cargo \
 rust-libc+default-devel \
 "
