# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtkwave"
PV = "3.3.121"
PR = "6.el10_1"
PACKAGES = " \
 gtkwave \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gtkwave-3.3.121-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe37e01b87e36262fe519e2fc57f2f2a6568fcd91559ad5c8174734569538069"

URI_x86_64_v2_gtkwave = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtkwave-3.3.121-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtkwave;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtkwave}"
SRC_URI[x86_64_v2_gtkwave.sha256sum] = "14f98ebda07a79aa7aa35a98a7574d79d81c63bc2210b7e8be115c91afcc469c"

URI_aarch64_gtkwave = "${EPEL_MIRROR}/aarch64/Packages/g/gtkwave-3.3.121-6.el10_1.aarch64.rpm;name=aarch64_gtkwave;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtkwave}"
SRC_URI[aarch64_gtkwave.sha256sum] = "46539efe9b8c2b5fa3b17ab25cbbeb21553a96a34aad41f5cf6d5f11cf66cd65"

RDEPENDS:gtkwave = " \
 Judy \
 bzip2-libs \
 cairo \
 gdk-pixbuf2 \
 gdk-pixbuf2-modules-extra \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 pango \
 shared-mime-info \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
