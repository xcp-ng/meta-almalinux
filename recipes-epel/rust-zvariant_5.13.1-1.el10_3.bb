# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zvariant"
PV = "5.13.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-zvariant+arrayvec-devel \
 rust-zvariant+camino-devel \
 rust-zvariant+chrono-devel \
 rust-zvariant+default-devel \
 rust-zvariant+enumflags2-devel \
 rust-zvariant+gvariant-devel \
 rust-zvariant+option-as-array-devel \
 rust-zvariant+ostree-tests-devel \
 rust-zvariant+serde_bytes-devel \
 rust-zvariant+time-devel \
 rust-zvariant+url-devel \
 rust-zvariant+uuid-devel \
 rust-zvariant-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zvariant-5.13.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a59b3ac1a9277029ab22c7786526172c0c7d171a0d44693566e5dc605fd0fe3a"

URI_x86_64_v2_rust-zvariant+arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+arrayvec-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+arrayvec-devel}"
SRC_URI[x86_64_v2_rust-zvariant+arrayvec-devel.sha256sum] = "19d9e282f66ac831f9f99a1fe5d35ca2112419e4e00291a55730a81834467964"

URI_x86_64_v2_rust-zvariant+camino-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+camino-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+camino-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+camino-devel}"
SRC_URI[x86_64_v2_rust-zvariant+camino-devel.sha256sum] = "a89ffbee9a01b715066734d7c923bedbba8ce1065d886237f751177c3fb27a4d"

URI_x86_64_v2_rust-zvariant+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+chrono-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+chrono-devel}"
SRC_URI[x86_64_v2_rust-zvariant+chrono-devel.sha256sum] = "7321da6ca9c8acd4f3ee7c9972c01cabc43cb086b1df99f48e685ca5e0e405ff"

URI_x86_64_v2_rust-zvariant+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+default-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+default-devel}"
SRC_URI[x86_64_v2_rust-zvariant+default-devel.sha256sum] = "9b12a6f6d59f8cbbfa4ec20eed6cf68ff388d23417d9e9c1602c5026c80181b6"

URI_x86_64_v2_rust-zvariant+enumflags2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+enumflags2-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+enumflags2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+enumflags2-devel}"
SRC_URI[x86_64_v2_rust-zvariant+enumflags2-devel.sha256sum] = "bd5139931c532e7d88830004ff86c1f82fc049073ed742fb279cd81e10c46481"

URI_x86_64_v2_rust-zvariant+gvariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+gvariant-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+gvariant-devel}"
SRC_URI[x86_64_v2_rust-zvariant+gvariant-devel.sha256sum] = "ee9a2059935b296db50740f62f614308843352fc22479b39a6f1e29ce7895643"

URI_x86_64_v2_rust-zvariant+option-as-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+option-as-array-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+option-as-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+option-as-array-devel}"
SRC_URI[x86_64_v2_rust-zvariant+option-as-array-devel.sha256sum] = "570d61355f7a5cc64659265393117a5d1e534c9be5017cbb1396a9c67182db75"

URI_x86_64_v2_rust-zvariant+ostree-tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+ostree-tests-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+ostree-tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+ostree-tests-devel}"
SRC_URI[x86_64_v2_rust-zvariant+ostree-tests-devel.sha256sum] = "a2ec75f09654fe6859ce32f39a095b0630483d55a6c64a1f0be479531066c950"

URI_x86_64_v2_rust-zvariant+serde_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+serde_bytes-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+serde_bytes-devel}"
SRC_URI[x86_64_v2_rust-zvariant+serde_bytes-devel.sha256sum] = "a7efdd1539804bac710118ab743413abd2e1d3cfa33fdcd2458e55232a8d0da2"

URI_x86_64_v2_rust-zvariant+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+time-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+time-devel}"
SRC_URI[x86_64_v2_rust-zvariant+time-devel.sha256sum] = "d08ec4d11635f413f8c89aec29c7f8ee37329b972c73043d30c1a92c8519627a"

URI_x86_64_v2_rust-zvariant+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+url-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+url-devel}"
SRC_URI[x86_64_v2_rust-zvariant+url-devel.sha256sum] = "870d17a6de9030cf530b79c12065d2a467a6db3397f73d89af885f22d1e01957"

URI_x86_64_v2_rust-zvariant+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+uuid-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+uuid-devel}"
SRC_URI[x86_64_v2_rust-zvariant+uuid-devel.sha256sum] = "4f6dfd6638444070ff2b6439ebdf3ef0dd37b757a6feeeca046cbd449ff1de0c"

URI_x86_64_v2_rust-zvariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant-devel}"
SRC_URI[x86_64_v2_rust-zvariant-devel.sha256sum] = "1215a97a118a91f563a4887a4484f895fee38ce5684efb18a4ba17fbd127e5b4"

URI_aarch64_rust-zvariant+arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+arrayvec-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+arrayvec-devel}"
SRC_URI[aarch64_rust-zvariant+arrayvec-devel.sha256sum] = "984a18aeddf505d04277b0ec61f22ed710932fc09d6e287986aa8835561a3872"

URI_aarch64_rust-zvariant+camino-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+camino-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant+camino-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+camino-devel}"
SRC_URI[aarch64_rust-zvariant+camino-devel.sha256sum] = "05ceb506ffd6c016643d4f5e4071cc191e824ec79b485d5a0b77696534e5c929"

URI_aarch64_rust-zvariant+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+chrono-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+chrono-devel}"
SRC_URI[aarch64_rust-zvariant+chrono-devel.sha256sum] = "e49466734accdb2aacfc642d1b8706836c298a9ce0011e34e35b646e65d4e0e8"

URI_aarch64_rust-zvariant+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+default-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+default-devel}"
SRC_URI[aarch64_rust-zvariant+default-devel.sha256sum] = "3d1dc756b0ff284042109e05b77ad613d5acfc0bb0805f473a28ed4d6e4c69fd"

URI_aarch64_rust-zvariant+enumflags2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+enumflags2-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant+enumflags2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+enumflags2-devel}"
SRC_URI[aarch64_rust-zvariant+enumflags2-devel.sha256sum] = "00bfd5a0db12f8bdb77358378915c7ef104d8f24f7b7847071e78420a0a3ff8e"

URI_aarch64_rust-zvariant+gvariant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+gvariant-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+gvariant-devel}"
SRC_URI[aarch64_rust-zvariant+gvariant-devel.sha256sum] = "c2149f18740c2ed5f47bcdd289406ad5402c7b2ffa725e09887899be4014693b"

URI_aarch64_rust-zvariant+option-as-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+option-as-array-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant+option-as-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+option-as-array-devel}"
SRC_URI[aarch64_rust-zvariant+option-as-array-devel.sha256sum] = "35d00624206d611e9401694791fe68a08a889bea0c0d50fe72f3f965d12287d7"

URI_aarch64_rust-zvariant+ostree-tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+ostree-tests-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant+ostree-tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+ostree-tests-devel}"
SRC_URI[aarch64_rust-zvariant+ostree-tests-devel.sha256sum] = "cb018e5d5203e180e612609d4516d1087fc9177a9de0f49433a025848498dd6e"

URI_aarch64_rust-zvariant+serde_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+serde_bytes-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+serde_bytes-devel}"
SRC_URI[aarch64_rust-zvariant+serde_bytes-devel.sha256sum] = "78040f11975dcb47fa92833d5b35ec2f34c84949bdc4928f813530bdd1fa6ce6"

URI_aarch64_rust-zvariant+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+time-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+time-devel}"
SRC_URI[aarch64_rust-zvariant+time-devel.sha256sum] = "3c2909d9d31638aa7e1844592609450041ef0db83597b0d1644205346f96ea4f"

URI_aarch64_rust-zvariant+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+url-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+url-devel}"
SRC_URI[aarch64_rust-zvariant+url-devel.sha256sum] = "2745cba01343686437a77c31c8733d4c900ac471defb65ad3ecdb0f70e0387a7"

URI_aarch64_rust-zvariant+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+uuid-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+uuid-devel}"
SRC_URI[aarch64_rust-zvariant+uuid-devel.sha256sum] = "b5b2b7d57e1a23e7c7acef08c68cd5772f0f314192a9f8baef514446c7ff506d"

URI_aarch64_rust-zvariant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant-devel}"
SRC_URI[aarch64_rust-zvariant-devel.sha256sum] = "caf2649fdf33e4a90b90c4bd40e4a040cfa4d3233d69ff5953ea6f977a3e6321"

RDEPENDS:rust-zvariant+arrayvec-devel = " \
 cargo \
 rust-arrayvec+default-devel \
 rust-arrayvec+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+camino-devel = " \
 cargo \
 rust-camino+default-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+chrono-devel = " \
 cargo \
 rust-chrono+serde-devel \
 rust-chrono-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+default-devel = " \
 cargo \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+enumflags2-devel = " \
 cargo \
 rust-enumflags2+default-devel \
 rust-enumflags2+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+gvariant-devel = " \
 cargo \
 rust-zvariant-devel \
 rust-zvariant_derive+gvariant-devel \
 rust-zvariant_utils+gvariant-devel \
 "
RDEPENDS:rust-zvariant+option-as-array-devel = " \
 cargo \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+ostree-tests-devel = " \
 cargo \
 rust-zvariant+gvariant-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+serde_bytes-devel = " \
 cargo \
 rust-serde_bytes+default-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+time-devel = " \
 cargo \
 rust-time+default-devel \
 rust-time+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+url-devel = " \
 cargo \
 rust-url+default-devel \
 rust-url+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+uuid-devel = " \
 cargo \
 rust-uuid+default-devel \
 rust-uuid+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant-devel = " \
 cargo \
 rust \
 rust-endi+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-winnow+default-devel \
 rust-zvariant_derive+default-devel \
 rust-zvariant_utils+default-devel \
 "
