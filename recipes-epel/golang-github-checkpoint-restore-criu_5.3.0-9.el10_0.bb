# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-checkpoint-restore-criu"
PV = "5.3.0"
PR = "9.el10_0"
PACKAGES = " \
 compat-golang-github-checkpoint-restore-criu-5-devel \
 golang-github-checkpoint-restore-criu-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-checkpoint-restore-criu-5.3.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6034d52ecdc99885294a5f49d55e11eb82cb36bbe6715bffe1e80ea0a8eee6c"

URI_x86_64_v2_compat-golang-github-checkpoint-restore-criu-5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-checkpoint-restore-criu-5-devel-5.3.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-checkpoint-restore-criu-5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-checkpoint-restore-criu-5-devel}"
SRC_URI[x86_64_v2_compat-golang-github-checkpoint-restore-criu-5-devel.sha256sum] = "fc05133158fb625fdf55fe9cc6d14c8491c98c57e4749b3fa9316a25f87c394d"

URI_x86_64_v2_golang-github-checkpoint-restore-criu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-checkpoint-restore-criu-devel-5.3.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-checkpoint-restore-criu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-checkpoint-restore-criu-devel}"
SRC_URI[x86_64_v2_golang-github-checkpoint-restore-criu-devel.sha256sum] = "d4e571eb16d49364154de755d25ad2beaf60a5b1c47ed201ad4eae1642121f3a"

URI_aarch64_compat-golang-github-checkpoint-restore-criu-5-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-checkpoint-restore-criu-5-devel-5.3.0-9.el10_0.noarch.rpm;name=aarch64_compat-golang-github-checkpoint-restore-criu-5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-checkpoint-restore-criu-5-devel}"
SRC_URI[aarch64_compat-golang-github-checkpoint-restore-criu-5-devel.sha256sum] = "f51e64c91fa67c0886b0e518e440c4b73ebfa3faa0b883f8786bfff84f9a030e"

URI_aarch64_golang-github-checkpoint-restore-criu-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-checkpoint-restore-criu-devel-5.3.0-9.el10_0.noarch.rpm;name=aarch64_golang-github-checkpoint-restore-criu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-checkpoint-restore-criu-devel}"
SRC_URI[aarch64_golang-github-checkpoint-restore-criu-devel.sha256sum] = "2ea325d377d0bebeaf6b0db802075706e2403f37da0491175396434bc10978b3"

RDEPENDS:compat-golang-github-checkpoint-restore-criu-5-devel = " \
 go-filesystem \
 golang-github-checkpoint-restore-criu-devel \
 "
RDEPENDS:golang-github-checkpoint-restore-criu-devel = " \
 go-filesystem \
 golang-google-protobuf-devel \
 golang-x-sys-devel \
 "
