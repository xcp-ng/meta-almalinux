# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-signature"
PV = "2.2.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-signature+alloc-devel \
 rust-signature+default-devel \
 rust-signature+derive-devel \
 rust-signature+digest-devel \
 rust-signature+rand_core-devel \
 rust-signature+std-devel \
 rust-signature-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-signature-2.2.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33f46e77bbeb85c2073c44d19bee8ff88c46d921ea063cc65e48d164950dcba7"

URI_x86_64_v2_rust-signature+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature+alloc-devel-2.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature+alloc-devel}"
SRC_URI[x86_64_v2_rust-signature+alloc-devel.sha256sum] = "4818039666e22f0e19a09d487109649575f329ab7382057f14eb02eddd3e8fc7"

URI_x86_64_v2_rust-signature+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature+default-devel-2.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature+default-devel}"
SRC_URI[x86_64_v2_rust-signature+default-devel.sha256sum] = "aed531f7776e64c0a43fab67893fc3e273811ae77e684dcdefcc0891838c98bd"

URI_x86_64_v2_rust-signature+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature+derive-devel-2.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature+derive-devel}"
SRC_URI[x86_64_v2_rust-signature+derive-devel.sha256sum] = "dc151f1c8083014e94881160df18a7b7238a3ef6a11da5e6a852b573038f9348"

URI_x86_64_v2_rust-signature+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature+digest-devel-2.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature+digest-devel}"
SRC_URI[x86_64_v2_rust-signature+digest-devel.sha256sum] = "c47862d8435fa0e48eea6d5be37c21cbe9e7121ddd1a1193c9b391042d86c6d3"

URI_x86_64_v2_rust-signature+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature+rand_core-devel-2.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature+rand_core-devel}"
SRC_URI[x86_64_v2_rust-signature+rand_core-devel.sha256sum] = "d994dc6e25746d358cf3292d4e0f7bdbc1672a182ff57367ea53bc91bbb9381b"

URI_x86_64_v2_rust-signature+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature+std-devel-2.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature+std-devel}"
SRC_URI[x86_64_v2_rust-signature+std-devel.sha256sum] = "1d35db3b15449defcc67fe064039475c7cafbe8341160e9d8e0f2df1a1bf8ad3"

URI_x86_64_v2_rust-signature-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature-devel-2.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature-devel}"
SRC_URI[x86_64_v2_rust-signature-devel.sha256sum] = "35161f6fe4d4ae67bff513c84d97089ae7799dafd06923291732422b5038da68"

URI_aarch64_rust-signature+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature+alloc-devel-2.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-signature+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature+alloc-devel}"
SRC_URI[aarch64_rust-signature+alloc-devel.sha256sum] = "0bcc5cd4438c9399706f00218e088e001cdac742191888379f9dd1edaab14a77"

URI_aarch64_rust-signature+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature+default-devel-2.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-signature+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature+default-devel}"
SRC_URI[aarch64_rust-signature+default-devel.sha256sum] = "aa07f47903ddd9f7c53d148b933be7c224e87285993f04a382de4bb5249e0ef6"

URI_aarch64_rust-signature+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature+derive-devel-2.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-signature+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature+derive-devel}"
SRC_URI[aarch64_rust-signature+derive-devel.sha256sum] = "6cc8df6830b4cf57d35f01198c17db30de62aedc010e5e164f85c3cac67b4c5c"

URI_aarch64_rust-signature+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature+digest-devel-2.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-signature+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature+digest-devel}"
SRC_URI[aarch64_rust-signature+digest-devel.sha256sum] = "8c9b8ce64a1552d15aae38fbb00cf7c4240b9d03f8c3559d0ff549a6c0277e69"

URI_aarch64_rust-signature+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature+rand_core-devel-2.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-signature+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature+rand_core-devel}"
SRC_URI[aarch64_rust-signature+rand_core-devel.sha256sum] = "ff938642cc99de123d5fbb8933eda04a816f7cc5c1ace50f93d34288dc69ac8d"

URI_aarch64_rust-signature+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature+std-devel-2.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-signature+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature+std-devel}"
SRC_URI[aarch64_rust-signature+std-devel.sha256sum] = "d60da44c6a66f2081f2d97dd458260220e91b355bc836390af990fa4b1ea32f0"

URI_aarch64_rust-signature-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature-devel-2.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-signature-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature-devel}"
SRC_URI[aarch64_rust-signature-devel.sha256sum] = "bca255de3aee9a2df836f99923b2077fbbc03d40d5753af7050bb38c38910662"

RDEPENDS:rust-signature+alloc-devel = " \
 cargo \
 rust-signature-devel \
 "
RDEPENDS:rust-signature+default-devel = " \
 cargo \
 rust-signature-devel \
 "
RDEPENDS:rust-signature+derive-devel = " \
 cargo \
 rust-signature-devel \
 rust-signature_derive+default-devel \
 "
RDEPENDS:rust-signature+digest-devel = " \
 cargo \
 rust-digest-devel \
 rust-signature-devel \
 "
RDEPENDS:rust-signature+rand_core-devel = " \
 cargo \
 rust-rand_core0.6-devel \
 rust-signature-devel \
 "
RDEPENDS:rust-signature+std-devel = " \
 cargo \
 rust-rand_core0.6+std-devel \
 rust-rand_core0.6-devel \
 rust-signature+alloc-devel \
 rust-signature-devel \
 "
RDEPENDS:rust-signature-devel = " \
 cargo \
 rust \
 "
