# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-smartypants"
PV = "2.0.1"
PR = "22.el10_0"
PACKAGES = " \
 python-smartypants-doc \
 python3-smartypants \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-smartypants-2.0.1-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2bba5014ce0d6c5630c2ad5b4ec4a7bc299a532c5a3a7c8ac4f9d3be3c9d494"

URI_x86_64_v2_python-smartypants-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-smartypants-doc-2.0.1-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-smartypants-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-smartypants-doc}"
SRC_URI[x86_64_v2_python-smartypants-doc.sha256sum] = "da46a89128d3ba421e332e62fe7ac6cdfbae7215cef5ad15c3f1a2f4d9e3e1c1"

URI_x86_64_v2_python3-smartypants = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-smartypants-2.0.1-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-smartypants;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-smartypants}"
SRC_URI[x86_64_v2_python3-smartypants.sha256sum] = "202edc2b73e75d76fd266cc76b4f39c7aacaec8264449f8c86e7ac01e0323794"

URI_aarch64_python-smartypants-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-smartypants-doc-2.0.1-22.el10_0.noarch.rpm;name=aarch64_python-smartypants-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-smartypants-doc}"
SRC_URI[aarch64_python-smartypants-doc.sha256sum] = "b652738394e4f7d942cc7f6afdadc67687d35c1b60e0acb6673afd4c79a7125f"

URI_aarch64_python3-smartypants = "${EPEL_MIRROR}/aarch64/Packages/p/python3-smartypants-2.0.1-22.el10_0.noarch.rpm;name=aarch64_python3-smartypants;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-smartypants}"
SRC_URI[aarch64_python3-smartypants.sha256sum] = "e30f8df71c676e551d892533d3b8c3f9f1758b13a15ce00220a3ec143d655c1b"

RDEPENDS:python-smartypants-doc = " \
 "
RDEPENDS:python3-smartypants = " \
 python3 \
 "
