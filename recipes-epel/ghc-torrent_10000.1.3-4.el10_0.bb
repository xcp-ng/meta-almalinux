# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-torrent"
PV = "10000.1.3"
PR = "4.el10_0"
PACKAGES = " \
 ghc-torrent \
 ghc-torrent-devel \
 ghc-torrent-doc \
 ghc-torrent-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-torrent-10000.1.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "48f1cbde7e587e03307f4f0a733d9390257300d304aecd236e4d015802d5c6c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-torrent-10000.1.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-torrent;unpack=0"
SRC_URI[x86_64_v2_ghc-torrent.sha256sum] = "9f5021582eaf45b6fbd7f61d75f15f4a55763dff7966426c242fc2f1880a6edc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-torrent-devel-10000.1.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-torrent-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-torrent-devel.sha256sum] = "7c4f0e7228b0d7236d87709385a7272a86c5159c50ea6627db265001295329ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-torrent-doc-10000.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-torrent-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-torrent-doc.sha256sum] = "97e52c4bc1fa1c4005be755990a70e4a6dcf9c8a0605cb9264d19f3dc37082d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-torrent-prof-10000.1.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-torrent-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-torrent-prof.sha256sum] = "586db8da199832b71df89de863d57162d2a0f695c972995cd2688e99ee9676d5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-torrent-10000.1.3-4.el10_0.aarch64.rpm;name=aarch64_ghc-torrent;unpack=0"
SRC_URI[aarch64_ghc-torrent.sha256sum] = "e822fcd891ea0136f53202d6a2673c28338888ed86241091d177ee3ab4fdc7b1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-torrent-devel-10000.1.3-4.el10_0.aarch64.rpm;name=aarch64_ghc-torrent-devel;unpack=0"
SRC_URI[aarch64_ghc-torrent-devel.sha256sum] = "8800848012d2b41afcf0009eebdce7530edbd20abfb85a4ac374dda4379e8163"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-torrent-doc-10000.1.3-4.el10_0.noarch.rpm;name=aarch64_ghc-torrent-doc;unpack=0"
SRC_URI[aarch64_ghc-torrent-doc.sha256sum] = "1a6b7fd7081729fdce4367c6736275266c8316a826ba6224a261751ddd84bc5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-torrent-prof-10000.1.3-4.el10_0.aarch64.rpm;name=aarch64_ghc-torrent-prof;unpack=0"
SRC_URI[aarch64_ghc-torrent-prof.sha256sum] = "64f6b54e1041c0ee115280fa50b371b89f76d3e6408f27636f2a2baa37c4288d"

RDEPENDS:ghc-torrent = " \
 ghc-array \
 ghc-base \
 ghc-bencode \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-stm \
 ghc-syb \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-transformers-compat \
 glibc \
 gmp \
 "
RDEPENDS:ghc-torrent-devel = " \
 ghc-base-devel \
 ghc-bencode-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-filepath-devel \
 ghc-syb-devel \
 ghc-torrent \
 "
RDEPENDS:ghc-torrent-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-torrent-prof = " \
 ghc-base-prof \
 ghc-bencode-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-filepath-prof \
 ghc-syb-prof \
 ghc-torrent-devel \
 "
