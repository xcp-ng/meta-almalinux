# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Getopt-Long-Descriptive"
PV = "0.114"
PR = "1.el10_0"
PACKAGES = " \
 perl-Getopt-Long-Descriptive \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Getopt-Long-Descriptive-0.114-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10daf44ce48a79e5261bfd00a01a0db2a2a61434fdc5d179c8b770d140a18c7f"

URI_x86_64_v2_perl-Getopt-Long-Descriptive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Getopt-Long-Descriptive-0.114-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Getopt-Long-Descriptive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Getopt-Long-Descriptive}"
SRC_URI[x86_64_v2_perl-Getopt-Long-Descriptive.sha256sum] = "a2dfc3a2ce21a8eb1bb47c3ea4ea5914570579c44dbd869d3c25026d16116432"

URI_aarch64_perl-Getopt-Long-Descriptive = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Getopt-Long-Descriptive-0.114-1.el10_0.noarch.rpm;name=aarch64_perl-Getopt-Long-Descriptive;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Getopt-Long-Descriptive}"
SRC_URI[aarch64_perl-Getopt-Long-Descriptive.sha256sum] = "bf91880de9fcaab6c018be3a66400ff02e08aeba1fe342f0e454a1463c3539e6"

RDEPENDS:perl-Getopt-Long-Descriptive = " \
 perl-Carp \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-Getopt-Long-Descriptive \
 perl-Params-Validate \
 perl-Scalar-List-Utils \
 perl-Sub-Exporter \
 perl-libs \
 perl-overload \
 "
