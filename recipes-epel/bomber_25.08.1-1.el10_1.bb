# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bomber"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 bomber \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bomber-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b863ba986c3b5b7c6dea46c9124c05624a92660e4b0068028960dcb328c74c3"

URI_x86_64_v2_bomber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bomber-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bomber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bomber}"
SRC_URI[x86_64_v2_bomber.sha256sum] = "5db7e97603704dbc7987819c66a1ac391fa3cb5a799ae8f88bf793a28472d05a"

URI_aarch64_bomber = "${EPEL_MIRROR}/aarch64/Packages/b/bomber-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_bomber;unpack=0"
SRC_URI:append = " ${URI_aarch64_bomber}"
SRC_URI[aarch64_bomber.sha256sum] = "ec2e5c55a2b385165ef216064b8e1cc4e1098149222a198b129cb389620b6326"

RDEPENDS:bomber = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
