# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-omp"
PV = "6.4.2"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 rocm-omp \
 rocm-omp-devel \
 rocm-omp-static \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rocm-omp-6.4.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "91ffbe7e582adb98a2ba83271ceafab8129e1f8b122c66eb82d2f3dd2da47c7b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-omp-6.4.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-omp;unpack=0"
SRC_URI[x86_64_v2_rocm-omp.sha256sum] = "5f51cc58ddb2fe954c0eb7cfffa5ea7e764f1ea285d618e0353887f91bb77707"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-omp-devel-6.4.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-omp-devel;unpack=0"
SRC_URI[x86_64_v2_rocm-omp-devel.sha256sum] = "20d2d23772586ecdb909c7afb3db7c4a183d0574ad767a0db926fe1591545516"
RPROVIDES:rocm-omp-devel:append:x86_64_v2 = " virtual/libomp.so_VERSION__64bit_ virtual/libomp.so___64bit_"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-omp-static-6.4.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-omp-static;unpack=0"
SRC_URI[x86_64_v2_rocm-omp-static.sha256sum] = "cb608bb20b5b7273d884aeeaae129e28492effa079849bed1e4e089e642e7b74"

RDEPENDS:rocm-omp = " \
 rocm-llvm-filesystem \
 "
RDEPENDS:rocm-omp-devel = " \
 glibc \
 rocm-omp \
 "
RDEPENDS:rocm-omp-static = " \
 rocm-omp-devel \
 "
