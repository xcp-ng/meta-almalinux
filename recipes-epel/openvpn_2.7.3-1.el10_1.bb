# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openvpn"
PV = "2.7.3"
PR = "1.el10_1"
PACKAGES = " \
 openvpn \
 openvpn-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/openvpn-2.7.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6d6e77c7f9e1a269b81e3a849276b94433644af8a21224011ca43931609d13bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvpn-2.7.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvpn;unpack=0"
SRC_URI[x86_64_v2_openvpn.sha256sum] = "42d41033ad3f8d726e39708dcf3bb873f944e2bf1010040d5ee49ef718c8383b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvpn-devel-2.7.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvpn-devel;unpack=0"
SRC_URI[x86_64_v2_openvpn-devel.sha256sum] = "a56f90db48b92615ac654bc25293e5dd9b18492c84c711aa3fd2afe48af28ee9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openvpn-2.7.3-1.el10_1.aarch64.rpm;name=aarch64_openvpn;unpack=0"
SRC_URI[aarch64_openvpn.sha256sum] = "033a36d5293322b844a5dc6c3c09dc674d69180675f6cabef70c98dae38602a6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openvpn-devel-2.7.3-1.el10_1.aarch64.rpm;name=aarch64_openvpn-devel;unpack=0"
SRC_URI[aarch64_openvpn-devel.sha256sum] = "d61d11666e1e2ea38f337bf6b9ae163baf0a83f847d8f5f6760d9997b9adf02c"

RDEPENDS:openvpn = " \
 bash \
 gawk \
 glibc \
 libcap-ng \
 libnl3 \
 libselinux \
 lz4-libs \
 lzo \
 openssl-libs \
 pam-libs \
 pkcs11-helper \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:openvpn-devel = " \
 "
