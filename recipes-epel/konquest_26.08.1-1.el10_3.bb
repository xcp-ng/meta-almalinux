# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konquest"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 konquest \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/konquest-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "54939a0ed32e7f14970cf92d4528ad2ba86fa25cd29ea09e141d4a801319289e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konquest-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konquest;unpack=0"
SRC_URI[x86_64_v2_konquest.sha256sum] = "3c2e0eeedcc11ee24046121ebe30b10dd2fa0a9ec5c55f673ad86832c9b1ebf5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/konquest-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_konquest;unpack=0"
SRC_URI[aarch64_konquest.sha256sum] = "73b09ec8c5911be29a7628a2e26329ecd1729c38b0c3ca2212e7e465c98acb98"

RDEPENDS:konquest = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtscxml \
 qt6-qtsvg \
 "
