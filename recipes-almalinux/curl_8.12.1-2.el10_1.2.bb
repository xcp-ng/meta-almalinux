# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "curl"
PV = "8.12.1"
PR = "2.el10_1.2"
PACKAGES = " \
 curl \
 libcurl \
 libcurl-devel \
 libcurl-minimal \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/curl-8.12.1-2.el10_1.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3aec324616f2b5c0e9bf9840dd88fb1bcead94ac7b5c4d5a985892a516c1abd"

URI_x86_64_v2_curl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/curl-8.12.1-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_curl}"
SRC_URI[x86_64_v2_curl.sha256sum] = "57d6e6c346937ecf12b03b11125c3ecb137f2f6b32b2151fbb6fd3600cffc844"
RPROVIDES:curl:append:x86_64_v2 = " virtual/wget_or_curl"

URI_x86_64_v2_libcurl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcurl-8.12.1-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_libcurl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcurl}"
SRC_URI[x86_64_v2_libcurl.sha256sum] = "dafd5064fc08becb4cfb580f7791891ad24edc494d9742039188687fad21bbc3"
RPROVIDES:libcurl:append:x86_64_v2 = " virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2 virtual/libcurl_x86-64_ virtual/libcurl_x86-64__eq_8.12.1-2.el10_1.2 virtual/libcurl_x86-64__ge_7.29.0 virtual/libcurl_x86-64__ge_7.52.0 virtual/libcurl_x86-64__ge_8.12.1-2.el10_1.2 virtual/libcurl_x86-64__ge_8.9.1"

URI_x86_64_v2_libcurl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcurl-devel-8.12.1-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_libcurl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcurl-devel}"
SRC_URI[x86_64_v2_libcurl-devel.sha256sum] = "e5eb96e1467e1a3eaf964edac1351028f70324ef2046d47154c898b81e6cb674"

URI_x86_64_v2_libcurl-minimal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcurl-minimal-8.12.1-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_libcurl-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcurl-minimal}"
SRC_URI[x86_64_v2_libcurl-minimal.sha256sum] = "aa783e14bee053230b09c9a1a41c0dcf4d00110acc61cbf8586cb895d39a3feb"
RPROVIDES:libcurl-minimal:append:x86_64_v2 = " virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2 virtual/libcurl_x86-64_ virtual/libcurl_x86-64__eq_8.12.1-2.el10_1.2 virtual/libcurl_x86-64__ge_7.29.0 virtual/libcurl_x86-64__ge_7.52.0 virtual/libcurl_x86-64__ge_8.12.1-2.el10_1.2 virtual/libcurl_x86-64__ge_8.9.1"

URI_aarch64_curl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/curl-8.12.1-2.el10_1.2.aarch64.rpm;name=aarch64_curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_curl}"
SRC_URI[aarch64_curl.sha256sum] = "d8e04377679518295a2026abe951818ec7df37dc7309edb0983faee1bee9d911"
RPROVIDES:curl:append:aarch64 = " virtual/wget_or_curl"

URI_aarch64_libcurl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcurl-8.12.1-2.el10_1.2.aarch64.rpm;name=aarch64_libcurl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcurl}"
SRC_URI[aarch64_libcurl.sha256sum] = "ca383caba7290c8170423e7f26813dea2ee8b2f82cc15e1d7a71ca8b9dcf4bc6"
RPROVIDES:libcurl:append:aarch64 = " virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_aarch-64_ virtual/libcurl_aarch-64__eq_8.12.1-2.el10_1.2 virtual/libcurl_aarch-64__ge_7.29.0 virtual/libcurl_aarch-64__ge_7.52.0 virtual/libcurl_aarch-64__ge_8.12.1-2.el10_1.2 virtual/libcurl_aarch-64__ge_8.9.1 virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2"

URI_aarch64_libcurl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcurl-devel-8.12.1-2.el10_1.2.aarch64.rpm;name=aarch64_libcurl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcurl-devel}"
SRC_URI[aarch64_libcurl-devel.sha256sum] = "dff0ad82628380a9f089693963f39ae03214eb69d3e7a1defc9f010e8d8ab121"

URI_aarch64_libcurl-minimal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcurl-minimal-8.12.1-2.el10_1.2.aarch64.rpm;name=aarch64_libcurl-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcurl-minimal}"
SRC_URI[aarch64_libcurl-minimal.sha256sum] = "980ff9711cb365bf5fb6bab86dd89af039a383f8ad6d884966c029bd7d7b50ff"
RPROVIDES:libcurl-minimal:append:aarch64 = " virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_aarch-64_ virtual/libcurl_aarch-64__eq_8.12.1-2.el10_1.2 virtual/libcurl_aarch-64__ge_7.29.0 virtual/libcurl_aarch-64__ge_7.52.0 virtual/libcurl_aarch-64__ge_8.12.1-2.el10_1.2 virtual/libcurl_aarch-64__ge_8.9.1 virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2"

RDEPENDS:curl:x86_64_v2 = " \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__ge_8.12.1-2.el10_1.2 \
"
RDEPENDS:curl:aarch64 = " \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__ge_8.12.1-2.el10_1.2 \
"
RDEPENDS:libcurl = " \
 glibc \
 krb5-libs \
 libbrotli \
 libidn2 \
 libnghttp2 \
 libpsl \
 libssh \
 openldap \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libcurl-devel:x86_64_v2 = " \
 bash \
 brotli-devel \
 krb5-devel \
 libidn2-devel \
 libnghttp2-devel \
 libpsl-devel \
 libssh-devel \
 openssl-devel \
 pkgconf-pkg-config \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__eq_8.12.1-2.el10_1.2 \
 zlib-ng-compat-devel \
"
RDEPENDS:libcurl-devel:aarch64 = " \
 bash \
 brotli-devel \
 krb5-devel \
 libidn2-devel \
 libnghttp2-devel \
 libpsl-devel \
 libssh-devel \
 openssl-devel \
 pkgconf-pkg-config \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__eq_8.12.1-2.el10_1.2 \
 zlib-ng-compat-devel \
"
RDEPENDS:libcurl-minimal = " \
 glibc \
 krb5-libs \
 libidn2 \
 libnghttp2 \
 openssl-libs \
 zlib-ng-compat \
 "
