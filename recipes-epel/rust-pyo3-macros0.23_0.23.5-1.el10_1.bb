# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros0.23"
PV = "0.23.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-pyo3-macros0.23+default-devel \
 rust-pyo3-macros0.23+experimental-async-devel \
 rust-pyo3-macros0.23+multiple-pymethods-devel \
 rust-pyo3-macros0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros0.23-0.23.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "555b47c5ff9d0fed41c3542ad29b9fbe63b0a4b08d66eec8cec60f57b970482a"

URI_x86_64_v2_rust-pyo3-macros0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.23+default-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.23+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.23+default-devel.sha256sum] = "4991c39ed203bb7cbec05e85c0197b1d4f276c3a71144274c8fc0e21bedc8453"

URI_x86_64_v2_rust-pyo3-macros0.23+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.23+experimental-async-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.23+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.23+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.23+experimental-async-devel.sha256sum] = "330cb58e2ba7e2adafa5548c13e4e7a0321088529ce099c14b96106a996f37a0"

URI_x86_64_v2_rust-pyo3-macros0.23+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.23+multiple-pymethods-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.23+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.23+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.23+multiple-pymethods-devel.sha256sum] = "073f8d411232ef8eb3125358f548813b5ee3cc146bb06712baf1319d6277a827"

URI_x86_64_v2_rust-pyo3-macros0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.23-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.23-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.23-devel.sha256sum] = "18d260c422893539ebe8a1c87c524496776b498438ba0babea0b9527f6cdd950"

URI_aarch64_rust-pyo3-macros0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.23+default-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.23+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.23+default-devel.sha256sum] = "5be29d7d713693791a172e6f4d0afedf526902148305c77303f323fa340df62d"

URI_aarch64_rust-pyo3-macros0.23+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.23+experimental-async-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros0.23+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.23+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.23+experimental-async-devel.sha256sum] = "e658dab90ed68b581b8f9a57576088abff2ba9187964a2b88723c57f3721e3a2"

URI_aarch64_rust-pyo3-macros0.23+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.23+multiple-pymethods-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros0.23+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.23+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.23+multiple-pymethods-devel.sha256sum] = "ad110059f543068101f8603584d51563ce7ca91ac89f53e4d9a4ea4b3accdd3e"

URI_aarch64_rust-pyo3-macros0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.23-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.23-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.23-devel.sha256sum] = "8455fd8d2c1f95f116861bd2e7db738ad4876c9fa61e4332aec674915a99648b"

RDEPENDS:rust-pyo3-macros0.23+default-devel = " \
 cargo \
 rust-pyo3-macros0.23-devel \
 "
RDEPENDS:rust-pyo3-macros0.23+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend0.23+experimental-async-devel \
 rust-pyo3-macros0.23-devel \
 "
RDEPENDS:rust-pyo3-macros0.23+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros0.23-devel \
 "
RDEPENDS:rust-pyo3-macros0.23-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-pyo3-macros-backend0.23+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 "
