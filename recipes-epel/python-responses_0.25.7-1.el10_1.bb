# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-responses"
PV = "0.25.7"
PR = "1.el10_1"
PACKAGES = " \
 python3-responses \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-responses-0.25.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9ce0421cf0b803c54f7ef3992d9a2ecda07420e3ea76fe7da068f7008d429d3"

URI_x86_64_v2_python3-responses = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-responses-0.25.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-responses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-responses}"
SRC_URI[x86_64_v2_python3-responses.sha256sum] = "f0f0ee524021d45da37756e40deb1011f67af13ce44647523b60672b10d60a78"

URI_aarch64_python3-responses = "${EPEL_MIRROR}/aarch64/Packages/p/python3-responses-0.25.7-1.el10_1.noarch.rpm;name=aarch64_python3-responses;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-responses}"
SRC_URI[aarch64_python3-responses.sha256sum] = "db0dd378ca8308d2ee9d43d6bb021236522e4aa4664c74732349273e6a07cd6e"

RDEPENDS:python3-responses = " \
 python3 \
 python3-pyyaml \
 python3-requests \
 python3-urllib3 \
 "
