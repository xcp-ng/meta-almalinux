# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aodhclient"
PV = "3.10.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-aodhclient \
 python3-aodhclient-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aodhclient-3.10.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8a6aa8376a129fecbabb87760ea853a7cb00126981279bec0ad6a0b57f3437d"

URI_x86_64_v2_python3-aodhclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aodhclient-3.10.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aodhclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aodhclient}"
SRC_URI[x86_64_v2_python3-aodhclient.sha256sum] = "e8d64ad34004d5a50b1dd592fc7b53d71230f558823d5fccb7005bd37b50f779"

URI_x86_64_v2_python3-aodhclient-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aodhclient-tests-3.10.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aodhclient-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aodhclient-tests}"
SRC_URI[x86_64_v2_python3-aodhclient-tests.sha256sum] = "f6d819daac8432766a01e75ff628f5b8e41b9d927cee4e9955df930bb9b537d1"

URI_aarch64_python3-aodhclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aodhclient-3.10.1-1.el10_2.noarch.rpm;name=aarch64_python3-aodhclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aodhclient}"
SRC_URI[aarch64_python3-aodhclient.sha256sum] = "a1169020b6ccc49eb08ab4e6b86c167984f8c40c9a7fd329690b8f19514fdb5b"

URI_aarch64_python3-aodhclient-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aodhclient-tests-3.10.1-1.el10_2.noarch.rpm;name=aarch64_python3-aodhclient-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aodhclient-tests}"
SRC_URI[aarch64_python3-aodhclient-tests.sha256sum] = "7a73d82892a78a585e677ca1339c1c7342efb272efe14ab3b3b77dfdb1e0346e"

RDEPENDS:python3-aodhclient = " \
 python3 \
 python3-cliff \
 python3-keystoneauth1 \
 python3-osc-lib \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-pyparsing \
 "
RDEPENDS:python3-aodhclient-tests = " \
 python3 \
 python3-aodhclient \
 "
