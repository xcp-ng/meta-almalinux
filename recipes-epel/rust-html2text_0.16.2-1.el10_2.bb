# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-html2text"
PV = "0.16.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-html2text+css-devel \
 rust-html2text+css_ext-devel \
 rust-html2text+default-devel \
 rust-html2text+html_trace-devel \
 rust-html2text+html_trace_bt-devel \
 rust-html2text-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-html2text-0.16.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0496cb38818c8a7105d65d55dc6e0c237ad84c18671c72093d322576543a54fd"

URI_x86_64_v2_rust-html2text+css-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html2text+css-devel-0.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html2text+css-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html2text+css-devel}"
SRC_URI[x86_64_v2_rust-html2text+css-devel.sha256sum] = "6c044d33a973f30eae98c8cfdfd94e71f87f7e8891f4ae4035994b871fe40dd3"

URI_x86_64_v2_rust-html2text+css_ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html2text+css_ext-devel-0.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html2text+css_ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html2text+css_ext-devel}"
SRC_URI[x86_64_v2_rust-html2text+css_ext-devel.sha256sum] = "b52a6243a7d6115079f19de56884e2fa944548f557ce65762577a05c2fb5d329"

URI_x86_64_v2_rust-html2text+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html2text+default-devel-0.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html2text+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html2text+default-devel}"
SRC_URI[x86_64_v2_rust-html2text+default-devel.sha256sum] = "16e780df5e02866bb7903140ff22324ca1dac1794297a23f2f6b0bfb1440fab6"

URI_x86_64_v2_rust-html2text+html_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html2text+html_trace-devel-0.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html2text+html_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html2text+html_trace-devel}"
SRC_URI[x86_64_v2_rust-html2text+html_trace-devel.sha256sum] = "6f26b18bcac550096859c39e4dfcac907ccd306d88f68366219c664d3357f553"

URI_x86_64_v2_rust-html2text+html_trace_bt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html2text+html_trace_bt-devel-0.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html2text+html_trace_bt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html2text+html_trace_bt-devel}"
SRC_URI[x86_64_v2_rust-html2text+html_trace_bt-devel.sha256sum] = "1edee29ad59525c1051a72df308009dee0da44d5d58a9f0de60994d83a0642c0"

URI_x86_64_v2_rust-html2text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html2text-devel-0.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html2text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html2text-devel}"
SRC_URI[x86_64_v2_rust-html2text-devel.sha256sum] = "2955395a7e7495e2d5e005e427fb1875fd5b9749cd923de4532042b008fab564"

URI_aarch64_rust-html2text+css-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html2text+css-devel-0.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-html2text+css-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html2text+css-devel}"
SRC_URI[aarch64_rust-html2text+css-devel.sha256sum] = "1776141433e089e09533834b26a592d21e43ee7045def24d7cb618672ca0bd2e"

URI_aarch64_rust-html2text+css_ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html2text+css_ext-devel-0.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-html2text+css_ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html2text+css_ext-devel}"
SRC_URI[aarch64_rust-html2text+css_ext-devel.sha256sum] = "5be6fe636f373e5847ad5ab8cdb1d0bac6b244ad4a999e12eb1f4570ae8bd561"

URI_aarch64_rust-html2text+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html2text+default-devel-0.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-html2text+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html2text+default-devel}"
SRC_URI[aarch64_rust-html2text+default-devel.sha256sum] = "217689df056d6f3780dfe3f7523969a5483a6ba6dbdc3125ef8e6dbf4ea4f8df"

URI_aarch64_rust-html2text+html_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html2text+html_trace-devel-0.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-html2text+html_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html2text+html_trace-devel}"
SRC_URI[aarch64_rust-html2text+html_trace-devel.sha256sum] = "80be09509f5b9c624c1e2db8387e704d3f045f1720f2f785ee051d4af5ff36b5"

URI_aarch64_rust-html2text+html_trace_bt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html2text+html_trace_bt-devel-0.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-html2text+html_trace_bt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html2text+html_trace_bt-devel}"
SRC_URI[aarch64_rust-html2text+html_trace_bt-devel.sha256sum] = "19e5cff11886fac72ba64b66f764cb14ec3d2eb680d7048741f645808ba50185"

URI_aarch64_rust-html2text-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html2text-devel-0.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-html2text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html2text-devel}"
SRC_URI[aarch64_rust-html2text-devel.sha256sum] = "b1d987e7bd95c754b8418f143670cb5e9903aebef4fb720cc275fe9381cb4e85"

RDEPENDS:rust-html2text+css-devel = " \
 cargo \
 rust-html2text-devel \
 rust-nom+default-devel \
 "
RDEPENDS:rust-html2text+css_ext-devel = " \
 cargo \
 rust-html2text+css-devel \
 rust-html2text-devel \
 "
RDEPENDS:rust-html2text+default-devel = " \
 cargo \
 rust-html2text-devel \
 "
RDEPENDS:rust-html2text+html_trace-devel = " \
 cargo \
 rust-html2text-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-html2text+html_trace_bt-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-html2text+html_trace-devel \
 rust-html2text-devel \
 "
RDEPENDS:rust-html2text-devel = " \
 cargo \
 rust \
 rust-html5ever0.35+default-devel \
 rust-tendril0.4+default-devel \
 rust-thiserror+default-devel \
 rust-unicode-width+default-devel \
 "
