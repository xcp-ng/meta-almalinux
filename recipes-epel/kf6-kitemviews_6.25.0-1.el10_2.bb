# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kitemviews"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kitemviews \
 kf6-kitemviews-devel \
 kf6-kitemviews-doc \
 kf6-kitemviews-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kitemviews-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02fcb1247b8f6e73930b9e9f5eccf54f5e14dd2fc708555e5502fc645cbd57f5"

URI_x86_64_v2_kf6-kitemviews = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemviews;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews}"
SRC_URI[x86_64_v2_kf6-kitemviews.sha256sum] = "723f88644872288004835682425af4e20424b2ae0e60fe055c484492adcd9b78"

URI_x86_64_v2_kf6-kitemviews-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemviews-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews-devel}"
SRC_URI[x86_64_v2_kf6-kitemviews-devel.sha256sum] = "cc5caf7a4e21ac504584141f6c397a0768724369dd841a280c3bbbe96cd4e87b"

URI_x86_64_v2_kf6-kitemviews-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemviews-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews-doc}"
SRC_URI[x86_64_v2_kf6-kitemviews-doc.sha256sum] = "64146524872395d72bf60c5f895161768bd062473d920c851392bc62001c53a1"

URI_x86_64_v2_kf6-kitemviews-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemviews-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews-html}"
SRC_URI[x86_64_v2_kf6-kitemviews-html.sha256sum] = "5bb5af9dfab0c124cabde37dd26150afd7d6ef7e5de15d234642895324b0b6d7"

URI_aarch64_kf6-kitemviews = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kitemviews;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews}"
SRC_URI[aarch64_kf6-kitemviews.sha256sum] = "ec3bdae3a4c3e9d221fdde3f05aad3f1908a0468937b9899fe5e9fea851d56c8"

URI_aarch64_kf6-kitemviews-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kitemviews-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews-devel}"
SRC_URI[aarch64_kf6-kitemviews-devel.sha256sum] = "ba27da030e8f79a98ff7eda739629e6862997bff0e300a8e88d2a2983834e12d"

URI_aarch64_kf6-kitemviews-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kitemviews-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews-doc}"
SRC_URI[aarch64_kf6-kitemviews-doc.sha256sum] = "5f5cb703c611f2c2d0d465d769572ef639c786725f80448ab3340ca923621342"

URI_aarch64_kf6-kitemviews-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kitemviews-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews-html}"
SRC_URI[aarch64_kf6-kitemviews-html.sha256sum] = "7ab3d3d1f28e7b54934e7bc8f1d3ec3397656eae782922fa62196047c95d202c"

RDEPENDS:kf6-kitemviews = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kitemviews-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kitemviews \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kitemviews-doc = " \
 "
RDEPENDS:kf6-kitemviews-html = " \
 "
