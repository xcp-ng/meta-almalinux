# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-float16"
PV = "0.1.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-float16+default-devel \
 rust-float16+std-devel \
 rust-float16-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-float16-0.1.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0df8d6115c2936849219a7cb2f51096b23a1d72389bc202abe0a42190a0d114"

URI_aarch64_rust-float16+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float16+default-devel-0.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-float16+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float16+default-devel}"
SRC_URI[aarch64_rust-float16+default-devel.sha256sum] = "67faaae1a855431b00008f6d506288c12d11ca771e37525edf9a0a40adedf7df"

URI_aarch64_rust-float16+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float16+std-devel-0.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-float16+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float16+std-devel}"
SRC_URI[aarch64_rust-float16+std-devel.sha256sum] = "7d8ed4b6fc1f18a0bb56ffc230b28e1aae8d25c1df1bdbd99a25ca7ca2e50d30"

URI_aarch64_rust-float16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float16-devel-0.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-float16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float16-devel}"
SRC_URI[aarch64_rust-float16-devel.sha256sum] = "6b0e6a14d042ee8f0ab40230c78d64873a271f973c75589c6430a905663e228d"

RDEPENDS:rust-float16+default-devel = " \
 cargo \
 rust-float16+std-devel \
 rust-float16-devel \
 "
RDEPENDS:rust-float16+std-devel = " \
 cargo \
 rust-float16-devel \
 "
RDEPENDS:rust-float16-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-rustc_version+default-devel \
 "
