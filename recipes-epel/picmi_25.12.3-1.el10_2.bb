# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "picmi"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 picmi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/picmi-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5cc6030ec767939aad4ebac8f9a73d29618400c4a1c8d75a06d85b017c6dba88"

URI_x86_64_v2_picmi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/picmi-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_picmi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_picmi}"
SRC_URI[x86_64_v2_picmi.sha256sum] = "8835321c27fea58246d570cc3d682680bb6094a50467029b9ee5547188b1a8b3"

URI_aarch64_picmi = "${EPEL_MIRROR}/aarch64/Packages/p/picmi-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_picmi;unpack=0"
SRC_URI:append = " ${URI_aarch64_picmi}"
SRC_URI[aarch64_picmi.sha256sum] = "1fd96c236c57e5ae313baf749d77d727e338e8112d47b6f153cbc592a173ba12"

RDEPENDS:picmi = " \
 glibc \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
