# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snafu"
PV = "0.8.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-snafu+alloc-devel \
 rust-snafu+backtrace-devel \
 rust-snafu+backtraces-impl-backtrace-crate-devel \
 rust-snafu+default-devel \
 rust-snafu+futures-core-crate-devel \
 rust-snafu+futures-crate-devel \
 rust-snafu+futures-devel \
 rust-snafu+guide-devel \
 rust-snafu+internal-dev-dependencies-devel \
 rust-snafu+pin-project-devel \
 rust-snafu+rust_1_61-devel \
 rust-snafu+rust_1_65-devel \
 rust-snafu+rust_1_81-devel \
 rust-snafu+std-devel \
 rust-snafu+unstable-core-error-devel \
 rust-snafu+unstable-provider-api-devel \
 rust-snafu+unstable-try-trait-devel \
 rust-snafu-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snafu-0.8.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e31b49f9ef9ea6a7ca4fbc76d7c5cbbb2026d00d36bf2f109945e3d4e1d5e1e"

URI_x86_64_v2_rust-snafu+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+alloc-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+alloc-devel}"
SRC_URI[x86_64_v2_rust-snafu+alloc-devel.sha256sum] = "e2d835b5e2cd68a8ba0930b75ce7e29f5039b7d38e3afd3b3bd31a97ec0c5ea1"

URI_x86_64_v2_rust-snafu+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+backtrace-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+backtrace-devel}"
SRC_URI[x86_64_v2_rust-snafu+backtrace-devel.sha256sum] = "893ed3987845660930b46e25f0f37870c338bd86532890aa9244a364611f56d7"

URI_x86_64_v2_rust-snafu+backtraces-impl-backtrace-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+backtraces-impl-backtrace-crate-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+backtraces-impl-backtrace-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+backtraces-impl-backtrace-crate-devel}"
SRC_URI[x86_64_v2_rust-snafu+backtraces-impl-backtrace-crate-devel.sha256sum] = "ad6203c8e5cc36b1ce5c837dc4c9505cdab08c1b007d79f5eec8074df21d1751"

URI_x86_64_v2_rust-snafu+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+default-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+default-devel}"
SRC_URI[x86_64_v2_rust-snafu+default-devel.sha256sum] = "e0e6d3fd60bd7c96c34d33fc14b03779e30448f432eb5cb869184aa3d231ac72"

URI_x86_64_v2_rust-snafu+futures-core-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+futures-core-crate-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+futures-core-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+futures-core-crate-devel}"
SRC_URI[x86_64_v2_rust-snafu+futures-core-crate-devel.sha256sum] = "23cdaaf4b2b2cdd62841240e8761f1025ee156202b8d181a29168c4b63c7dd14"

URI_x86_64_v2_rust-snafu+futures-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+futures-crate-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+futures-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+futures-crate-devel}"
SRC_URI[x86_64_v2_rust-snafu+futures-crate-devel.sha256sum] = "e31753531c1e77ba92a45a0e7a9723e53e562215359a6990183efba33c259146"

URI_x86_64_v2_rust-snafu+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+futures-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+futures-devel}"
SRC_URI[x86_64_v2_rust-snafu+futures-devel.sha256sum] = "0db752c2b1f859d030e3d5439002744166ea47db8254f5f17c15cb723da692cd"

URI_x86_64_v2_rust-snafu+guide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+guide-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+guide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+guide-devel}"
SRC_URI[x86_64_v2_rust-snafu+guide-devel.sha256sum] = "088e249106f45ccc5b93e123b37565c5ee7af7413b0b5ff33bc18f5a2792049b"

URI_x86_64_v2_rust-snafu+internal-dev-dependencies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+internal-dev-dependencies-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+internal-dev-dependencies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+internal-dev-dependencies-devel}"
SRC_URI[x86_64_v2_rust-snafu+internal-dev-dependencies-devel.sha256sum] = "d86be7ee9c26e010d1e9a428e3797266f9994a3dc8055844c765aa94edaeec40"

URI_x86_64_v2_rust-snafu+pin-project-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+pin-project-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+pin-project-devel}"
SRC_URI[x86_64_v2_rust-snafu+pin-project-devel.sha256sum] = "f39bbb63e5035b7aeb9dc6483a153d6081e491d3fc5e442c3162a277bd37e00f"

URI_x86_64_v2_rust-snafu+rust_1_61-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+rust_1_61-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+rust_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+rust_1_61-devel}"
SRC_URI[x86_64_v2_rust-snafu+rust_1_61-devel.sha256sum] = "66ecb46312f7035138a2530d026e67516cb8811e2ce753351e879e7e35be9ded"

URI_x86_64_v2_rust-snafu+rust_1_65-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+rust_1_65-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+rust_1_65-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+rust_1_65-devel}"
SRC_URI[x86_64_v2_rust-snafu+rust_1_65-devel.sha256sum] = "2c0cc5699b93ecd7ecb3b3cb8103fa484bb1357a0f9b05de65c36280b987a0c2"

URI_x86_64_v2_rust-snafu+rust_1_81-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+rust_1_81-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+rust_1_81-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+rust_1_81-devel}"
SRC_URI[x86_64_v2_rust-snafu+rust_1_81-devel.sha256sum] = "cb4cccdda8de9b7a05fa839a39882ee6fc4d5fd9f41d736c187b20384dbb19a7"

URI_x86_64_v2_rust-snafu+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+std-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+std-devel}"
SRC_URI[x86_64_v2_rust-snafu+std-devel.sha256sum] = "46809d21ba6de582550719337e2723d4ac9b89eceaebe6e7ea73f69a9ae85e57"

URI_x86_64_v2_rust-snafu+unstable-core-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+unstable-core-error-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+unstable-core-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+unstable-core-error-devel}"
SRC_URI[x86_64_v2_rust-snafu+unstable-core-error-devel.sha256sum] = "bd05bfd7315017705e055acaa0905fa6f829e461d427fa9dfd40f133f95439d9"

URI_x86_64_v2_rust-snafu+unstable-provider-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+unstable-provider-api-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+unstable-provider-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+unstable-provider-api-devel}"
SRC_URI[x86_64_v2_rust-snafu+unstable-provider-api-devel.sha256sum] = "91fb8afc1c87bc7b6467be907f7043bf70ccfd573ebf8cf201d83c09de5a8721"

URI_x86_64_v2_rust-snafu+unstable-try-trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+unstable-try-trait-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+unstable-try-trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+unstable-try-trait-devel}"
SRC_URI[x86_64_v2_rust-snafu+unstable-try-trait-devel.sha256sum] = "4cd506a1f897b6d59dd96a55f73d58a086278858b804b7c3ba844fa8a28636ff"

URI_x86_64_v2_rust-snafu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-devel}"
SRC_URI[x86_64_v2_rust-snafu-devel.sha256sum] = "1463cd2c25fa3e8d962983992e71ecc376b6ae1885337ebee73829f18c3075dd"

URI_aarch64_rust-snafu+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+alloc-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+alloc-devel}"
SRC_URI[aarch64_rust-snafu+alloc-devel.sha256sum] = "faca5408632f3678f6032c6e4ec3389e46bc1fabaaf2349d902e2cf663d45132"

URI_aarch64_rust-snafu+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+backtrace-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+backtrace-devel}"
SRC_URI[aarch64_rust-snafu+backtrace-devel.sha256sum] = "737e158289edb34d24c01aabb8cb52628ff15504d38ea2fffa9fb433ed5cfd8f"

URI_aarch64_rust-snafu+backtraces-impl-backtrace-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+backtraces-impl-backtrace-crate-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+backtraces-impl-backtrace-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+backtraces-impl-backtrace-crate-devel}"
SRC_URI[aarch64_rust-snafu+backtraces-impl-backtrace-crate-devel.sha256sum] = "6fa4ba264c4045bf23f2a3f36876d514d95e01ee2870d5716c2247a6310493bf"

URI_aarch64_rust-snafu+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+default-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+default-devel}"
SRC_URI[aarch64_rust-snafu+default-devel.sha256sum] = "23c1393acdb11f61f2cd4ee6a412610dc87d894489fdcf41d3181b12ea09391a"

URI_aarch64_rust-snafu+futures-core-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+futures-core-crate-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+futures-core-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+futures-core-crate-devel}"
SRC_URI[aarch64_rust-snafu+futures-core-crate-devel.sha256sum] = "a7b71a460c8b7dc8f670daed216d2e62e1bff1c3e2f501fe241dc6e29e9c16f8"

URI_aarch64_rust-snafu+futures-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+futures-crate-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+futures-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+futures-crate-devel}"
SRC_URI[aarch64_rust-snafu+futures-crate-devel.sha256sum] = "932d224e511643c0d311845a26bf86dfc84b77509eb24c535e34e33517431743"

URI_aarch64_rust-snafu+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+futures-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+futures-devel}"
SRC_URI[aarch64_rust-snafu+futures-devel.sha256sum] = "dfcbc1e7de4d2c16e9808bd1eef79459a391c14cd9cb7f9d8d39830528432e35"

URI_aarch64_rust-snafu+guide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+guide-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+guide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+guide-devel}"
SRC_URI[aarch64_rust-snafu+guide-devel.sha256sum] = "7c54135fa5548b81f890fb692897912358a05016048615f499268db8fd05ba1d"

URI_aarch64_rust-snafu+internal-dev-dependencies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+internal-dev-dependencies-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+internal-dev-dependencies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+internal-dev-dependencies-devel}"
SRC_URI[aarch64_rust-snafu+internal-dev-dependencies-devel.sha256sum] = "dd41b00ef09257c522f6fe3f27f7143099141f25db7b6e62d14ba29f5d968aa3"

URI_aarch64_rust-snafu+pin-project-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+pin-project-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+pin-project-devel}"
SRC_URI[aarch64_rust-snafu+pin-project-devel.sha256sum] = "846188cde530664f2b642019f12468127a3c071a139a03baf8732b51798b18ab"

URI_aarch64_rust-snafu+rust_1_61-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+rust_1_61-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+rust_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+rust_1_61-devel}"
SRC_URI[aarch64_rust-snafu+rust_1_61-devel.sha256sum] = "51b202fd79362da19ec3a14cb8d8100157737b991b1a6acf375d306d9bdd7e24"

URI_aarch64_rust-snafu+rust_1_65-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+rust_1_65-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+rust_1_65-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+rust_1_65-devel}"
SRC_URI[aarch64_rust-snafu+rust_1_65-devel.sha256sum] = "ca0d2d5cd5a74e28806f2d417e4530f346a69b29052117673e7d7e1e9f02e875"

URI_aarch64_rust-snafu+rust_1_81-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+rust_1_81-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+rust_1_81-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+rust_1_81-devel}"
SRC_URI[aarch64_rust-snafu+rust_1_81-devel.sha256sum] = "2a6325ac4b28e7055b1a1c6d6f87607d18ee325d91ad760d33173ec0ff72930b"

URI_aarch64_rust-snafu+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+std-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+std-devel}"
SRC_URI[aarch64_rust-snafu+std-devel.sha256sum] = "0b052ec0d7fc879aee65e0dd6d10f979f5d36a3b7123e475bd8c01c81f51a3b5"

URI_aarch64_rust-snafu+unstable-core-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+unstable-core-error-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+unstable-core-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+unstable-core-error-devel}"
SRC_URI[aarch64_rust-snafu+unstable-core-error-devel.sha256sum] = "17cbef68b30b712bfdfa8b1f16b1e1625aad120ab504c11f4d8a7a760c409a24"

URI_aarch64_rust-snafu+unstable-provider-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+unstable-provider-api-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+unstable-provider-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+unstable-provider-api-devel}"
SRC_URI[aarch64_rust-snafu+unstable-provider-api-devel.sha256sum] = "1924856b483ba08f1d0438f0fb334f65388a9857ab36f4d5527f911d539628e3"

URI_aarch64_rust-snafu+unstable-try-trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+unstable-try-trait-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu+unstable-try-trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+unstable-try-trait-devel}"
SRC_URI[aarch64_rust-snafu+unstable-try-trait-devel.sha256sum] = "8177f5e6ba891808df60eef686428969b6d3e5279d82923e4eeef63696993e55"

URI_aarch64_rust-snafu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-devel}"
SRC_URI[aarch64_rust-snafu-devel.sha256sum] = "ab02116736b1c5e9afce3b18b726923d20ea67338e7953b78fb80d004f27c459"

RDEPENDS:rust-snafu+alloc-devel = " \
 cargo \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+backtraces-impl-backtrace-crate-devel = " \
 cargo \
 rust-snafu+backtrace-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+default-devel = " \
 cargo \
 rust-snafu+rust_1_65-devel \
 rust-snafu+std-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+futures-core-crate-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+futures-crate-devel = " \
 cargo \
 rust-futures-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+futures-devel = " \
 cargo \
 rust-snafu+futures-core-crate-devel \
 rust-snafu+pin-project-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+guide-devel = " \
 cargo \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+internal-dev-dependencies-devel = " \
 cargo \
 rust-snafu+futures-crate-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+pin-project-devel = " \
 cargo \
 rust-pin-project-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+rust_1_61-devel = " \
 cargo \
 rust-snafu-derive+rust_1_61-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+rust_1_65-devel = " \
 cargo \
 rust-snafu+rust_1_61-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+rust_1_81-devel = " \
 cargo \
 rust-snafu+rust_1_65-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+std-devel = " \
 cargo \
 rust-snafu+alloc-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+unstable-core-error-devel = " \
 cargo \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+unstable-provider-api-devel = " \
 cargo \
 rust-snafu-derive+unstable-provider-api-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+unstable-try-trait-devel = " \
 cargo \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu-devel = " \
 bash \
 cargo \
 rust \
 rust-snafu-derive+default-devel \
 "
