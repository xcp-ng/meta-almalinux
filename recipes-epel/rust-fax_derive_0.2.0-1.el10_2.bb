# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fax_derive"
PV = "0.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-fax_derive+default-devel \
 rust-fax_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fax_derive-0.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e7dd475984a03504e44c0c82562daad349a883825a4d0a2fd4829fd3ca74046"

URI_x86_64_v2_rust-fax_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fax_derive+default-devel-0.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fax_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fax_derive+default-devel}"
SRC_URI[x86_64_v2_rust-fax_derive+default-devel.sha256sum] = "45319940db8e5f0c6dc7073b28f10fdd097dff62d183defc55bf0d51f87ae899"

URI_x86_64_v2_rust-fax_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fax_derive-devel-0.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fax_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fax_derive-devel}"
SRC_URI[x86_64_v2_rust-fax_derive-devel.sha256sum] = "acbac9f18f6c20ff21c580d5c1dd08c50bdf085a7b9f58eaadb266beb5f1bccd"

URI_aarch64_rust-fax_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fax_derive+default-devel-0.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-fax_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fax_derive+default-devel}"
SRC_URI[aarch64_rust-fax_derive+default-devel.sha256sum] = "bfdb2ab8a535957d61489f8f169c75309d34c432925a694da04520337351cc29"

URI_aarch64_rust-fax_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fax_derive-devel-0.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-fax_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fax_derive-devel}"
SRC_URI[aarch64_rust-fax_derive-devel.sha256sum] = "0f6d0decf5fa45718fc3883c78841261be90dbfa5ee81c00cb2aacb3a005b2a8"

RDEPENDS:rust-fax_derive+default-devel = " \
 cargo \
 rust-fax_derive-devel \
 "
RDEPENDS:rust-fax_derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
