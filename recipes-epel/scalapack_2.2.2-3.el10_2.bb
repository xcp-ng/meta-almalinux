# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scalapack"
PV = "2.2.2"
PR = "3.el10_2"
PACKAGES = " \
 scalapack-common \
 scalapack-mpich \
 scalapack-mpich-devel \
 scalapack-mpich-static \
 scalapack-openmpi \
 scalapack-openmpi-devel \
 scalapack-openmpi-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scalapack-2.2.2-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99f86fdff6478cecc1c34fb79df8bcd1aa6e035bc250557019804ecf4534bb30"

URI_x86_64_v2_scalapack-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-common-2.2.2-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-common}"
SRC_URI[x86_64_v2_scalapack-common.sha256sum] = "c361a51f183b406727d2120724dc9722a16c494a65bc37b8644ed9a96fb537b9"

URI_x86_64_v2_scalapack-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-mpich-2.2.2-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-mpich}"
SRC_URI[x86_64_v2_scalapack-mpich.sha256sum] = "def3b0270b998ef2efbf7fcfe73131664a34f1653c996ed61c855866804ae7cd"

URI_x86_64_v2_scalapack-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-mpich-devel-2.2.2-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-mpich-devel}"
SRC_URI[x86_64_v2_scalapack-mpich-devel.sha256sum] = "b849d0f98b372ab20ec7d651da7e7486ccde303f9b552e4e2cff2e63abd3998e"

URI_x86_64_v2_scalapack-mpich-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-mpich-static-2.2.2-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-mpich-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-mpich-static}"
SRC_URI[x86_64_v2_scalapack-mpich-static.sha256sum] = "a6a32ab8e2773a4da3fabda47722fb8f72288511943ef17177d697db179048c3"

URI_x86_64_v2_scalapack-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-openmpi-2.2.2-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-openmpi}"
SRC_URI[x86_64_v2_scalapack-openmpi.sha256sum] = "d73ac8eb2e8ba4b617c0434cb5bb87216c9fd2a61e6794dcfc0409e051c4dd97"

URI_x86_64_v2_scalapack-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-openmpi-devel-2.2.2-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-openmpi-devel}"
SRC_URI[x86_64_v2_scalapack-openmpi-devel.sha256sum] = "a4741af2c90b4a6aa282b393c07bf9f9f9009cfc8233ecbaf6224eeea73fcefb"

URI_x86_64_v2_scalapack-openmpi-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-openmpi-static-2.2.2-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-openmpi-static}"
SRC_URI[x86_64_v2_scalapack-openmpi-static.sha256sum] = "479d175818c09292b161fa5acfd837153a16a6c81cdad249bdd27b41b24e663b"

URI_aarch64_scalapack-common = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-common-2.2.2-3.el10_2.aarch64.rpm;name=aarch64_scalapack-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-common}"
SRC_URI[aarch64_scalapack-common.sha256sum] = "781ab6aa5c4ad9fd6b3e942b68d4fe55778f68adc8806f584f06ea66f87f6d18"

URI_aarch64_scalapack-mpich = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-mpich-2.2.2-3.el10_2.aarch64.rpm;name=aarch64_scalapack-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-mpich}"
SRC_URI[aarch64_scalapack-mpich.sha256sum] = "6b5fb575e9a64f00591b27e001717fa02016f0e4272dea262255117471270ace"

URI_aarch64_scalapack-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-mpich-devel-2.2.2-3.el10_2.aarch64.rpm;name=aarch64_scalapack-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-mpich-devel}"
SRC_URI[aarch64_scalapack-mpich-devel.sha256sum] = "3103ac5bcaa81d3d78640a493d386d3a8bf5cdae6693210dc48609a6aaf94c94"

URI_aarch64_scalapack-mpich-static = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-mpich-static-2.2.2-3.el10_2.aarch64.rpm;name=aarch64_scalapack-mpich-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-mpich-static}"
SRC_URI[aarch64_scalapack-mpich-static.sha256sum] = "482b3a3c0b73ac9bac7080a2acd037ddabe0280cc9dfad39e221c8a25a70bf81"

URI_aarch64_scalapack-openmpi = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-openmpi-2.2.2-3.el10_2.aarch64.rpm;name=aarch64_scalapack-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-openmpi}"
SRC_URI[aarch64_scalapack-openmpi.sha256sum] = "cfc7ed0f3c03ac97ebfdfee0ee98684fc9b37bf043523c12d0ea0a31db14ae7c"

URI_aarch64_scalapack-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-openmpi-devel-2.2.2-3.el10_2.aarch64.rpm;name=aarch64_scalapack-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-openmpi-devel}"
SRC_URI[aarch64_scalapack-openmpi-devel.sha256sum] = "19639abefd786fbb3b61386d5583c9400a765550a82bf0d2500d99f767f41f32"

URI_aarch64_scalapack-openmpi-static = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-openmpi-static-2.2.2-3.el10_2.aarch64.rpm;name=aarch64_scalapack-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-openmpi-static}"
SRC_URI[aarch64_scalapack-openmpi-static.sha256sum] = "e5069bb8df8bf6692438f5f14f189ee991b0a39b05790fef9c966a662fc2fc09"

RDEPENDS:scalapack-common = " \
 cmake-filesystem \
 "
RDEPENDS:scalapack-mpich = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 mpich \
 scalapack-common \
 "
RDEPENDS:scalapack-mpich-devel = " \
 mpich-devel \
 scalapack-mpich \
 "
RDEPENDS:scalapack-mpich-static = " \
 scalapack-mpich-devel \
 "
RDEPENDS:scalapack-openmpi = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 openmpi \
 scalapack-common \
 "
RDEPENDS:scalapack-openmpi-devel = " \
 openmpi-devel \
 scalapack-openmpi \
 "
RDEPENDS:scalapack-openmpi-static = " \
 scalapack-openmpi-devel \
 "
