# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-pretty-terminal"
PV = "0.1.0.0"
PR = "15.el10_0"
PACKAGES = " \
 ghc-pretty-terminal \
 ghc-pretty-terminal-devel \
 ghc-pretty-terminal-doc \
 ghc-pretty-terminal-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-pretty-terminal-0.1.0.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4eb4ce1a282b61e636b1e468ec0fe9c16cee5c5f4ed676b2272db27717bcda2"

URI_x86_64_v2_ghc-pretty-terminal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pretty-terminal-0.1.0.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pretty-terminal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pretty-terminal}"
SRC_URI[x86_64_v2_ghc-pretty-terminal.sha256sum] = "a77efdd8a88511c2e38b008483b8ab652c7713218352a75b293e7fc52958f196"

URI_x86_64_v2_ghc-pretty-terminal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pretty-terminal-devel-0.1.0.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pretty-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pretty-terminal-devel}"
SRC_URI[x86_64_v2_ghc-pretty-terminal-devel.sha256sum] = "8ccac82cffa24b2ff7ee953f23a813a180540fe3f362d6fc7caee0b3dd30ef74"

URI_x86_64_v2_ghc-pretty-terminal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pretty-terminal-doc-0.1.0.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pretty-terminal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pretty-terminal-doc}"
SRC_URI[x86_64_v2_ghc-pretty-terminal-doc.sha256sum] = "b5b1a2fbdbdcf60dbdc97b18292f96353cb0fdc2466dc15ad6b92e89e43a424b"

URI_x86_64_v2_ghc-pretty-terminal-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pretty-terminal-prof-0.1.0.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pretty-terminal-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pretty-terminal-prof}"
SRC_URI[x86_64_v2_ghc-pretty-terminal-prof.sha256sum] = "98f173f67454c99c19859f5533eb5bc1c030d847d119ec6c4474ab47aec25983"

URI_aarch64_ghc-pretty-terminal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pretty-terminal-0.1.0.0-15.el10_0.aarch64.rpm;name=aarch64_ghc-pretty-terminal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pretty-terminal}"
SRC_URI[aarch64_ghc-pretty-terminal.sha256sum] = "d2456a1cc3a70c694d1129f5ac4980ed11742f6be68fe71553372c1952cf1a60"

URI_aarch64_ghc-pretty-terminal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pretty-terminal-devel-0.1.0.0-15.el10_0.aarch64.rpm;name=aarch64_ghc-pretty-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pretty-terminal-devel}"
SRC_URI[aarch64_ghc-pretty-terminal-devel.sha256sum] = "167f70d54c1119c840268c5f6abdef66a4f6e35a2583b36b283cb8390acaf6dc"

URI_aarch64_ghc-pretty-terminal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pretty-terminal-doc-0.1.0.0-15.el10_0.noarch.rpm;name=aarch64_ghc-pretty-terminal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pretty-terminal-doc}"
SRC_URI[aarch64_ghc-pretty-terminal-doc.sha256sum] = "4121b2667408df392ef749eb246e3c5f6a29bbe7b2c86e015db07bd3011bf7f7"

URI_aarch64_ghc-pretty-terminal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pretty-terminal-prof-0.1.0.0-15.el10_0.aarch64.rpm;name=aarch64_ghc-pretty-terminal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pretty-terminal-prof}"
SRC_URI[aarch64_ghc-pretty-terminal-prof.sha256sum] = "4c417bed297553c2c815aa713a2d246c4b0be4af44e6268259f519a5ca5cdd52"

RDEPENDS:ghc-pretty-terminal = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-pretty-terminal-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-pretty-terminal \
 ghc-text-devel \
 "
RDEPENDS:ghc-pretty-terminal-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pretty-terminal-prof = " \
 ghc-base-prof \
 ghc-pretty-terminal-devel \
 ghc-text-prof \
 "
