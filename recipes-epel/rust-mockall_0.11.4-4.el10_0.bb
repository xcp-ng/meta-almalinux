# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mockall"
PV = "0.11.4"
PR = "4.el10_0"
PACKAGES = " \
 rust-mockall+default-devel \
 rust-mockall-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mockall-0.11.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6cc9ca9ae76bb4fbcf67a13cdf3aa6ae93fa605e346ff26d1a3bf702f5380f5"

URI_x86_64_v2_rust-mockall+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockall+default-devel-0.11.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockall+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockall+default-devel}"
SRC_URI[x86_64_v2_rust-mockall+default-devel.sha256sum] = "e59921d055ce25a217965a255c944ede33b87ca354e95f2125a157ade1ee8c2f"

URI_x86_64_v2_rust-mockall-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockall-devel-0.11.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockall-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockall-devel}"
SRC_URI[x86_64_v2_rust-mockall-devel.sha256sum] = "be7ad1256da8d3cc9927fe41901c7f1ba62191dae45253f92cb9fb82cb2befe4"

URI_aarch64_rust-mockall+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockall+default-devel-0.11.4-4.el10_0.noarch.rpm;name=aarch64_rust-mockall+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockall+default-devel}"
SRC_URI[aarch64_rust-mockall+default-devel.sha256sum] = "4870445bc3746faf1e89311e543e1b1ad9c2cfd1e9ccd39ed0d01cf3ad535a82"

URI_aarch64_rust-mockall-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockall-devel-0.11.4-4.el10_0.noarch.rpm;name=aarch64_rust-mockall-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockall-devel}"
SRC_URI[aarch64_rust-mockall-devel.sha256sum] = "28c1678ea83c5378a11541597aa7ba71989f9957bc6e1b13654e24ba925cba15"

RDEPENDS:rust-mockall+default-devel = " \
 cargo \
 rust-mockall-devel \
 "
RDEPENDS:rust-mockall-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-downcast+default-devel \
 rust-fragile+default-devel \
 rust-lazy_static+default-devel \
 rust-mockall_derive+default-devel \
 rust-predicates-tree+default-devel \
 rust-predicates2+default-devel \
 "
