# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vim"
PE = "2"
PV = "9.1.083"
PR = "23.el10"
PACKAGES = " \
 vim-X11 \
 vim-common \
 vim-data \
 vim-enhanced \
 vim-filesystem \
 vim-minimal \
 xxd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/vim-9.1.083-23.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "daac17d5689ce93889d061166b0d3910e7025bc4e2152ea95ca7c19ab15a813a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-X11-9.1.083-23.el10.x86_64_v2.rpm;name=x86_64_v2_vim-X11;unpack=0"
SRC_URI[x86_64_v2_vim-X11.sha256sum] = "7106e2ffe13bbe021e51759fd70184c86ba4e5fb06a88cb354f9d46c96edaa93"
RPROVIDES:vim-X11:append:x86_64_v2 = " virtual/vim-enhanced_or_vim-X11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-common-9.1.083-23.el10.x86_64_v2.rpm;name=x86_64_v2_vim-common;unpack=0"
SRC_URI[x86_64_v2_vim-common.sha256sum] = "9b065a58ecd54c61a246f3d73b520bec76c6ba24fd6471673caf9f7f77144065"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-data-9.1.083-23.el10.noarch.rpm;name=x86_64_v2_vim-data;unpack=0"
SRC_URI[x86_64_v2_vim-data.sha256sum] = "81c90dbc31733ec48125818f8e49fbc19ec6d571d0a16b137b7a9febbd5ca3c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-enhanced-9.1.083-23.el10.x86_64_v2.rpm;name=x86_64_v2_vim-enhanced;unpack=0"
SRC_URI[x86_64_v2_vim-enhanced.sha256sum] = "f63de74e6cd9e6f70385d98207d87f7224533dbda621ec5cd52c5cbe8b4ebad2"
RPROVIDES:vim-enhanced:append:x86_64_v2 = " virtual/vim-enhanced_or_vim-X11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-filesystem-9.1.083-23.el10.noarch.rpm;name=x86_64_v2_vim-filesystem;unpack=0"
SRC_URI[x86_64_v2_vim-filesystem.sha256sum] = "807f1feaf6501cca4ea0289ddf24f4a11a5ace60dc445de45d0fb8f7a6f3e3e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-minimal-9.1.083-23.el10.x86_64_v2.rpm;name=x86_64_v2_vim-minimal;unpack=0"
SRC_URI[x86_64_v2_vim-minimal.sha256sum] = "b73c2b2c6239bd9d96cd81cacd216ee2a2e89315ea2fc2c1713f6742aad29126"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xxd-9.1.083-23.el10.x86_64_v2.rpm;name=x86_64_v2_xxd;unpack=0"
SRC_URI[x86_64_v2_xxd.sha256sum] = "fe12a314558e7c150b8c6d57ee183a6ec7cbbd0809a84db857ab170cf028284b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-X11-9.1.083-23.el10.aarch64.rpm;name=aarch64_vim-X11;unpack=0"
SRC_URI[aarch64_vim-X11.sha256sum] = "d56d831d718cd91172ac499ef4591861cbd46678506aedb5906f5f2760e1d2ff"
RPROVIDES:vim-X11:append:aarch64 = " virtual/vim-enhanced_or_vim-X11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-common-9.1.083-23.el10.aarch64.rpm;name=aarch64_vim-common;unpack=0"
SRC_URI[aarch64_vim-common.sha256sum] = "18624a4b1bb23a9e06fdc6b057bd34ffacbad052d996b6f34da3e9285493871a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-data-9.1.083-23.el10.noarch.rpm;name=aarch64_vim-data;unpack=0"
SRC_URI[aarch64_vim-data.sha256sum] = "81c90dbc31733ec48125818f8e49fbc19ec6d571d0a16b137b7a9febbd5ca3c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-enhanced-9.1.083-23.el10.aarch64.rpm;name=aarch64_vim-enhanced;unpack=0"
SRC_URI[aarch64_vim-enhanced.sha256sum] = "404398d10dd256cefb8a6f06566ddf06cfc85f05f4322828b6508d449ea62490"
RPROVIDES:vim-enhanced:append:aarch64 = " virtual/vim-enhanced_or_vim-X11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-filesystem-9.1.083-23.el10.noarch.rpm;name=aarch64_vim-filesystem;unpack=0"
SRC_URI[aarch64_vim-filesystem.sha256sum] = "807f1feaf6501cca4ea0289ddf24f4a11a5ace60dc445de45d0fb8f7a6f3e3e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-minimal-9.1.083-23.el10.aarch64.rpm;name=aarch64_vim-minimal;unpack=0"
SRC_URI[aarch64_vim-minimal.sha256sum] = "8916a6a0f929d7edf339891c2e49e711a63e1115e17bab1bc78c720dd9f2e973"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xxd-9.1.083-23.el10.aarch64.rpm;name=aarch64_xxd;unpack=0"
SRC_URI[aarch64_xxd.sha256sum] = "24a45353e23243020c467344a63cc5153e9f6be92434dcff4e76835bf783fde7"

RDEPENDS:vim-X11 = " \
 bash \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libICE \
 libSM \
 libX11 \
 libXt \
 libacl \
 libattr \
 libcanberra \
 libselinux \
 ncurses-libs \
 pango \
 vim-common \
 "
RDEPENDS:vim-common = " \
 bash \
 vim-data \
 vim-filesystem \
 xxd \
 "
RDEPENDS:vim-data = " \
 "
RDEPENDS:vim-enhanced = " \
 bash \
 glibc \
 libacl \
 libselinux \
 ncurses-libs \
 vim-common \
 which \
 "
RDEPENDS:vim-filesystem = " \
 "
RDEPENDS:vim-minimal = " \
 bash \
 glibc \
 libacl \
 libselinux \
 ncurses-libs \
 vim-data \
 "
RDEPENDS:xxd = " \
 glibc \
 "
