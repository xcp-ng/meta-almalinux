# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skladnik"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 skladnik \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/skladnik-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b8355388b7f7d6f420d3f3fe3edc22e708a0d74f6bc6d68d62bdf37f4fa7f19d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/skladnik-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_skladnik;unpack=0"
SRC_URI[x86_64_v2_skladnik.sha256sum] = "b0ed985ffac18b6effb5e9058bc67ebe1ff744079514b9ee6bd3d7474d1346ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/skladnik-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_skladnik;unpack=0"
SRC_URI[aarch64_skladnik.sha256sum] = "109599128da1a451b80a21ed00f22ef0256f67adc59ffe75735fa3d4aa7cebb3"

RDEPENDS:skladnik = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
