# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "QXlsx"
PV = "1.4.10"
PR = "5.el10_2"
PACKAGES = " \
 QXlsx \
 QXlsx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/QXlsx-1.4.10-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f8fcfd5c51338a615e0ccf2be7e52886e949926b1ed5f1ab9f3ab5fef8f6024"

URI_x86_64_v2_QXlsx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/QXlsx-1.4.10-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_QXlsx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_QXlsx}"
SRC_URI[x86_64_v2_QXlsx.sha256sum] = "0e441995943a315937a3a84fcbbdf390239811db41b715317e5abfbe07d12656"

URI_x86_64_v2_QXlsx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/QXlsx-devel-1.4.10-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_QXlsx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_QXlsx-devel}"
SRC_URI[x86_64_v2_QXlsx-devel.sha256sum] = "15539119115789da9df7ecc915256af271a391d08926b00d431b0d8256dddc9a"

URI_aarch64_QXlsx = "${EPEL_MIRROR}/aarch64/Packages/q/QXlsx-1.4.10-5.el10_2.aarch64.rpm;name=aarch64_QXlsx;unpack=0"
SRC_URI:append = " ${URI_aarch64_QXlsx}"
SRC_URI[aarch64_QXlsx.sha256sum] = "779c0fdcb60cbfd723e7b7e897fa886432ef670f75be7b9bc95730f2b312880c"

URI_aarch64_QXlsx-devel = "${EPEL_MIRROR}/aarch64/Packages/q/QXlsx-devel-1.4.10-5.el10_2.aarch64.rpm;name=aarch64_QXlsx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_QXlsx-devel}"
SRC_URI[aarch64_QXlsx-devel.sha256sum] = "3e7c3cadf71f588f894c752c58b2ee82e5421af990c0cae788a2baf8783945bb"

RDEPENDS:QXlsx = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:QXlsx-devel = " \
 QXlsx \
 cmake-filesystem \
 "
