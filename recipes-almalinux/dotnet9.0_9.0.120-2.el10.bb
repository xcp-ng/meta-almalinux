# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet9.0"
PV = "9.0.120"
PR = "2.el10"
PACKAGES = " \
 aspnetcore-runtime-9.0 \
 aspnetcore-runtime-dbg-9.0 \
 aspnetcore-targeting-pack-9.0 \
 dotnet-apphost-pack-9.0 \
 dotnet-hostfxr-9.0 \
 dotnet-runtime-9.0 \
 dotnet-runtime-dbg-9.0 \
 dotnet-sdk-9.0 \
 dotnet-sdk-9.0-source-built-artifacts \
 dotnet-sdk-aot-9.0 \
 dotnet-sdk-dbg-9.0 \
 dotnet-targeting-pack-9.0 \
 dotnet-templates-9.0 \
 netstandard-targeting-pack-2.1 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet9.0-9.0.120-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ae6eaa005eabeb3a2a8e802a8a0b9c273ac92efeede079bd02e149b851066cb9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-9.0-9.0.19-2.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-9.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-runtime-9.0.sha256sum] = "33929ba57923d3de3a10c36458d45330bcacf85bcb669bef39fd2bc26d6455f5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-9.0-9.0.19-2.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-9.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-9.0.sha256sum] = "b6fe4bcf1e6f7b45013a2379d891e4afcd4352ed6410b89c3acd1c76410c058a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-9.0-9.0.19-2.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-9.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-9.0.sha256sum] = "e0ec20c5a623c0fc0c33b50c9e2c422180710d9b07bbe7dc0d993d0f4f5bd553"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-9.0-9.0.19-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-apphost-pack-9.0.sha256sum] = "225252bee6d033e24d177f43b31c7446d7f42e2e554744ab9b8e9c94bb6153c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-9.0-9.0.19-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-hostfxr-9.0.sha256sum] = "dfe552043db934e20c6c41574396592577419b0625cfae9f9c58a0827a1a1b9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-9.0-9.0.19-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-runtime-9.0.sha256sum] = "be7104a01543bd596847daca37f0469fb56830af34ed954cdc180ea98b6e7a40"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-9.0-9.0.19-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-9.0.sha256sum] = "e8c3c00a3a66c43529c0262f25b0e051a2679f56fd60c4db9d8ea9ec9d61eb83"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-9.0-9.0.120-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-9.0.sha256sum] = "d4ba826b9f402ac87eb5e9d48405c08132fca7a6915f5a2a28e3290849c7d782"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-9.0-source-built-artifacts-9.0.120-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-9.0-source-built-artifacts;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-9.0-source-built-artifacts.sha256sum] = "84155ebfba337e09c2063a41dfb267e5d111d059e20f924e8eb3caee70f9f217"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-aot-9.0-9.0.120-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-aot-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-aot-9.0.sha256sum] = "6f832056e4bf147df1f474fa45581ab70a7953494f7128eb07f30c3270aa03db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-9.0-9.0.120-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-9.0.sha256sum] = "1a312d10ae0159f36610026e557983cdaf0cff36f8e1ab825896143d69ec6eca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-9.0-9.0.19-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-targeting-pack-9.0.sha256sum] = "62465c06f84f33b5eb6db8f5da58a2676d934205635f0f49ef627abbcf308852"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-9.0-9.0.120-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-templates-9.0.sha256sum] = "877cf8df9d4c97ffe10b27d73719163fcc6b5a91e5c3fd7da21d46955163c4a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/netstandard-targeting-pack-2.1-9.0.120-2.el10.x86_64_v2.rpm;name=x86_64_v2_netstandard-targeting-pack-2.1;unpack=0"
SRC_URI[x86_64_v2_netstandard-targeting-pack-2.1.sha256sum] = "5be482973f2ecdfb1536994c4ccc205963d13281411a01c5482e11e57d76db56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-9.0-9.0.19-2.el10.aarch64.rpm;name=aarch64_aspnetcore-runtime-9.0;unpack=0"
SRC_URI[aarch64_aspnetcore-runtime-9.0.sha256sum] = "c8fbb28ce203943dca999fee81881e4d009ec254d19c01cbbaaae80057633d60"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-9.0-9.0.19-2.el10.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-9.0;unpack=0"
SRC_URI[aarch64_aspnetcore-runtime-dbg-9.0.sha256sum] = "527a813f0a789557df6529230fa006feeee47ecab915dabaa6c7260b93b4a811"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-9.0-9.0.19-2.el10.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-9.0;unpack=0"
SRC_URI[aarch64_aspnetcore-targeting-pack-9.0.sha256sum] = "0999b96cff3e3f679f6a2ad4b7fc639dd5c58dc2a507cdc7ac80ef5b48234086"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-9.0-9.0.19-2.el10.aarch64.rpm;name=aarch64_dotnet-apphost-pack-9.0;unpack=0"
SRC_URI[aarch64_dotnet-apphost-pack-9.0.sha256sum] = "25dbfef477059f7039f38d7b63e444cb826684dfe1aee8e62e39750cac3f806c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-9.0-9.0.19-2.el10.aarch64.rpm;name=aarch64_dotnet-hostfxr-9.0;unpack=0"
SRC_URI[aarch64_dotnet-hostfxr-9.0.sha256sum] = "56fbab1b862672552f64205074427f822f215fb6a8766d7d4419c01b1f583f86"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-9.0-9.0.19-2.el10.aarch64.rpm;name=aarch64_dotnet-runtime-9.0;unpack=0"
SRC_URI[aarch64_dotnet-runtime-9.0.sha256sum] = "93d11296a07bd9c007ee885a6bb347d5c5ce947e687754e08b0458d73107a247"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-9.0-9.0.19-2.el10.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-9.0;unpack=0"
SRC_URI[aarch64_dotnet-runtime-dbg-9.0.sha256sum] = "ceb6905365ddc31d20e66dbf72cf862dd9e2e5f277b52db54e97a9160d6eb4cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-9.0-9.0.120-2.el10.aarch64.rpm;name=aarch64_dotnet-sdk-9.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-9.0.sha256sum] = "4255c958ef7fcc40c35cb7d9b5ca44e563bfe73c1eb4c13d3f0f3fbd2271d36f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-9.0-source-built-artifacts-9.0.120-2.el10.aarch64.rpm;name=aarch64_dotnet-sdk-9.0-source-built-artifacts;unpack=0"
SRC_URI[aarch64_dotnet-sdk-9.0-source-built-artifacts.sha256sum] = "d0de04ab176e582005f8ca292f0594766af7a25457dacf3f58b304df73b41a11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-aot-9.0-9.0.120-2.el10.aarch64.rpm;name=aarch64_dotnet-sdk-aot-9.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-aot-9.0.sha256sum] = "a3f8a5a54a5dbfcf77817114efa30d83fbb94926d0eb7fd6ca2ace31d1e5098a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-9.0-9.0.120-2.el10.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-9.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-dbg-9.0.sha256sum] = "28f8c07920c40d828c235d772beed0310230eddac10367b90fbe9b94bcd6b5f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-9.0-9.0.19-2.el10.aarch64.rpm;name=aarch64_dotnet-targeting-pack-9.0;unpack=0"
SRC_URI[aarch64_dotnet-targeting-pack-9.0.sha256sum] = "19e64fa55622c41d264f406fd1b2d063329dd51e48ee90027ed0353d27a1211f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-9.0-9.0.120-2.el10.aarch64.rpm;name=aarch64_dotnet-templates-9.0;unpack=0"
SRC_URI[aarch64_dotnet-templates-9.0.sha256sum] = "0cd01828a6066c695c3884e41c1dd0947df09a2e93a12849001b0499359217ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/netstandard-targeting-pack-2.1-9.0.120-2.el10.aarch64.rpm;name=aarch64_netstandard-targeting-pack-2.1;unpack=0"
SRC_URI[aarch64_netstandard-targeting-pack-2.1.sha256sum] = "f775710d7b70d6e72033a12bf407cc00ee72dd0844bbd1868e64eba5181b1665"

RDEPENDS:aspnetcore-runtime-9.0 = " \
 dotnet-runtime-9.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-9.0 = " \
 aspnetcore-runtime-9.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-9.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-9.0 = " \
 dotnet-host \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-hostfxr-9.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-9.0 = " \
 dotnet-hostfxr-9.0 \
 glibc \
 libbrotli \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-9.0 = " \
 dotnet-runtime-9.0 \
 "
RDEPENDS:dotnet-sdk-9.0 = " \
 aspnetcore-runtime-9.0 \
 aspnetcore-targeting-pack-9.0 \
 dotnet-apphost-pack-9.0 \
 dotnet-runtime-9.0 \
 dotnet-targeting-pack-9.0 \
 dotnet-templates-9.0 \
 glibc \
 libgcc \
 libstdc++ \
 netstandard-targeting-pack-2.1 \
 "
RDEPENDS:dotnet-sdk-9.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-aot-9.0 = " \
 bash \
 brotli-devel \
 clang \
 dotnet-sdk-9.0 \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-devel \
 openssl-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:dotnet-sdk-dbg-9.0 = " \
 dotnet-sdk-9.0 \
 "
RDEPENDS:dotnet-targeting-pack-9.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-9.0 = " \
 dotnet-host \
 "
RDEPENDS:netstandard-targeting-pack-2.1 = " \
 dotnet-host \
 "
