# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3_0.23"
PV = "0.23.5"
PR = "4.el10_1"
PACKAGES = " \
 rust-pyo3_0.23+abi3-devel \
 rust-pyo3_0.23+abi3-py310-devel \
 rust-pyo3_0.23+abi3-py311-devel \
 rust-pyo3_0.23+abi3-py312-devel \
 rust-pyo3_0.23+abi3-py37-devel \
 rust-pyo3_0.23+abi3-py38-devel \
 rust-pyo3_0.23+abi3-py39-devel \
 rust-pyo3_0.23+anyhow-devel \
 rust-pyo3_0.23+auto-initialize-devel \
 rust-pyo3_0.23+chrono-devel \
 rust-pyo3_0.23+chrono-tz-devel \
 rust-pyo3_0.23+default-devel \
 rust-pyo3_0.23+either-devel \
 rust-pyo3_0.23+experimental-async-devel \
 rust-pyo3_0.23+experimental-inspect-devel \
 rust-pyo3_0.23+extension-module-devel \
 rust-pyo3_0.23+eyre-devel \
 rust-pyo3_0.23+full-devel \
 rust-pyo3_0.23+hashbrown-devel \
 rust-pyo3_0.23+indexmap-devel \
 rust-pyo3_0.23+indoc-devel \
 rust-pyo3_0.23+inventory-devel \
 rust-pyo3_0.23+macros-devel \
 rust-pyo3_0.23+multiple-pymethods-devel \
 rust-pyo3_0.23+nightly-devel \
 rust-pyo3_0.23+num-bigint-devel \
 rust-pyo3_0.23+num-complex-devel \
 rust-pyo3_0.23+num-rational-devel \
 rust-pyo3_0.23+py-clone-devel \
 rust-pyo3_0.23+pyo3-macros-devel \
 rust-pyo3_0.23+rust_decimal-devel \
 rust-pyo3_0.23+serde-devel \
 rust-pyo3_0.23+smallvec-devel \
 rust-pyo3_0.23+unindent-devel \
 rust-pyo3_0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3_0.23-0.23.5-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30ffeb424bd082296bb2e7d3c96e12d5c3a9b6828763269bd54626da21314273"

URI_x86_64_v2_rust-pyo3_0.23+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+abi3-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+abi3-devel.sha256sum] = "65608d2aa1a78687eeb489da8f2d7804d8db59e56563e49e50658fda54ed44ee"

URI_x86_64_v2_rust-pyo3_0.23+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+abi3-py310-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+abi3-py310-devel.sha256sum] = "adf7bc3bb6fa3fa3669e2c41f321527a30239dee41e554d19b44eff72de6c637"

URI_x86_64_v2_rust-pyo3_0.23+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+abi3-py311-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+abi3-py311-devel.sha256sum] = "800fc73d182066d84979674a84ccd4408232dabd02be4ba1b3686f9eaa0602ea"

URI_x86_64_v2_rust-pyo3_0.23+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+abi3-py312-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+abi3-py312-devel.sha256sum] = "202a93bc00c1d61a555f2f3d83cc50f88be1b174f32f9c31e7e4b49f05dff3c2"

URI_x86_64_v2_rust-pyo3_0.23+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+abi3-py37-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+abi3-py37-devel.sha256sum] = "43b49254c564e94175a3c70e8cb6e05f3123b3e12f5ef9ae6fdbd4dffbe2662b"

URI_x86_64_v2_rust-pyo3_0.23+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+abi3-py38-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+abi3-py38-devel.sha256sum] = "a1e3dde68dbcce8bfa18a1fcb2fe37ade4f07be05217a05a39b210edb7b70189"

URI_x86_64_v2_rust-pyo3_0.23+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+abi3-py39-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+abi3-py39-devel.sha256sum] = "bbc8dc7d0f22685d1510b889ae7cf8022a9cd267fc99200fdeceaa82c6471738"

URI_x86_64_v2_rust-pyo3_0.23+anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+anyhow-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+anyhow-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+anyhow-devel.sha256sum] = "5c6669efbbe4f166b96b306d88aa279652ee78d085d7a1b678b664194f5e7acf"

URI_x86_64_v2_rust-pyo3_0.23+auto-initialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+auto-initialize-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+auto-initialize-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+auto-initialize-devel.sha256sum] = "b731d3a40bba1c5eeb21d8438adcbfc28b3d0fdd70982f6fcf2e1d6e3c8df150"

URI_x86_64_v2_rust-pyo3_0.23+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+chrono-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+chrono-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+chrono-devel.sha256sum] = "1d4edcdd9d279038f600aa821488a5e2a1f42a60b9b46d1ce52c5ce6c871180c"

URI_x86_64_v2_rust-pyo3_0.23+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+chrono-tz-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+chrono-tz-devel.sha256sum] = "c6328bdf45554874ff0d6be11694ec3bf0ea4fba497de16759d2487a24638c36"

URI_x86_64_v2_rust-pyo3_0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+default-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+default-devel.sha256sum] = "c721271538b2e8402951cc48f5a3ae0ec607f452a0e5b42bbb44fca095c4080f"

URI_x86_64_v2_rust-pyo3_0.23+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+either-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+either-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+either-devel.sha256sum] = "3c361b37a7eb08827c3a4709331dea93289bc49fcf355271d72f97675a34dcd0"

URI_x86_64_v2_rust-pyo3_0.23+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+experimental-async-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+experimental-async-devel.sha256sum] = "f29c3f73e46fd46f62f3e8ab28c7343612f3b73770587fe619cdcc351e987423"

URI_x86_64_v2_rust-pyo3_0.23+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+experimental-inspect-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+experimental-inspect-devel.sha256sum] = "976cd58d162e38fb90ed25a98bb9a561f4d1c1d55ce0b956654b4dae65dc1df7"

URI_x86_64_v2_rust-pyo3_0.23+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+extension-module-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+extension-module-devel.sha256sum] = "45289637ca10290ee0359c2da2a2c0ceebd17d50f852df8826bd27d3a8a5fe8d"

URI_x86_64_v2_rust-pyo3_0.23+eyre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+eyre-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+eyre-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+eyre-devel.sha256sum] = "220ded351674212157accf852cabcf8d9f10e9e7b163400677024f04504a5450"

URI_x86_64_v2_rust-pyo3_0.23+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+full-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+full-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+full-devel.sha256sum] = "97f48aa0f414cf35941e0ae617d9c097b903d23378adc748dcf332f13ae11924"

URI_x86_64_v2_rust-pyo3_0.23+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+hashbrown-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+hashbrown-devel.sha256sum] = "8200e9cce5d6671f5c6eb9289602dd78ad08c050d846927e4a21c9798bc392c0"

URI_x86_64_v2_rust-pyo3_0.23+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+indexmap-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+indexmap-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+indexmap-devel.sha256sum] = "b49ebe787a0ab93be1053cda92d41feebbee91c2f0f79b470f839770f7b9f0df"

URI_x86_64_v2_rust-pyo3_0.23+indoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+indoc-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+indoc-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+indoc-devel.sha256sum] = "744e555f1e2d0819ad69bc1372e9a06fcce129662b903283ce4c279123da8287"

URI_x86_64_v2_rust-pyo3_0.23+inventory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+inventory-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+inventory-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+inventory-devel.sha256sum] = "10ca06cd5e9c76849b236d5b0cb7c850d42cf56269f06f81d60aec6ead548e3e"

URI_x86_64_v2_rust-pyo3_0.23+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+macros-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+macros-devel.sha256sum] = "69f8789e9c7de2b6ed5ef64302f8294fd5da04852fb1a30685641a34a9c4bab5"

URI_x86_64_v2_rust-pyo3_0.23+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+multiple-pymethods-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+multiple-pymethods-devel.sha256sum] = "2aeb4d91a47dcbe6fb1568a621a8063439ed6d330ab9fcf78bbbf0ca803c855a"

URI_x86_64_v2_rust-pyo3_0.23+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+nightly-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+nightly-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+nightly-devel.sha256sum] = "14edd06d1c7994d3dad36cddb293512b86ad45671dedc965cafc271c6247fe35"

URI_x86_64_v2_rust-pyo3_0.23+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+num-bigint-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+num-bigint-devel.sha256sum] = "37f82a57fc960ffd665d2de30c02122149f2456a71ea9167fce9c7f5ab113c91"

URI_x86_64_v2_rust-pyo3_0.23+num-complex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+num-complex-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+num-complex-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+num-complex-devel.sha256sum] = "4d98a4feaf906a8f888274881f02976e8a262c085accecb4273ddafdc84808c2"

URI_x86_64_v2_rust-pyo3_0.23+num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+num-rational-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+num-rational-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+num-rational-devel.sha256sum] = "bf78447546c5e36f2a0fc2aca20d051a224968ae4808a1bf234950536a74dfbf"

URI_x86_64_v2_rust-pyo3_0.23+py-clone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+py-clone-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+py-clone-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+py-clone-devel.sha256sum] = "0f9ec21f673c367464ca5397bf448774d7d3174911d68a3b9de5e62dc0c3030f"

URI_x86_64_v2_rust-pyo3_0.23+pyo3-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+pyo3-macros-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+pyo3-macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+pyo3-macros-devel.sha256sum] = "9973a2a5e282be45c101cdff04a403e1f2d739f81a6fb3ef83e2efff68f853b5"

URI_x86_64_v2_rust-pyo3_0.23+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+rust_decimal-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+rust_decimal-devel.sha256sum] = "ec6cdcdad335e71002f5d2a53694bf9f1dbec5a2e9814062e804c243004c4284"

URI_x86_64_v2_rust-pyo3_0.23+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+serde-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+serde-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+serde-devel.sha256sum] = "4c28acea206d575ae832878d8e1fe2af7e22be38ad556bac392c9455f7bf9614"

URI_x86_64_v2_rust-pyo3_0.23+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+smallvec-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+smallvec-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+smallvec-devel.sha256sum] = "301e25e3be8b23c85583a2677f1f8f13d058942f51394329654b0db2c1cca400"

URI_x86_64_v2_rust-pyo3_0.23+unindent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+unindent-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23+unindent-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23+unindent-devel.sha256sum] = "047121f9482d474df05f45dc9c5fbed28cf14d1c3bbc32ca72c08375ecdf39ff"

URI_x86_64_v2_rust-pyo3_0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23-devel-0.23.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.23-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.23-devel.sha256sum] = "e00cab5d0f07368b5cb600f4f2273ffdf8be977735c043c3b53131459c348e7b"

URI_aarch64_rust-pyo3_0.23+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+abi3-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+abi3-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+abi3-devel.sha256sum] = "56365e3b68a5844814a0a015ed1bc0206d85bcc767f309485018f4d5c58d88bb"

URI_aarch64_rust-pyo3_0.23+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+abi3-py310-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+abi3-py310-devel.sha256sum] = "148f780d370ac5aa905f8ac90dac368615c0ff916fa18b4be653dfa36ae9a0e9"

URI_aarch64_rust-pyo3_0.23+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+abi3-py311-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+abi3-py311-devel.sha256sum] = "afd461a80719d7582a62cf4078446ea746e3104a8010a22eb0fbd4d78df29b5f"

URI_aarch64_rust-pyo3_0.23+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+abi3-py312-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+abi3-py312-devel.sha256sum] = "fba31abf5ec9adc53f6ccb66a3421919f000f3812420c0c5de09da8aabeaa8ca"

URI_aarch64_rust-pyo3_0.23+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+abi3-py37-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+abi3-py37-devel.sha256sum] = "9d86d16baa97cfde68c18046c44f3ba7ae6540d92b6c81bbe51000b0a0071375"

URI_aarch64_rust-pyo3_0.23+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+abi3-py38-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+abi3-py38-devel.sha256sum] = "c493e2052a8cb9410ba089168b09621ec7e48ec2d72b44865800850a77179e91"

URI_aarch64_rust-pyo3_0.23+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+abi3-py39-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+abi3-py39-devel.sha256sum] = "5e7bbc07642014717a6117ce90b8bf2c5f2d301669e4b03af36e4d7c6c26aa22"

URI_aarch64_rust-pyo3_0.23+anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+anyhow-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+anyhow-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+anyhow-devel.sha256sum] = "7aaa1b91412cb240c8a0638946924721501bc2c357b0f5f62851a31e44b4c802"

URI_aarch64_rust-pyo3_0.23+auto-initialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+auto-initialize-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+auto-initialize-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+auto-initialize-devel.sha256sum] = "b03890db14a26bfde0f9b0788e290f5044b3be8a9e583dce1732e39ce8ff30f8"

URI_aarch64_rust-pyo3_0.23+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+chrono-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+chrono-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+chrono-devel.sha256sum] = "35a52f684c87ad1352f7b42f2f5dd8d5ac054ffd9fc3058a2e01c0f73c595c19"

URI_aarch64_rust-pyo3_0.23+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+chrono-tz-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+chrono-tz-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+chrono-tz-devel.sha256sum] = "d40ca123f30d94b50d627de71acc838c9b429113103e3c2194247c3289b0c7bf"

URI_aarch64_rust-pyo3_0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+default-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+default-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+default-devel.sha256sum] = "2f2dd187df14241a6490d3af7442a0c3c3e7a5b5de604d50960ea6c2c2f51622"

URI_aarch64_rust-pyo3_0.23+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+either-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+either-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+either-devel.sha256sum] = "5d7afd35bd3d36a5cf6f7f657f47cd2395dd8e8cbbc4e5da843482a09e66bca2"

URI_aarch64_rust-pyo3_0.23+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+experimental-async-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+experimental-async-devel.sha256sum] = "f9911589ad7640a6078488334514d97b019253272fd4b5e157639d645c247460"

URI_aarch64_rust-pyo3_0.23+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+experimental-inspect-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+experimental-inspect-devel.sha256sum] = "dfbed097c4b41813cf4150c5348c5fb4c0af903b687a3937338493a4ec85e880"

URI_aarch64_rust-pyo3_0.23+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+extension-module-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+extension-module-devel.sha256sum] = "6734b6622fefb970d0e2e2182969e56cd6162ecf7f8593f064b3537c104de596"

URI_aarch64_rust-pyo3_0.23+eyre-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+eyre-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+eyre-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+eyre-devel.sha256sum] = "59e4d29c76f0a6b615416fc84fc88c94d8a3e1454301a8ef5a333c876acbe8fc"

URI_aarch64_rust-pyo3_0.23+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+full-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+full-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+full-devel.sha256sum] = "86c3b2ff9f485fa3ad7202c8ab470d26fe2a82ec85b7aec5d7b6b3c165c93560"

URI_aarch64_rust-pyo3_0.23+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+hashbrown-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+hashbrown-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+hashbrown-devel.sha256sum] = "6a95d6b96b0c239a4063a00c4f39b84dc05eaf2c419cb4c9482593adcfa3e8f4"

URI_aarch64_rust-pyo3_0.23+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+indexmap-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+indexmap-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+indexmap-devel.sha256sum] = "a1df8509dd012e302af66ca7018b86312477c87a40ddf58bf24a9026164db6ba"

URI_aarch64_rust-pyo3_0.23+indoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+indoc-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+indoc-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+indoc-devel.sha256sum] = "f5ad598f4f1e2a81cad4e29dfc2c3d1d73d051091e3576fac49165d48ab6663f"

URI_aarch64_rust-pyo3_0.23+inventory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+inventory-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+inventory-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+inventory-devel.sha256sum] = "67527727e838698f30695931ea0100a160b9c74da96aede1e2e7493e2d230fe5"

URI_aarch64_rust-pyo3_0.23+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+macros-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+macros-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+macros-devel.sha256sum] = "f603dc9a39d661a3c1ec63dabab706ffd5e1de03c8f8403fd88f3fb9adc3cd28"

URI_aarch64_rust-pyo3_0.23+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+multiple-pymethods-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+multiple-pymethods-devel.sha256sum] = "39498a78c53813db1b7f2da4a6417a4116c164846e8a269103124d50e6278931"

URI_aarch64_rust-pyo3_0.23+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+nightly-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+nightly-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+nightly-devel.sha256sum] = "a7e02680f66f04337eca0b7942420d59935c9641f8cecd1d83bced267ffa6f52"

URI_aarch64_rust-pyo3_0.23+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+num-bigint-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+num-bigint-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+num-bigint-devel.sha256sum] = "9fafe5e685892689a7712c26a4e149569c7461f547f5cb9f43b10aebdef9148d"

URI_aarch64_rust-pyo3_0.23+num-complex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+num-complex-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+num-complex-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+num-complex-devel.sha256sum] = "7de91d76a59ed7a66fd4c3376e7feab68ec1654f9de74390c5f39c45b5614dd0"

URI_aarch64_rust-pyo3_0.23+num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+num-rational-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+num-rational-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+num-rational-devel.sha256sum] = "17bb3a29f23572279aea63912f8a12db4b20eae6c4e7229b0d89a30713b632a6"

URI_aarch64_rust-pyo3_0.23+py-clone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+py-clone-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+py-clone-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+py-clone-devel.sha256sum] = "ad63ef0704bf48d492707338c4199c4e97d817a7757346693e8d66f9c07cef96"

URI_aarch64_rust-pyo3_0.23+pyo3-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+pyo3-macros-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+pyo3-macros-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+pyo3-macros-devel.sha256sum] = "d615a332a93e969a29eab4d64aa0a93e774ec5aaa9c595c069eca2dd4efe2a9d"

URI_aarch64_rust-pyo3_0.23+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+rust_decimal-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+rust_decimal-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+rust_decimal-devel.sha256sum] = "a7c6ee8ac775395483d2ba4fd6ccaf775cc828f3d175d6eebff051ed5c1a7482"

URI_aarch64_rust-pyo3_0.23+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+serde-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+serde-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+serde-devel.sha256sum] = "ca30c349944bae20418f38ff1a7678f78d04e066621d24b03894042b441ff22a"

URI_aarch64_rust-pyo3_0.23+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+smallvec-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+smallvec-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+smallvec-devel.sha256sum] = "d44a8aa2f7c1d09192c47514fb8852ca43f37dcd18b495aa00d1a5c6093aa7c1"

URI_aarch64_rust-pyo3_0.23+unindent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+unindent-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23+unindent-devel}"
SRC_URI[aarch64_rust-pyo3_0.23+unindent-devel.sha256sum] = "0e978cdaa98914cadda0a043d914a2780051805642c2cb5c5f8a0c7dd9c7c1c4"

URI_aarch64_rust-pyo3_0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23-devel-0.23.5-4.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.23-devel}"
SRC_URI[aarch64_rust-pyo3_0.23-devel.sha256sum] = "8a5be1b2df3eedb48189fc1f97e370c68a22ddccb94944e43d714fcf6f813e51"

RDEPENDS:rust-pyo3_0.23+abi3-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py310-devel \
 rust-pyo3_0.23+abi3-py311-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py311-devel \
 rust-pyo3_0.23+abi3-py312-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py312-devel \
 rust-pyo3_0.23+abi3-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py37-devel \
 rust-pyo3_0.23+abi3-py38-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py38-devel \
 rust-pyo3_0.23+abi3-py39-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py39-devel \
 rust-pyo3_0.23+abi3-py310-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+anyhow-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+auto-initialize-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+default-devel = " \
 cargo \
 rust-pyo3_0.23+macros-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+either-devel = " \
 cargo \
 rust-either+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros0.23+default-devel \
 rust-pyo3-macros0.23+experimental-async-devel \
 rust-pyo3_0.23+macros-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+experimental-inspect-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi0.23+extension-module-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+eyre-devel = " \
 cargo \
 rust-eyre+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+full-devel = " \
 cargo \
 rust-pyo3_0.23+anyhow-devel \
 rust-pyo3_0.23+chrono-devel \
 rust-pyo3_0.23+chrono-tz-devel \
 rust-pyo3_0.23+either-devel \
 rust-pyo3_0.23+experimental-async-devel \
 rust-pyo3_0.23+experimental-inspect-devel \
 rust-pyo3_0.23+eyre-devel \
 rust-pyo3_0.23+hashbrown-devel \
 rust-pyo3_0.23+indexmap-devel \
 rust-pyo3_0.23+macros-devel \
 rust-pyo3_0.23+num-bigint-devel \
 rust-pyo3_0.23+num-complex-devel \
 rust-pyo3_0.23+num-rational-devel \
 rust-pyo3_0.23+py-clone-devel \
 rust-pyo3_0.23+rust_decimal-devel \
 rust-pyo3_0.23+serde-devel \
 rust-pyo3_0.23+smallvec-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+hashbrown-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~ \
 "
RDEPENDS:rust-pyo3_0.23+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+indoc-devel = " \
 cargo \
 rust-indoc+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+inventory-devel = " \
 cargo \
 rust-inventory+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+macros-devel = " \
 cargo \
 rust-pyo3_0.23+indoc-devel \
 rust-pyo3_0.23+pyo3-macros-devel \
 rust-pyo3_0.23+unindent-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros0.23+default-devel \
 rust-pyo3-macros0.23+multiple-pymethods-devel \
 rust-pyo3_0.23+inventory-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+nightly-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+num-complex-devel = " \
 cargo \
 rust-num-complex+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+num-rational-devel = " \
 cargo \
 rust-num-rational+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+py-clone-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+pyo3-macros-devel = " \
 cargo \
 rust-pyo3-macros0.23+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+rust_decimal-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-pyo3_0.23+serde-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-pyo3_0.23+smallvec-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-pyo3_0.23+unindent-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 rust-unindent+default-devel \
 "
RDEPENDS:rust-pyo3_0.23-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-memoffset+default-devel \
 rust-once_cell+default-devel \
 rust-portable-atomic+default-devel \
 rust-pyo3-build-config0.23+default-devel \
 rust-pyo3-build-config0.23+resolve-config-devel \
 rust-pyo3-ffi0.23+default-devel \
 "
