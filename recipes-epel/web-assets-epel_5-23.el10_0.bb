# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "web-assets-epel"
PV = "5"
PR = "23.el10_0"
PACKAGES = " \
 web-assets-devel \
 web-assets-httpd \
 web-assets-nginx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/web-assets-epel-5-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05d71c5600287beb44d030548bf0c84103c751bfac4c561696539cdb3c249fa4"

URI_x86_64_v2_web-assets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/web-assets-devel-5-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_web-assets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_web-assets-devel}"
SRC_URI[x86_64_v2_web-assets-devel.sha256sum] = "ff5c5d49d853905f0e5d6e12b62a2b4175950a868ccdfff7e7b98e4e1f1d08e9"

URI_x86_64_v2_web-assets-httpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/web-assets-httpd-5-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_web-assets-httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_web-assets-httpd}"
SRC_URI[x86_64_v2_web-assets-httpd.sha256sum] = "2849ebf85f2eda9e357e957462fefc4742bb9ff40ee02171e42dbe0cfa54b2e8"

URI_x86_64_v2_web-assets-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/web-assets-nginx-5-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_web-assets-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_web-assets-nginx}"
SRC_URI[x86_64_v2_web-assets-nginx.sha256sum] = "61922543ae8541be562ca475a14ea5e40550ad4cd9b5a0c7f9329c1937603a2a"

URI_aarch64_web-assets-devel = "${EPEL_MIRROR}/aarch64/Packages/w/web-assets-devel-5-23.el10_0.noarch.rpm;name=aarch64_web-assets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_web-assets-devel}"
SRC_URI[aarch64_web-assets-devel.sha256sum] = "a4518a7849328dbbabf310ced80557d6c67ef196735d30341be477e73ac832bc"

URI_aarch64_web-assets-httpd = "${EPEL_MIRROR}/aarch64/Packages/w/web-assets-httpd-5-23.el10_0.noarch.rpm;name=aarch64_web-assets-httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_web-assets-httpd}"
SRC_URI[aarch64_web-assets-httpd.sha256sum] = "1316c8fad916c0c01eb2c3846384de8dab383f5e41bee658d98b33f013585b56"

URI_aarch64_web-assets-nginx = "${EPEL_MIRROR}/aarch64/Packages/w/web-assets-nginx-5-23.el10_0.noarch.rpm;name=aarch64_web-assets-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_web-assets-nginx}"
SRC_URI[aarch64_web-assets-nginx.sha256sum] = "7d60fd8612bce90a515bbf27a04abf31d5fc03e0dc2ac001ae0547e9d4239106"

RDEPENDS:web-assets-devel = " \
 web-assets-filesystem \
 "
RDEPENDS:web-assets-httpd = " \
 bash \
 httpd \
 web-assets-filesystem \
 "
RDEPENDS:web-assets-nginx = " \
 bash \
 nginx \
 web-assets-filesystem \
 "
