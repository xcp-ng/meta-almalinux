# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest"
PV = "0.12.15"
PR = "1.el10_0"
PACKAGES = " \
 rust-reqwest+__rustls-devel \
 rust-reqwest+__rustls-ring-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+cookies-devel \
 rust-reqwest+default-devel \
 rust-reqwest+default-tls-devel \
 rust-reqwest+deflate-devel \
 rust-reqwest+gzip-devel \
 rust-reqwest+h2-devel \
 rust-reqwest+hickory-dns-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+json-devel \
 rust-reqwest+multipart-devel \
 rust-reqwest+native-tls-alpn-devel \
 rust-reqwest+native-tls-devel \
 rust-reqwest+rustls-tls-devel \
 rust-reqwest+rustls-tls-manual-roots-devel \
 rust-reqwest+rustls-tls-manual-roots-no-provider-devel \
 rust-reqwest+rustls-tls-native-roots-devel \
 rust-reqwest+rustls-tls-native-roots-no-provider-devel \
 rust-reqwest+rustls-tls-no-provider-devel \
 rust-reqwest+rustls-tls-webpki-roots-devel \
 rust-reqwest+rustls-tls-webpki-roots-no-provider-devel \
 rust-reqwest+slab-devel \
 rust-reqwest+socks-devel \
 rust-reqwest+stream-devel \
 rust-reqwest+trust-dns-devel \
 rust-reqwest+zstd-devel \
 rust-reqwest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-0.12.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "356cf617dc2679c979e9f3f4878cd65f588efce659a3cf0a1d69e042e07a6236"

URI_x86_64_v2_rust-reqwest+__rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__rustls-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__rustls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__rustls-devel.sha256sum] = "6db4e65670ebd99d20c90880c477776ca1ff2ea71fa6d7068fd9d99bbf9902dc"

URI_x86_64_v2_rust-reqwest+__rustls-ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__rustls-ring-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__rustls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__rustls-ring-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__rustls-ring-devel.sha256sum] = "328a9f3b0cf7313202bc1e323097939abec5fc27552da7428fc780cd60d988b7"

URI_x86_64_v2_rust-reqwest+__tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__tls-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__tls-devel.sha256sum] = "098780cd9330f2e3b1bdd61429946a93f3e0d57ced4003ddba293ad6f9cf0d37"

URI_x86_64_v2_rust-reqwest+blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+blocking-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+blocking-devel}"
SRC_URI[x86_64_v2_rust-reqwest+blocking-devel.sha256sum] = "e72024b5ba49bf2b8e82596ca0a60afdf98fd400e108a84dcbac85f15ba01253"

URI_x86_64_v2_rust-reqwest+charset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+charset-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+charset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+charset-devel}"
SRC_URI[x86_64_v2_rust-reqwest+charset-devel.sha256sum] = "3bc03d809c5f9bb6cc40fe6df82d32d9a64e4476fe38923d9eb33efdc5a55bc9"

URI_x86_64_v2_rust-reqwest+cookies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+cookies-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+cookies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+cookies-devel}"
SRC_URI[x86_64_v2_rust-reqwest+cookies-devel.sha256sum] = "44b6276fa6f618971df6817dde283b8df232043074e09a7bfbb7c349a8c08d44"

URI_x86_64_v2_rust-reqwest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+default-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest+default-devel.sha256sum] = "4710d931ee1e9f294983de9cd9873ccb409d029d2295821d153ca203a0b25b3a"

URI_x86_64_v2_rust-reqwest+default-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+default-tls-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+default-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+default-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+default-tls-devel.sha256sum] = "d1af0f1911ac997a8cd0a60fb290fd2dfc3e09708609e231388c89a9f8256a53"

URI_x86_64_v2_rust-reqwest+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+deflate-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+deflate-devel}"
SRC_URI[x86_64_v2_rust-reqwest+deflate-devel.sha256sum] = "b76513aadb01d2b389455934a78dc7b2c547df3f184c8921096a45ad967be5dd"

URI_x86_64_v2_rust-reqwest+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+gzip-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+gzip-devel}"
SRC_URI[x86_64_v2_rust-reqwest+gzip-devel.sha256sum] = "75f73565e3f7b6489470481bdac827386825dce0297cacdc8bab7ac9a5ff7455"

URI_x86_64_v2_rust-reqwest+h2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+h2-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+h2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+h2-devel}"
SRC_URI[x86_64_v2_rust-reqwest+h2-devel.sha256sum] = "4fa04d6377157cb13101c8f88a90c4dde4a1cc3138d45cb7fcf1358639e8f368"

URI_x86_64_v2_rust-reqwest+hickory-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+hickory-dns-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+hickory-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+hickory-dns-devel}"
SRC_URI[x86_64_v2_rust-reqwest+hickory-dns-devel.sha256sum] = "7a5945e3d02130104d2deff09c7bb5bf448f8be5abfd1006c743af1b8bedd0fd"

URI_x86_64_v2_rust-reqwest+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+http2-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+http2-devel}"
SRC_URI[x86_64_v2_rust-reqwest+http2-devel.sha256sum] = "8717e80ebf5e5251182bb3d33a5f76ee154213cb9d57a6b1f7642aba67b56ca0"

URI_x86_64_v2_rust-reqwest+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+json-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+json-devel}"
SRC_URI[x86_64_v2_rust-reqwest+json-devel.sha256sum] = "be81bf327447a375505ceb9dc83ca7b31fd211f1b4e5bac896bd753d686e3d52"

URI_x86_64_v2_rust-reqwest+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+multipart-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+multipart-devel}"
SRC_URI[x86_64_v2_rust-reqwest+multipart-devel.sha256sum] = "9ab2866b386eb2e867111940ba4493f6905ec735d7d74b4228cab2a2fe895dda"

URI_x86_64_v2_rust-reqwest+native-tls-alpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+native-tls-alpn-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+native-tls-alpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+native-tls-alpn-devel}"
SRC_URI[x86_64_v2_rust-reqwest+native-tls-alpn-devel.sha256sum] = "ea56964fe29cbc3f14d62ec6418674088d06d57b34b803fe4d09aa7eb928c5f4"

URI_x86_64_v2_rust-reqwest+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+native-tls-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+native-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+native-tls-devel.sha256sum] = "d3619f5938ed874f2744270f3fc631ae3ec4cdd2d290a855ea862a04b192ef9d"

URI_x86_64_v2_rust-reqwest+rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-devel.sha256sum] = "c595cf69b0fc53273cc9efbaa6d3d098bc815c3b01a3d5c5a66e04a00d540415"

URI_x86_64_v2_rust-reqwest+rustls-tls-manual-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-manual-roots-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-manual-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-manual-roots-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-manual-roots-devel.sha256sum] = "5f4880c371bb79833bf6de990995742c96ebdb0477eb6d4a1487fafe5cfd8492"

URI_x86_64_v2_rust-reqwest+rustls-tls-manual-roots-no-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-manual-roots-no-provider-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-manual-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-manual-roots-no-provider-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-manual-roots-no-provider-devel.sha256sum] = "89cbe37b0ec0fd66e1f9ea751b07a330e66c2ad7803c6b73bf1c7a5b3cf9c765"

URI_x86_64_v2_rust-reqwest+rustls-tls-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-native-roots-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-native-roots-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-native-roots-devel.sha256sum] = "2a1757a0adc92519bcd0a1cb7eb60e7e8285f53fbaf030a49ec72126fbf512b5"

URI_x86_64_v2_rust-reqwest+rustls-tls-native-roots-no-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-native-roots-no-provider-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-native-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-native-roots-no-provider-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-native-roots-no-provider-devel.sha256sum] = "d8b3ebfeaccaa0c7dd0bf0fc6363c983e2499c155ad6f79baa6f4b6cd61e08b7"

URI_x86_64_v2_rust-reqwest+rustls-tls-no-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-no-provider-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-no-provider-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-no-provider-devel.sha256sum] = "3dcc03ba16356e46cf9e471ba839ae0c921f14a195938e4d387e00583107b634"

URI_x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-webpki-roots-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-devel.sha256sum] = "5e729397b9b696c0e48afbafd5d6a777d142957df5c6d7970a8b9915bb32e991"

URI_x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-tls-webpki-roots-no-provider-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel.sha256sum] = "cef3c900da450309d94265d22c269542f0d017723b2b67345e55a5cf36dbabb5"

URI_x86_64_v2_rust-reqwest+slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+slab-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+slab-devel}"
SRC_URI[x86_64_v2_rust-reqwest+slab-devel.sha256sum] = "f465e397c01d711135708f84221a761500d366f7c438d4384cf740e8c563e6dd"

URI_x86_64_v2_rust-reqwest+socks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+socks-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+socks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+socks-devel}"
SRC_URI[x86_64_v2_rust-reqwest+socks-devel.sha256sum] = "3a40bd9048afb33eff8f151e9e30e73b89c7fe723e062e9e7a0bebd114e95ae2"

URI_x86_64_v2_rust-reqwest+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+stream-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+stream-devel}"
SRC_URI[x86_64_v2_rust-reqwest+stream-devel.sha256sum] = "ee360711a9e7e6b42e075109c571312950d28ffd91deb33c4adabb3d00a63f7f"

URI_x86_64_v2_rust-reqwest+trust-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+trust-dns-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+trust-dns-devel}"
SRC_URI[x86_64_v2_rust-reqwest+trust-dns-devel.sha256sum] = "e1e6c452a8324e174e40496cfcdd7c2af63022352a6b7598119922df979f4d88"

URI_x86_64_v2_rust-reqwest+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+zstd-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+zstd-devel}"
SRC_URI[x86_64_v2_rust-reqwest+zstd-devel.sha256sum] = "f46636b5488c5fa2bb198827783ef631fd243342b2f8d98e5ae17cff97bbf6e9"

URI_x86_64_v2_rust-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-devel-0.12.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-devel}"
SRC_URI[x86_64_v2_rust-reqwest-devel.sha256sum] = "5fe08ce417e91bdeec727476744807178c2733818ddddf57c99cc9fb1ae0b73e"

URI_aarch64_rust-reqwest+__rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__rustls-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+__rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__rustls-devel}"
SRC_URI[aarch64_rust-reqwest+__rustls-devel.sha256sum] = "3d6b04ccd063647d8070c6a7ba31eb7dbdbc03a899847d7953a14287eb1ec101"

URI_aarch64_rust-reqwest+__rustls-ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__rustls-ring-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+__rustls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__rustls-ring-devel}"
SRC_URI[aarch64_rust-reqwest+__rustls-ring-devel.sha256sum] = "7385e3b33607b3037f23a3ff9381d6c42f84fa3ca38f26c767fcae09e5f36864"

URI_aarch64_rust-reqwest+__tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__tls-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+__tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__tls-devel}"
SRC_URI[aarch64_rust-reqwest+__tls-devel.sha256sum] = "7bffebef7f4104b1702f30663cee35c6a1f03547fc7648ed8a46a14d790d5853"

URI_aarch64_rust-reqwest+blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+blocking-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+blocking-devel}"
SRC_URI[aarch64_rust-reqwest+blocking-devel.sha256sum] = "0dc8592df976ab80a247b4b79a5b305a38075928af6b58913c6b1ff2d8195616"

URI_aarch64_rust-reqwest+charset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+charset-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+charset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+charset-devel}"
SRC_URI[aarch64_rust-reqwest+charset-devel.sha256sum] = "0960545ff48399cef1ecfb8695d779c1735c139728fbbab5d9c8a9a4630b383f"

URI_aarch64_rust-reqwest+cookies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+cookies-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+cookies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+cookies-devel}"
SRC_URI[aarch64_rust-reqwest+cookies-devel.sha256sum] = "b831272e5f510f3c96628542c437b433140696ac6c2cbf89f52502cb6a71484f"

URI_aarch64_rust-reqwest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+default-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+default-devel}"
SRC_URI[aarch64_rust-reqwest+default-devel.sha256sum] = "b32db7f066d3b76dc00134926d66ef37253d2090a28c7861272711a4134203cc"

URI_aarch64_rust-reqwest+default-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+default-tls-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+default-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+default-tls-devel}"
SRC_URI[aarch64_rust-reqwest+default-tls-devel.sha256sum] = "35196081322a0a64c8394b72c95fa9641c0c32bf3c317991c4d299a80052667f"

URI_aarch64_rust-reqwest+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+deflate-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+deflate-devel}"
SRC_URI[aarch64_rust-reqwest+deflate-devel.sha256sum] = "ebefceacc13effc0b1fae8a7ad48de3352c18675616105218a1c234b734b9ca3"

URI_aarch64_rust-reqwest+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+gzip-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+gzip-devel}"
SRC_URI[aarch64_rust-reqwest+gzip-devel.sha256sum] = "dd69d65d2fb2486f6d0cffd1314787e66646570de6b02f95d3c0d2e522d79b51"

URI_aarch64_rust-reqwest+h2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+h2-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+h2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+h2-devel}"
SRC_URI[aarch64_rust-reqwest+h2-devel.sha256sum] = "16d9317f45769a025eb08c7002d9e3986bbdf074af4d0d33b4a78fbfa32f66e7"

URI_aarch64_rust-reqwest+hickory-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+hickory-dns-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+hickory-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+hickory-dns-devel}"
SRC_URI[aarch64_rust-reqwest+hickory-dns-devel.sha256sum] = "0582fb7a792e5152de883b4f087e5af8a315db8903ab1d17cf2d9bfc16f6a431"

URI_aarch64_rust-reqwest+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+http2-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+http2-devel}"
SRC_URI[aarch64_rust-reqwest+http2-devel.sha256sum] = "d4a57d41e5129f2795a445977d0e9a7018e0a9746c9d4b1c38f0e1675e9f3cb6"

URI_aarch64_rust-reqwest+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+json-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+json-devel}"
SRC_URI[aarch64_rust-reqwest+json-devel.sha256sum] = "4c6c50241edb2d2eab6fb9d290be80785e74b107a4f1ba7f3d03c088aa92bfe7"

URI_aarch64_rust-reqwest+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+multipart-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+multipart-devel}"
SRC_URI[aarch64_rust-reqwest+multipart-devel.sha256sum] = "78819be8364b547200d607cc845eddc064d86602b8ca3f5cd9fd89cfe8e454ce"

URI_aarch64_rust-reqwest+native-tls-alpn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+native-tls-alpn-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+native-tls-alpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+native-tls-alpn-devel}"
SRC_URI[aarch64_rust-reqwest+native-tls-alpn-devel.sha256sum] = "553a032a124eee27512476a7f1e7259bf2774cc241d80272fe3f20cd645ee759"

URI_aarch64_rust-reqwest+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+native-tls-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+native-tls-devel}"
SRC_URI[aarch64_rust-reqwest+native-tls-devel.sha256sum] = "06b89dd63dc6af3433522cd17f31d3a5207998364d3b24945b0513f2beb51576"

URI_aarch64_rust-reqwest+rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-devel.sha256sum] = "d91794954819f57f936e396479d023785c9e40e4a5f54f4778150738878cb841"

URI_aarch64_rust-reqwest+rustls-tls-manual-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-manual-roots-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-manual-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-manual-roots-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-manual-roots-devel.sha256sum] = "a6e26e6aed65ff4e7fab22baad03081ac2f1c81c2612d1e1fdf3c12e1acdfebe"

URI_aarch64_rust-reqwest+rustls-tls-manual-roots-no-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-manual-roots-no-provider-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-manual-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-manual-roots-no-provider-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-manual-roots-no-provider-devel.sha256sum] = "634f20db40f6ddc5af839dc2c5ad97fc6426279ccafa8398f3861d439a0a3c05"

URI_aarch64_rust-reqwest+rustls-tls-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-native-roots-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-native-roots-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-native-roots-devel.sha256sum] = "fd842402d9f6ec8c8002ff57e2a384a6684b9c0910f5bb2b77bf8245e4937b0d"

URI_aarch64_rust-reqwest+rustls-tls-native-roots-no-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-native-roots-no-provider-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-native-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-native-roots-no-provider-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-native-roots-no-provider-devel.sha256sum] = "06799aad2dbbddf80df3b60130d3385dc7664916ab62134e8ca0c8508d4ab396"

URI_aarch64_rust-reqwest+rustls-tls-no-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-no-provider-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-no-provider-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-no-provider-devel.sha256sum] = "3e78f3133913ffc3f54d862dc11ad7595ac0196ca937b222a561b2b2a18e229a"

URI_aarch64_rust-reqwest+rustls-tls-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-webpki-roots-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-webpki-roots-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-webpki-roots-devel.sha256sum] = "1baf98d55369664218fa234e5e68edff859b263a723d531f2122a0b9097faf7e"

URI_aarch64_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-tls-webpki-roots-no-provider-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-tls-webpki-roots-no-provider-devel.sha256sum] = "78b8710e9321f4d38f3f1eed1de8e3040c7d0af20713e53b31e4c4f58442c860"

URI_aarch64_rust-reqwest+slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+slab-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+slab-devel}"
SRC_URI[aarch64_rust-reqwest+slab-devel.sha256sum] = "89d6ee275ecf24ad40d3ff4ffcf8ceec30124ea05be3744d9bfe72af6d38d211"

URI_aarch64_rust-reqwest+socks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+socks-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+socks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+socks-devel}"
SRC_URI[aarch64_rust-reqwest+socks-devel.sha256sum] = "76c0d869570c793398d0a24564c6e8574e89a7f4833d612d90b2cae15871ddd8"

URI_aarch64_rust-reqwest+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+stream-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+stream-devel}"
SRC_URI[aarch64_rust-reqwest+stream-devel.sha256sum] = "c65ee0770c9832dbeaa6774507de623b703e5a00416c83fb436c0ddbf53f83a1"

URI_aarch64_rust-reqwest+trust-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+trust-dns-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+trust-dns-devel}"
SRC_URI[aarch64_rust-reqwest+trust-dns-devel.sha256sum] = "a5875025e4053347ce724f7ce1ad68bd79160a089b180a20dac4f46b21e392eb"

URI_aarch64_rust-reqwest+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+zstd-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+zstd-devel}"
SRC_URI[aarch64_rust-reqwest+zstd-devel.sha256sum] = "375e91ef3503687a81038521e983d11e76a6012a5e855e6c12c015e03595dfaa"

URI_aarch64_rust-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-devel-0.12.15-1.el10_0.noarch.rpm;name=aarch64_rust-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-devel}"
SRC_URI[aarch64_rust-reqwest-devel.sha256sum] = "a9cb8d3882619a403bbb8498a70a3c00897b6e6d11cd7fa54e6b1e7a298d21e6"

RDEPENDS:rust-reqwest+__rustls-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-rustls-pemfile+default-devel \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types+default-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-reqwest+__rustls-ring-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+ring-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest-devel \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-reqwest+__tls-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-rustls-pemfile+default-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-reqwest+blocking-devel = " \
 cargo \
 rust-futures-channel+default-devel \
 rust-futures-channel+sink-devel \
 rust-futures-util+io-devel \
 rust-futures-util+sink-devel \
 rust-reqwest-devel \
 rust-tokio+sync-devel \
 "
RDEPENDS:rust-reqwest+charset-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+cookies-devel = " \
 cargo \
 rust-cookie+default-devel \
 rust-cookie_store+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+default-devel = " \
 cargo \
 rust-reqwest+charset-devel \
 rust-reqwest+default-tls-devel \
 rust-reqwest+http2-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+default-tls-devel = " \
 cargo \
 rust-hyper-tls+default-devel \
 rust-native-tls+default-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest-devel \
 rust-tokio-native-tls+default-devel \
 "
RDEPENDS:rust-reqwest+deflate-devel = " \
 cargo \
 rust-async-compression+tokio-devel \
 rust-async-compression+zlib-devel \
 rust-async-compression-devel \
 rust-reqwest-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-reqwest+gzip-devel = " \
 cargo \
 rust-async-compression+gzip-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression-devel \
 rust-reqwest-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-reqwest+h2-devel = " \
 cargo \
 rust-h2+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+hickory-dns-devel = " \
 cargo \
 rust-hickory-resolver+default-devel \
 rust-hickory-resolver+tokio-runtime-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+http2-devel = " \
 cargo \
 rust-hyper+http2-devel \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+http2-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-hyper-util+http2-devel \
 rust-reqwest+h2-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+json-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-reqwest+multipart-devel = " \
 cargo \
 rust-mime_guess-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+native-tls-alpn-devel = " \
 cargo \
 rust-hyper-tls+alpn-devel \
 rust-hyper-tls+default-devel \
 rust-native-tls+alpn-devel \
 rust-native-tls+default-devel \
 rust-reqwest+native-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+native-tls-devel = " \
 cargo \
 rust-reqwest+default-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-devel = " \
 cargo \
 rust-reqwest+rustls-tls-webpki-roots-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-manual-roots-devel = " \
 cargo \
 rust-reqwest+__rustls-ring-devel \
 rust-reqwest+rustls-tls-manual-roots-no-provider-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-manual-roots-no-provider-devel = " \
 cargo \
 rust-reqwest+__rustls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-native-roots-devel = " \
 cargo \
 rust-reqwest+__rustls-ring-devel \
 rust-reqwest+rustls-tls-native-roots-no-provider-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-native-roots-no-provider-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+native-tokio-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest+__rustls-devel \
 rust-reqwest-devel \
 rust-rustls-native-certs+default-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-no-provider-devel = " \
 cargo \
 rust-reqwest+rustls-tls-manual-roots-no-provider-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-webpki-roots-devel = " \
 cargo \
 rust-reqwest+__rustls-ring-devel \
 rust-reqwest+rustls-tls-webpki-roots-no-provider-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+rustls-tls-webpki-roots-no-provider-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls+webpki-tokio-devel \
 rust-hyper-rustls-devel \
 rust-reqwest+__rustls-devel \
 rust-reqwest-devel \
 rust-webpki-roots+default-devel \
 "
RDEPENDS:rust-reqwest+slab-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-slab+default-devel \
 "
RDEPENDS:rust-reqwest+socks-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-tokio-socks+default-devel \
 "
RDEPENDS:rust-reqwest+stream-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-tokio+fs-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-reqwest+trust-dns-devel = " \
 cargo \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+zstd-devel = " \
 cargo \
 rust-async-compression+tokio-devel \
 rust-async-compression+zstd-devel \
 rust-async-compression-devel \
 rust-reqwest-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-reqwest-devel = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-bytes+default-devel \
 rust-futures-core-devel \
 rust-futures-util-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-hyper+client-devel \
 rust-hyper+default-devel \
 rust-hyper+http1-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+tokio-devel \
 rust-ipnet+default-devel \
 rust-log+default-devel \
 rust-mime+default-devel \
 rust-once_cell+default-devel \
 rust-percent-encoding+default-devel \
 rust-pin-project-lite+default-devel \
 rust-serde+default-devel \
 rust-serde_urlencoded+default-devel \
 rust-sync_wrapper+default-devel \
 rust-sync_wrapper+futures-devel \
 rust-tokio+net-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tower+timeout-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 rust-tower-service+default-devel \
 rust-url+default-devel \
 "
