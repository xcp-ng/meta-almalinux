# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "annobin"
PV = "13.22"
PR = "1.el10"
PACKAGES = " \
 annobin-annocheck \
 annobin-docs \
 annobin-libannocheck \
 annobin-plugin-clang \
 annobin-plugin-gcc \
 annobin-plugin-llvm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/annobin-13.22-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd3009c8371127d90193db351fcfb6b7898e390ce00ee3fd76fb13331e9506c1"

URI_x86_64_v2_annobin-annocheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-annocheck-13.22-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-annocheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-annocheck}"
SRC_URI[x86_64_v2_annobin-annocheck.sha256sum] = "034a1158ed578da3f1f6488aebb31d4f810ff16446bb47803ec313c65dceb418"

URI_x86_64_v2_annobin-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-docs-13.22-1.el10.noarch.rpm;name=x86_64_v2_annobin-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-docs}"
SRC_URI[x86_64_v2_annobin-docs.sha256sum] = "9feafeaf4aa77c8e61bcd9976999700c6fd707f9527ec066eedb04319c8c04ce"

URI_x86_64_v2_annobin-libannocheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-libannocheck-13.22-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-libannocheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-libannocheck}"
SRC_URI[x86_64_v2_annobin-libannocheck.sha256sum] = "5a839b7370a04c423019cc8e9254ed66be843faa4915fc86b75cd6c88c68ebdf"

URI_x86_64_v2_annobin-plugin-clang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-clang-13.22-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-plugin-clang}"
SRC_URI[x86_64_v2_annobin-plugin-clang.sha256sum] = "d8ae9ef1ed4024a49c258af39a8baaa6c627b744d82581a2574da477efec9a56"

URI_x86_64_v2_annobin-plugin-gcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-gcc-13.22-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-plugin-gcc}"
SRC_URI[x86_64_v2_annobin-plugin-gcc.sha256sum] = "66fc56d1c2b862ad084a0280cfca19bb31edf96507c39c50ed399ffa99de1285"

URI_x86_64_v2_annobin-plugin-llvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-llvm-13.22-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-llvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-plugin-llvm}"
SRC_URI[x86_64_v2_annobin-plugin-llvm.sha256sum] = "83b5a48793ba6843e1afa4a5676411b193018cdfbb12d7c2d4ec26ef18e711f1"

URI_aarch64_annobin-annocheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-annocheck-13.22-1.el10.aarch64.rpm;name=aarch64_annobin-annocheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-annocheck}"
SRC_URI[aarch64_annobin-annocheck.sha256sum] = "1a5f37947c5c1579a799c42f3f38960b149dec3ac813a7ea58430a19caa46e0d"

URI_aarch64_annobin-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-docs-13.22-1.el10.noarch.rpm;name=aarch64_annobin-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-docs}"
SRC_URI[aarch64_annobin-docs.sha256sum] = "9feafeaf4aa77c8e61bcd9976999700c6fd707f9527ec066eedb04319c8c04ce"

URI_aarch64_annobin-libannocheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-libannocheck-13.22-1.el10.aarch64.rpm;name=aarch64_annobin-libannocheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-libannocheck}"
SRC_URI[aarch64_annobin-libannocheck.sha256sum] = "e03fc2ee223088c6d23165dbe04206896ebad84315787bfa6ef89ee3b6700dc6"

URI_aarch64_annobin-plugin-clang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-clang-13.22-1.el10.aarch64.rpm;name=aarch64_annobin-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-plugin-clang}"
SRC_URI[aarch64_annobin-plugin-clang.sha256sum] = "0c58064e56b276c0d4b02cda0ff625a8ad0b406c8af511268f085e90b1cf1812"

URI_aarch64_annobin-plugin-gcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-gcc-13.22-1.el10.aarch64.rpm;name=aarch64_annobin-plugin-gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-plugin-gcc}"
SRC_URI[aarch64_annobin-plugin-gcc.sha256sum] = "d4fba145c3b1abf6b757dc05d08847af88b0279d1c94075f5717c53b6d7affe9"

URI_aarch64_annobin-plugin-llvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-llvm-13.22-1.el10.aarch64.rpm;name=aarch64_annobin-plugin-llvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-plugin-llvm}"
SRC_URI[aarch64_annobin-plugin-llvm.sha256sum] = "de69152362a63682f64c3d078e392f812693f33aeeda2817213e3d022961a58a"

RDEPENDS:annobin-annocheck = " \
 annobin-docs \
 cpio \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 rpm \
 rpm-libs \
 "
RDEPENDS:annobin-docs = " \
 "
RDEPENDS:annobin-libannocheck = " \
 annobin-docs \
 glibc \
 pkgconf-pkg-config \
 "
RDEPENDS:annobin-plugin-clang = " \
 annobin-docs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
RDEPENDS:annobin-plugin-gcc = " \
 annobin-docs \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:annobin-plugin-llvm = " \
 annobin-docs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
