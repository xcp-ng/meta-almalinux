# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tower-service"
PV = "0.3.3"
PR = "2.el10_0"
PACKAGES = " \
 rust-tower-service+default-devel \
 rust-tower-service-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tower-service-0.3.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fabedc1329e05537d067f3fd10a1bfee1e9c505820ce2bfc23cd40a1b5882c9c"

URI_x86_64_v2_rust-tower-service+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-service+default-devel-0.3.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-service+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-service+default-devel}"
SRC_URI[x86_64_v2_rust-tower-service+default-devel.sha256sum] = "24169c04d295f68ace34155af62af5bc719895e7ab02b8dc20e4c7b0793ae2d4"

URI_x86_64_v2_rust-tower-service-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-service-devel-0.3.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-service-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-service-devel}"
SRC_URI[x86_64_v2_rust-tower-service-devel.sha256sum] = "7763bf95400c35e6ddbecbbd5b42cfbe14dc5674b78b42bc31dad4a8a2b0fa23"

URI_aarch64_rust-tower-service+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-service+default-devel-0.3.3-2.el10_0.noarch.rpm;name=aarch64_rust-tower-service+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-service+default-devel}"
SRC_URI[aarch64_rust-tower-service+default-devel.sha256sum] = "8eda7aefe6dad0bc166b126a6ea54bb8b9682d18d1dd4274aeb59b0967e134a8"

URI_aarch64_rust-tower-service-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-service-devel-0.3.3-2.el10_0.noarch.rpm;name=aarch64_rust-tower-service-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-service-devel}"
SRC_URI[aarch64_rust-tower-service-devel.sha256sum] = "438a5c4c947525125eb42460312aed8544ac41cae80418dfb353084e94ed0eb0"

RDEPENDS:rust-tower-service+default-devel = " \
 cargo \
 rust-tower-service-devel \
 "
RDEPENDS:rust-tower-service-devel = " \
 cargo \
 "
