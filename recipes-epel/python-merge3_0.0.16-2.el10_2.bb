# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-merge3"
PV = "0.0.16"
PR = "2.el10_2"
PACKAGES = " \
 python3-merge3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-merge3-0.0.16-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "810f8caa591008e2111e4a74eb32feb8635813dd56a6446b31d0862dfeced750"

URI_x86_64_v2_python3-merge3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-merge3-0.0.16-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-merge3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-merge3}"
SRC_URI[x86_64_v2_python3-merge3.sha256sum] = "5fc27fb6a805704991db31e41c7348a0dbb1096de13665e8c20e2e1353e80483"

URI_aarch64_python3-merge3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-merge3-0.0.16-2.el10_2.noarch.rpm;name=aarch64_python3-merge3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-merge3}"
SRC_URI[aarch64_python3-merge3.sha256sum] = "44ff9f595955760fe05b86d19b9017f2a59c3a1ad13e4b01b4b55c9611ad5856"

RDEPENDS:python3-merge3 = " \
 python3 \
 "
