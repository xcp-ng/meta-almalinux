# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virtme-ng"
PV = "1.38"
PR = "1.el10_2"
PACKAGES = " \
 virtme-ng \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/virtme-ng-1.38-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd957e6f7282d5e8b001b4d75a2ea8ed68f8556dc5c3142e0b73bf0f992003de"

URI_x86_64_v2_virtme-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/virtme-ng-1.38-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_virtme-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virtme-ng}"
SRC_URI[x86_64_v2_virtme-ng.sha256sum] = "99e81bab5ad1f3c4f105a898b82ffdd12e97de83ad7fa4fb371c17263d559ffc"

URI_aarch64_virtme-ng = "${EPEL_MIRROR}/aarch64/Packages/v/virtme-ng-1.38-1.el10_2.noarch.rpm;name=aarch64_virtme-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_virtme-ng}"
SRC_URI[aarch64_virtme-ng.sha256sum] = "b7f3a8b391464f571bf7d164d09cd917c4be9e38e8255563117ae2f065df111b"

RDEPENDS:virtme-ng = " \
 bash \
 python3 \
 python3-argcomplete \
 python3-requests \
 python3-setuptools \
 "
