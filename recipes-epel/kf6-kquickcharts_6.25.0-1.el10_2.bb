# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kquickcharts"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kquickcharts \
 kf6-kquickcharts-devel \
 kf6-kquickcharts-doc \
 kf6-kquickcharts-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kquickcharts-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c86f7a589f111a1bb8f18db992286db83a0cc529061eb6c79f559248098f50b5"

URI_x86_64_v2_kf6-kquickcharts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kquickcharts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kquickcharts}"
SRC_URI[x86_64_v2_kf6-kquickcharts.sha256sum] = "23feeb49a9cf343224d6352a294f0854eb37bbf8da07a6e29bc73e5288537d2e"

URI_x86_64_v2_kf6-kquickcharts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kquickcharts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kquickcharts-devel}"
SRC_URI[x86_64_v2_kf6-kquickcharts-devel.sha256sum] = "065aa11779b4a67739231c4a146ac32f0345768ddf39479efadf79eb4cce9ad3"

URI_x86_64_v2_kf6-kquickcharts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kquickcharts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kquickcharts-doc}"
SRC_URI[x86_64_v2_kf6-kquickcharts-doc.sha256sum] = "adc1e0aea4ceaae1f48039b3769531a28f892081e6813be77701f0c2650e78bd"

URI_x86_64_v2_kf6-kquickcharts-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kquickcharts-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kquickcharts-html}"
SRC_URI[x86_64_v2_kf6-kquickcharts-html.sha256sum] = "db58ab3182d49a6e44fecc02a2898ea4f16ca0bd739473bdb77442deb1296b8a"

URI_aarch64_kf6-kquickcharts = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kquickcharts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kquickcharts}"
SRC_URI[aarch64_kf6-kquickcharts.sha256sum] = "22dbe9bd57d2a48f908b9e0019a452a7864b403f5d0ba8b3765b9e25a5051455"

URI_aarch64_kf6-kquickcharts-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kquickcharts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kquickcharts-devel}"
SRC_URI[aarch64_kf6-kquickcharts-devel.sha256sum] = "437323d46c68840cc0a8e6a25777b92ac9d175ac36955fd6753afb028254fd9b"

URI_aarch64_kf6-kquickcharts-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kquickcharts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kquickcharts-doc}"
SRC_URI[aarch64_kf6-kquickcharts-doc.sha256sum] = "d481716a05984425192f4b76a1405977b9b420fa2dfe21de03a57ea1c5350803"

URI_aarch64_kf6-kquickcharts-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kquickcharts-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kquickcharts-html}"
SRC_URI[aarch64_kf6-kquickcharts-html.sha256sum] = "03b8b6b739585a2a54912b9dc8e95e15ff74122140e83079d148fa9aff111f9c"

RDEPENDS:kf6-kquickcharts = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kquickcharts-devel = " \
 cmake-filesystem \
 kf6-kquickcharts \
 "
RDEPENDS:kf6-kquickcharts-doc = " \
 "
RDEPENDS:kf6-kquickcharts-html = " \
 "
