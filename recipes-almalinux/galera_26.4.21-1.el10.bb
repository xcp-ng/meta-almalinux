# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "galera"
PV = "26.4.21"
PR = "1.el10"
PACKAGES = " \
 galera \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/galera-26.4.21-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3eada1efddcd3e66fbbbf5815dcedf67e98eb883a9691ddd14c6f51dd24b4635"

URI_x86_64_v2_galera = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/galera-26.4.21-1.el10.x86_64_v2.rpm;name=x86_64_v2_galera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_galera}"
SRC_URI[x86_64_v2_galera.sha256sum] = "af4569dcc98c81d1d87dfa964e8d5dfd72e6f39434653c277d562dd05fff12d1"

URI_aarch64_galera = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/galera-26.4.21-1.el10.aarch64.rpm;name=aarch64_galera;unpack=0"
SRC_URI:append = " ${URI_aarch64_galera}"
SRC_URI[aarch64_galera.sha256sum] = "54e05a5898c6f9efc32136641e73b0bc4d575d2cba7510eccb38ea4fe313908e"

RDEPENDS:galera = " \
 bash \
 boost-program-options \
 glibc \
 libgcc \
 libstdc++ \
 nmap-ncat \
 openssl-libs \
 procps-ng \
 shadow-utils \
 systemd \
 "
