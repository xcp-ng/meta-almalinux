# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opencryptoki"
PV = "3.26.0"
PR = "2.el10"
PACKAGES:x86_64_v2 = " \
 opencryptoki \
 opencryptoki-ccatok \
 opencryptoki-devel \
 opencryptoki-icsftok \
 opencryptoki-libs \
 opencryptoki-swtok \
"
PACKAGES:aarch64 = " \
 opencryptoki \
 opencryptoki-devel \
 opencryptoki-icsftok \
 opencryptoki-libs \
 opencryptoki-swtok \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/opencryptoki-3.26.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7dad6a3f30cd5a24767d70dd325843391ad14192d9094805a4a685daad1ebc0"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - opencryptoki: libcap.so.2()(64bit)

URI_x86_64_v2_opencryptoki = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-3.26.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_opencryptoki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki}"
SRC_URI[x86_64_v2_opencryptoki.sha256sum] = "b5f12ce5f89c85750231c36bfb30afd2d36f562474e180ca33be98d55f257019"

URI_x86_64_v2_opencryptoki-ccatok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-ccatok-3.26.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-ccatok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-ccatok}"
SRC_URI[x86_64_v2_opencryptoki-ccatok.sha256sum] = "ccc49792c4bebce081d59bec3a4682afaff63616c79f8a1cffe8c14b71d929fa"
RPROVIDES:opencryptoki-ccatok:x86_64_v2 = "virtual/opencryptoki_token_"

URI_x86_64_v2_opencryptoki-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/opencryptoki-devel-3.26.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-devel}"
SRC_URI[x86_64_v2_opencryptoki-devel.sha256sum] = "0d7dff5c5c5d704fd2c91f5cfe7b5217088b6bec498c35936127d110d9b6fe4b"

URI_x86_64_v2_opencryptoki-icsftok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-icsftok-3.26.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-icsftok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-icsftok}"
SRC_URI[x86_64_v2_opencryptoki-icsftok.sha256sum] = "8454fb2147f73e3f37c7268fa52bbdf2a763a553a38c23721fcaa48f87d842b0"
RPROVIDES:opencryptoki-icsftok:x86_64_v2 = "virtual/opencryptoki_token_"

URI_x86_64_v2_opencryptoki-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-libs-3.26.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-libs}"
SRC_URI[x86_64_v2_opencryptoki-libs.sha256sum] = "b28140960ed7e6527ee61bdbe2b1715cb2409639a00c46c5dea14badc5c2207c"

URI_x86_64_v2_opencryptoki-swtok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-swtok-3.26.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-swtok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-swtok}"
SRC_URI[x86_64_v2_opencryptoki-swtok.sha256sum] = "0c58e69db604ad1aad195d5da767be41c760dd5958418479ec00cb955ccd7cd8"
RPROVIDES:opencryptoki-swtok:x86_64_v2 = "virtual/opencryptoki_token_"

URI_aarch64_opencryptoki = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-3.26.0-2.el10.aarch64.rpm;name=aarch64_opencryptoki;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki}"
SRC_URI[aarch64_opencryptoki.sha256sum] = "b4a6086e2a6c1b76f9e944fad56c363a06d80da2d787e33ec7871bdbf48676de"

URI_aarch64_opencryptoki-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/opencryptoki-devel-3.26.0-2.el10.aarch64.rpm;name=aarch64_opencryptoki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki-devel}"
SRC_URI[aarch64_opencryptoki-devel.sha256sum] = "afc05e4c86797e1abd5439fa7ddc7e0cd795ed15b2430c03941ccc86571bb218"

URI_aarch64_opencryptoki-icsftok = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-icsftok-3.26.0-2.el10.aarch64.rpm;name=aarch64_opencryptoki-icsftok;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki-icsftok}"
SRC_URI[aarch64_opencryptoki-icsftok.sha256sum] = "8d37fc3c709d8c76345e7fea6021f386c1dc2663eaf17890f2d85cedb70cf35f"
RPROVIDES:opencryptoki-icsftok:aarch64 = "virtual/opencryptoki_token_"

URI_aarch64_opencryptoki-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-libs-3.26.0-2.el10.aarch64.rpm;name=aarch64_opencryptoki-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki-libs}"
SRC_URI[aarch64_opencryptoki-libs.sha256sum] = "99b1598ef31e9ed0b84afb9838ff0f2b1c97eddc1750438fc5f29b172b6f2b46"

URI_aarch64_opencryptoki-swtok = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-swtok-3.26.0-2.el10.aarch64.rpm;name=aarch64_opencryptoki-swtok;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki-swtok}"
SRC_URI[aarch64_opencryptoki-swtok.sha256sum] = "f3ddc59149489d38b1061b131d1b05cf107384dd787c4fed03a5c0e5e3f03aec"
RPROVIDES:opencryptoki-swtok:aarch64 = "virtual/opencryptoki_token_"

RDEPENDS:opencryptoki:x86_64_v2 = " \
 bash \
 diffutils \
 glibc \
 libcap \
 opencryptoki-libs \
 openssl \
 openssl-libs \
 selinux-policy \
 shadow-utils \
 systemd \
 virtual/coreutils \
 virtual/opencryptoki_token_ \
"
RDEPENDS:opencryptoki:aarch64 = " \
 bash \
 diffutils \
 glibc \
 opencryptoki-libs \
 openssl \
 openssl-libs \
 selinux-policy \
 shadow-utils \
 systemd \
 virtual/coreutils \
 virtual/opencryptoki_token_ \
"
RDEPENDS:opencryptoki-ccatok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:opencryptoki-devel = " \
 opencryptoki-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:opencryptoki-icsftok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:opencryptoki-libs = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 shadow-utils \
 "
RDEPENDS:opencryptoki-swtok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/opencryptoki_token_"

PROVIDES:append:aarch64 = " rpm/virtual/opencryptoki_token_"
