# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-syn"
PV = "3.0.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-syn+clone-impls-devel \
 rust-syn+default-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+test-devel \
 rust-syn+visit-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-syn-3.0.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dfe74dcb6351e81b45931a726bee4ad88c62f2f92866ec2f43f390653c5fa80f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+clone-impls-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+clone-impls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+clone-impls-devel.sha256sum] = "d5379026882a0b5893e2fcb38d08d18523beef134197e5a261dafb13f490cf0c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+default-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+default-devel.sha256sum] = "d825d2022609d95f91646254dc2225811c611e5c6adb099cd26887e7a3b9d2d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+derive-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+derive-devel.sha256sum] = "9c308a5909139621f2edae1963c7184b99aae8125a8487ec3aeea8d5484018f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+extra-traits-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+extra-traits-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+extra-traits-devel.sha256sum] = "21436c9e41d9edd2ab97afd7202a5a0ec4a1cb68d49b097025afe259a3e071bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+fold-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+fold-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+fold-devel.sha256sum] = "fd26ee5ff7f2e4ef0cb49d9c893988312b84c018cfb5451450b2ed41d91a2873"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+full-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+full-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+full-devel.sha256sum] = "08b4f941965d7ade08fd9cb0cb233ae058bb1e23490cd97dbccfe594fe1508f7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+parsing-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+parsing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+parsing-devel.sha256sum] = "22bdbeaf8349dcbb5e89c02f474dd288249d4f775cb676c08a0bfa6e38aea592"
RPROVIDES:rust-syn+parsing-devel:append:x86_64_v2 = " virtual/crate_syn/parsing__ge_1.0.0_with_crate_syn/parsing__lt_4.0.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+printing-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+printing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+printing-devel.sha256sum] = "d1fa25532acf8e06f370eb79fc597157f72cfd1fc63e8cc1170826369ad2e70e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+proc-macro-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+proc-macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+proc-macro-devel.sha256sum] = "172f8c31bbd19bb03add00e317f0df641367c43c57e723927c20963be2f2802d"
RPROVIDES:rust-syn+proc-macro-devel:append:x86_64_v2 = " virtual/crate_syn/proc-macro__ge_1.0.0_with_crate_syn/proc-macro__lt_4.0.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+test-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+test-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+test-devel.sha256sum] = "056ec29362493cc9218dca54e5bad5b9dbc2646b6798b4b82bd9b149c9acda8f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+visit-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+visit-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+visit-devel.sha256sum] = "69044931bdaebebd66db389909a174d02fcd56c4ce466254dddfae0b8d9d0d7f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+visit-mut-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+visit-mut-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+visit-mut-devel.sha256sum] = "f2c01036eec090e7f07560818cad1f9f43d5291afa45dd3182adaa7a7e9696e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn-devel.sha256sum] = "860c71baed77b2684a42dc1203942cd3c05fd4b61e3720793e4b2dcde0bdc64d"
RPROVIDES:rust-syn-devel:append:x86_64_v2 = " virtual/crate_syn__ge_1.0.0_with_crate_syn__lt_4.0.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+clone-impls-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-syn+clone-impls-devel;unpack=0"
SRC_URI[aarch64_rust-syn+clone-impls-devel.sha256sum] = "ad7139f6b1c264c8ea94b044360e4be1c8ca8f0a3a15067aac849919392ec8d2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+default-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-syn+default-devel;unpack=0"
SRC_URI[aarch64_rust-syn+default-devel.sha256sum] = "e813dad6e50a2ad59b214fd117ddfd6429c9b035030006d3485f0a8da6d79b56"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+derive-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-syn+derive-devel;unpack=0"
SRC_URI[aarch64_rust-syn+derive-devel.sha256sum] = "3e4396c567c926f62a456e37cd71fc44a2a1b3d0140b66f4d2bcdc699f63b5df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+extra-traits-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-syn+extra-traits-devel;unpack=0"
SRC_URI[aarch64_rust-syn+extra-traits-devel.sha256sum] = "a06ba03a613af39060a10ec97394e9f1916530661c177e591cb2768e2e65031e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+fold-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-syn+fold-devel;unpack=0"
SRC_URI[aarch64_rust-syn+fold-devel.sha256sum] = "61c51ffb58005512e63e34dbc719b4d2764a4edfb9b7216228383abb15aaef75"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+full-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-syn+full-devel;unpack=0"
SRC_URI[aarch64_rust-syn+full-devel.sha256sum] = "e485e98195bd8c6c10fb3618712936e65a64441dbd3f03ef4c574ade69eb0e60"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+parsing-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-syn+parsing-devel;unpack=0"
SRC_URI[aarch64_rust-syn+parsing-devel.sha256sum] = "92f54f54614fd09e9d7ea8f0b696cdadeebf234232b2709c0bcfc5ffd1715c87"
RPROVIDES:rust-syn+parsing-devel:append:aarch64 = " virtual/crate_syn/parsing__ge_1.0.0_with_crate_syn/parsing__lt_4.0.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+printing-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-syn+printing-devel;unpack=0"
SRC_URI[aarch64_rust-syn+printing-devel.sha256sum] = "4f40d6dca5cdf74d215ebc930616a19ed7b938ea2e09603d1f106c5ec5371338"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+proc-macro-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-syn+proc-macro-devel;unpack=0"
SRC_URI[aarch64_rust-syn+proc-macro-devel.sha256sum] = "c93bad0d4e1af3dcccbeb33ec9595c0b34224451678450aab60d9eefbaa80950"
RPROVIDES:rust-syn+proc-macro-devel:append:aarch64 = " virtual/crate_syn/proc-macro__ge_1.0.0_with_crate_syn/proc-macro__lt_4.0.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+test-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-syn+test-devel;unpack=0"
SRC_URI[aarch64_rust-syn+test-devel.sha256sum] = "ff719f29b87dcb76730dd9eda014800efab417b31fb40ed8dd98915f0bdeccfd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+visit-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-syn+visit-devel;unpack=0"
SRC_URI[aarch64_rust-syn+visit-devel.sha256sum] = "1563961b6a1c7a2501cdbfee4db5c44ccb16244dca4847c1392446418e5cec4a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+visit-mut-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-syn+visit-mut-devel;unpack=0"
SRC_URI[aarch64_rust-syn+visit-mut-devel.sha256sum] = "93d869fda9556b358b270ccfebcf9f3ad9131e4918d2e8d483e137f910ba1e69"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-syn-devel;unpack=0"
SRC_URI[aarch64_rust-syn-devel.sha256sum] = "825cc0c90c2116b8df129d280752ad72629ccbeddd95b5531b34f93850168952"
RPROVIDES:rust-syn-devel:append:aarch64 = " virtual/crate_syn__ge_1.0.0_with_crate_syn__lt_4.0.0~"

RDEPENDS:rust-syn+clone-impls-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+default-devel = " \
 cargo \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+derive-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+extra-traits-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+fold-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+full-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+parsing-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+printing-devel = " \
 cargo \
 rust-quote-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+proc-macro-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+test-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+visit-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+visit-mut-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-unicode-ident+default-devel \
 "
