# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-awscrt"
PV = "0.27.2"
PR = "1.el10_0"
PACKAGES = " \
 python3-awscrt \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-awscrt-0.27.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67905b384eb5f5f578ef2e8cbf5f5e2ceb698ac65fc4b07570f31e572d7cfbd9"

URI_x86_64_v2_python3-awscrt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-awscrt-0.27.2-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-awscrt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-awscrt}"
SRC_URI[x86_64_v2_python3-awscrt.sha256sum] = "4bec01d1f107345dabac13f95b8f89123d5c69f3817cff140f3a334e06e2cc0d"

URI_aarch64_python3-awscrt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-awscrt-0.27.2-1.el10_0.aarch64.rpm;name=aarch64_python3-awscrt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-awscrt}"
SRC_URI[aarch64_python3-awscrt.sha256sum] = "42f84d34817fc7cb4b080b9c93cab8671ad9b138c8f643fba805cd1965f955de"

RDEPENDS:python3-awscrt = " \
 glibc \
 libgcc \
 openssl-libs \
 python3 \
 "
