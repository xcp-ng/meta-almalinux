# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openbao"
PV = "2.6.3"
PR = "2.el10_3"
PACKAGES = " \
 openbao \
 openbao-vault-compat \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/openbao-2.6.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4b9430dfa7fd5ea3b3bd0af5ddb8f8eee03d16b4584c5750b959a1c5c08a9c42"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbao-2.6.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbao;unpack=0"
SRC_URI[x86_64_v2_openbao.sha256sum] = "3e5777edafe96c10185303e3fa0bff2653a66abfa6c3909e9671e4b59322ae8e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbao-vault-compat-2.6.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbao-vault-compat;unpack=0"
SRC_URI[x86_64_v2_openbao-vault-compat.sha256sum] = "5fd934617c18e13eab02629f8d6bb0d8c354947088ae844caf14b0e238d6d06c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openbao-2.6.3-2.el10_3.aarch64.rpm;name=aarch64_openbao;unpack=0"
SRC_URI[aarch64_openbao.sha256sum] = "a3fbab01ef76c69896f7efe24be0c381e0ba3dc9a82b449307433d341e309f9e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openbao-vault-compat-2.6.3-2.el10_3.aarch64.rpm;name=aarch64_openbao-vault-compat;unpack=0"
SRC_URI[aarch64_openbao-vault-compat.sha256sum] = "c748f6377bc0f3afef6b4335921b81638f0233b850d6f5cba842e83ad512a364"

RDEPENDS:openbao = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:openbao-vault-compat = " \
 openbao \
 "
