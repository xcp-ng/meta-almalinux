# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-home"
PV = "0.5.12"
PR = "1.el10_2"
PACKAGES = " \
 rust-home+default-devel \
 rust-home-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-home-0.5.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0f5503a0d74ed9a342b07ed819afa32630f9122dd68f75076b9b1ff72b84b1e"

URI_x86_64_v2_rust-home+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-home+default-devel-0.5.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-home+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-home+default-devel}"
SRC_URI[x86_64_v2_rust-home+default-devel.sha256sum] = "364bcaef6a0ae128b535713b49d0aa9ee2fada34242fa3fe7e9a1ebdce5737e9"

URI_x86_64_v2_rust-home-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-home-devel-0.5.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-home-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-home-devel}"
SRC_URI[x86_64_v2_rust-home-devel.sha256sum] = "7ad770860484b3086c36ab2aba37f1142158fe404ce156be490aaffeab98e7c8"

URI_aarch64_rust-home+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-home+default-devel-0.5.12-1.el10_2.noarch.rpm;name=aarch64_rust-home+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-home+default-devel}"
SRC_URI[aarch64_rust-home+default-devel.sha256sum] = "b05a6cad1732d7d671c6fbd09f3a334e5050b473f6a1010cdaada65c94950a1f"

URI_aarch64_rust-home-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-home-devel-0.5.12-1.el10_2.noarch.rpm;name=aarch64_rust-home-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-home-devel}"
SRC_URI[aarch64_rust-home-devel.sha256sum] = "e8f6b6fca9be266187de12822ef661fdb5655f3690740095367e73fe924c762e"

RDEPENDS:rust-home+default-devel = " \
 cargo \
 rust-home-devel \
 "
RDEPENDS:rust-home-devel = " \
 cargo \
 rust \
 "
