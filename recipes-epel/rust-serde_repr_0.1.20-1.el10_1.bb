# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_repr"
PV = "0.1.20"
PR = "1.el10_1"
PACKAGES = " \
 rust-serde_repr+default-devel \
 rust-serde_repr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_repr-0.1.20-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7cba31bc9a8824ee38fa86f07836badf8fbc98e2fd07775fdbfd584bab5ef88"

URI_x86_64_v2_rust-serde_repr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_repr+default-devel-0.1.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_repr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_repr+default-devel}"
SRC_URI[x86_64_v2_rust-serde_repr+default-devel.sha256sum] = "03d441677c1d0307774046ef832d82f5c4a97b24cb5df9ab5f0f07459f17238b"

URI_x86_64_v2_rust-serde_repr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_repr-devel-0.1.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_repr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_repr-devel}"
SRC_URI[x86_64_v2_rust-serde_repr-devel.sha256sum] = "1fbced3ccf29351fac4c5a1069f36d16cd410a0f1912ce9ab923220b8d4113a5"

URI_aarch64_rust-serde_repr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_repr+default-devel-0.1.20-1.el10_1.noarch.rpm;name=aarch64_rust-serde_repr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_repr+default-devel}"
SRC_URI[aarch64_rust-serde_repr+default-devel.sha256sum] = "4ce582af31341e1e1182a352302c6ba9c375dba9964c60e9a6d0ddc7dca5ea16"

URI_aarch64_rust-serde_repr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_repr-devel-0.1.20-1.el10_1.noarch.rpm;name=aarch64_rust-serde_repr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_repr-devel}"
SRC_URI[aarch64_rust-serde_repr-devel.sha256sum] = "2842c6c5eb42be9de03ace8b79a34b6545fe6b0e0e22f52bf178d5cf4ce10265"

RDEPENDS:rust-serde_repr+default-devel = " \
 cargo \
 rust-serde_repr-devel \
 "
RDEPENDS:rust-serde_repr-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
