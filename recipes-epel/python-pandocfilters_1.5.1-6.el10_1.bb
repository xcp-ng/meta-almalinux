# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pandocfilters"
PV = "1.5.1"
PR = "6.el10_1"
PACKAGES = " \
 python3-pandocfilters \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pandocfilters-1.5.1-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20c32597c31ff52c04dc8a22c3139f60f06bc6c2a53bbe2097294f30ed3db45e"

URI_x86_64_v2_python3-pandocfilters = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pandocfilters-1.5.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pandocfilters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pandocfilters}"
SRC_URI[x86_64_v2_python3-pandocfilters.sha256sum] = "bdfb67697852ae123a6326a7e6080705ac8e4ffc1653dea56b3e0ef01dab30a4"

URI_aarch64_python3-pandocfilters = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pandocfilters-1.5.1-6.el10_1.noarch.rpm;name=aarch64_python3-pandocfilters;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pandocfilters}"
SRC_URI[aarch64_python3-pandocfilters.sha256sum] = "a32ca021c227463c683339b91e79ddb2d599cf6d426aea8cfe92276bde374f3e"

RDEPENDS:python3-pandocfilters = " \
 python3 \
 "
