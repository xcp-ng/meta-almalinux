# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-llvm-bitcode"
PV = "0.1.2"
PR = "4.el10_0"
PACKAGES = " \
 rust-llvm-bitcode+default-devel \
 rust-llvm-bitcode-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-llvm-bitcode-0.1.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0721c52120e78ab142a8cf05549eaea4a1ccf232c914186a69ce1313d847e90"

URI_x86_64_v2_rust-llvm-bitcode+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-llvm-bitcode+default-devel-0.1.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-llvm-bitcode+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-llvm-bitcode+default-devel}"
SRC_URI[x86_64_v2_rust-llvm-bitcode+default-devel.sha256sum] = "6a8a7d837949c41b9d97c16394fbd26b5538e7762c5a68158bb00ad3f99bc376"

URI_x86_64_v2_rust-llvm-bitcode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-llvm-bitcode-devel-0.1.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-llvm-bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-llvm-bitcode-devel}"
SRC_URI[x86_64_v2_rust-llvm-bitcode-devel.sha256sum] = "c6b8bc819bd3b3da3cc75873c92fbaed8a8c6bde20ec2aa092aab62bec7338a9"

URI_aarch64_rust-llvm-bitcode+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-llvm-bitcode+default-devel-0.1.2-4.el10_0.noarch.rpm;name=aarch64_rust-llvm-bitcode+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-llvm-bitcode+default-devel}"
SRC_URI[aarch64_rust-llvm-bitcode+default-devel.sha256sum] = "915dae65763fc6ca936386fd96903a2ab318e4e7ce6baa08980fe2dc970e0396"

URI_aarch64_rust-llvm-bitcode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-llvm-bitcode-devel-0.1.2-4.el10_0.noarch.rpm;name=aarch64_rust-llvm-bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-llvm-bitcode-devel}"
SRC_URI[aarch64_rust-llvm-bitcode-devel.sha256sum] = "022942c703d6d3f6d36db46e71acb99a6005270fa7ba433f7bf6067899dc0a70"

RDEPENDS:rust-llvm-bitcode+default-devel = " \
 cargo \
 rust-llvm-bitcode-devel \
 "
RDEPENDS:rust-llvm-bitcode-devel = " \
 cargo \
 rust-num_enum+default-devel \
 "
