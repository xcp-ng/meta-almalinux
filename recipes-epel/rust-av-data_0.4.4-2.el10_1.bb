# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-av-data"
PV = "0.4.4"
PR = "2.el10_1"
PACKAGES = " \
 rust-av-data+default-devel \
 rust-av-data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-av-data-0.4.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6dc116563d7e9fe32d416ad604148f3186ebfc6b76a0b39fa94eca34e9fdb26"

URI_x86_64_v2_rust-av-data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-data+default-devel-0.4.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-data+default-devel}"
SRC_URI[x86_64_v2_rust-av-data+default-devel.sha256sum] = "70dc8cbdd28200d2469d23ad817970aa395d9faa3dc90055f31c6aa495ad3d8a"

URI_x86_64_v2_rust-av-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-data-devel-0.4.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-data-devel}"
SRC_URI[x86_64_v2_rust-av-data-devel.sha256sum] = "424f61eca20b92339c11c8856018729ae9815db9680c46ad274420eab61273c7"

URI_aarch64_rust-av-data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-data+default-devel-0.4.4-2.el10_1.noarch.rpm;name=aarch64_rust-av-data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-data+default-devel}"
SRC_URI[aarch64_rust-av-data+default-devel.sha256sum] = "d79cbe828a61baf466e652a7454d95f55ba85a84daad673eae13f7faea4285dc"

URI_aarch64_rust-av-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-data-devel-0.4.4-2.el10_1.noarch.rpm;name=aarch64_rust-av-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-data-devel}"
SRC_URI[aarch64_rust-av-data-devel.sha256sum] = "94492233bbed11f667bcb117bbaa4483174e247aa96748ad5b240f4f6f32cec4"

RDEPENDS:rust-av-data+default-devel = " \
 cargo \
 rust-av-data-devel \
 "
RDEPENDS:rust-av-data-devel = " \
 cargo \
 rust-byte-slice-cast+default-devel \
 rust-bytes+default-devel \
 rust-num-derive+default-devel \
 rust-num-rational+default-devel \
 rust-num-traits+default-devel \
 "
