# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mrtg"
PV = "2.17.10"
PR = "13.el10"
PACKAGES = " \
 mrtg \
 mrtg-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mrtg-2.17.10-13.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "18322d8657b100339d49ed29fc939d35d28a72dfdacd899fad9d4eb4b4e23295"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mrtg-2.17.10-13.el10.x86_64_v2.rpm;name=x86_64_v2_mrtg;unpack=0"
SRC_URI[x86_64_v2_mrtg.sha256sum] = "cf95fa6eeea13ad255787edb5787d910d17af79e761551d0595bfbc61111ccff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mrtg-selinux-2.17.10-13.el10.noarch.rpm;name=x86_64_v2_mrtg-selinux;unpack=0"
SRC_URI[x86_64_v2_mrtg-selinux.sha256sum] = "9770aac568da71e202b4f290fca56729431eb578eb907a376c182100fa48fb77"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mrtg-2.17.10-13.el10.aarch64.rpm;name=aarch64_mrtg;unpack=0"
SRC_URI[aarch64_mrtg.sha256sum] = "9c4150d2fece7e360563374831a560dd89cd4d6d720c61d31b0ee98a7adf9628"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mrtg-selinux-2.17.10-13.el10.noarch.rpm;name=aarch64_mrtg-selinux;unpack=0"
SRC_URI[aarch64_mrtg-selinux.sha256sum] = "9770aac568da71e202b4f290fca56729431eb578eb907a376c182100fa48fb77"

RDEPENDS:mrtg = " \
 bash \
 gd \
 glibc \
 mrtg \
 mrtg-selinux \
 perl-CGI \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IO \
 perl-IO-Socket-INET6 \
 perl-Math-BigInt \
 perl-POSIX \
 perl-Pod-Usage \
 perl-SNMP_Session \
 perl-Socket \
 perl-Socket6 \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-locale \
 perl-vars \
 systemd \
 "
RDEPENDS:mrtg-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
