# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kparts"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kparts \
 kf6-kparts-devel \
 kf6-kparts-doc \
 kf6-kparts-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kparts-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd87e1f6685be7ad32b88d059aa89fe9829e7cb9b95fac2071438a70238dffd7"

URI_x86_64_v2_kf6-kparts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kparts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts}"
SRC_URI[x86_64_v2_kf6-kparts.sha256sum] = "41cc69d6fbe3bf5cb778d26b60966cc1b67d34656b246f66319e68994163ad69"

URI_x86_64_v2_kf6-kparts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kparts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts-devel}"
SRC_URI[x86_64_v2_kf6-kparts-devel.sha256sum] = "399740fe480e788ca199f889d10165f0f9888f828b0ec2e831b53984608b8f45"

URI_x86_64_v2_kf6-kparts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kparts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts-doc}"
SRC_URI[x86_64_v2_kf6-kparts-doc.sha256sum] = "2240173ad1e2d856cc9de9b88c7fb28efb9b8719f48dec677205349a01acc08c"

URI_x86_64_v2_kf6-kparts-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kparts-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts-html}"
SRC_URI[x86_64_v2_kf6-kparts-html.sha256sum] = "7e4ba9dd2016573eb209ef56f28243234d37dadf732d08ccccc06a0fde6fb568"

URI_aarch64_kf6-kparts = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kparts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts}"
SRC_URI[aarch64_kf6-kparts.sha256sum] = "978ba3ec3f0fbd001b1002143d9749c6f04df82ec5dd971dd31e7af7b53189a1"

URI_aarch64_kf6-kparts-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kparts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts-devel}"
SRC_URI[aarch64_kf6-kparts-devel.sha256sum] = "a38e28d2c9e16db49a8909b2e1bc6ce0f1ea680866e427555a65e6716aa34054"

URI_aarch64_kf6-kparts-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kparts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts-doc}"
SRC_URI[aarch64_kf6-kparts-doc.sha256sum] = "eadf7959c2a56a73749031b06e506c38a3daf9b7d5a1c413ce159a56888f6e2b"

URI_aarch64_kf6-kparts-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kparts-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts-html}"
SRC_URI[aarch64_kf6-kparts-html.sha256sum] = "c1066cdea000b12dfce0c5f4163a9821a1d2c80b4ed3211d53736590ed3bb204"

RDEPENDS:kf6-kparts = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kparts-devel = " \
 cmake-filesystem \
 kf6-kio-devel \
 kf6-kparts \
 kf6-ktextwidgets-devel \
 kf6-kxmlgui-devel \
 "
RDEPENDS:kf6-kparts-doc = " \
 "
RDEPENDS:kf6-kparts-html = " \
 "
