# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcalendarcore"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcalendarcore \
 kf6-kcalendarcore-devel \
 kf6-kcalendarcore-doc \
 kf6-kcalendarcore-html \
 python3-kf6-kcalendarcore \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kcalendarcore-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c566e8ac9595d7eccfcc3058f2f1b16865f37a6d844839359477634e993d3329"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcalendarcore;unpack=0"
SRC_URI[x86_64_v2_kf6-kcalendarcore.sha256sum] = "929cca73c53659f8c8df9ef17727c92a661b9b91070b384eb99a276807d478c8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcalendarcore-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kcalendarcore-devel.sha256sum] = "dea3994660a0cf6b73e0eda340738946cb571072af621129c62520c70ba7e72b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcalendarcore-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kcalendarcore-doc.sha256sum] = "d1c12506eb1efd554eef769944c44d854e3bd76c39d1d30e5c57661ac31c0c5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcalendarcore-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kcalendarcore-html.sha256sum] = "73769510ebbff0d464c8d2006f6e4aa5f86cbb5a1acf6da9440dd2303f124821"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kcalendarcore-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kcalendarcore;unpack=0"
SRC_URI[x86_64_v2_python3-kf6-kcalendarcore.sha256sum] = "716dc8212fc8171747a7757e4e6644b412c9097eac7e540c513be183926de92a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcalendarcore;unpack=0"
SRC_URI[aarch64_kf6-kcalendarcore.sha256sum] = "843845d4d316e90b053e032c229614a7badb368cce600ace6467701aaf48ad7f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcalendarcore-devel;unpack=0"
SRC_URI[aarch64_kf6-kcalendarcore-devel.sha256sum] = "813ad23d3f60f3e12f776289ef970bd0b2cc91637b261fde6d95af1074deea69"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcalendarcore-doc;unpack=0"
SRC_URI[aarch64_kf6-kcalendarcore-doc.sha256sum] = "ed61ff9ec0b0c0cf737aaaf0e4dfb344df018edf62b0206e37da6d2a961cfed1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcalendarcore-html;unpack=0"
SRC_URI[aarch64_kf6-kcalendarcore-html.sha256sum] = "3d8814c11b7f30838b1a2805d68c532970ffa08264ab87cd69b903e6b0fa0de6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kcalendarcore-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kcalendarcore;unpack=0"
SRC_URI[aarch64_python3-kf6-kcalendarcore.sha256sum] = "cb1e74e53fb217f9f359d30174fc4e0c974e47fbd64ecb46c6b70618ed17d555"

RDEPENDS:kf6-kcalendarcore = " \
 glibc \
 libical \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcalendarcore-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore \
 libical-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcalendarcore-doc = " \
 "
RDEPENDS:kf6-kcalendarcore-html = " \
 "
RDEPENDS:python3-kf6-kcalendarcore = " \
 glibc \
 kf6-kcalendarcore \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
