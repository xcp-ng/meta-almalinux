# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-asaskevich-govalidator"
PV = "11.0.1"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-asaskevich-govalidator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-asaskevich-govalidator-11.0.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bad2847d7fcaa8f3a6eda069be89a4ee5c4d1d1425331c0ccb61ac813f491a5"

URI_x86_64_v2_golang-github-asaskevich-govalidator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-asaskevich-govalidator-devel-11.0.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-asaskevich-govalidator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-asaskevich-govalidator-devel}"
SRC_URI[x86_64_v2_golang-github-asaskevich-govalidator-devel.sha256sum] = "2cda83d7b034b6d4a72211d2566bcad5e3ae114fdd998ab379245bab6ccb7376"

URI_aarch64_golang-github-asaskevich-govalidator-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-asaskevich-govalidator-devel-11.0.1-12.el10_0.noarch.rpm;name=aarch64_golang-github-asaskevich-govalidator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-asaskevich-govalidator-devel}"
SRC_URI[aarch64_golang-github-asaskevich-govalidator-devel.sha256sum] = "9c1c8e0d195e2ba70783f32de4af981b47af0cdeb162ffae17bf8246d6def814"

RDEPENDS:golang-github-asaskevich-govalidator-devel = " \
 go-filesystem \
 "
