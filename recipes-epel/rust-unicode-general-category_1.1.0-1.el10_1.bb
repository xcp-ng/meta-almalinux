# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-general-category"
PV = "1.1.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-unicode-general-category+default-devel \
 rust-unicode-general-category-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-general-category-1.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e91083c2561388a7e3b139430183177bbddd8f8e24321b41385f1843702f9d6"

URI_x86_64_v2_rust-unicode-general-category+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-general-category+default-devel-1.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-general-category+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-general-category+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-general-category+default-devel.sha256sum] = "0bdce1a9ed68d9236fdd40bf46013d673c058745da962857e41f1b88151e6475"

URI_x86_64_v2_rust-unicode-general-category-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-general-category-devel-1.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-general-category-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-general-category-devel}"
SRC_URI[x86_64_v2_rust-unicode-general-category-devel.sha256sum] = "beef8821552c9923af7bd38ba17931c2720ee8a5977a770f60278cda87fa0222"

URI_aarch64_rust-unicode-general-category+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-general-category+default-devel-1.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-unicode-general-category+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-general-category+default-devel}"
SRC_URI[aarch64_rust-unicode-general-category+default-devel.sha256sum] = "7a4a385c7c86c2b37105bac4eedaa9179e2333060890636902baf8b345be4146"

URI_aarch64_rust-unicode-general-category-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-general-category-devel-1.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-unicode-general-category-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-general-category-devel}"
SRC_URI[aarch64_rust-unicode-general-category-devel.sha256sum] = "0ef1af4e3821f485563f1e59eca67316854b03ed7076d0e73b4972bb139bae50"

RDEPENDS:rust-unicode-general-category+default-devel = " \
 cargo \
 rust-unicode-general-category-devel \
 "
RDEPENDS:rust-unicode-general-category-devel = " \
 cargo \
 "
