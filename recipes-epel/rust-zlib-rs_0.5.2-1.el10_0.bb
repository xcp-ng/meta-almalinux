# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zlib-rs"
PV = "0.5.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-zlib-rs+c-allocator-devel \
 rust-zlib-rs+default-devel \
 rust-zlib-rs+rust-allocator-devel \
 rust-zlib-rs+std-devel \
 rust-zlib-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zlib-rs-0.5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fda8804f0af169cffea30cb26738985e5beb7eccde99c11c0e37f75bb4fabdcf"

URI_x86_64_v2_rust-zlib-rs+c-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+c-allocator-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+c-allocator-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+c-allocator-devel.sha256sum] = "483baca7df2c0d3a3c73ca048d1b0febe798d768af5c049bf867fe1fd5029a1b"

URI_x86_64_v2_rust-zlib-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+default-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+default-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+default-devel.sha256sum] = "3ee668ea2f533e7553fefb0ea81be22e486454b8181592b0acaaaca33c6d729d"

URI_x86_64_v2_rust-zlib-rs+rust-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+rust-allocator-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+rust-allocator-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+rust-allocator-devel.sha256sum] = "2e5c91fe63a1091e4931161c5fbb3b05d93efff69df2d0d63c4c0ff97a02a899"

URI_x86_64_v2_rust-zlib-rs+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+std-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+std-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+std-devel.sha256sum] = "07c4648959e99cfa563e4b779c752fd563a5ba063de0cf47273be269940cf40f"

URI_x86_64_v2_rust-zlib-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs-devel.sha256sum] = "c46aed56694af03ea55b98110f8a0ef828e1b3083d0eb33c3a8cbecd1871f383"

URI_aarch64_rust-zlib-rs+c-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+c-allocator-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-zlib-rs+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+c-allocator-devel}"
SRC_URI[aarch64_rust-zlib-rs+c-allocator-devel.sha256sum] = "0993de8e7ee6d066f286e5d8f2f4407b66e42cd91a63a728af262d2624e03af7"

URI_aarch64_rust-zlib-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+default-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-zlib-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+default-devel}"
SRC_URI[aarch64_rust-zlib-rs+default-devel.sha256sum] = "97f153e624131febf5009b3b0ff7d944aface503446484853bd10da2cdaf7dce"

URI_aarch64_rust-zlib-rs+rust-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+rust-allocator-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-zlib-rs+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+rust-allocator-devel}"
SRC_URI[aarch64_rust-zlib-rs+rust-allocator-devel.sha256sum] = "da13799f5556e786c0bd654eeedf6b73c1f4f16b84679546679d86df679d375f"

URI_aarch64_rust-zlib-rs+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+std-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-zlib-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+std-devel}"
SRC_URI[aarch64_rust-zlib-rs+std-devel.sha256sum] = "bbafc5d11bad790f5f4b61102470b742ab8d4a417ecdb3dadddf0b5850abcd18"

URI_aarch64_rust-zlib-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs-devel}"
SRC_URI[aarch64_rust-zlib-rs-devel.sha256sum] = "4e30f64f2977ed1032ca6e0f0e863cf7cc2d18c326a65b9b31e78f584168f2c4"

RDEPENDS:rust-zlib-rs+c-allocator-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+default-devel = " \
 cargo \
 rust-zlib-rs+c-allocator-devel \
 rust-zlib-rs+std-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+rust-allocator-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+std-devel = " \
 cargo \
 rust-zlib-rs+rust-allocator-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs-devel = " \
 cargo \
 rust \
 "
