# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ratatui-core"
PV = "0.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-ratatui-core+anstyle-devel \
 rust-ratatui-core+default-devel \
 rust-ratatui-core+document-features-devel \
 rust-ratatui-core+layout-cache-devel \
 rust-ratatui-core+palette-devel \
 rust-ratatui-core+portable-atomic-devel \
 rust-ratatui-core+scrolling-regions-devel \
 rust-ratatui-core+serde-devel \
 rust-ratatui-core+std-devel \
 rust-ratatui-core+underline-color-devel \
 rust-ratatui-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ratatui-core-0.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6dec693d3eb8e689db96fb349416b388db80539241fe65b8d124f89ddac39b38"

URI_x86_64_v2_rust-ratatui-core+anstyle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-core+anstyle-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-core+anstyle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-core+anstyle-devel}"
SRC_URI[x86_64_v2_rust-ratatui-core+anstyle-devel.sha256sum] = "b6123aaa9a8a99ad306cc0427be3fcbd6c16859da42f261e171155ba91b9f8b9"

URI_x86_64_v2_rust-ratatui-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-core+default-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-core+default-devel}"
SRC_URI[x86_64_v2_rust-ratatui-core+default-devel.sha256sum] = "fc90e403ef89133ca21c310a3b6ad3f7b6a4c07f80c9bd264567b7c7609e1ebb"

URI_x86_64_v2_rust-ratatui-core+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-core+document-features-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-core+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-core+document-features-devel}"
SRC_URI[x86_64_v2_rust-ratatui-core+document-features-devel.sha256sum] = "a51b3af4dd05d26df6fef697d55f4e48e80965321b0cba73d622098b6b32ff64"

URI_x86_64_v2_rust-ratatui-core+layout-cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-core+layout-cache-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-core+layout-cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-core+layout-cache-devel}"
SRC_URI[x86_64_v2_rust-ratatui-core+layout-cache-devel.sha256sum] = "f1810ab05237934a2508160def18cc79921db572d196bfcf8aa503482ee80a76"

URI_x86_64_v2_rust-ratatui-core+palette-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-core+palette-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-core+palette-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-core+palette-devel}"
SRC_URI[x86_64_v2_rust-ratatui-core+palette-devel.sha256sum] = "71be4038b770308b654a57136af43a77c53e9120bfdc16b65c495385cb560930"

URI_x86_64_v2_rust-ratatui-core+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-core+portable-atomic-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-core+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-core+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-ratatui-core+portable-atomic-devel.sha256sum] = "cebf9d50112b33f45ef73561f1f75a612580d3e0bc1ccfcab0b11237303a43dd"

URI_x86_64_v2_rust-ratatui-core+scrolling-regions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-core+scrolling-regions-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-core+scrolling-regions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-core+scrolling-regions-devel}"
SRC_URI[x86_64_v2_rust-ratatui-core+scrolling-regions-devel.sha256sum] = "10adaf506785f5ceab04d1da8932b051c4a40660b1cc8f8922a506b7ccf0f8ea"

URI_x86_64_v2_rust-ratatui-core+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-core+serde-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-core+serde-devel}"
SRC_URI[x86_64_v2_rust-ratatui-core+serde-devel.sha256sum] = "3fea4b76a81b389bffaad32aa8cfcc02f10fdb1c3cd938cb4920a84ca93cc704"

URI_x86_64_v2_rust-ratatui-core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-core+std-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-core+std-devel}"
SRC_URI[x86_64_v2_rust-ratatui-core+std-devel.sha256sum] = "527fc8370192446f6873b0e1f89bcd02f893e9080e8dbee124106dad7d344d0c"

URI_x86_64_v2_rust-ratatui-core+underline-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-core+underline-color-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-core+underline-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-core+underline-color-devel}"
SRC_URI[x86_64_v2_rust-ratatui-core+underline-color-devel.sha256sum] = "ae766910340a69d2885af735acd99c89b71f673d2e6302874402fd8478784889"

URI_x86_64_v2_rust-ratatui-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-core-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-core-devel}"
SRC_URI[x86_64_v2_rust-ratatui-core-devel.sha256sum] = "d11a872974c334d74e4c9a91e913ffe8427001d44c19a14a340dd4987e07b2e9"

URI_aarch64_rust-ratatui-core+anstyle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-core+anstyle-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-core+anstyle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-core+anstyle-devel}"
SRC_URI[aarch64_rust-ratatui-core+anstyle-devel.sha256sum] = "45266d475dcfbd52b88d64cce5bfd76f1618a4f1239df6c42c441c3cfb579b47"

URI_aarch64_rust-ratatui-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-core+default-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-core+default-devel}"
SRC_URI[aarch64_rust-ratatui-core+default-devel.sha256sum] = "b9417759a895b07bf39b2f40aa0aee195321cc52d2a7c0cc3ad97eb810d9a7f0"

URI_aarch64_rust-ratatui-core+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-core+document-features-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-core+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-core+document-features-devel}"
SRC_URI[aarch64_rust-ratatui-core+document-features-devel.sha256sum] = "8018ee4e376bc474315ed1732881a6dd3bad912b1aae2a1b3e314c551a59996a"

URI_aarch64_rust-ratatui-core+layout-cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-core+layout-cache-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-core+layout-cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-core+layout-cache-devel}"
SRC_URI[aarch64_rust-ratatui-core+layout-cache-devel.sha256sum] = "e55a94dc73760a90e05a720b3a1f771f2cdfd8f8774db61dde90dbde01be9019"

URI_aarch64_rust-ratatui-core+palette-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-core+palette-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-core+palette-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-core+palette-devel}"
SRC_URI[aarch64_rust-ratatui-core+palette-devel.sha256sum] = "81acd21dc6f25cef9d128d21a2ac1a88e81126aaed3861f810e66bd63c94faef"

URI_aarch64_rust-ratatui-core+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-core+portable-atomic-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-core+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-core+portable-atomic-devel}"
SRC_URI[aarch64_rust-ratatui-core+portable-atomic-devel.sha256sum] = "78c8db09ee284e739de70b695148b9e1b2be4d539015b6f27def30ce89dac9cb"

URI_aarch64_rust-ratatui-core+scrolling-regions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-core+scrolling-regions-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-core+scrolling-regions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-core+scrolling-regions-devel}"
SRC_URI[aarch64_rust-ratatui-core+scrolling-regions-devel.sha256sum] = "5db21d1ce0acd04d886754f6037f4779d67592887980377c05950dfd0844c34c"

URI_aarch64_rust-ratatui-core+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-core+serde-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-core+serde-devel}"
SRC_URI[aarch64_rust-ratatui-core+serde-devel.sha256sum] = "11fba8966032f9fe8a4fe6ac585028afe262ad8044dd5fb5803fb168e412b4fd"

URI_aarch64_rust-ratatui-core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-core+std-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-core+std-devel}"
SRC_URI[aarch64_rust-ratatui-core+std-devel.sha256sum] = "c66839be1f0ed7ca5f1d404e8b1bf5068ca22a0e5a99a840a480646d0d1b23a5"

URI_aarch64_rust-ratatui-core+underline-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-core+underline-color-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-core+underline-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-core+underline-color-devel}"
SRC_URI[aarch64_rust-ratatui-core+underline-color-devel.sha256sum] = "ecbff85162f3f3eff06af79732759bfb93f4629eb8cfe59e9e4acc7adfac1e1d"

URI_aarch64_rust-ratatui-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-core-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-core-devel}"
SRC_URI[aarch64_rust-ratatui-core-devel.sha256sum] = "7568ef2af5bacbedac0d46ac3424c509f939e8b315b18e3033dbca3f9c7662ac"

RDEPENDS:rust-ratatui-core+anstyle-devel = " \
 cargo \
 rust-anstyle+default-devel \
 rust-ratatui-core-devel \
 "
RDEPENDS:rust-ratatui-core+default-devel = " \
 cargo \
 rust-ratatui-core-devel \
 "
RDEPENDS:rust-ratatui-core+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-ratatui-core-devel \
 "
RDEPENDS:rust-ratatui-core+layout-cache-devel = " \
 cargo \
 rust-ratatui-core+std-devel \
 rust-ratatui-core-devel \
 "
RDEPENDS:rust-ratatui-core+palette-devel = " \
 cargo \
 rust-palette+default-devel \
 rust-ratatui-core+std-devel \
 rust-ratatui-core-devel \
 "
RDEPENDS:rust-ratatui-core+portable-atomic-devel = " \
 cargo \
 rust-kasuari+portable-atomic-devel \
 rust-ratatui-core-devel \
 "
RDEPENDS:rust-ratatui-core+scrolling-regions-devel = " \
 cargo \
 rust-ratatui-core-devel \
 "
RDEPENDS:rust-ratatui-core+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-compact_str0.9+serde-devel \
 rust-ratatui-core+std-devel \
 rust-ratatui-core-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-ratatui-core+std-devel = " \
 cargo \
 rust-compact_str0.9+std-devel \
 rust-itertools0.14+use_std-devel \
 rust-kasuari+std-devel \
 rust-ratatui-core-devel \
 rust-strum0.27+std-devel \
 rust-thiserror+std-devel \
 rust-unicode-truncate+std-devel \
 "
RDEPENDS:rust-ratatui-core+underline-color-devel = " \
 cargo \
 rust-ratatui-core-devel \
 "
RDEPENDS:rust-ratatui-core-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-compact_str0.9-devel \
 rust-hashbrown0.16+default-devel \
 rust-indoc+default-devel \
 rust-itertools0.14+use_alloc-devel \
 rust-itertools0.14-devel \
 rust-kasuari-devel \
 rust-lru+default-devel \
 rust-strum0.27+derive-devel \
 rust-strum0.27-devel \
 rust-thiserror-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-truncate-devel \
 rust-unicode-width+default-devel \
 "
