# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl"
PE = "4"
PV = "5.40.2"
PR = "515.el10_2"
PACKAGES = " \
 perl \
 perl-Attribute-Handlers \
 perl-AutoLoader \
 perl-AutoSplit \
 perl-B \
 perl-Benchmark \
 perl-Class-Struct \
 perl-Config-Extensions \
 perl-DBM_Filter \
 perl-Devel-Peek \
 perl-Devel-SelfStubber \
 perl-DirHandle \
 perl-Dumpvalue \
 perl-DynaLoader \
 perl-English \
 perl-Errno \
 perl-ExtUtils-Constant \
 perl-ExtUtils-Embed \
 perl-ExtUtils-Miniperl \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-DosGlob \
 perl-File-Find \
 perl-File-stat \
 perl-FileCache \
 perl-FileHandle \
 perl-FindBin \
 perl-GDBM_File \
 perl-Getopt-Std \
 perl-Hash-Util \
 perl-Hash-Util-FieldHash \
 perl-I18N-Collate \
 perl-I18N-LangTags \
 perl-I18N-Langinfo \
 perl-IO \
 perl-IPC-Open3 \
 perl-Locale-Maketext-Simple \
 perl-Math-Complex \
 perl-Memoize \
 perl-Module-Loaded \
 perl-NDBM_File \
 perl-NEXT \
 perl-Net \
 perl-ODBM_File \
 perl-Opcode \
 perl-POSIX \
 perl-Pod-Functions \
 perl-Pod-Html \
 perl-Safe \
 perl-Search-Dict \
 perl-SelectSaver \
 perl-SelfLoader \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Term-Complete \
 perl-Term-ReadLine \
 perl-Test \
 perl-Text-Abbrev \
 perl-Thread \
 perl-Thread-Semaphore \
 perl-Tie \
 perl-Tie-File \
 perl-Tie-Memoize \
 perl-Time \
 perl-Time-Piece \
 perl-Unicode-UCD \
 perl-User-pwent \
 perl-autouse \
 perl-base \
 perl-blib \
 perl-debugger \
 perl-deprecate \
 perl-devel \
 perl-diagnostics \
 perl-doc \
 perl-encoding-warnings \
 perl-fields \
 perl-filetest \
 perl-if \
 perl-interpreter \
 perl-less \
 perl-lib \
 perl-libnetcfg \
 perl-libs \
 perl-locale \
 perl-macros \
 perl-meta-notation \
 perl-mro \
 perl-open \
 perl-overload \
 perl-overloading \
 perl-ph \
 perl-sigtrap \
 perl-sort \
 perl-subs \
 perl-utils \
 perl-vars \
 perl-vmsish \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-5.40.2-515.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9b294cda3117fa52b6654a0dfd30c4a0dbd77513f5d3d377ff811899c5ed8bc6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-5.40.2-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl;unpack=0"
SRC_URI[x86_64_v2_perl.sha256sum] = "78ffbcbb5e8a829cf53cb76e409e8496553d2ea384eee3eb32e76edba0d71661"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Attribute-Handlers-1.03-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Attribute-Handlers;unpack=0"
SRC_URI[x86_64_v2_perl-Attribute-Handlers.sha256sum] = "77b3940fa81302f640a8fc18a554e27c5a3788da8a3c05b1f3e1bc3d75795a37"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-AutoLoader-5.74-515.el10_2.noarch.rpm;name=x86_64_v2_perl-AutoLoader;unpack=0"
SRC_URI[x86_64_v2_perl-AutoLoader.sha256sum] = "1b540d06f1b3584f80113b6c546b8864cd617dffbb8513045b03d7132e826012"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-AutoSplit-5.74-515.el10_2.noarch.rpm;name=x86_64_v2_perl-AutoSplit;unpack=0"
SRC_URI[x86_64_v2_perl-AutoSplit.sha256sum] = "6b59cf08fb7286fb3f4198e45cd3d4f5006406267051a10617fb5304cd5266d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-B-1.89-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-B;unpack=0"
SRC_URI[x86_64_v2_perl-B.sha256sum] = "c2cacf8a77e9ba4da4b5dff05893df7f59738be1b737675cc7f140d02490c73f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Benchmark-1.25-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Benchmark;unpack=0"
SRC_URI[x86_64_v2_perl-Benchmark.sha256sum] = "b7973b40a45771d3dfd56138ebae057d2fbaf20fda1998e379b0210fd9be01a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Class-Struct-0.68-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Class-Struct;unpack=0"
SRC_URI[x86_64_v2_perl-Class-Struct.sha256sum] = "f67705171349b9de0f487263220dbf6cb9e59eb628540da756ce686222c81324"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Config-Extensions-0.03-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Config-Extensions;unpack=0"
SRC_URI[x86_64_v2_perl-Config-Extensions.sha256sum] = "735ba0cc433b5cf1e24d38cde1b3370a929cb3d7e9d19a4191862d988e7e06f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DBM_Filter-0.06-515.el10_2.noarch.rpm;name=x86_64_v2_perl-DBM_Filter;unpack=0"
SRC_URI[x86_64_v2_perl-DBM_Filter.sha256sum] = "9c44ff926043c1465c2b3f769f5d460af437848027936af2885671f71c45b6c3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Devel-Peek-1.34-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-Devel-Peek;unpack=0"
SRC_URI[x86_64_v2_perl-Devel-Peek.sha256sum] = "4281e6b6efb1a858a6b0b5d87247e3372eb2b6c052096c65396cdc537bd986f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Devel-SelfStubber-1.06-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Devel-SelfStubber;unpack=0"
SRC_URI[x86_64_v2_perl-Devel-SelfStubber.sha256sum] = "9bf0cebe98e3c5d7c7391fc556d152673f3f4ac637e62559e72f00322c9665ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DirHandle-1.05-515.el10_2.noarch.rpm;name=x86_64_v2_perl-DirHandle;unpack=0"
SRC_URI[x86_64_v2_perl-DirHandle.sha256sum] = "c74ec5ab698006562d3ebd6b4dcbd879c336390d3e5cca29cb4cce85b85b5a7d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Dumpvalue-2.27-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Dumpvalue;unpack=0"
SRC_URI[x86_64_v2_perl-Dumpvalue.sha256sum] = "5c387af29496631904e0e4512b0042204cdfe1760561da0a1a7779cd1b9432c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DynaLoader-1.56-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-DynaLoader;unpack=0"
SRC_URI[x86_64_v2_perl-DynaLoader.sha256sum] = "781cff99b8d4982e4082bd9842a1762e36cc2ea6cd357e7d46f815be690ae8ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-English-1.11-515.el10_2.noarch.rpm;name=x86_64_v2_perl-English;unpack=0"
SRC_URI[x86_64_v2_perl-English.sha256sum] = "a81d60d0b8acf592731701a57479d115867187afff5573bd5a82fe8b130972a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Errno-1.38-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-Errno;unpack=0"
SRC_URI[x86_64_v2_perl-Errno.sha256sum] = "6712921f5cdcefc80245839d630ebab0599f56aa847922d607b4a2cdd7f406b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Constant-0.25-515.el10_2.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Constant;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Constant.sha256sum] = "873bb09b54d407b9bf5ff9c9e00e0c0053f12ca3a38e094acf6fe08c2101501e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Embed-1.35-515.el10_2.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Embed;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Embed.sha256sum] = "68dcc2966462f39ae38c5ebcae4c337dc9e0b06c3ea981844a143d3995c06753"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Miniperl-1.14-515.el10_2.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Miniperl;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Miniperl.sha256sum] = "2b7283b3c5536e3fd89917266b3465b22de4dfbf604834e918ccc589888a8a26"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Fcntl-1.18-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-Fcntl;unpack=0"
SRC_URI[x86_64_v2_perl-Fcntl.sha256sum] = "2c54317c1c8e463201eb41c7f6323ffbad8a90883db9443318bf71ddde32b691"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Basename-2.86-515.el10_2.noarch.rpm;name=x86_64_v2_perl-File-Basename;unpack=0"
SRC_URI[x86_64_v2_perl-File-Basename.sha256sum] = "20a9f2b8c608e5b9882e2d7cc64546b067e53ccd2148bbfee2b72c0bfae4b16b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Compare-1.100.800-515.el10_2.noarch.rpm;name=x86_64_v2_perl-File-Compare;unpack=0"
SRC_URI[x86_64_v2_perl-File-Compare.sha256sum] = "4812e8816160f70feaec391bd210415bca4a44a5155b126c3fb1ef14674b80d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Copy-2.41-515.el10_2.noarch.rpm;name=x86_64_v2_perl-File-Copy;unpack=0"
SRC_URI[x86_64_v2_perl-File-Copy.sha256sum] = "52be131ea7d5f9df8f083bcaadde9c8b8cf8165b5dbba326c37eee56e9525871"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-DosGlob-1.12-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-File-DosGlob;unpack=0"
SRC_URI[x86_64_v2_perl-File-DosGlob.sha256sum] = "05d423b510f75dac4de9390b089ed82e126f84acc6675fa98ff6c20dafde0e0e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Find-1.44-515.el10_2.noarch.rpm;name=x86_64_v2_perl-File-Find;unpack=0"
SRC_URI[x86_64_v2_perl-File-Find.sha256sum] = "d2938662e54a406e838d0dd5c4ea5832760add3e33b8ef1251185069975d53a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-stat-1.14-515.el10_2.noarch.rpm;name=x86_64_v2_perl-File-stat;unpack=0"
SRC_URI[x86_64_v2_perl-File-stat.sha256sum] = "f31ab167489a383653e674718b8132503908c89658587c11e60a45911165c658"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-FileCache-1.10-515.el10_2.noarch.rpm;name=x86_64_v2_perl-FileCache;unpack=0"
SRC_URI[x86_64_v2_perl-FileCache.sha256sum] = "30820f41d03438df0a89b8dea91241e253b67eacf1cf81d8fff01551dd83ab5e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-FileHandle-2.05-515.el10_2.noarch.rpm;name=x86_64_v2_perl-FileHandle;unpack=0"
SRC_URI[x86_64_v2_perl-FileHandle.sha256sum] = "fb1ce05e33fb4e041f6807b80f5895d12700cc578bc662ee3681533d04d61e27"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-FindBin-1.54-515.el10_2.noarch.rpm;name=x86_64_v2_perl-FindBin;unpack=0"
SRC_URI[x86_64_v2_perl-FindBin.sha256sum] = "541141d26cff39e511d41ad2e104dbedff7ae004eb7b60a75f1d264f0da639e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-GDBM_File-1.24-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-GDBM_File;unpack=0"
SRC_URI[x86_64_v2_perl-GDBM_File.sha256sum] = "5b1418992a073fb19e7d0c1ddaed7d1503cc40ceef3e26722c101e15acba89f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Getopt-Std-1.14-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Getopt-Std;unpack=0"
SRC_URI[x86_64_v2_perl-Getopt-Std.sha256sum] = "49e8e4357d64fff7c22f72bda9bbab91c9393e87d6b40473e2f3e03a651d79ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Hash-Util-0.32-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-Hash-Util;unpack=0"
SRC_URI[x86_64_v2_perl-Hash-Util.sha256sum] = "a6563b916d63681632f62ef41bab439af2989a044b84e6a8ce964c081081d4c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Hash-Util-FieldHash-1.27-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-Hash-Util-FieldHash;unpack=0"
SRC_URI[x86_64_v2_perl-Hash-Util-FieldHash.sha256sum] = "99b9cb19bb490fe38df504e81cb13d13a1085963e0caa4755d263549aa2ca488"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-I18N-Collate-1.02-515.el10_2.noarch.rpm;name=x86_64_v2_perl-I18N-Collate;unpack=0"
SRC_URI[x86_64_v2_perl-I18N-Collate.sha256sum] = "680f8b26caf1903d88f8d96263ad903bc239369406b6895e6bc27ed923fbae59"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-I18N-LangTags-0.45-515.el10_2.noarch.rpm;name=x86_64_v2_perl-I18N-LangTags;unpack=0"
SRC_URI[x86_64_v2_perl-I18N-LangTags.sha256sum] = "069d8a8848580110635885e2c251c7423daaed882265d3fe5c2f4465f09dd325"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-I18N-Langinfo-0.24-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-I18N-Langinfo;unpack=0"
SRC_URI[x86_64_v2_perl-I18N-Langinfo.sha256sum] = "d05e984e4cd9ad689a94203e3a4c6ded2376da6ac8207e7156cff4bc4e506a93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IO-1.55-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-IO;unpack=0"
SRC_URI[x86_64_v2_perl-IO.sha256sum] = "b7907ee381f6e6352b90ef21b9d16917b8f14092c384ee2c757e5501471db7ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IPC-Open3-1.22-515.el10_2.noarch.rpm;name=x86_64_v2_perl-IPC-Open3;unpack=0"
SRC_URI[x86_64_v2_perl-IPC-Open3.sha256sum] = "2fe04d10b167fa28ece32046dc240d5132475190736ac8dda602198c8b51e0ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Locale-Maketext-Simple-0.21-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Locale-Maketext-Simple;unpack=0"
SRC_URI[x86_64_v2_perl-Locale-Maketext-Simple.sha256sum] = "ae46f3e2dc6318944c86ec74827ce3532cdb6a197c6944b69e880923c4c65136"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Math-Complex-1.62-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Math-Complex;unpack=0"
SRC_URI[x86_64_v2_perl-Math-Complex.sha256sum] = "8dc64964e85a19776cd9190076559c2f76282a5d55cc10f9dcdfe14dae924e30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Memoize-1.16-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Memoize;unpack=0"
SRC_URI[x86_64_v2_perl-Memoize.sha256sum] = "568f92b74173236bcdb6ffd602c20f30d5ce36ddc15a9ef60bdd9531791e5d38"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Module-Loaded-0.08-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Module-Loaded;unpack=0"
SRC_URI[x86_64_v2_perl-Module-Loaded.sha256sum] = "5ec1d001a8904f13be93731dc3ee10d52fea7b19718e01dde887e892f9d59e9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-NDBM_File-1.17-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-NDBM_File;unpack=0"
SRC_URI[x86_64_v2_perl-NDBM_File.sha256sum] = "1d31d36ffeaccfc3aaff5ab9560037107e44714a4c7fbd93a26460cb7d4b40d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-NEXT-0.69-515.el10_2.noarch.rpm;name=x86_64_v2_perl-NEXT;unpack=0"
SRC_URI[x86_64_v2_perl-NEXT.sha256sum] = "b9d74ebb73608e7ae8a41f1845f6ddffbde82b348053bf57d772c4cf1298e2f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Net-1.04-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Net;unpack=0"
SRC_URI[x86_64_v2_perl-Net.sha256sum] = "32c8b627ee7e2970b1dabfa3c1024adbd59dd604b26059aa8c2dd768f3843337"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ODBM_File-1.18-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-ODBM_File;unpack=0"
SRC_URI[x86_64_v2_perl-ODBM_File.sha256sum] = "efa1746c365178cf476e9efb22f80cc16b2e232eaf8c632db88cde5cbb9cdc70"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Opcode-1.65-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-Opcode;unpack=0"
SRC_URI[x86_64_v2_perl-Opcode.sha256sum] = "68cb62749f22887e84248eb8758039e084c59f81ef288669db901218b780f4bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-POSIX-2.20-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-POSIX;unpack=0"
SRC_URI[x86_64_v2_perl-POSIX.sha256sum] = "81440a2b1e08f964aac132faabeee86c3b2fc8210036ef790d569f7db73cf580"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Pod-Functions-1.14-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Pod-Functions;unpack=0"
SRC_URI[x86_64_v2_perl-Pod-Functions.sha256sum] = "ac655c5595560dcb46f735702ea26b21b12051be8238ba0d5e0a38ab6f6b598d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Pod-Html-1.35-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Pod-Html;unpack=0"
SRC_URI[x86_64_v2_perl-Pod-Html.sha256sum] = "cde6d99dc6bedf83080168ce89ab7278dbae79370c09def2315c05a847acf9dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Safe-2.46-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Safe;unpack=0"
SRC_URI[x86_64_v2_perl-Safe.sha256sum] = "72689b14d3ed67db6d8a591e812f40b77b791b19725266586057351632e00fd1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Search-Dict-1.07-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Search-Dict;unpack=0"
SRC_URI[x86_64_v2_perl-Search-Dict.sha256sum] = "1a7a937662f78d99a2dc924c7f668c42980aca692656cf16a5a5d1e21e6a4315"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-SelectSaver-1.02-515.el10_2.noarch.rpm;name=x86_64_v2_perl-SelectSaver;unpack=0"
SRC_URI[x86_64_v2_perl-SelectSaver.sha256sum] = "7b99d763a3936e28b58fa9304fed7b558d8c71ad7e808a5751f3969dac867a76"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-SelfLoader-1.27-515.el10_2.noarch.rpm;name=x86_64_v2_perl-SelfLoader;unpack=0"
SRC_URI[x86_64_v2_perl-SelfLoader.sha256sum] = "4d9f02c0fedb9b29b19bc90d97045e6d723657d1f214c7e2f2490390a781c3a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Symbol-1.09-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Symbol;unpack=0"
SRC_URI[x86_64_v2_perl-Symbol.sha256sum] = "6812dec84019716837e33bae8700473e5b2e874091c1a288a8dbb1726153c5c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Sys-Hostname-1.25-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Hostname;unpack=0"
SRC_URI[x86_64_v2_perl-Sys-Hostname.sha256sum] = "f4cc44cc14d67b9c222e8851db9154f6b0c9d060857083bb134065f1a8dacc52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Term-Complete-1.403-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Term-Complete;unpack=0"
SRC_URI[x86_64_v2_perl-Term-Complete.sha256sum] = "f79ccfdef83bcc3d0425411387915ed8065e98f2ceb6fe02965034b5ade87dbc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Term-ReadLine-1.17-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Term-ReadLine;unpack=0"
SRC_URI[x86_64_v2_perl-Term-ReadLine.sha256sum] = "41bde263dee0557bb68f9f1d2baa8d57c8d3df3fba08a5d94ecdde225220d3b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Test-1.31-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Test;unpack=0"
SRC_URI[x86_64_v2_perl-Test.sha256sum] = "c070ca356ba1f71ae941a4b48c70eb6eea140fb8851e89fe70b444e7c15c5a25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Text-Abbrev-1.02-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Text-Abbrev;unpack=0"
SRC_URI[x86_64_v2_perl-Text-Abbrev.sha256sum] = "43665b451f519dbeb4b8a05f066cc6481f8b6c143cf3e594852598a3a6b222ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Thread-3.05-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Thread;unpack=0"
SRC_URI[x86_64_v2_perl-Thread.sha256sum] = "342387b69d0d36619df2041b925e664c5a207142020f6c17137a4ef5e7f9f184"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Thread-Semaphore-2.13-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Thread-Semaphore;unpack=0"
SRC_URI[x86_64_v2_perl-Thread-Semaphore.sha256sum] = "2d138bc731d07a757d3301cd9d65f224ad3c2a96be63b1b60cd24e1c3ddfd0e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Tie-4.6-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Tie;unpack=0"
SRC_URI[x86_64_v2_perl-Tie.sha256sum] = "e7694d6af15a4e0a27f0f2619e94bf0671e47509e7b2fadd52f4f6e193ada11c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Tie-File-1.09-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Tie-File;unpack=0"
SRC_URI[x86_64_v2_perl-Tie-File.sha256sum] = "8a33b58207a8349608b744f83eb4dc94995c8d4315559c15ba26bfd0793fac03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Tie-Memoize-1.1-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Tie-Memoize;unpack=0"
SRC_URI[x86_64_v2_perl-Tie-Memoize.sha256sum] = "a59eb6b1ae8899f296df3fcf49cd61046571493289821a2c792002f2a31c4027"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Time-1.04-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Time;unpack=0"
SRC_URI[x86_64_v2_perl-Time.sha256sum] = "648dff6e0b21d2c42534adf498ff6f73ddc53f26c65c64ad56180a18d42fc119"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Time-Piece-1.3401-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-Time-Piece;unpack=0"
SRC_URI[x86_64_v2_perl-Time-Piece.sha256sum] = "8dab4bea11cf3dda9b14174092f0a6e3dd416d20f5c110d7483bf811b98fda9d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Unicode-UCD-0.78-515.el10_2.noarch.rpm;name=x86_64_v2_perl-Unicode-UCD;unpack=0"
SRC_URI[x86_64_v2_perl-Unicode-UCD.sha256sum] = "4307fa601ecd6edee189194d08a35b90113a9dc2e1e1c6a6a66195ec18e8d8ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-User-pwent-1.05-515.el10_2.noarch.rpm;name=x86_64_v2_perl-User-pwent;unpack=0"
SRC_URI[x86_64_v2_perl-User-pwent.sha256sum] = "116856c6ec904a94c4b9e26465c0f24d542f6ac279c1065c986de45686011ec0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-autouse-1.11-515.el10_2.noarch.rpm;name=x86_64_v2_perl-autouse;unpack=0"
SRC_URI[x86_64_v2_perl-autouse.sha256sum] = "c92493fe5c4a3219b4b5313325c3ff68fc3d174cbe86b442e42cb89e470aac60"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-base-2.27-515.el10_2.noarch.rpm;name=x86_64_v2_perl-base;unpack=0"
SRC_URI[x86_64_v2_perl-base.sha256sum] = "9be41847f8862fdbf8b1e5c6e81cd416a80f62bffde4ab2cddf02837e9ce25ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-blib-1.07-515.el10_2.noarch.rpm;name=x86_64_v2_perl-blib;unpack=0"
SRC_URI[x86_64_v2_perl-blib.sha256sum] = "cc2a05ecd7afe0c7472aafc23a4ebe0fc7d88f744f8db7f22c533cb55779d38a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-debugger-1.60-515.el10_2.noarch.rpm;name=x86_64_v2_perl-debugger;unpack=0"
SRC_URI[x86_64_v2_perl-debugger.sha256sum] = "fb02e587b5524c489f54e76bb0796c696e9a08765198c33a0f44aa81847457a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-deprecate-0.04-515.el10_2.noarch.rpm;name=x86_64_v2_perl-deprecate;unpack=0"
SRC_URI[x86_64_v2_perl-deprecate.sha256sum] = "c05f4aa40a78c4f09380639cbcbbbd486d773026ea9acccf16495fcdb03be30f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-devel-5.40.2-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-devel;unpack=0"
SRC_URI[x86_64_v2_perl-devel.sha256sum] = "e78de70705bf80926aafd87b0e26a9022e23ad189e54d072c74b063ca609ca5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-diagnostics-1.40-515.el10_2.noarch.rpm;name=x86_64_v2_perl-diagnostics;unpack=0"
SRC_URI[x86_64_v2_perl-diagnostics.sha256sum] = "c8f1dc682cb1f2bf17efbda24578b0e02926b13a3e818a6d145dd4265d6ece39"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-doc-5.40.2-515.el10_2.noarch.rpm;name=x86_64_v2_perl-doc;unpack=0"
SRC_URI[x86_64_v2_perl-doc.sha256sum] = "6cad19426ac95604a5cd8d62f8a8ffb5a38b8e8d807a982102a412825683beb8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-encoding-warnings-0.14-515.el10_2.noarch.rpm;name=x86_64_v2_perl-encoding-warnings;unpack=0"
SRC_URI[x86_64_v2_perl-encoding-warnings.sha256sum] = "b8ecd57b3ebe7a0915a2932be16e7cefb2daa9d9c21ab1bc51e41bc4b14f252f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-fields-2.27-515.el10_2.noarch.rpm;name=x86_64_v2_perl-fields;unpack=0"
SRC_URI[x86_64_v2_perl-fields.sha256sum] = "e70d012a4965534f70adb38c3bada5c20cbb42fc8ab2e8b685cba1d6ae51ac75"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-filetest-1.03-515.el10_2.noarch.rpm;name=x86_64_v2_perl-filetest;unpack=0"
SRC_URI[x86_64_v2_perl-filetest.sha256sum] = "5ea84443d067654a9188b0fbdea88de0a413a87cca469418d8a7a2c81a63eb47"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-if-0.61.000-515.el10_2.noarch.rpm;name=x86_64_v2_perl-if;unpack=0"
SRC_URI[x86_64_v2_perl-if.sha256sum] = "d81719bd35a08f147b531c2c7251abb2fdd658f32d157ad322f18d5db317b398"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-interpreter-5.40.2-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-interpreter;unpack=0"
SRC_URI[x86_64_v2_perl-interpreter.sha256sum] = "f479d79b4bedfcbe3d012cc7255dc576903d810453ef07f17a91fd3d2001167b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-less-0.03-515.el10_2.noarch.rpm;name=x86_64_v2_perl-less;unpack=0"
SRC_URI[x86_64_v2_perl-less.sha256sum] = "aff27fa71a37ec8dd7133ac6cfe955671da4baaa92fd1ce496e7930d188a4556"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-lib-0.65-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-lib;unpack=0"
SRC_URI[x86_64_v2_perl-lib.sha256sum] = "ff43e00ecf6de497ce1c11fc6262a23acc13224ce81f6e6f1a186ad6f526486b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-libnetcfg-5.40.2-515.el10_2.noarch.rpm;name=x86_64_v2_perl-libnetcfg;unpack=0"
SRC_URI[x86_64_v2_perl-libnetcfg.sha256sum] = "b6dd427dc290c38944e15a0c841f529374558fd9cc21cdb584dd0c8fe7bf32f7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-libs-5.40.2-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-libs;unpack=0"
SRC_URI[x86_64_v2_perl-libs.sha256sum] = "fdb1c08b96b1de8fde1aa93806c25ce251c24cfe738a3771dd8831df3fda88ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-locale-1.12-515.el10_2.noarch.rpm;name=x86_64_v2_perl-locale;unpack=0"
SRC_URI[x86_64_v2_perl-locale.sha256sum] = "c17fc22826e6adf2289f1e63d4d28f43d7938df26a23fabca9f891cd7a93313e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-macros-5.40.2-515.el10_2.noarch.rpm;name=x86_64_v2_perl-macros;unpack=0"
SRC_URI[x86_64_v2_perl-macros.sha256sum] = "fc7b48c861b581799e1c2bfb69697896fbacdd6dc84be691b3671b469cbd76bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-meta-notation-5.40.2-515.el10_2.noarch.rpm;name=x86_64_v2_perl-meta-notation;unpack=0"
SRC_URI[x86_64_v2_perl-meta-notation.sha256sum] = "fe5a31ee08cb8e227798d7a83e589736648047ac72ce10ce68043d70bf3bd8f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-mro-1.29-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-mro;unpack=0"
SRC_URI[x86_64_v2_perl-mro.sha256sum] = "59ec6abecbf2fa79f57f52dd7e82a6917f8fcc26ba85e9eef70dde612914da0d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-open-1.13-515.el10_2.noarch.rpm;name=x86_64_v2_perl-open;unpack=0"
SRC_URI[x86_64_v2_perl-open.sha256sum] = "ef32423ccb9fb8aadb65d75956ca93b17f2d48ad869a00265d5b18e074f9e67d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-overload-1.37-515.el10_2.noarch.rpm;name=x86_64_v2_perl-overload;unpack=0"
SRC_URI[x86_64_v2_perl-overload.sha256sum] = "d3c7074b151fa50dc7404bf110e451f8a9847525e8e29fd17009086ae4ebb2e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-overloading-0.02-515.el10_2.noarch.rpm;name=x86_64_v2_perl-overloading;unpack=0"
SRC_URI[x86_64_v2_perl-overloading.sha256sum] = "7696783c9ba2e5642cd1a30e303621daf02bf97a44f97abb2711b7d17befd20b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ph-5.40.2-515.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-ph;unpack=0"
SRC_URI[x86_64_v2_perl-ph.sha256sum] = "6c63aeab4cd9a49240d6a64e98b17f3fe8dea7dbb15dd3c8f674046e778c7415"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-sigtrap-1.10-515.el10_2.noarch.rpm;name=x86_64_v2_perl-sigtrap;unpack=0"
SRC_URI[x86_64_v2_perl-sigtrap.sha256sum] = "c4a150e1b3c392d2bb8602ece64c0a1216c248abcea67c2a9379cb46a1911ce8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-sort-2.05-515.el10_2.noarch.rpm;name=x86_64_v2_perl-sort;unpack=0"
SRC_URI[x86_64_v2_perl-sort.sha256sum] = "f00ca350e4e5d6843b1ed839dabd26abfce7f303dffa9b76559b86b7160eef9c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-subs-1.04-515.el10_2.noarch.rpm;name=x86_64_v2_perl-subs;unpack=0"
SRC_URI[x86_64_v2_perl-subs.sha256sum] = "a45bb41b5f9be010da79ffbb237a445e115026b6a66594ff029d7993071754f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-utils-5.40.2-515.el10_2.noarch.rpm;name=x86_64_v2_perl-utils;unpack=0"
SRC_URI[x86_64_v2_perl-utils.sha256sum] = "9cf990e411b795dac07fb0e455ab88d72d70095974d3606451d554b1a89ed148"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-vars-1.05-515.el10_2.noarch.rpm;name=x86_64_v2_perl-vars;unpack=0"
SRC_URI[x86_64_v2_perl-vars.sha256sum] = "93da3932faa665745d14ccf5a9ddd860f562d08fbe184619cd4a7b8b274fe012"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-vmsish-1.04-515.el10_2.noarch.rpm;name=x86_64_v2_perl-vmsish;unpack=0"
SRC_URI[x86_64_v2_perl-vmsish.sha256sum] = "114d1690b48e176ae300aa8758eb208c31d1b490b24d8ee9e87ba6f5d21cc209"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-5.40.2-515.el10_2.aarch64.rpm;name=aarch64_perl;unpack=0"
SRC_URI[aarch64_perl.sha256sum] = "b9cee31a15b41ba2209263b0ad6a186c8709ebf36974aea50996a14d7190a3a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Attribute-Handlers-1.03-515.el10_2.noarch.rpm;name=aarch64_perl-Attribute-Handlers;unpack=0"
SRC_URI[aarch64_perl-Attribute-Handlers.sha256sum] = "77b3940fa81302f640a8fc18a554e27c5a3788da8a3c05b1f3e1bc3d75795a37"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-AutoLoader-5.74-515.el10_2.noarch.rpm;name=aarch64_perl-AutoLoader;unpack=0"
SRC_URI[aarch64_perl-AutoLoader.sha256sum] = "1b540d06f1b3584f80113b6c546b8864cd617dffbb8513045b03d7132e826012"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-AutoSplit-5.74-515.el10_2.noarch.rpm;name=aarch64_perl-AutoSplit;unpack=0"
SRC_URI[aarch64_perl-AutoSplit.sha256sum] = "6b59cf08fb7286fb3f4198e45cd3d4f5006406267051a10617fb5304cd5266d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-B-1.89-515.el10_2.aarch64.rpm;name=aarch64_perl-B;unpack=0"
SRC_URI[aarch64_perl-B.sha256sum] = "8b9cf479d8b5888a95e8abc987ef252d09baae97312a79b046060a50bc701b9c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Benchmark-1.25-515.el10_2.noarch.rpm;name=aarch64_perl-Benchmark;unpack=0"
SRC_URI[aarch64_perl-Benchmark.sha256sum] = "b7973b40a45771d3dfd56138ebae057d2fbaf20fda1998e379b0210fd9be01a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Class-Struct-0.68-515.el10_2.noarch.rpm;name=aarch64_perl-Class-Struct;unpack=0"
SRC_URI[aarch64_perl-Class-Struct.sha256sum] = "f67705171349b9de0f487263220dbf6cb9e59eb628540da756ce686222c81324"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Config-Extensions-0.03-515.el10_2.noarch.rpm;name=aarch64_perl-Config-Extensions;unpack=0"
SRC_URI[aarch64_perl-Config-Extensions.sha256sum] = "735ba0cc433b5cf1e24d38cde1b3370a929cb3d7e9d19a4191862d988e7e06f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DBM_Filter-0.06-515.el10_2.noarch.rpm;name=aarch64_perl-DBM_Filter;unpack=0"
SRC_URI[aarch64_perl-DBM_Filter.sha256sum] = "9c44ff926043c1465c2b3f769f5d460af437848027936af2885671f71c45b6c3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Devel-Peek-1.34-515.el10_2.aarch64.rpm;name=aarch64_perl-Devel-Peek;unpack=0"
SRC_URI[aarch64_perl-Devel-Peek.sha256sum] = "a9d45bf2a19103841d46d665ebf37bdb387e0456a11575e9a264a0e29f451246"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Devel-SelfStubber-1.06-515.el10_2.noarch.rpm;name=aarch64_perl-Devel-SelfStubber;unpack=0"
SRC_URI[aarch64_perl-Devel-SelfStubber.sha256sum] = "9bf0cebe98e3c5d7c7391fc556d152673f3f4ac637e62559e72f00322c9665ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DirHandle-1.05-515.el10_2.noarch.rpm;name=aarch64_perl-DirHandle;unpack=0"
SRC_URI[aarch64_perl-DirHandle.sha256sum] = "c74ec5ab698006562d3ebd6b4dcbd879c336390d3e5cca29cb4cce85b85b5a7d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Dumpvalue-2.27-515.el10_2.noarch.rpm;name=aarch64_perl-Dumpvalue;unpack=0"
SRC_URI[aarch64_perl-Dumpvalue.sha256sum] = "5c387af29496631904e0e4512b0042204cdfe1760561da0a1a7779cd1b9432c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DynaLoader-1.56-515.el10_2.aarch64.rpm;name=aarch64_perl-DynaLoader;unpack=0"
SRC_URI[aarch64_perl-DynaLoader.sha256sum] = "6c63a74ec8194c328ca2396b615da2adace95aa6f423c1d71d53f859db4b434c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-English-1.11-515.el10_2.noarch.rpm;name=aarch64_perl-English;unpack=0"
SRC_URI[aarch64_perl-English.sha256sum] = "a81d60d0b8acf592731701a57479d115867187afff5573bd5a82fe8b130972a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Errno-1.38-515.el10_2.aarch64.rpm;name=aarch64_perl-Errno;unpack=0"
SRC_URI[aarch64_perl-Errno.sha256sum] = "ef0c42ff86bf23bf0ea740d7365bb2680727c5c8fc613368448567835c855593"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ExtUtils-Constant-0.25-515.el10_2.noarch.rpm;name=aarch64_perl-ExtUtils-Constant;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Constant.sha256sum] = "873bb09b54d407b9bf5ff9c9e00e0c0053f12ca3a38e094acf6fe08c2101501e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ExtUtils-Embed-1.35-515.el10_2.noarch.rpm;name=aarch64_perl-ExtUtils-Embed;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Embed.sha256sum] = "68dcc2966462f39ae38c5ebcae4c337dc9e0b06c3ea981844a143d3995c06753"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ExtUtils-Miniperl-1.14-515.el10_2.noarch.rpm;name=aarch64_perl-ExtUtils-Miniperl;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Miniperl.sha256sum] = "2b7283b3c5536e3fd89917266b3465b22de4dfbf604834e918ccc589888a8a26"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Fcntl-1.18-515.el10_2.aarch64.rpm;name=aarch64_perl-Fcntl;unpack=0"
SRC_URI[aarch64_perl-Fcntl.sha256sum] = "f14f7b9997cea96e7ec7a16971e4655ba3596fdadf04f0cac914e0d28d2d3f6f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Basename-2.86-515.el10_2.noarch.rpm;name=aarch64_perl-File-Basename;unpack=0"
SRC_URI[aarch64_perl-File-Basename.sha256sum] = "20a9f2b8c608e5b9882e2d7cc64546b067e53ccd2148bbfee2b72c0bfae4b16b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Compare-1.100.800-515.el10_2.noarch.rpm;name=aarch64_perl-File-Compare;unpack=0"
SRC_URI[aarch64_perl-File-Compare.sha256sum] = "4812e8816160f70feaec391bd210415bca4a44a5155b126c3fb1ef14674b80d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Copy-2.41-515.el10_2.noarch.rpm;name=aarch64_perl-File-Copy;unpack=0"
SRC_URI[aarch64_perl-File-Copy.sha256sum] = "52be131ea7d5f9df8f083bcaadde9c8b8cf8165b5dbba326c37eee56e9525871"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-DosGlob-1.12-515.el10_2.aarch64.rpm;name=aarch64_perl-File-DosGlob;unpack=0"
SRC_URI[aarch64_perl-File-DosGlob.sha256sum] = "57770f3d8fcffb0ea0b4e009241c471d85418c780468b09294f2a765ad0a2522"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Find-1.44-515.el10_2.noarch.rpm;name=aarch64_perl-File-Find;unpack=0"
SRC_URI[aarch64_perl-File-Find.sha256sum] = "d2938662e54a406e838d0dd5c4ea5832760add3e33b8ef1251185069975d53a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-stat-1.14-515.el10_2.noarch.rpm;name=aarch64_perl-File-stat;unpack=0"
SRC_URI[aarch64_perl-File-stat.sha256sum] = "f31ab167489a383653e674718b8132503908c89658587c11e60a45911165c658"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-FileCache-1.10-515.el10_2.noarch.rpm;name=aarch64_perl-FileCache;unpack=0"
SRC_URI[aarch64_perl-FileCache.sha256sum] = "30820f41d03438df0a89b8dea91241e253b67eacf1cf81d8fff01551dd83ab5e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-FileHandle-2.05-515.el10_2.noarch.rpm;name=aarch64_perl-FileHandle;unpack=0"
SRC_URI[aarch64_perl-FileHandle.sha256sum] = "fb1ce05e33fb4e041f6807b80f5895d12700cc578bc662ee3681533d04d61e27"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-FindBin-1.54-515.el10_2.noarch.rpm;name=aarch64_perl-FindBin;unpack=0"
SRC_URI[aarch64_perl-FindBin.sha256sum] = "541141d26cff39e511d41ad2e104dbedff7ae004eb7b60a75f1d264f0da639e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-GDBM_File-1.24-515.el10_2.aarch64.rpm;name=aarch64_perl-GDBM_File;unpack=0"
SRC_URI[aarch64_perl-GDBM_File.sha256sum] = "9914eae9d9181518f66e879219114cbf3ffdfb91028f59b329f3ed22020403b8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Getopt-Std-1.14-515.el10_2.noarch.rpm;name=aarch64_perl-Getopt-Std;unpack=0"
SRC_URI[aarch64_perl-Getopt-Std.sha256sum] = "49e8e4357d64fff7c22f72bda9bbab91c9393e87d6b40473e2f3e03a651d79ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Hash-Util-0.32-515.el10_2.aarch64.rpm;name=aarch64_perl-Hash-Util;unpack=0"
SRC_URI[aarch64_perl-Hash-Util.sha256sum] = "0a7062968938aaf7fb0dc2f2432546929a84d5c83cf307c5115c0ee550386768"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Hash-Util-FieldHash-1.27-515.el10_2.aarch64.rpm;name=aarch64_perl-Hash-Util-FieldHash;unpack=0"
SRC_URI[aarch64_perl-Hash-Util-FieldHash.sha256sum] = "aaae01bacd203c64df110c7fb68251b3797d114782af470bc2b8ef576fc5611e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-I18N-Collate-1.02-515.el10_2.noarch.rpm;name=aarch64_perl-I18N-Collate;unpack=0"
SRC_URI[aarch64_perl-I18N-Collate.sha256sum] = "680f8b26caf1903d88f8d96263ad903bc239369406b6895e6bc27ed923fbae59"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-I18N-LangTags-0.45-515.el10_2.noarch.rpm;name=aarch64_perl-I18N-LangTags;unpack=0"
SRC_URI[aarch64_perl-I18N-LangTags.sha256sum] = "069d8a8848580110635885e2c251c7423daaed882265d3fe5c2f4465f09dd325"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-I18N-Langinfo-0.24-515.el10_2.aarch64.rpm;name=aarch64_perl-I18N-Langinfo;unpack=0"
SRC_URI[aarch64_perl-I18N-Langinfo.sha256sum] = "1d9e867b6e3fbc94c9cc1005038100b6e7185e1a1f29ae293d33d391f6befc7f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IO-1.55-515.el10_2.aarch64.rpm;name=aarch64_perl-IO;unpack=0"
SRC_URI[aarch64_perl-IO.sha256sum] = "4e5ae4f09808e570cdcd0c04f520b80eecd42cf1d8ede04de964fbbb081ebd00"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IPC-Open3-1.22-515.el10_2.noarch.rpm;name=aarch64_perl-IPC-Open3;unpack=0"
SRC_URI[aarch64_perl-IPC-Open3.sha256sum] = "2fe04d10b167fa28ece32046dc240d5132475190736ac8dda602198c8b51e0ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Locale-Maketext-Simple-0.21-515.el10_2.noarch.rpm;name=aarch64_perl-Locale-Maketext-Simple;unpack=0"
SRC_URI[aarch64_perl-Locale-Maketext-Simple.sha256sum] = "ae46f3e2dc6318944c86ec74827ce3532cdb6a197c6944b69e880923c4c65136"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Math-Complex-1.62-515.el10_2.noarch.rpm;name=aarch64_perl-Math-Complex;unpack=0"
SRC_URI[aarch64_perl-Math-Complex.sha256sum] = "8dc64964e85a19776cd9190076559c2f76282a5d55cc10f9dcdfe14dae924e30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Memoize-1.16-515.el10_2.noarch.rpm;name=aarch64_perl-Memoize;unpack=0"
SRC_URI[aarch64_perl-Memoize.sha256sum] = "568f92b74173236bcdb6ffd602c20f30d5ce36ddc15a9ef60bdd9531791e5d38"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Module-Loaded-0.08-515.el10_2.noarch.rpm;name=aarch64_perl-Module-Loaded;unpack=0"
SRC_URI[aarch64_perl-Module-Loaded.sha256sum] = "5ec1d001a8904f13be93731dc3ee10d52fea7b19718e01dde887e892f9d59e9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-NDBM_File-1.17-515.el10_2.aarch64.rpm;name=aarch64_perl-NDBM_File;unpack=0"
SRC_URI[aarch64_perl-NDBM_File.sha256sum] = "989c0a7456bab192415e25e18688852a75871d04d2f66b27ec11adfcca215772"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-NEXT-0.69-515.el10_2.noarch.rpm;name=aarch64_perl-NEXT;unpack=0"
SRC_URI[aarch64_perl-NEXT.sha256sum] = "b9d74ebb73608e7ae8a41f1845f6ddffbde82b348053bf57d772c4cf1298e2f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Net-1.04-515.el10_2.noarch.rpm;name=aarch64_perl-Net;unpack=0"
SRC_URI[aarch64_perl-Net.sha256sum] = "32c8b627ee7e2970b1dabfa3c1024adbd59dd604b26059aa8c2dd768f3843337"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ODBM_File-1.18-515.el10_2.aarch64.rpm;name=aarch64_perl-ODBM_File;unpack=0"
SRC_URI[aarch64_perl-ODBM_File.sha256sum] = "c2feba06842302b3d79e32377bd64bc42eac980470d7afe4363a31849f135685"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Opcode-1.65-515.el10_2.aarch64.rpm;name=aarch64_perl-Opcode;unpack=0"
SRC_URI[aarch64_perl-Opcode.sha256sum] = "aef813c80160064f0a8fb077d8c369e6c96dfc4626c9a1e710a88b7dfa6b6a57"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-POSIX-2.20-515.el10_2.aarch64.rpm;name=aarch64_perl-POSIX;unpack=0"
SRC_URI[aarch64_perl-POSIX.sha256sum] = "b5a948abcd4b0a1ce906a96de90ee1db256d3248392968439cff9c753be46161"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Pod-Functions-1.14-515.el10_2.noarch.rpm;name=aarch64_perl-Pod-Functions;unpack=0"
SRC_URI[aarch64_perl-Pod-Functions.sha256sum] = "ac655c5595560dcb46f735702ea26b21b12051be8238ba0d5e0a38ab6f6b598d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Pod-Html-1.35-515.el10_2.noarch.rpm;name=aarch64_perl-Pod-Html;unpack=0"
SRC_URI[aarch64_perl-Pod-Html.sha256sum] = "cde6d99dc6bedf83080168ce89ab7278dbae79370c09def2315c05a847acf9dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Safe-2.46-515.el10_2.noarch.rpm;name=aarch64_perl-Safe;unpack=0"
SRC_URI[aarch64_perl-Safe.sha256sum] = "72689b14d3ed67db6d8a591e812f40b77b791b19725266586057351632e00fd1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Search-Dict-1.07-515.el10_2.noarch.rpm;name=aarch64_perl-Search-Dict;unpack=0"
SRC_URI[aarch64_perl-Search-Dict.sha256sum] = "1a7a937662f78d99a2dc924c7f668c42980aca692656cf16a5a5d1e21e6a4315"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-SelectSaver-1.02-515.el10_2.noarch.rpm;name=aarch64_perl-SelectSaver;unpack=0"
SRC_URI[aarch64_perl-SelectSaver.sha256sum] = "7b99d763a3936e28b58fa9304fed7b558d8c71ad7e808a5751f3969dac867a76"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-SelfLoader-1.27-515.el10_2.noarch.rpm;name=aarch64_perl-SelfLoader;unpack=0"
SRC_URI[aarch64_perl-SelfLoader.sha256sum] = "4d9f02c0fedb9b29b19bc90d97045e6d723657d1f214c7e2f2490390a781c3a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Symbol-1.09-515.el10_2.noarch.rpm;name=aarch64_perl-Symbol;unpack=0"
SRC_URI[aarch64_perl-Symbol.sha256sum] = "6812dec84019716837e33bae8700473e5b2e874091c1a288a8dbb1726153c5c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Sys-Hostname-1.25-515.el10_2.aarch64.rpm;name=aarch64_perl-Sys-Hostname;unpack=0"
SRC_URI[aarch64_perl-Sys-Hostname.sha256sum] = "0a0a4be91e2055cf4505e33020f5980af74c4dc8a34fedcd6af6ae24cfc82235"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Term-Complete-1.403-515.el10_2.noarch.rpm;name=aarch64_perl-Term-Complete;unpack=0"
SRC_URI[aarch64_perl-Term-Complete.sha256sum] = "f79ccfdef83bcc3d0425411387915ed8065e98f2ceb6fe02965034b5ade87dbc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Term-ReadLine-1.17-515.el10_2.noarch.rpm;name=aarch64_perl-Term-ReadLine;unpack=0"
SRC_URI[aarch64_perl-Term-ReadLine.sha256sum] = "41bde263dee0557bb68f9f1d2baa8d57c8d3df3fba08a5d94ecdde225220d3b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Test-1.31-515.el10_2.noarch.rpm;name=aarch64_perl-Test;unpack=0"
SRC_URI[aarch64_perl-Test.sha256sum] = "c070ca356ba1f71ae941a4b48c70eb6eea140fb8851e89fe70b444e7c15c5a25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Text-Abbrev-1.02-515.el10_2.noarch.rpm;name=aarch64_perl-Text-Abbrev;unpack=0"
SRC_URI[aarch64_perl-Text-Abbrev.sha256sum] = "43665b451f519dbeb4b8a05f066cc6481f8b6c143cf3e594852598a3a6b222ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Thread-3.05-515.el10_2.noarch.rpm;name=aarch64_perl-Thread;unpack=0"
SRC_URI[aarch64_perl-Thread.sha256sum] = "342387b69d0d36619df2041b925e664c5a207142020f6c17137a4ef5e7f9f184"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Thread-Semaphore-2.13-515.el10_2.noarch.rpm;name=aarch64_perl-Thread-Semaphore;unpack=0"
SRC_URI[aarch64_perl-Thread-Semaphore.sha256sum] = "2d138bc731d07a757d3301cd9d65f224ad3c2a96be63b1b60cd24e1c3ddfd0e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Tie-4.6-515.el10_2.noarch.rpm;name=aarch64_perl-Tie;unpack=0"
SRC_URI[aarch64_perl-Tie.sha256sum] = "e7694d6af15a4e0a27f0f2619e94bf0671e47509e7b2fadd52f4f6e193ada11c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Tie-File-1.09-515.el10_2.noarch.rpm;name=aarch64_perl-Tie-File;unpack=0"
SRC_URI[aarch64_perl-Tie-File.sha256sum] = "8a33b58207a8349608b744f83eb4dc94995c8d4315559c15ba26bfd0793fac03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Tie-Memoize-1.1-515.el10_2.noarch.rpm;name=aarch64_perl-Tie-Memoize;unpack=0"
SRC_URI[aarch64_perl-Tie-Memoize.sha256sum] = "a59eb6b1ae8899f296df3fcf49cd61046571493289821a2c792002f2a31c4027"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Time-1.04-515.el10_2.noarch.rpm;name=aarch64_perl-Time;unpack=0"
SRC_URI[aarch64_perl-Time.sha256sum] = "648dff6e0b21d2c42534adf498ff6f73ddc53f26c65c64ad56180a18d42fc119"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Time-Piece-1.3401-515.el10_2.aarch64.rpm;name=aarch64_perl-Time-Piece;unpack=0"
SRC_URI[aarch64_perl-Time-Piece.sha256sum] = "e3a2f0cb2d876be19ee41cf599b0c04cba8d797dabd054c02b558a8cd9eee7f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Unicode-UCD-0.78-515.el10_2.noarch.rpm;name=aarch64_perl-Unicode-UCD;unpack=0"
SRC_URI[aarch64_perl-Unicode-UCD.sha256sum] = "4307fa601ecd6edee189194d08a35b90113a9dc2e1e1c6a6a66195ec18e8d8ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-User-pwent-1.05-515.el10_2.noarch.rpm;name=aarch64_perl-User-pwent;unpack=0"
SRC_URI[aarch64_perl-User-pwent.sha256sum] = "116856c6ec904a94c4b9e26465c0f24d542f6ac279c1065c986de45686011ec0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-autouse-1.11-515.el10_2.noarch.rpm;name=aarch64_perl-autouse;unpack=0"
SRC_URI[aarch64_perl-autouse.sha256sum] = "c92493fe5c4a3219b4b5313325c3ff68fc3d174cbe86b442e42cb89e470aac60"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-base-2.27-515.el10_2.noarch.rpm;name=aarch64_perl-base;unpack=0"
SRC_URI[aarch64_perl-base.sha256sum] = "9be41847f8862fdbf8b1e5c6e81cd416a80f62bffde4ab2cddf02837e9ce25ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-blib-1.07-515.el10_2.noarch.rpm;name=aarch64_perl-blib;unpack=0"
SRC_URI[aarch64_perl-blib.sha256sum] = "cc2a05ecd7afe0c7472aafc23a4ebe0fc7d88f744f8db7f22c533cb55779d38a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-debugger-1.60-515.el10_2.noarch.rpm;name=aarch64_perl-debugger;unpack=0"
SRC_URI[aarch64_perl-debugger.sha256sum] = "fb02e587b5524c489f54e76bb0796c696e9a08765198c33a0f44aa81847457a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-deprecate-0.04-515.el10_2.noarch.rpm;name=aarch64_perl-deprecate;unpack=0"
SRC_URI[aarch64_perl-deprecate.sha256sum] = "c05f4aa40a78c4f09380639cbcbbbd486d773026ea9acccf16495fcdb03be30f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-devel-5.40.2-515.el10_2.aarch64.rpm;name=aarch64_perl-devel;unpack=0"
SRC_URI[aarch64_perl-devel.sha256sum] = "14d4ddafe55134e2c40f620277fe2e9e7f92bf8f12d49a2f2b4c9d5fae4fc4ca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-diagnostics-1.40-515.el10_2.noarch.rpm;name=aarch64_perl-diagnostics;unpack=0"
SRC_URI[aarch64_perl-diagnostics.sha256sum] = "c8f1dc682cb1f2bf17efbda24578b0e02926b13a3e818a6d145dd4265d6ece39"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-doc-5.40.2-515.el10_2.noarch.rpm;name=aarch64_perl-doc;unpack=0"
SRC_URI[aarch64_perl-doc.sha256sum] = "6cad19426ac95604a5cd8d62f8a8ffb5a38b8e8d807a982102a412825683beb8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-encoding-warnings-0.14-515.el10_2.noarch.rpm;name=aarch64_perl-encoding-warnings;unpack=0"
SRC_URI[aarch64_perl-encoding-warnings.sha256sum] = "b8ecd57b3ebe7a0915a2932be16e7cefb2daa9d9c21ab1bc51e41bc4b14f252f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-fields-2.27-515.el10_2.noarch.rpm;name=aarch64_perl-fields;unpack=0"
SRC_URI[aarch64_perl-fields.sha256sum] = "e70d012a4965534f70adb38c3bada5c20cbb42fc8ab2e8b685cba1d6ae51ac75"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-filetest-1.03-515.el10_2.noarch.rpm;name=aarch64_perl-filetest;unpack=0"
SRC_URI[aarch64_perl-filetest.sha256sum] = "5ea84443d067654a9188b0fbdea88de0a413a87cca469418d8a7a2c81a63eb47"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-if-0.61.000-515.el10_2.noarch.rpm;name=aarch64_perl-if;unpack=0"
SRC_URI[aarch64_perl-if.sha256sum] = "d81719bd35a08f147b531c2c7251abb2fdd658f32d157ad322f18d5db317b398"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-interpreter-5.40.2-515.el10_2.aarch64.rpm;name=aarch64_perl-interpreter;unpack=0"
SRC_URI[aarch64_perl-interpreter.sha256sum] = "56b32580dd5f2bd6aabde67758890a09f48495a8693a83633255590db51ab119"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-less-0.03-515.el10_2.noarch.rpm;name=aarch64_perl-less;unpack=0"
SRC_URI[aarch64_perl-less.sha256sum] = "aff27fa71a37ec8dd7133ac6cfe955671da4baaa92fd1ce496e7930d188a4556"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-lib-0.65-515.el10_2.aarch64.rpm;name=aarch64_perl-lib;unpack=0"
SRC_URI[aarch64_perl-lib.sha256sum] = "e57d01df82a99384d1cad5492494e2634c3fdfa1754fe0988ff9521ede96a231"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-libnetcfg-5.40.2-515.el10_2.noarch.rpm;name=aarch64_perl-libnetcfg;unpack=0"
SRC_URI[aarch64_perl-libnetcfg.sha256sum] = "b6dd427dc290c38944e15a0c841f529374558fd9cc21cdb584dd0c8fe7bf32f7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-libs-5.40.2-515.el10_2.aarch64.rpm;name=aarch64_perl-libs;unpack=0"
SRC_URI[aarch64_perl-libs.sha256sum] = "6fda6a46419145c51701248f49031b932ef24a75021bbfffea54170c4dae2949"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-locale-1.12-515.el10_2.noarch.rpm;name=aarch64_perl-locale;unpack=0"
SRC_URI[aarch64_perl-locale.sha256sum] = "c17fc22826e6adf2289f1e63d4d28f43d7938df26a23fabca9f891cd7a93313e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-macros-5.40.2-515.el10_2.noarch.rpm;name=aarch64_perl-macros;unpack=0"
SRC_URI[aarch64_perl-macros.sha256sum] = "fc7b48c861b581799e1c2bfb69697896fbacdd6dc84be691b3671b469cbd76bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-meta-notation-5.40.2-515.el10_2.noarch.rpm;name=aarch64_perl-meta-notation;unpack=0"
SRC_URI[aarch64_perl-meta-notation.sha256sum] = "fe5a31ee08cb8e227798d7a83e589736648047ac72ce10ce68043d70bf3bd8f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-mro-1.29-515.el10_2.aarch64.rpm;name=aarch64_perl-mro;unpack=0"
SRC_URI[aarch64_perl-mro.sha256sum] = "299d2596cebdf6b60d6d86e5f30429439a2d3b3eaad6647cfad4c7a2cb65b00c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-open-1.13-515.el10_2.noarch.rpm;name=aarch64_perl-open;unpack=0"
SRC_URI[aarch64_perl-open.sha256sum] = "ef32423ccb9fb8aadb65d75956ca93b17f2d48ad869a00265d5b18e074f9e67d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-overload-1.37-515.el10_2.noarch.rpm;name=aarch64_perl-overload;unpack=0"
SRC_URI[aarch64_perl-overload.sha256sum] = "d3c7074b151fa50dc7404bf110e451f8a9847525e8e29fd17009086ae4ebb2e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-overloading-0.02-515.el10_2.noarch.rpm;name=aarch64_perl-overloading;unpack=0"
SRC_URI[aarch64_perl-overloading.sha256sum] = "7696783c9ba2e5642cd1a30e303621daf02bf97a44f97abb2711b7d17befd20b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ph-5.40.2-515.el10_2.aarch64.rpm;name=aarch64_perl-ph;unpack=0"
SRC_URI[aarch64_perl-ph.sha256sum] = "feb84908e79d966c8c74c1a607a00cf461955757739615873c08c31100dcc5d9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-sigtrap-1.10-515.el10_2.noarch.rpm;name=aarch64_perl-sigtrap;unpack=0"
SRC_URI[aarch64_perl-sigtrap.sha256sum] = "c4a150e1b3c392d2bb8602ece64c0a1216c248abcea67c2a9379cb46a1911ce8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-sort-2.05-515.el10_2.noarch.rpm;name=aarch64_perl-sort;unpack=0"
SRC_URI[aarch64_perl-sort.sha256sum] = "f00ca350e4e5d6843b1ed839dabd26abfce7f303dffa9b76559b86b7160eef9c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-subs-1.04-515.el10_2.noarch.rpm;name=aarch64_perl-subs;unpack=0"
SRC_URI[aarch64_perl-subs.sha256sum] = "a45bb41b5f9be010da79ffbb237a445e115026b6a66594ff029d7993071754f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-utils-5.40.2-515.el10_2.noarch.rpm;name=aarch64_perl-utils;unpack=0"
SRC_URI[aarch64_perl-utils.sha256sum] = "9cf990e411b795dac07fb0e455ab88d72d70095974d3606451d554b1a89ed148"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-vars-1.05-515.el10_2.noarch.rpm;name=aarch64_perl-vars;unpack=0"
SRC_URI[aarch64_perl-vars.sha256sum] = "93da3932faa665745d14ccf5a9ddd860f562d08fbe184619cd4a7b8b274fe012"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-vmsish-1.04-515.el10_2.noarch.rpm;name=aarch64_perl-vmsish;unpack=0"
SRC_URI[aarch64_perl-vmsish.sha256sum] = "114d1690b48e176ae300aa8758eb208c31d1b490b24d8ee9e87ba6f5d21cc209"

RDEPENDS:perl = " \
 perl-Archive-Tar \
 perl-Attribute-Handlers \
 perl-AutoLoader \
 perl-AutoSplit \
 perl-B \
 perl-Benchmark \
 perl-CPAN \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-CPAN-Meta-YAML \
 perl-Carp \
 perl-Class-Struct \
 perl-Compress-Raw-Bzip2 \
 perl-Compress-Raw-Zlib \
 perl-Config-Extensions \
 perl-Config-Perl-V \
 perl-DBM_Filter \
 perl-Data-Dumper \
 perl-Devel-PPPort \
 perl-Devel-Peek \
 perl-Devel-SelfStubber \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-DirHandle \
 perl-Dumpvalue \
 perl-DynaLoader \
 perl-Encode \
 perl-Encode-devel \
 perl-English \
 perl-Env \
 perl-Errno \
 perl-Exporter \
 perl-ExtUtils-CBuilder \
 perl-ExtUtils-Command \
 perl-ExtUtils-Constant \
 perl-ExtUtils-Embed \
 perl-ExtUtils-Install \
 perl-ExtUtils-MM-Utils \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-ExtUtils-Miniperl \
 perl-ExtUtils-ParseXS \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-DosGlob \
 perl-File-Fetch \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-File-stat \
 perl-FileCache \
 perl-FileHandle \
 perl-Filter \
 perl-Filter-Simple \
 perl-FindBin \
 perl-GDBM_File \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-HTTP-Tiny \
 perl-Hash-Util \
 perl-Hash-Util-FieldHash \
 perl-I18N-Collate \
 perl-I18N-LangTags \
 perl-I18N-Langinfo \
 perl-IO \
 perl-IO-Compress \
 perl-IO-Socket-IP \
 perl-IO-Zlib \
 perl-IPC-Cmd \
 perl-IPC-Open3 \
 perl-IPC-SysV \
 perl-JSON-PP \
 perl-Locale-Maketext \
 perl-Locale-Maketext-Simple \
 perl-MIME-Base64 \
 perl-Math-BigInt \
 perl-Math-BigInt-FastCalc \
 perl-Math-Complex \
 perl-Memoize \
 perl-Module-CoreList \
 perl-Module-CoreList-tools \
 perl-Module-Load \
 perl-Module-Load-Conditional \
 perl-Module-Loaded \
 perl-Module-Metadata \
 perl-NDBM_File \
 perl-NEXT \
 perl-Net \
 perl-Net-Ping \
 perl-ODBM_File \
 perl-Opcode \
 perl-POSIX \
 perl-Params-Check \
 perl-PathTools \
 perl-Perl-OSType \
 perl-PerlIO-via-QuotedPrint \
 perl-Pod-Checker \
 perl-Pod-Escapes \
 perl-Pod-Functions \
 perl-Pod-Html \
 perl-Pod-Perldoc \
 perl-Pod-Simple \
 perl-Pod-Usage \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Search-Dict \
 perl-SelectSaver \
 perl-SelfLoader \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Term-ANSIColor \
 perl-Term-Cap \
 perl-Term-Complete \
 perl-Term-ReadLine \
 perl-Term-Table \
 perl-Test \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Test2-Suite \
 perl-Text-Abbrev \
 perl-Text-Balanced \
 perl-Text-ParseWords \
 perl-Text-Tabs+Wrap \
 perl-Thread \
 perl-Thread-Queue \
 perl-Thread-Semaphore \
 perl-Tie \
 perl-Tie-File \
 perl-Tie-Memoize \
 perl-Tie-RefHash \
 perl-Time \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-Time-Piece \
 perl-Unicode-Collate \
 perl-Unicode-Normalize \
 perl-Unicode-UCD \
 perl-User-pwent \
 perl-autodie \
 perl-autouse \
 perl-base \
 perl-bignum \
 perl-blib \
 perl-constant \
 perl-debugger \
 perl-deprecate \
 perl-devel \
 perl-diagnostics \
 perl-doc \
 perl-encoding \
 perl-encoding-warnings \
 perl-experimental \
 perl-fields \
 perl-filetest \
 perl-if \
 perl-interpreter \
 perl-less \
 perl-lib \
 perl-libnet \
 perl-libnetcfg \
 perl-libs \
 perl-locale \
 perl-macros \
 perl-meta-notation \
 perl-mro \
 perl-open \
 perl-overload \
 perl-overloading \
 perl-parent \
 perl-perlfaq \
 perl-ph \
 perl-podlators \
 perl-sigtrap \
 perl-sort \
 perl-subs \
 perl-threads \
 perl-threads-shared \
 perl-utils \
 perl-vars \
 perl-version \
 perl-vmsish \
 "
RDEPENDS:perl-Attribute-Handlers = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-AutoLoader = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-AutoSplit = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Path \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-B = " \
 glibc \
 perl-B \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-if \
 perl-libs \
 perl-overloading \
 "
RDEPENDS:perl-Benchmark = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Class-Struct = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Config-Extensions = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-DBM_Filter = " \
 perl-Carp \
 perl-Encode \
 perl-IO-Compress \
 perl-libs \
 "
RDEPENDS:perl-Devel-Peek = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Devel-SelfStubber = " \
 perl-PathTools \
 perl-SelfLoader \
 perl-libs \
 "
RDEPENDS:perl-DirHandle = " \
 perl-Carp \
 perl-Symbol \
 perl-libs \
 "
RDEPENDS:perl-Dumpvalue = " \
 perl-libs \
 "
RDEPENDS:perl-DynaLoader = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-English = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Errno = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-ExtUtils-Constant = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-ExtUtils-Constant \
 perl-Text-Tabs+Wrap \
 perl-constant \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-ExtUtils-Embed = " \
 perl-Exporter \
 perl-PathTools \
 perl-devel \
 perl-libs \
 "
RDEPENDS:perl-ExtUtils-Miniperl = " \
 perl-Exporter \
 perl-ExtUtils-Embed \
 perl-devel \
 perl-libs \
 "
RDEPENDS:perl-Fcntl = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-File-Basename = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-File-Compare = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-File-Copy = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-File-DosGlob = " \
 glibc \
 perl-Text-ParseWords \
 perl-libs \
 "
RDEPENDS:perl-File-Find = " \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-File-stat = " \
 perl-Carp \
 perl-Class-Struct \
 perl-Exporter \
 perl-Fcntl \
 perl-Symbol \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-FileCache = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-FileHandle = " \
 perl-Exporter \
 perl-IO \
 perl-libs \
 "
RDEPENDS:perl-FindBin = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-GDBM_File = " \
 gdbm-libs \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Getopt-Std = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Hash-Util = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Hash-Util-FieldHash \
 perl-libs \
 "
RDEPENDS:perl-Hash-Util-FieldHash = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-I18N-Collate = " \
 perl-Exporter \
 perl-POSIX \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-I18N-LangTags = " \
 perl-Exporter \
 perl-I18N-LangTags \
 perl-libs \
 "
RDEPENDS:perl-I18N-Langinfo = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-IO = " \
 glibc \
 perl-Carp \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-stat \
 perl-IO \
 perl-PathTools \
 perl-SelectSaver \
 perl-Socket \
 perl-Symbol \
 perl-libs \
 "
RDEPENDS:perl-IPC-Open3 = " \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-IO \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-Symbol \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Locale-Maketext-Simple = " \
 perl-Locale-Maketext \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-Math-Complex = " \
 perl-Exporter \
 perl-Math-Complex \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Memoize = " \
 perl-Carp \
 perl-Exporter \
 perl-NDBM_File \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-libs \
 "
RDEPENDS:perl-Module-Loaded = " \
 perl-Carp \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-NDBM_File = " \
 gdbm-libs \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-NEXT = " \
 perl-Carp \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Net = " \
 perl-Class-Struct \
 perl-Exporter \
 perl-Socket \
 perl-libs \
 "
RDEPENDS:perl-ODBM_File = " \
 gdbm-libs \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-Opcode = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Opcode \
 perl-libs \
 perl-subs \
 "
RDEPENDS:perl-POSIX = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-libs \
 perl-locale \
 "
RDEPENDS:perl-Pod-Functions = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Pod-Html = " \
 perl-Exporter \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Html \
 perl-Pod-Simple \
 perl-Text-Tabs+Wrap \
 perl-interpreter \
 perl-libs \
 perl-locale \
 perl-parent \
 "
RDEPENDS:perl-Safe = " \
 perl-B \
 perl-Carp \
 perl-Opcode \
 perl-Scalar-List-Utils \
 perl-libs \
 "
RDEPENDS:perl-Search-Dict = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-SelectSaver = " \
 perl-Carp \
 perl-Symbol \
 perl-libs \
 "
RDEPENDS:perl-SelfLoader = " \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-libs \
 "
RDEPENDS:perl-Symbol = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Sys-Hostname = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Term-Complete = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Term-ReadLine = " \
 perl-Term-Cap \
 perl-libs \
 "
RDEPENDS:perl-Test = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Temp \
 perl-libs \
 "
RDEPENDS:perl-Text-Abbrev = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Thread = " \
 perl-Exporter \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 "
RDEPENDS:perl-Thread-Semaphore = " \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-threads-shared \
 "
RDEPENDS:perl-Tie = " \
 perl-Carp \
 perl-Tie \
 perl-libs \
 "
RDEPENDS:perl-Tie-File = " \
 perl-Carp \
 perl-Fcntl \
 perl-POSIX \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Tie-Memoize = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-Time = " \
 perl-Class-Struct \
 perl-Exporter \
 perl-Time \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-Time-Piece = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-Time-Local \
 perl-Time-Piece \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Unicode-UCD = " \
 perl-Carp \
 perl-Exporter \
 perl-PathTools \
 perl-Storable \
 perl-Unicode-Normalize \
 perl-if \
 perl-libs \
 "
RDEPENDS:perl-User-pwent = " \
 perl-Carp \
 perl-Class-Struct \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-autouse = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-base = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-blib = " \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-debugger = " \
 perl-IO \
 perl-PathTools \
 perl-Term-ReadLine \
 perl-libs \
 perl-meta-notation \
 perl-mro \
 perl-threads \
 perl-threads-shared \
 perl-vars \
 "
RDEPENDS:perl-deprecate = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-devel = " \
 libxcrypt-devel \
 perl-Devel-PPPort \
 perl-ExtUtils-Constant \
 perl-ExtUtils-Install \
 perl-ExtUtils-ParseXS \
 perl-File-Compare \
 perl-File-Path \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Text-Tabs+Wrap \
 perl-interpreter \
 perl-libs \
 perl-vars \
 redhat-rpm-config \
 systemtap-sdt-devel \
 systemtap-sdt-dtrace \
 "
RDEPENDS:perl-diagnostics = " \
 perl-Carp \
 perl-Getopt-Std \
 perl-Text-Tabs+Wrap \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-doc = " \
 perl-libs \
 "
RDEPENDS:perl-encoding-warnings = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-fields = " \
 perl-Carp \
 perl-Hash-Util \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-filetest = " \
 perl-libs \
 "
RDEPENDS:perl-if = " \
 perl-libs \
 "
RDEPENDS:perl-interpreter = " \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-less = " \
 perl-libs \
 "
RDEPENDS:perl-lib = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-libnetcfg = " \
 perl-ExtUtils-MakeMaker \
 perl-Getopt-Std \
 perl-IO \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-libs = " \
 glibc \
 libxcrypt \
 perl-Carp \
 perl-DynaLoader \
 perl-Encode \
 perl-Exporter \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-locale = " \
 perl-Carp \
 perl-POSIX \
 perl-libs \
 "
RDEPENDS:perl-macros = " \
 perl-interpreter \
 "
RDEPENDS:perl-meta-notation = " \
 perl-libs \
 "
RDEPENDS:perl-mro = " \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-open = " \
 perl-Carp \
 perl-Encode \
 perl-encoding \
 perl-libs \
 "
RDEPENDS:perl-overload = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-mro \
 perl-overloading \
 "
RDEPENDS:perl-overloading = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-ph = " \
 perl-libs \
 "
RDEPENDS:perl-sigtrap = " \
 perl-Carp \
 perl-Symbol \
 perl-libs \
 perl-meta-notation \
 "
RDEPENDS:perl-sort = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-subs = " \
 perl-libs \
 "
RDEPENDS:perl-utils = " \
 perl-File-Basename \
 perl-File-Path \
 perl-Getopt-Std \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-vars = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-vmsish = " \
 perl-libs \
 "
