# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "x2goclient"
PV = "4.1.2.3"
PR = "7.el10_0"
PACKAGES = " \
 x2goclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/x2goclient-4.1.2.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f199c538df1b0f1ab1753f08e6d43e836db640bba54662341cdd36100002ee5"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - x2goclient: nxproxy

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - x2goclient: nxproxy

URI_x86_64_v2_x2goclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/x2goclient-4.1.2.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_x2goclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_x2goclient}"
SRC_URI[x86_64_v2_x2goclient.sha256sum] = "13f1b6d2c72bdef7f23fc58b608afc626a7534c39bd42cb6aed45b55b2a138ee"

URI_aarch64_x2goclient = "${EPEL_MIRROR}/aarch64/Packages/x/x2goclient-4.1.2.3-7.el10_0.aarch64.rpm;name=aarch64_x2goclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_x2goclient}"
SRC_URI[aarch64_x2goclient.sha256sum] = "94c177b8d7035e1d1c0fb76311aa0cd85f06405eb2022bbfab31b21d9450f6c8"

RDEPENDS:x2goclient = " \
 cups-libs \
 glibc \
 hicolor-icon-theme \
 libX11 \
 libXpm \
 libgcc \
 libssh \
 libstdc++ \
 openldap \
 openssh-clients \
 openssh-server \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtsvg \
 qt5-qtx11extras \
 "
