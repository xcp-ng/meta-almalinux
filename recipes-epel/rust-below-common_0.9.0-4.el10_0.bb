# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-common"
PV = "0.9.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-below-common+default-devel \
 rust-below-common-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-common-0.9.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b64f5f03e186c386923be788cf6e0dc81f0395cf4bd6e6b5315efefcf7dc32d1"

URI_x86_64_v2_rust-below-common+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-common+default-devel-0.9.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-common+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-common+default-devel}"
SRC_URI[x86_64_v2_rust-below-common+default-devel.sha256sum] = "3f3609796589ebdeb3f0b837241651a72f426b94a7df430e4ba27e1fa040842f"

URI_x86_64_v2_rust-below-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-common-devel-0.9.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-common-devel}"
SRC_URI[x86_64_v2_rust-below-common-devel.sha256sum] = "c41446381873b566c5e8dd93f7c54882d176340884520f4517918a4125bd2566"

URI_aarch64_rust-below-common+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-common+default-devel-0.9.0-4.el10_0.noarch.rpm;name=aarch64_rust-below-common+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-common+default-devel}"
SRC_URI[aarch64_rust-below-common+default-devel.sha256sum] = "5f1c5c63b793d4ab28d7fd92080be1e9ea20ab86e44662b9cf0a1b550a93a727"

URI_aarch64_rust-below-common-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-common-devel-0.9.0-4.el10_0.noarch.rpm;name=aarch64_rust-below-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-common-devel}"
SRC_URI[aarch64_rust-below-common-devel.sha256sum] = "79475bda40baf7ed5634a7085e5ca8a2355c506e3e919310e4a8e3ca7213d701"

RDEPENDS:rust-below-common+default-devel = " \
 cargo \
 rust-below-common-devel \
 "
RDEPENDS:rust-below-common-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-chrono+clock-devel \
 rust-chrono+serde-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-cursive0.20+crossterm-backend-devel \
 rust-cursive0.20-devel \
 rust-humantime+default-devel \
 rust-once_cell+default-devel \
 rust-regex+default-devel \
 rust-slog+default-devel \
 rust-slog+max_level_trace-devel \
 rust-slog+nested-values-devel \
 rust-slog-term+default-devel \
 rust-walkdir+default-devel \
 "
