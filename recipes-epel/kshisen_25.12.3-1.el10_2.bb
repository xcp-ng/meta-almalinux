# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kshisen"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kshisen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kshisen-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7335aaad1aecd66a86930a99e00390d82f1a0b93ee4b52bc1f053f8dcc534ced"

URI_x86_64_v2_kshisen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kshisen-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kshisen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kshisen}"
SRC_URI[x86_64_v2_kshisen.sha256sum] = "5c2f448b02fad5fa4e5a974bab1c823366d5a48311ecb163bd08f017e9ef0e8b"

URI_aarch64_kshisen = "${EPEL_MIRROR}/aarch64/Packages/k/kshisen-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kshisen;unpack=0"
SRC_URI:append = " ${URI_aarch64_kshisen}"
SRC_URI[aarch64_kshisen.sha256sum] = "6f5774bac46716f70359c9cf825d4ae13caf81378922a41177e9afd2f995d108"

RDEPENDS:kshisen = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libkmahjongg \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
