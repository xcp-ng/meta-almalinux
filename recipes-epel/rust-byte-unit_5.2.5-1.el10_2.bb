# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-byte-unit"
PV = "5.2.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-byte-unit+bit-devel \
 rust-byte-unit+byte-devel \
 rust-byte-unit+default-devel \
 rust-byte-unit+rust_decimal-devel \
 rust-byte-unit+schemars-devel \
 rust-byte-unit+serde-devel \
 rust-byte-unit+std-devel \
 rust-byte-unit+u128-devel \
 rust-byte-unit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-byte-unit-5.2.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ead92a78a102fb647410ba236fd29afa19dd065b1a7bd8e7fd4b25dd0cf2a88e"

URI_x86_64_v2_rust-byte-unit+bit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+bit-devel-5.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+bit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+bit-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+bit-devel.sha256sum] = "c35d09db7d7d48ed1fd463ca53f02d6854c9864c412a6833f37dcda611f9b8e8"

URI_x86_64_v2_rust-byte-unit+byte-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+byte-devel-5.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+byte-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+byte-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+byte-devel.sha256sum] = "2d3b4fd3214321c5c6a2ced7e2da211a0f3daa80a11fb727cab10a38cb5a84a4"

URI_x86_64_v2_rust-byte-unit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+default-devel-5.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+default-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+default-devel.sha256sum] = "73a54d5ddc39246cb8037a01ae32cad68b289584ad68c634317e3c27d078b187"

URI_x86_64_v2_rust-byte-unit+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+rust_decimal-devel-5.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+rust_decimal-devel.sha256sum] = "277ef5efa2dabb174e20b6dda73003d594d4adbf7be75792665ddf5d8b3f03de"

URI_x86_64_v2_rust-byte-unit+schemars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+schemars-devel-5.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+schemars-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+schemars-devel.sha256sum] = "45a3d78171c6b896d48fe8c1269817990fd4aa754aab592f9a5f1f34380054ec"

URI_x86_64_v2_rust-byte-unit+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+serde-devel-5.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+serde-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+serde-devel.sha256sum] = "a56f6fb727c872cf899decd6d5c18f2687ea27672058db2ae2d8f65f6d3f6c80"

URI_x86_64_v2_rust-byte-unit+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+std-devel-5.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+std-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+std-devel.sha256sum] = "84672f07d71d2c6acf3ed15e5950c0b0394de192cf8fae03c2773b5c2134b150"

URI_x86_64_v2_rust-byte-unit+u128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+u128-devel-5.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+u128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+u128-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+u128-devel.sha256sum] = "39d00791fe795e360974b9e5ceb5fdaf7e9251fe6ba5b4d0a64dcf69dfbc3cc4"

URI_x86_64_v2_rust-byte-unit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit-devel-5.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit-devel}"
SRC_URI[x86_64_v2_rust-byte-unit-devel.sha256sum] = "343b30e77f5a260e7f559ab4dd61434ee85640a91e5489a749066ff9165ac2f7"

URI_aarch64_rust-byte-unit+bit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+bit-devel-5.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-byte-unit+bit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+bit-devel}"
SRC_URI[aarch64_rust-byte-unit+bit-devel.sha256sum] = "1ec753f83b14990f5d6ebc00abb4f3c0550e3b6c1908a16bf297f4727d6974c3"

URI_aarch64_rust-byte-unit+byte-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+byte-devel-5.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-byte-unit+byte-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+byte-devel}"
SRC_URI[aarch64_rust-byte-unit+byte-devel.sha256sum] = "e69bc72d7b8e35dc366924c9532474981be72e47ad330594f62eab6fe9691f89"

URI_aarch64_rust-byte-unit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+default-devel-5.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-byte-unit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+default-devel}"
SRC_URI[aarch64_rust-byte-unit+default-devel.sha256sum] = "c044addce81cc1ddb1c12c0d7bbfec4bd7d7fd0502b164aceca0866ffb6f8a8f"

URI_aarch64_rust-byte-unit+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+rust_decimal-devel-5.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-byte-unit+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+rust_decimal-devel}"
SRC_URI[aarch64_rust-byte-unit+rust_decimal-devel.sha256sum] = "9612529bcacdba666e5490d4645c92fd67e0c2cce147962d2abdcc0508ecaf53"

URI_aarch64_rust-byte-unit+schemars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+schemars-devel-5.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-byte-unit+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+schemars-devel}"
SRC_URI[aarch64_rust-byte-unit+schemars-devel.sha256sum] = "d21c1c542c9f72287cc54a1f0bd385de6171becb290d2117d6869737af379867"

URI_aarch64_rust-byte-unit+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+serde-devel-5.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-byte-unit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+serde-devel}"
SRC_URI[aarch64_rust-byte-unit+serde-devel.sha256sum] = "b4f5b4f18ddc050702d4c3457019e0fa6933e1e841191f9e5cf8e7b293281cae"

URI_aarch64_rust-byte-unit+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+std-devel-5.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-byte-unit+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+std-devel}"
SRC_URI[aarch64_rust-byte-unit+std-devel.sha256sum] = "139cc5a6a6cd2227ba4406aa70ef78cf0ec229b4763fbf38539c967dda5b331c"

URI_aarch64_rust-byte-unit+u128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+u128-devel-5.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-byte-unit+u128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+u128-devel}"
SRC_URI[aarch64_rust-byte-unit+u128-devel.sha256sum] = "cfce5d0a1199b6907376c62579101517db6a3f47e5f878399d611f64b5771a8e"

URI_aarch64_rust-byte-unit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit-devel-5.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-byte-unit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit-devel}"
SRC_URI[aarch64_rust-byte-unit-devel.sha256sum] = "e972f07d5e6861098348fb59c37f7e05781e4d4f8e7fde54fcc1c3c8dce78d97"

RDEPENDS:rust-byte-unit+bit-devel = " \
 cargo \
 rust-byte-unit+rust_decimal-devel \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit+byte-devel = " \
 cargo \
 rust-byte-unit+rust_decimal-devel \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit+default-devel = " \
 cargo \
 rust-byte-unit+byte-devel \
 rust-byte-unit+std-devel \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit+rust_decimal-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-byte-unit+schemars-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-byte-unit+serde-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-byte-unit+std-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 rust-schemars+std-devel \
 rust-schemars-devel \
 rust-serde+alloc-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-byte-unit+u128-devel = " \
 cargo \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit-devel = " \
 cargo \
 rust \
 rust-utf8-width+default-devel \
 "
