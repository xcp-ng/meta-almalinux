# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpsd"
PE = "1"
PV = "3.26.1"
PR = "5.el10"
PACKAGES = " \
 gpsd \
 gpsd-clients \
 python3-gpsd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gpsd-3.26.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8416734e86a2fce200179224d02d80946e75803ef74c618f479d959f219d6d49"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gpsd-3.26.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_gpsd;unpack=0"
SRC_URI[x86_64_v2_gpsd.sha256sum] = "607a211a53aadf27531b5ebc2e17de47c8867b72f5804fa7a27bdc0419d2e696"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gpsd-clients-3.26.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_gpsd-clients;unpack=0"
SRC_URI[x86_64_v2_gpsd-clients.sha256sum] = "149f34b45576f98861a34ecc65ce8805a6c53a7b8cdb4719396d2181e6029ef5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-gpsd-3.26.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-gpsd;unpack=0"
SRC_URI[x86_64_v2_python3-gpsd.sha256sum] = "c101327a0e0970709b1572406f6ddbcbc1416f94f54810a8ad43bd6648e33069"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gpsd-3.26.1-5.el10.aarch64.rpm;name=aarch64_gpsd;unpack=0"
SRC_URI[aarch64_gpsd.sha256sum] = "a6d0ff6ebf0e399323804cc413cbe03f663217d189122c1b604d7bd714fc7e40"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gpsd-clients-3.26.1-5.el10.aarch64.rpm;name=aarch64_gpsd-clients;unpack=0"
SRC_URI[aarch64_gpsd-clients.sha256sum] = "b4a53df65506be7796693dcc614cabb58471060a1ac9c09b26da7f82b7bf14cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-gpsd-3.26.1-5.el10.aarch64.rpm;name=aarch64_python3-gpsd;unpack=0"
SRC_URI[aarch64_python3-gpsd.sha256sum] = "80ff8f6e601ba185cdfc8e5ffec5452ccf3a4cd077c1758c9930c450496537da"

RDEPENDS:gpsd = " \
 bash \
 bluez-libs \
 dbus-libs \
 glibc \
 libusb1 \
 ncurses-libs \
 systemd \
 systemd-udev \
 "
RDEPENDS:gpsd-clients = " \
 bash \
 bluez-libs \
 dbus-libs \
 glibc \
 libusb1 \
 ncurses-libs \
 python3 \
 python3-gpsd \
 "
RDEPENDS:python3-gpsd = " \
 glibc \
 python3 \
 python3-pyserial \
 "
