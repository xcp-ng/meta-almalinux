# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalk"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kalk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kalk-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc9872dda460198e65b26d64bdd36ffae8efbd85ba8471cc0a2dccd729578706"

URI_x86_64_v2_kalk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalk-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalk}"
SRC_URI[x86_64_v2_kalk.sha256sum] = "66d93c1bd127c45a610581398d0249f7e3fd9692779c68ac2c612e361846ea7b"

URI_aarch64_kalk = "${EPEL_MIRROR}/aarch64/Packages/k/kalk-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kalk;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalk}"
SRC_URI[aarch64_kalk.sha256sum] = "89b0c21ebef9a0d6795db959d00535f422df266c1fce5033e70ad0b2b9813350"

RDEPENDS:kalk = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kunitconversion \
 kf6-qqc2-desktop-style \
 kf6-sonnet \
 libqalculate \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
