# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rsa"
PV = "0.9.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-rsa+default-devel \
 rust-rsa+getrandom-devel \
 rust-rsa+hazmat-devel \
 rust-rsa+pem-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+serde-devel \
 rust-rsa+sha1-devel \
 rust-rsa+sha2-devel \
 rust-rsa+std-devel \
 rust-rsa+u64_digit-devel \
 rust-rsa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rsa-0.9.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "153452bea10b60811a3d2b8871ab734d5a8ebb941f6441bb0e2b5003a741ef0c"

URI_x86_64_v2_rust-rsa+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+default-devel-0.9.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+default-devel}"
SRC_URI[x86_64_v2_rust-rsa+default-devel.sha256sum] = "5c72f844f0df382bbfcf429b59a1c931f72d1c0e64f1cdbc9264e4dce6c9269d"

URI_x86_64_v2_rust-rsa+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+getrandom-devel-0.9.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+getrandom-devel}"
SRC_URI[x86_64_v2_rust-rsa+getrandom-devel.sha256sum] = "3649535aa4a15b7f7f789ab84c4131d30c6fe0f1f6b9275564aed5f3e0ed2347"

URI_x86_64_v2_rust-rsa+hazmat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+hazmat-devel-0.9.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+hazmat-devel}"
SRC_URI[x86_64_v2_rust-rsa+hazmat-devel.sha256sum] = "2c1e9b7ff17da5e348901608e82b7ed59a2e277a2f78bcd80abbfbf7eea22053"

URI_x86_64_v2_rust-rsa+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+pem-devel-0.9.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+pem-devel}"
SRC_URI[x86_64_v2_rust-rsa+pem-devel.sha256sum] = "6ec501d8f5ac0db9ec1ffb0b45230f750f7315d0668e373ccd44d23ff9b38cc5"

URI_x86_64_v2_rust-rsa+pkcs5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+pkcs5-devel-0.9.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+pkcs5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+pkcs5-devel}"
SRC_URI[x86_64_v2_rust-rsa+pkcs5-devel.sha256sum] = "2722585e8875e09c1bf720e07e9fc76d055c38ad09746065056b17d1d1644a26"

URI_x86_64_v2_rust-rsa+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+serde-devel-0.9.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+serde-devel}"
SRC_URI[x86_64_v2_rust-rsa+serde-devel.sha256sum] = "c9a9d65db6c1e045b5221c3c60fae7f9a20d9b44796b5a2e0b56d9272ff1fcb7"

URI_x86_64_v2_rust-rsa+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+sha1-devel-0.9.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+sha1-devel}"
SRC_URI[x86_64_v2_rust-rsa+sha1-devel.sha256sum] = "f82ed00fb9f06c84ef8b48c547b6d3f4a5f4277ab1441e661f2b01481391d65e"

URI_x86_64_v2_rust-rsa+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+sha2-devel-0.9.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+sha2-devel}"
SRC_URI[x86_64_v2_rust-rsa+sha2-devel.sha256sum] = "7e55638d761ba3d67dae83975f77373894ad67dca5e4bd411ec533fe7706cffc"

URI_x86_64_v2_rust-rsa+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+std-devel-0.9.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+std-devel}"
SRC_URI[x86_64_v2_rust-rsa+std-devel.sha256sum] = "f0fbd9daacc86fbea96c60219fac044cdd625f58ab8201250573d31c0c59f5f0"

URI_x86_64_v2_rust-rsa+u64_digit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+u64_digit-devel-0.9.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+u64_digit-devel}"
SRC_URI[x86_64_v2_rust-rsa+u64_digit-devel.sha256sum] = "0841994d6adea30fe81d9bc12da17902eb68c6c080ab80160994aee46fc930b4"

URI_x86_64_v2_rust-rsa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa-devel-0.9.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa-devel}"
SRC_URI[x86_64_v2_rust-rsa-devel.sha256sum] = "fef8c6e7193bdbeec5b5ece5066c73c74b26719c44fa69043b935646ad69c54e"

URI_aarch64_rust-rsa+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+default-devel-0.9.10-1.el10_1.noarch.rpm;name=aarch64_rust-rsa+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+default-devel}"
SRC_URI[aarch64_rust-rsa+default-devel.sha256sum] = "890f42af5ca5c85778feae3dab97cbde07edf8caa1461af2640b8723f888cdf0"

URI_aarch64_rust-rsa+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+getrandom-devel-0.9.10-1.el10_1.noarch.rpm;name=aarch64_rust-rsa+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+getrandom-devel}"
SRC_URI[aarch64_rust-rsa+getrandom-devel.sha256sum] = "7409f85a3dccaf349e3a5e2f197e175dc11a35432c44c1a648b5ebec873261e8"

URI_aarch64_rust-rsa+hazmat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+hazmat-devel-0.9.10-1.el10_1.noarch.rpm;name=aarch64_rust-rsa+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+hazmat-devel}"
SRC_URI[aarch64_rust-rsa+hazmat-devel.sha256sum] = "2b7a5356f49724ae4975ed8e7304d1205f7b0880ca34b1caaf98da5b60dbbf1e"

URI_aarch64_rust-rsa+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+pem-devel-0.9.10-1.el10_1.noarch.rpm;name=aarch64_rust-rsa+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+pem-devel}"
SRC_URI[aarch64_rust-rsa+pem-devel.sha256sum] = "e41677920ee4bf9a278e89beca7ed5fccd74a4d77abc41584c2aa7ff49594ead"

URI_aarch64_rust-rsa+pkcs5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+pkcs5-devel-0.9.10-1.el10_1.noarch.rpm;name=aarch64_rust-rsa+pkcs5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+pkcs5-devel}"
SRC_URI[aarch64_rust-rsa+pkcs5-devel.sha256sum] = "e9f79cde9b77dc7feaf88427af0d27282fa7f91e5b2a889d434d23348b9b8d1d"

URI_aarch64_rust-rsa+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+serde-devel-0.9.10-1.el10_1.noarch.rpm;name=aarch64_rust-rsa+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+serde-devel}"
SRC_URI[aarch64_rust-rsa+serde-devel.sha256sum] = "61719dcedc78a263f550d223c1e55fb1633c16ae65420c842031b1bc027f6025"

URI_aarch64_rust-rsa+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+sha1-devel-0.9.10-1.el10_1.noarch.rpm;name=aarch64_rust-rsa+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+sha1-devel}"
SRC_URI[aarch64_rust-rsa+sha1-devel.sha256sum] = "779f5fead73cea4ab6fd7966ac9dd2ee90051a6b7965a6f85b5fe61ff3aa3436"

URI_aarch64_rust-rsa+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+sha2-devel-0.9.10-1.el10_1.noarch.rpm;name=aarch64_rust-rsa+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+sha2-devel}"
SRC_URI[aarch64_rust-rsa+sha2-devel.sha256sum] = "2df2f3e1791462c7bef7980d15ac5cc9f1ddc0555a019895feee6f1e21c5910b"

URI_aarch64_rust-rsa+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+std-devel-0.9.10-1.el10_1.noarch.rpm;name=aarch64_rust-rsa+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+std-devel}"
SRC_URI[aarch64_rust-rsa+std-devel.sha256sum] = "1b8f7935db9aeeee2a30691a39dae25795d0c35109b404aeaef82e6979f89dfd"

URI_aarch64_rust-rsa+u64_digit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+u64_digit-devel-0.9.10-1.el10_1.noarch.rpm;name=aarch64_rust-rsa+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+u64_digit-devel}"
SRC_URI[aarch64_rust-rsa+u64_digit-devel.sha256sum] = "c96adcceefa0d835805f7f1c6fdc3e34f0570f8ee7c1d5d08cfd3a5a810bd899"

URI_aarch64_rust-rsa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa-devel-0.9.10-1.el10_1.noarch.rpm;name=aarch64_rust-rsa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa-devel}"
SRC_URI[aarch64_rust-rsa-devel.sha256sum] = "daa1106645be275df4f972cba543bd52b0aefcb7c4971ac772d606fcb23f33f7"

RDEPENDS:rust-rsa+default-devel = " \
 cargo \
 rust-rsa+pem-devel \
 rust-rsa+std-devel \
 rust-rsa+u64_digit-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+getrandom-devel = " \
 cargo \
 rust-rand_core0.6+getrandom-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+hazmat-devel = " \
 cargo \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+pem-devel = " \
 cargo \
 rust-pkcs1+pem-devel \
 rust-pkcs8+pem-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+pkcs5-devel = " \
 cargo \
 rust-pkcs8+encryption-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+serde-devel = " \
 cargo \
 rust-num-bigint-dig+serde-devel \
 rust-rsa-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rsa+sha1-devel = " \
 cargo \
 rust-rsa-devel \
 rust-sha1+oid-devel \
 rust-sha1-devel \
 "
RDEPENDS:rust-rsa+sha2-devel = " \
 cargo \
 rust-rsa-devel \
 rust-sha2+oid-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-rsa+std-devel = " \
 cargo \
 rust-digest+std-devel \
 rust-pkcs1+std-devel \
 rust-pkcs8+std-devel \
 rust-rand_core0.6+std-devel \
 rust-rsa-devel \
 rust-signature+std-devel \
 "
RDEPENDS:rust-rsa+u64_digit-devel = " \
 cargo \
 rust-num-bigint-dig+u64_digit-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa-devel = " \
 cargo \
 rust \
 rust-const-oid-devel \
 rust-digest+alloc-devel \
 rust-digest+oid-devel \
 rust-digest-devel \
 rust-num-bigint-dig+i128-devel \
 rust-num-bigint-dig+prime-devel \
 rust-num-bigint-dig+zeroize-devel \
 rust-num-bigint-dig-devel \
 rust-num-integer-devel \
 rust-num-traits+libm-devel \
 rust-num-traits-devel \
 rust-pkcs1+alloc-devel \
 rust-pkcs1+pkcs8-devel \
 rust-pkcs1-devel \
 rust-pkcs8+alloc-devel \
 rust-pkcs8-devel \
 rust-rand_core0.6-devel \
 rust-signature+alloc-devel \
 rust-signature+digest-devel \
 rust-signature+rand_core-devel \
 rust-signature-devel \
 rust-spki+alloc-devel \
 rust-spki-devel \
 rust-subtle-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize+default-devel \
 "
