# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zbus"
PV = "5.12.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-zbus+async-executor-devel \
 rust-zbus+async-fs-devel \
 rust-zbus+async-io-devel \
 rust-zbus+async-lock-devel \
 rust-zbus+async-process-devel \
 rust-zbus+async-task-devel \
 rust-zbus+blocking-api-devel \
 rust-zbus+blocking-devel \
 rust-zbus+bus-impl-devel \
 rust-zbus+camino-devel \
 rust-zbus+chrono-devel \
 rust-zbus+default-devel \
 rust-zbus+option-as-array-devel \
 rust-zbus+p2p-devel \
 rust-zbus+serde_bytes-devel \
 rust-zbus+time-devel \
 rust-zbus+tokio-devel \
 rust-zbus+url-devel \
 rust-zbus+uuid-devel \
 rust-zbus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zbus-5.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb6ff76779d7fe8d2c9fcc8b4d8848f9666bc4d19394fa1905a31f876a4cafed"

URI_x86_64_v2_rust-zbus+async-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-executor-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-executor-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-executor-devel.sha256sum] = "38dbe4a9f4627ef8b7485ad1d955dc10a930b5ff234de1e4449bbfbc9b127425"

URI_x86_64_v2_rust-zbus+async-fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-fs-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-fs-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-fs-devel.sha256sum] = "582a204dd06d09a71c2cb80976fbf01be24e3592ff1c0483896de690cecae4fb"

URI_x86_64_v2_rust-zbus+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-io-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-io-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-io-devel.sha256sum] = "397b34db9b65b5236527a8bd4f37f9fab94cad0d0134a2387323bbfab0098d5f"

URI_x86_64_v2_rust-zbus+async-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-lock-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-lock-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-lock-devel.sha256sum] = "b3fbc530260fc866d331f9434ad60d0ac3b0efca38ffd975138a102c8e11b8fe"

URI_x86_64_v2_rust-zbus+async-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-process-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-process-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-process-devel.sha256sum] = "26d79d809d5d1994b029bf38952752f8ed663b0dcc1bc00561659a0ce7f9d11e"

URI_x86_64_v2_rust-zbus+async-task-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-task-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-task-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-task-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-task-devel.sha256sum] = "7c5f04769feae21792d70e49dc7a501ce75e5d772a43265da190ef508573109a"

URI_x86_64_v2_rust-zbus+blocking-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+blocking-api-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+blocking-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+blocking-api-devel}"
SRC_URI[x86_64_v2_rust-zbus+blocking-api-devel.sha256sum] = "e9032ea8d3467aef70b366e7b030319b32e4d889dad26ae034ebdc6145cfd318"

URI_x86_64_v2_rust-zbus+blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+blocking-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+blocking-devel}"
SRC_URI[x86_64_v2_rust-zbus+blocking-devel.sha256sum] = "a2338225a50d44f4abb7337b17c70ecb0fc3b7c965f1f48b51f9e7e043575b5a"

URI_x86_64_v2_rust-zbus+bus-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+bus-impl-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+bus-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+bus-impl-devel}"
SRC_URI[x86_64_v2_rust-zbus+bus-impl-devel.sha256sum] = "d44e2373a02e46594b16e43cf613f345d04cf10f90a517898fe6b1ad78c928d2"

URI_x86_64_v2_rust-zbus+camino-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+camino-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+camino-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+camino-devel}"
SRC_URI[x86_64_v2_rust-zbus+camino-devel.sha256sum] = "e335bdeab6476cba3a54ba5b708485932526bb38ef8646409621dd883394d5ee"

URI_x86_64_v2_rust-zbus+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+chrono-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+chrono-devel}"
SRC_URI[x86_64_v2_rust-zbus+chrono-devel.sha256sum] = "0f249bf6f7b6332d3a8f4c08a72b190e41c1374a0cb9f013d9635905bd96649b"

URI_x86_64_v2_rust-zbus+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+default-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+default-devel}"
SRC_URI[x86_64_v2_rust-zbus+default-devel.sha256sum] = "828f0dcab67c34a059906b5bc3c3676a1c2fdff67b41019d53a2691e7d884077"

URI_x86_64_v2_rust-zbus+option-as-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+option-as-array-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+option-as-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+option-as-array-devel}"
SRC_URI[x86_64_v2_rust-zbus+option-as-array-devel.sha256sum] = "50b097e7ba0dae8dc99010bc2f1796befb5989fa62fc815aa2948a0fc4bb521b"

URI_x86_64_v2_rust-zbus+p2p-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+p2p-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+p2p-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+p2p-devel}"
SRC_URI[x86_64_v2_rust-zbus+p2p-devel.sha256sum] = "d733a9b3bf3665773b16eb37201ec476409a492fa35251ad2fc6653fac8c12b6"

URI_x86_64_v2_rust-zbus+serde_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+serde_bytes-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+serde_bytes-devel}"
SRC_URI[x86_64_v2_rust-zbus+serde_bytes-devel.sha256sum] = "5caf929d51379baf4c9ba2ff40f9e8def4a1daffa4f962cceb9aab802dd23514"

URI_x86_64_v2_rust-zbus+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+time-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+time-devel}"
SRC_URI[x86_64_v2_rust-zbus+time-devel.sha256sum] = "7d9f14d80a2861e68e48d2c648d2792e899483d0d79ab50b55b11145c1651131"

URI_x86_64_v2_rust-zbus+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+tokio-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+tokio-devel}"
SRC_URI[x86_64_v2_rust-zbus+tokio-devel.sha256sum] = "74ad7501cae6d1a5a1a1a2e98d90693b3c7f3a65c42cdf11c5a9a597c893e99b"

URI_x86_64_v2_rust-zbus+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+url-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+url-devel}"
SRC_URI[x86_64_v2_rust-zbus+url-devel.sha256sum] = "c6e388382d1a063e1bd2e272e2dabc699a0a578656faaaeb7045518a8f37542d"

URI_x86_64_v2_rust-zbus+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+uuid-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+uuid-devel}"
SRC_URI[x86_64_v2_rust-zbus+uuid-devel.sha256sum] = "4bdc6fb24ec61abf125cde92db1edcd96ae6363a0e8fb29073bc3fac8b03988d"

URI_x86_64_v2_rust-zbus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus-devel}"
SRC_URI[x86_64_v2_rust-zbus-devel.sha256sum] = "4debf8bdb62a97f8e7013c49148102f7bb13340228954a141cac85eee8b16f18"

URI_aarch64_rust-zbus+async-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-executor-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+async-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-executor-devel}"
SRC_URI[aarch64_rust-zbus+async-executor-devel.sha256sum] = "03276f187336b1b7115d47016e9468ed8ee3d7c7c6e908fcb1146f37c0bd8fde"

URI_aarch64_rust-zbus+async-fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-fs-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+async-fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-fs-devel}"
SRC_URI[aarch64_rust-zbus+async-fs-devel.sha256sum] = "7c0462da4df66cb9cbd974a5a0c133bcfbe984512284f7a0cb16ef060e8d2e2b"

URI_aarch64_rust-zbus+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-io-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-io-devel}"
SRC_URI[aarch64_rust-zbus+async-io-devel.sha256sum] = "7a1e121570210c0e878f5e19fb5010129efc51ba25d1fc92fe47e876df22df14"

URI_aarch64_rust-zbus+async-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-lock-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-lock-devel}"
SRC_URI[aarch64_rust-zbus+async-lock-devel.sha256sum] = "e134a148376dd7d1d2032dc2dc1ee7f7f6e2276a476f178dc526c27e8efed08b"

URI_aarch64_rust-zbus+async-process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-process-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+async-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-process-devel}"
SRC_URI[aarch64_rust-zbus+async-process-devel.sha256sum] = "a00acc49bbe5fea974d1ed7a220b2d8fa1593d79c0c988b2627066a491165271"

URI_aarch64_rust-zbus+async-task-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-task-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+async-task-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-task-devel}"
SRC_URI[aarch64_rust-zbus+async-task-devel.sha256sum] = "3319e8b4d35e291f81ed670635497a3b238a40a33cdfe5abf00dbcd422dc0975"

URI_aarch64_rust-zbus+blocking-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+blocking-api-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+blocking-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+blocking-api-devel}"
SRC_URI[aarch64_rust-zbus+blocking-api-devel.sha256sum] = "208f7715bc37b1542bf5d36de1fd5c89d41a68c7790a281cb765ea577f532312"

URI_aarch64_rust-zbus+blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+blocking-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+blocking-devel}"
SRC_URI[aarch64_rust-zbus+blocking-devel.sha256sum] = "1eb1da99b6d94bdaf6e21d9d5e3f7c8032aa4a456bf0ebc30804280819ce52bb"

URI_aarch64_rust-zbus+bus-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+bus-impl-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+bus-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+bus-impl-devel}"
SRC_URI[aarch64_rust-zbus+bus-impl-devel.sha256sum] = "5f62d45c1d9cb5dd411012ad52dc35b873d8aa613b25184e4aff677c5ad687e9"

URI_aarch64_rust-zbus+camino-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+camino-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+camino-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+camino-devel}"
SRC_URI[aarch64_rust-zbus+camino-devel.sha256sum] = "483a90f9ea50d9954a9d5a3e5957e003e4b9da8cd190e36de600eb9e8aa0212d"

URI_aarch64_rust-zbus+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+chrono-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+chrono-devel}"
SRC_URI[aarch64_rust-zbus+chrono-devel.sha256sum] = "0a95636db36260bd857390f3a91defb37c96d6412956adeb6816ffaeee7b799d"

URI_aarch64_rust-zbus+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+default-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+default-devel}"
SRC_URI[aarch64_rust-zbus+default-devel.sha256sum] = "11750339f6c2d90cc504d701908410ffead9223272f1976e4e0a479082cadfb6"

URI_aarch64_rust-zbus+option-as-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+option-as-array-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+option-as-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+option-as-array-devel}"
SRC_URI[aarch64_rust-zbus+option-as-array-devel.sha256sum] = "cde81298cd48ea538264922a76b5b0e9e2cb08019c5c8ac5aa6c142bb516e464"

URI_aarch64_rust-zbus+p2p-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+p2p-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+p2p-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+p2p-devel}"
SRC_URI[aarch64_rust-zbus+p2p-devel.sha256sum] = "22ccb5e00f89c50178709afa5e4509295e08a6f6175038fafe6936d31ae3b5c5"

URI_aarch64_rust-zbus+serde_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+serde_bytes-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+serde_bytes-devel}"
SRC_URI[aarch64_rust-zbus+serde_bytes-devel.sha256sum] = "b1b3f4026a3faed9fe8b49fb5bc98f43bf91eae872984932747bbde089890887"

URI_aarch64_rust-zbus+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+time-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+time-devel}"
SRC_URI[aarch64_rust-zbus+time-devel.sha256sum] = "be9216e2fdcc60dd754bfc62510945594f3dcb88d6216f72924e568cfa91e39c"

URI_aarch64_rust-zbus+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+tokio-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+tokio-devel}"
SRC_URI[aarch64_rust-zbus+tokio-devel.sha256sum] = "d8405231839f69bb748266405dcdc92c6193003640c38289d4310cf1657e023d"

URI_aarch64_rust-zbus+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+url-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+url-devel}"
SRC_URI[aarch64_rust-zbus+url-devel.sha256sum] = "5bafbcd01fedd3cf509eafe8e7cdb80b8140ec5437b2aa6ceebaf3f879927cdc"

URI_aarch64_rust-zbus+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+uuid-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+uuid-devel}"
SRC_URI[aarch64_rust-zbus+uuid-devel.sha256sum] = "20c223ac8174e4c2c701e71ba06a8c78caecf57b67060da571d7ae4a3a5a7b58"

URI_aarch64_rust-zbus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus-devel}"
SRC_URI[aarch64_rust-zbus-devel.sha256sum] = "cd395927e177e788f370301c72002beaa15a4424fed5879f2a131e6e0d4dc09b"

RDEPENDS:rust-zbus+async-executor-devel = " \
 cargo \
 rust-async-executor+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-fs-devel = " \
 cargo \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-io-devel = " \
 cargo \
 rust-async-io+default-devel \
 rust-zbus+async-executor-devel \
 rust-zbus+async-fs-devel \
 rust-zbus+async-lock-devel \
 rust-zbus+async-process-devel \
 rust-zbus+async-task-devel \
 rust-zbus+blocking-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-lock-devel = " \
 cargo \
 rust-async-lock+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-process-devel = " \
 cargo \
 rust-async-process+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-task-devel = " \
 cargo \
 rust-async-task+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+blocking-api-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zbus_macros+blocking-api-devel \
 "
RDEPENDS:rust-zbus+blocking-devel = " \
 cargo \
 rust-blocking+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+bus-impl-devel = " \
 cargo \
 rust-zbus+p2p-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+camino-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+camino-devel \
 "
RDEPENDS:rust-zbus+chrono-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+chrono-devel \
 "
RDEPENDS:rust-zbus+default-devel = " \
 cargo \
 rust-zbus+async-io-devel \
 rust-zbus+blocking-api-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+option-as-array-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+option-as-array-devel \
 "
RDEPENDS:rust-zbus+p2p-devel = " \
 cargo \
 rust-uuid+v4-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+serde_bytes-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+serde_bytes-devel \
 "
RDEPENDS:rust-zbus+time-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+time-devel \
 "
RDEPENDS:rust-zbus+tokio-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+url-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+url-devel \
 "
RDEPENDS:rust-zbus+uuid-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+uuid-devel \
 "
RDEPENDS:rust-zbus-devel = " \
 cargo \
 rust \
 rust-async-broadcast+default-devel \
 rust-async-trait+default-devel \
 rust-enumflags2+default-devel \
 rust-enumflags2+serde-devel \
 rust-event-listener+default-devel \
 rust-futures-core+default-devel \
 rust-futures-lite+std-devel \
 rust-futures-lite-devel \
 rust-hex+default-devel \
 rust-nix+socket-devel \
 rust-nix+uio-devel \
 rust-nix+user-devel \
 rust-nix-devel \
 rust-ordered-stream+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_repr+default-devel \
 rust-tracing+default-devel \
 rust-uuid+default-devel \
 rust-uuid+serde-devel \
 rust-winnow+default-devel \
 rust-zbus_macros+default-devel \
 rust-zbus_names+default-devel \
 rust-zvariant+default-devel \
 rust-zvariant+enumflags2-devel \
 "
