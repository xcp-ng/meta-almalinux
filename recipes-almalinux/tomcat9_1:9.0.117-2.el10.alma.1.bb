# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcat9"
PE = "1"
PV = "9.0.117"
PR = "2.el10.alma.1"
PACKAGES = " \
 tomcat9 \
 tomcat9-admin-webapps \
 tomcat9-docs-webapp \
 tomcat9-el-3.0-api \
 tomcat9-jsp-2.3-api \
 tomcat9-lib \
 tomcat9-servlet-4.0-api \
 tomcat9-webapps \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tomcat9-9.0.117-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "207397fe27886301bb89e5c44659fff4bf89856d1c57d3b46143585f95fb55a1"

URI_x86_64_v2_tomcat9 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-9.0.117-2.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9}"
SRC_URI[x86_64_v2_tomcat9.sha256sum] = "c5a89ee8a7aa29d0b32fce8ea4866e7c5c15eb4bab47fd3289fce754c1f2f429"

URI_x86_64_v2_tomcat9-admin-webapps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-admin-webapps-9.0.117-2.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-admin-webapps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-admin-webapps}"
SRC_URI[x86_64_v2_tomcat9-admin-webapps.sha256sum] = "f8d94b09229e5caa4676be41daf45bd62afe675724bb6dbc328d6e897871d35f"

URI_x86_64_v2_tomcat9-docs-webapp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-docs-webapp-9.0.117-2.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-docs-webapp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-docs-webapp}"
SRC_URI[x86_64_v2_tomcat9-docs-webapp.sha256sum] = "574ca4a4ffbce6c0ff8bbb73b3de5b4c713fe4e7127539a5acf156a6565e81ae"

URI_x86_64_v2_tomcat9-el-3.0-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-el-3.0-api-9.0.117-2.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-el-3.0-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-el-3.0-api}"
SRC_URI[x86_64_v2_tomcat9-el-3.0-api.sha256sum] = "593e205e2dd7b2513946df39b79413e282b56f0fefb3b743aa3de54b542c9812"

URI_x86_64_v2_tomcat9-jsp-2.3-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-jsp-2.3-api-9.0.117-2.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-jsp-2.3-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-jsp-2.3-api}"
SRC_URI[x86_64_v2_tomcat9-jsp-2.3-api.sha256sum] = "7331e250696a05943807079206fa4a5fb81544c53b12852523f79314b5fc72e7"

URI_x86_64_v2_tomcat9-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-lib-9.0.117-2.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-lib}"
SRC_URI[x86_64_v2_tomcat9-lib.sha256sum] = "1fbe86a98b8323b488789eeb3ea75d7d563991ff0433d83ad3f73310626ab9aa"
RPROVIDES:tomcat9-lib:x86_64_v2 = "virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-juli_ virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

URI_x86_64_v2_tomcat9-servlet-4.0-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-servlet-4.0-api-9.0.117-2.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-servlet-4.0-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-servlet-4.0-api}"
SRC_URI[x86_64_v2_tomcat9-servlet-4.0-api.sha256sum] = "ef3436e208c50dcb76c1695f77d660f02727fb0aad2ba5c79eca2eb21e00e57e"

URI_x86_64_v2_tomcat9-webapps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-webapps-9.0.117-2.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-webapps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-webapps}"
SRC_URI[x86_64_v2_tomcat9-webapps.sha256sum] = "991a9efd6ae179be8da630aae2ae7b5ae2ed0113f9a6f7b2ff43f3b2ef13be0d"

URI_aarch64_tomcat9 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-9.0.117-2.el10.alma.1.noarch.rpm;name=aarch64_tomcat9;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9}"
SRC_URI[aarch64_tomcat9.sha256sum] = "c5a89ee8a7aa29d0b32fce8ea4866e7c5c15eb4bab47fd3289fce754c1f2f429"

URI_aarch64_tomcat9-admin-webapps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-admin-webapps-9.0.117-2.el10.alma.1.noarch.rpm;name=aarch64_tomcat9-admin-webapps;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-admin-webapps}"
SRC_URI[aarch64_tomcat9-admin-webapps.sha256sum] = "f8d94b09229e5caa4676be41daf45bd62afe675724bb6dbc328d6e897871d35f"

URI_aarch64_tomcat9-docs-webapp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-docs-webapp-9.0.117-2.el10.alma.1.noarch.rpm;name=aarch64_tomcat9-docs-webapp;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-docs-webapp}"
SRC_URI[aarch64_tomcat9-docs-webapp.sha256sum] = "574ca4a4ffbce6c0ff8bbb73b3de5b4c713fe4e7127539a5acf156a6565e81ae"

URI_aarch64_tomcat9-el-3.0-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-el-3.0-api-9.0.117-2.el10.alma.1.noarch.rpm;name=aarch64_tomcat9-el-3.0-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-el-3.0-api}"
SRC_URI[aarch64_tomcat9-el-3.0-api.sha256sum] = "593e205e2dd7b2513946df39b79413e282b56f0fefb3b743aa3de54b542c9812"

URI_aarch64_tomcat9-jsp-2.3-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-jsp-2.3-api-9.0.117-2.el10.alma.1.noarch.rpm;name=aarch64_tomcat9-jsp-2.3-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-jsp-2.3-api}"
SRC_URI[aarch64_tomcat9-jsp-2.3-api.sha256sum] = "7331e250696a05943807079206fa4a5fb81544c53b12852523f79314b5fc72e7"

URI_aarch64_tomcat9-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-lib-9.0.117-2.el10.alma.1.noarch.rpm;name=aarch64_tomcat9-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-lib}"
SRC_URI[aarch64_tomcat9-lib.sha256sum] = "1fbe86a98b8323b488789eeb3ea75d7d563991ff0433d83ad3f73310626ab9aa"
RPROVIDES:tomcat9-lib:aarch64 = "virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-juli_ virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

URI_aarch64_tomcat9-servlet-4.0-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-servlet-4.0-api-9.0.117-2.el10.alma.1.noarch.rpm;name=aarch64_tomcat9-servlet-4.0-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-servlet-4.0-api}"
SRC_URI[aarch64_tomcat9-servlet-4.0-api.sha256sum] = "ef3436e208c50dcb76c1695f77d660f02727fb0aad2ba5c79eca2eb21e00e57e"

URI_aarch64_tomcat9-webapps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-webapps-9.0.117-2.el10.alma.1.noarch.rpm;name=aarch64_tomcat9-webapps;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-webapps}"
SRC_URI[aarch64_tomcat9-webapps.sha256sum] = "991a9efd6ae179be8da630aae2ae7b5ae2ed0113f9a6f7b2ff43f3b2ef13be0d"

RDEPENDS:tomcat9 = " \
 bash \
 javapackages-tools \
 shadow-utils \
 systemd \
 tomcat9-lib \
 virtual/java-headless_or_java-25-headless \
 "
RDEPENDS:tomcat9-admin-webapps = " \
 tomcat9 \
 "
RDEPENDS:tomcat9-docs-webapp = " \
 tomcat9 \
 "
RDEPENDS:tomcat9-el-3.0-api = " \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:tomcat9-jsp-2.3-api = " \
 bash \
 javapackages-filesystem \
 tomcat9-el-3.0-api \
 tomcat9-servlet-4.0-api \
 "
RDEPENDS:tomcat9-lib = " \
 ecj \
 javapackages-filesystem \
 tomcat9-el-3.0-api \
 tomcat9-jsp-2.3-api \
 tomcat9-servlet-4.0-api \
 virtual/coreutils \
 "
RDEPENDS:tomcat9-servlet-4.0-api = " \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:tomcat9-webapps = " \
 tomcat9 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina_ rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote_ rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-juli_ rpm/virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

PROVIDES:append:aarch64 = " rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina_ rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote_ rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-juli_ rpm/virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"
