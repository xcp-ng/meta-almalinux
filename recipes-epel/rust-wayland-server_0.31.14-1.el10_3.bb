# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-server"
PV = "0.31.14"
PR = "1.el10_3"
PACKAGES = " \
 rust-wayland-server+default-devel \
 rust-wayland-server+dlopen-devel \
 rust-wayland-server+libwayland_1_22-devel \
 rust-wayland-server+libwayland_1_23-devel \
 rust-wayland-server+log-devel \
 rust-wayland-server+system-devel \
 rust-wayland-server-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-server-0.31.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ca1784d62250ecd05d880c73d0bfa686e5c779ee4f3b8ef79fafdc923aacda6f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+default-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-server+default-devel.sha256sum] = "f8dd6daa0a076e73a6f507714ab419ce9a498460a48a7bcbc497fd170ce5161b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+dlopen-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+dlopen-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-server+dlopen-devel.sha256sum] = "8afaee435e34c2d506f1e6e7a27c059a3245a206b6e1c52674d23bad18178dc7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+libwayland_1_22-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+libwayland_1_22-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-server+libwayland_1_22-devel.sha256sum] = "7b8d7599d7fbcac35bcfe9153a14943cdf3f9d241a900b1628eec1d9c0be3831"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+libwayland_1_23-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+libwayland_1_23-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-server+libwayland_1_23-devel.sha256sum] = "fb6670a8467a823e602f89804f8d2f32dc6985719ad600fa0aa3740ac1947857"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+log-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-server+log-devel.sha256sum] = "4d1e9f3337c4eca3e8c8e9c52af3e0d83eebe7077dd74caafd7b97ffc61422ec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+system-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+system-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-server+system-devel.sha256sum] = "06c0580efacecaad0e6be0e0f110cec24110be58a0a69809a25b4d6c3934fa4e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-server-devel.sha256sum] = "471de3698665ea1e00e87bbeb4162cd11492efaa91b07b864a17a798f242a89a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+default-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-server+default-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-server+default-devel.sha256sum] = "4fc130aef87cce06ad2f0276ba3abc067aafc1f05b400c1417241fae6e9b9ab4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+dlopen-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-server+dlopen-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-server+dlopen-devel.sha256sum] = "fb43d90aba24e8fd9ede290b0fe7959112e673c434d35abb1241779738c4e3dd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+libwayland_1_22-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-server+libwayland_1_22-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-server+libwayland_1_22-devel.sha256sum] = "0c9835d7adaf8e33836fdfa91daafad1af2eec1754871eede6fa8ec852baa724"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+libwayland_1_23-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-server+libwayland_1_23-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-server+libwayland_1_23-devel.sha256sum] = "b52cfbc1769a7d9b882cdf5c723c0eef18858852f05ea1f20edde29089afc610"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+log-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-server+log-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-server+log-devel.sha256sum] = "416ab6568895c99247c87ba39f1a16e08ffa13c40bc387a8a2d092a04cce067f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+system-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-server+system-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-server+system-devel.sha256sum] = "45affb49401366bec532f37980871921afb125042f15770bd0a9a2622ad9c619"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-server-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-server-devel.sha256sum] = "745037eb33763f302c5bbf4056572633052b91238c393e17ed992beef14e7ddc"

RDEPENDS:rust-wayland-server+default-devel = " \
 cargo \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server+dlopen-devel = " \
 cargo \
 rust-wayland-backend+dlopen-devel \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server+libwayland_1_22-devel = " \
 cargo \
 rust-wayland-backend+libwayland_server_1_22-devel \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server+libwayland_1_23-devel = " \
 cargo \
 rust-wayland-backend+libwayland_server_1_23-devel \
 rust-wayland-server+libwayland_1_22-devel \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server+system-devel = " \
 cargo \
 rust-wayland-backend+server_system-devel \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-downcast-rs1+default-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
