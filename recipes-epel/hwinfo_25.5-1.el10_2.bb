# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hwinfo"
PV = "25.5"
PR = "1.el10_2"
PACKAGES = " \
 hwinfo \
 hwinfo-devel \
 hwinfo-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/h/hwinfo-25.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c91f33f76fdf85b458e14318f5e42a3baec6f9a6baa9daada2c71cf619ce28e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hwinfo-25.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hwinfo;unpack=0"
SRC_URI[x86_64_v2_hwinfo.sha256sum] = "09e3973bd59fdceb4dfa39bca33790e78cbcebc590cd2acfc6b9ae435702e20a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hwinfo-devel-25.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hwinfo-devel;unpack=0"
SRC_URI[x86_64_v2_hwinfo-devel.sha256sum] = "fcc43eb77127c2db7fc82c59b95891153f70211cdb51a95fa4e389e728c8a998"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hwinfo-libs-25.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hwinfo-libs;unpack=0"
SRC_URI[x86_64_v2_hwinfo-libs.sha256sum] = "12e65019765677b86178381d9d3c9363859de920c6acbcedb755b0e65687d088"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hwinfo-25.5-1.el10_2.aarch64.rpm;name=aarch64_hwinfo;unpack=0"
SRC_URI[aarch64_hwinfo.sha256sum] = "408b59657012d7c3b313af7a67b7b026ba133b78e688c3f26e4d65118283de27"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hwinfo-devel-25.5-1.el10_2.aarch64.rpm;name=aarch64_hwinfo-devel;unpack=0"
SRC_URI[aarch64_hwinfo-devel.sha256sum] = "b61bd69f98a82453a4c038e98efbed2f378c61bccfedc608ee86c3b4db54f9c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hwinfo-libs-25.5-1.el10_2.aarch64.rpm;name=aarch64_hwinfo-libs;unpack=0"
SRC_URI[aarch64_hwinfo-libs.sha256sum] = "a8b8c7a034d37b08e893056a2189ddd988c59cc775941d410b8a06a6d0f6650f"

RDEPENDS:hwinfo = " \
 bash \
 glibc \
 hwinfo-libs \
 perl-interpreter \
 "
RDEPENDS:hwinfo-devel = " \
 hwinfo-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:hwinfo-libs:x86_64_v2 = " \
 glibc \
 libuuid \
 libx86emu \
"
RDEPENDS:hwinfo-libs:aarch64 = " \
 glibc \
 libuuid \
"
