# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitflags"
PV = "2.13.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-bitflags+arbitrary-devel \
 rust-bitflags+bytemuck-devel \
 rust-bitflags+default-devel \
 rust-bitflags+example_generated-devel \
 rust-bitflags+serde-devel \
 rust-bitflags+serde_core-devel \
 rust-bitflags+std-devel \
 rust-bitflags-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bitflags-2.13.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce2355dc91ba172743a0626620d9d3c22812f8da530944d3701554a07297df77"

URI_x86_64_v2_rust-bitflags+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+arbitrary-devel-2.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-bitflags+arbitrary-devel.sha256sum] = "fc83003c8b81a5a10c3e37741635f95ad789896f48b39434f72f71cafdd1b9af"

URI_x86_64_v2_rust-bitflags+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+bytemuck-devel-2.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-bitflags+bytemuck-devel.sha256sum] = "dcd071a0e0b91de7c086469834c54c9dc782f66b9c2809bc4458b009eff485ad"

URI_x86_64_v2_rust-bitflags+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+default-devel-2.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+default-devel}"
SRC_URI[x86_64_v2_rust-bitflags+default-devel.sha256sum] = "3cf8c0a060e7a1c3314a502d9a0a3d005fb6da041eb63de0923b2194213d841c"

URI_x86_64_v2_rust-bitflags+example_generated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+example_generated-devel-2.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+example_generated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+example_generated-devel}"
SRC_URI[x86_64_v2_rust-bitflags+example_generated-devel.sha256sum] = "077c407eb0992c1ca19ff2c1dfee7bcf61eb6a3f7a670c9751dbc1bcd528894c"

URI_x86_64_v2_rust-bitflags+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+serde-devel-2.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+serde-devel}"
SRC_URI[x86_64_v2_rust-bitflags+serde-devel.sha256sum] = "7b4ca7120c68ff58e891b544559e9401a58d537a681b86506796e43ade00e37f"

URI_x86_64_v2_rust-bitflags+serde_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+serde_core-devel-2.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+serde_core-devel}"
SRC_URI[x86_64_v2_rust-bitflags+serde_core-devel.sha256sum] = "31ef21c9987d0d819ed0e7394dcb13d66f1a79e9f9455da70490dbe585a3fc2a"

URI_x86_64_v2_rust-bitflags+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+std-devel-2.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+std-devel}"
SRC_URI[x86_64_v2_rust-bitflags+std-devel.sha256sum] = "65f12fefdbf3081e7deab93b57fb87d6a53fd04304db44a590a2139d9b7dc45f"

URI_x86_64_v2_rust-bitflags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags-devel-2.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags-devel}"
SRC_URI[x86_64_v2_rust-bitflags-devel.sha256sum] = "ccf1f053bd105e01d6a024413c5b85cf243e8c42fa189b89d4252033c45cce79"

URI_aarch64_rust-bitflags+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+arbitrary-devel-2.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+arbitrary-devel}"
SRC_URI[aarch64_rust-bitflags+arbitrary-devel.sha256sum] = "875acd3b8d61705d35b77fc98e427cebe7c1e4700931b3497c1fc02b639d1fa7"

URI_aarch64_rust-bitflags+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+bytemuck-devel-2.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+bytemuck-devel}"
SRC_URI[aarch64_rust-bitflags+bytemuck-devel.sha256sum] = "b31cb39bfc4511a957cbe2f934579a1c0ee62ed7ca76871614a61705dbc8e0ba"

URI_aarch64_rust-bitflags+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+default-devel-2.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+default-devel}"
SRC_URI[aarch64_rust-bitflags+default-devel.sha256sum] = "b929193498524a46fc8393591096b5150d18dd1bddea5b016a6e5091bb4d3599"

URI_aarch64_rust-bitflags+example_generated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+example_generated-devel-2.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags+example_generated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+example_generated-devel}"
SRC_URI[aarch64_rust-bitflags+example_generated-devel.sha256sum] = "4d511def2283147a15083925ab55491d7559c83961f68baa9e5fd662dc7c633f"

URI_aarch64_rust-bitflags+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+serde-devel-2.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+serde-devel}"
SRC_URI[aarch64_rust-bitflags+serde-devel.sha256sum] = "17f7ba1926aa06f55d0d03d3f0a04b2347333805bc4522c879f3087571555542"

URI_aarch64_rust-bitflags+serde_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+serde_core-devel-2.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags+serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+serde_core-devel}"
SRC_URI[aarch64_rust-bitflags+serde_core-devel.sha256sum] = "cc13c64231c6753cce17e1100d096e5e1b47b9d498b68bc1dddba566a757aa0c"

URI_aarch64_rust-bitflags+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+std-devel-2.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+std-devel}"
SRC_URI[aarch64_rust-bitflags+std-devel.sha256sum] = "3c1c7c22660864264f718f7063bd69782c1a34d2180d9091cc84424b55a92c14"

URI_aarch64_rust-bitflags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags-devel-2.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags-devel}"
SRC_URI[aarch64_rust-bitflags-devel.sha256sum] = "ef6ce9843f1136c75c631aaa6f34f9d9f390dc46a33278c8095b75829aad5dff"

RDEPENDS:rust-bitflags+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+bytemuck-devel = " \
 cargo \
 rust-bitflags-devel \
 rust-bytemuck+default-devel \
 "
RDEPENDS:rust-bitflags+default-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+example_generated-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+serde-devel = " \
 cargo \
 rust-bitflags+serde_core-devel \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+serde_core-devel = " \
 cargo \
 rust-bitflags-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bitflags+std-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags-devel = " \
 cargo \
 rust \
 "
