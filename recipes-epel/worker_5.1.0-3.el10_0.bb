# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "worker"
PV = "5.1.0"
PR = "3.el10_0"
PACKAGES = " \
 worker \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/worker-5.1.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a4e738917a8a70ff5046803e00376b8b251ae3ca3a20188d39c158c107b07806"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/worker-5.1.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_worker;unpack=0"
SRC_URI[x86_64_v2_worker.sha256sum] = "dbb71267f3b8a8ea7e6b80869420f5c537fd19781be546537308b543003867c2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/worker-5.1.0-3.el10_0.aarch64.rpm;name=aarch64_worker;unpack=0"
SRC_URI[aarch64_worker.sha256sum] = "269f37439675c06b9d6ca9e12e3adb04536da947d9ba4e6bbc1867474c71bf6e"

RDEPENDS:worker = " \
 bash \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 python3 \
 "
