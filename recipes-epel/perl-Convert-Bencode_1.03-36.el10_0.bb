# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Convert-Bencode"
PV = "1.03"
PR = "36.el10_0"
PACKAGES = " \
 perl-Convert-Bencode \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Convert-Bencode-1.03-36.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b75429407dc3593320ef223ec3486b6c8be63083f06a12dc45541e1b95015969"

URI_x86_64_v2_perl-Convert-Bencode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Convert-Bencode-1.03-36.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Convert-Bencode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Convert-Bencode}"
SRC_URI[x86_64_v2_perl-Convert-Bencode.sha256sum] = "f0ef4a02f3c7e905a10f69714e0d299bf57dd5aded17b55b6410e598cdcc15c6"

URI_aarch64_perl-Convert-Bencode = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Convert-Bencode-1.03-36.el10_0.noarch.rpm;name=aarch64_perl-Convert-Bencode;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Convert-Bencode}"
SRC_URI[aarch64_perl-Convert-Bencode.sha256sum] = "35e8c28dff985a498834e9cf6abf476d2093e737190a9963af634acc6f88fba3"

RDEPENDS:perl-Convert-Bencode = " \
 perl-Exporter \
 perl-libs \
 "
