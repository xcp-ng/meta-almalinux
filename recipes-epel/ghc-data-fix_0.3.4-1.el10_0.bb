# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-data-fix"
PV = "0.3.4"
PR = "1.el10_0"
PACKAGES = " \
 ghc-data-fix \
 ghc-data-fix-devel \
 ghc-data-fix-doc \
 ghc-data-fix-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-data-fix-0.3.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0af8b5dd1a1e2e3f83bdec11a0f147b57a02814de346a59fa0dce9fd89594e83"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-fix-0.3.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-fix;unpack=0"
SRC_URI[x86_64_v2_ghc-data-fix.sha256sum] = "c24fe128b04799d6666071d9aecebdd2624b0bea202f8ec1c38d89d06610e75d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-fix-devel-0.3.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-fix-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-data-fix-devel.sha256sum] = "4af6cee8a9e968d5aee8cd9c7294b3145aa125ecb50aa7b6d82e8c9ff544bea2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-fix-doc-0.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-data-fix-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-data-fix-doc.sha256sum] = "cbca2bc54e14cd6c7c6fa7d994094a91b62cda899fda01d115fac6f49824344c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-fix-prof-0.3.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-fix-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-data-fix-prof.sha256sum] = "9ddfb475bc664e561a0f6cd10d2df355fab95d635738c72d607fa6cc8f93d28b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-fix-0.3.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-data-fix;unpack=0"
SRC_URI[aarch64_ghc-data-fix.sha256sum] = "c498682c35ffed521b6b5f2c867db0f9f8d2db4092d09e528ddee9d03134116d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-fix-devel-0.3.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-data-fix-devel;unpack=0"
SRC_URI[aarch64_ghc-data-fix-devel.sha256sum] = "d6eb907c232e5ec4dc92b48f49be46bc519f89661a0309f3c576fbe69384060f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-fix-doc-0.3.4-1.el10_0.noarch.rpm;name=aarch64_ghc-data-fix-doc;unpack=0"
SRC_URI[aarch64_ghc-data-fix-doc.sha256sum] = "6c4314bff36c518b964a32b6841eead6863c2c84014bfd98761423a90236993f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-fix-prof-0.3.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-data-fix-prof;unpack=0"
SRC_URI[aarch64_ghc-data-fix-prof.sha256sum] = "8b48cbbaad205af4aebd1128f34342fa947fc2fef171b48f5785510ebe553c57"

RDEPENDS:ghc-data-fix = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-data-fix-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-data-fix \
 ghc-deepseq-devel \
 ghc-hashable-devel \
 "
RDEPENDS:ghc-data-fix-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-data-fix-prof = " \
 ghc-base-prof \
 ghc-data-fix-devel \
 ghc-deepseq-prof \
 ghc-hashable-prof \
 "
