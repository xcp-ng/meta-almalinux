# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zeal"
PV = "0.8.1"
PR = "1.el10_3"
PACKAGES = " \
 zeal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zeal-0.8.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "126263049e68376f01d2f2737807e567db1e9e11f4d3b1e8752eb43c155cd7e0"

URI_x86_64_v2_zeal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zeal-0.8.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zeal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zeal}"
SRC_URI[x86_64_v2_zeal.sha256sum] = "ef5e1de5a27c34792ab8a1d8182eeee9a18a1d4fa90fa79028910ab8ffb7fc5f"

URI_aarch64_zeal = "${EPEL_MIRROR}/aarch64/Packages/z/zeal-0.8.1-1.el10_3.aarch64.rpm;name=aarch64_zeal;unpack=0"
SRC_URI:append = " ${URI_aarch64_zeal}"
SRC_URI[aarch64_zeal.sha256sum] = "dfac3be35017aa3ac5aecd760a9359b14854db49fc5df4cb14bb18f33170b98c"

RDEPENDS:zeal = " \
 glibc \
 hicolor-icon-theme \
 libarchive \
 libgcc \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 sqlite-libs \
 xcb-util-keysyms \
 "
