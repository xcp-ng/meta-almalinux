# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nom"
PV = "7.1.3"
PR = "4.el10_0"
PACKAGES = " \
 rust-nom+alloc-devel \
 rust-nom+default-devel \
 rust-nom+docsrs-devel \
 rust-nom+std-devel \
 rust-nom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nom-7.1.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f0b39f895e9ea95aabcd4f4c4d934547f46bd7de6b77fd7c82cc4dabeaf9baa"

URI_x86_64_v2_rust-nom+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom+alloc-devel-7.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom+alloc-devel}"
SRC_URI[x86_64_v2_rust-nom+alloc-devel.sha256sum] = "01e2f7c8f59da804c7bf9392cbc1d07415103a2b64760cc6bea2918e14874d42"

URI_x86_64_v2_rust-nom+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom+default-devel-7.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom+default-devel}"
SRC_URI[x86_64_v2_rust-nom+default-devel.sha256sum] = "4b13ebe630f96ae8012738b6644ba4764e74d49bcc2a90b715012ef6e755f0eb"

URI_x86_64_v2_rust-nom+docsrs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom+docsrs-devel-7.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom+docsrs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom+docsrs-devel}"
SRC_URI[x86_64_v2_rust-nom+docsrs-devel.sha256sum] = "28405e6d8f80a622fbae90542174ecbc20ac35cb92f0893b6463043075b70b42"

URI_x86_64_v2_rust-nom+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom+std-devel-7.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom+std-devel}"
SRC_URI[x86_64_v2_rust-nom+std-devel.sha256sum] = "e4bc6ae21d0c45f08a3873e673b40ba66cacc939b1fb74fe2a2396ca1cda55e8"

URI_x86_64_v2_rust-nom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom-devel-7.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom-devel}"
SRC_URI[x86_64_v2_rust-nom-devel.sha256sum] = "5b34d9380403b128b3f0a501ea7a670552310d70f893650c60716816259473ad"

URI_aarch64_rust-nom+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom+alloc-devel-7.1.3-4.el10_0.noarch.rpm;name=aarch64_rust-nom+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom+alloc-devel}"
SRC_URI[aarch64_rust-nom+alloc-devel.sha256sum] = "e2672d1cf3289c55953eeead5219c622165febd930fe4acdecd378e9a2e3ac52"

URI_aarch64_rust-nom+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom+default-devel-7.1.3-4.el10_0.noarch.rpm;name=aarch64_rust-nom+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom+default-devel}"
SRC_URI[aarch64_rust-nom+default-devel.sha256sum] = "ae3abcad50bc3ac0ae4aca183173519a523bfb2bea8af11c7069237a004146e9"

URI_aarch64_rust-nom+docsrs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom+docsrs-devel-7.1.3-4.el10_0.noarch.rpm;name=aarch64_rust-nom+docsrs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom+docsrs-devel}"
SRC_URI[aarch64_rust-nom+docsrs-devel.sha256sum] = "c46922911dd19906f08fc4ed658e4a3b65a10a62bdc91aaa63946f8974f7fcf1"

URI_aarch64_rust-nom+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom+std-devel-7.1.3-4.el10_0.noarch.rpm;name=aarch64_rust-nom+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom+std-devel}"
SRC_URI[aarch64_rust-nom+std-devel.sha256sum] = "cfe7b2047c143cb82706b3baeb5c8cbb49c592fba45ad7b31763e2795ee8ab32"

URI_aarch64_rust-nom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom-devel-7.1.3-4.el10_0.noarch.rpm;name=aarch64_rust-nom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom-devel}"
SRC_URI[aarch64_rust-nom-devel.sha256sum] = "16a9cf40e13a4e6e074fa441fe7dac6dd89e441036a03605437b4d170833eea8"

RDEPENDS:rust-nom+alloc-devel = " \
 cargo \
 rust-nom-devel \
 "
RDEPENDS:rust-nom+default-devel = " \
 cargo \
 rust-nom+std-devel \
 rust-nom-devel \
 "
RDEPENDS:rust-nom+docsrs-devel = " \
 cargo \
 rust-nom-devel \
 "
RDEPENDS:rust-nom+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-minimal-lexical+std-devel \
 rust-nom+alloc-devel \
 rust-nom-devel \
 "
RDEPENDS:rust-nom-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 rust-minimal-lexical-devel \
 "
