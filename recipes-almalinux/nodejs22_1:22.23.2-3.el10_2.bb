# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs22"
PE = "1"
PV = "22.23.2"
PR = "3.el10_2"
PACKAGES = " \
 nodejs \
 nodejs-devel \
 nodejs-docs \
 nodejs-full-i18n \
 nodejs-libs \
 nodejs-npm \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs22-22.23.2-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aaf00ff9afd79a51b8d057ccd88213f7eb542c40faadfd8bf218e6befd5f17f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-22.23.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs;unpack=0"
SRC_URI[x86_64_v2_nodejs.sha256sum] = "ac9639fb89a48e7ca30794ae9d9fc066a5153fc2ff3882041f37e9c7e6502a03"
RPROVIDES:nodejs:append:x86_64_v2 = " virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-devel-22.23.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs-devel;unpack=0"
SRC_URI[x86_64_v2_nodejs-devel.sha256sum] = "db7643c55b69e5fcbe5f14fcd955b8324280bf0e09f5bf39a6e94e1fbab23211"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-docs-22.23.2-3.el10_2.noarch.rpm;name=x86_64_v2_nodejs-docs;unpack=0"
SRC_URI[x86_64_v2_nodejs-docs.sha256sum] = "214fba9be3d9a6ef94f9450d61364b06af4c6aa7e8bf11fcc46229596bed6a07"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-full-i18n-22.23.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs-full-i18n;unpack=0"
SRC_URI[x86_64_v2_nodejs-full-i18n.sha256sum] = "3fa6db40a2b2ee20aee9a10b39221b78a9cd37ccb2c1412bc5983db29477acf0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-libs-22.23.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs-libs;unpack=0"
SRC_URI[x86_64_v2_nodejs-libs.sha256sum] = "da6552a177bf598b1eebca4b6995179f4d2907daf9a1c1a5709e8cb67f345b53"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-npm-10.9.8-1.22.23.2.3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs-npm;unpack=0"
SRC_URI[x86_64_v2_nodejs-npm.sha256sum] = "671efe4fba14fe0f5ec8e9553b35f17e2e1eecaa12f07f9d0f060c997125f86c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-22.23.2-3.el10_2.aarch64.rpm;name=aarch64_nodejs;unpack=0"
SRC_URI[aarch64_nodejs.sha256sum] = "1a4a7fa6ebfdb25f7d1dd8009c2fbb4ac7c16ccf1de5e69196e5ac46c040645f"
RPROVIDES:nodejs:append:aarch64 = " virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-devel-22.23.2-3.el10_2.aarch64.rpm;name=aarch64_nodejs-devel;unpack=0"
SRC_URI[aarch64_nodejs-devel.sha256sum] = "266364e849d0a46457610c31bcfa6d2f58e54685c4aabadb2bce626741204bac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-docs-22.23.2-3.el10_2.noarch.rpm;name=aarch64_nodejs-docs;unpack=0"
SRC_URI[aarch64_nodejs-docs.sha256sum] = "214fba9be3d9a6ef94f9450d61364b06af4c6aa7e8bf11fcc46229596bed6a07"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-full-i18n-22.23.2-3.el10_2.aarch64.rpm;name=aarch64_nodejs-full-i18n;unpack=0"
SRC_URI[aarch64_nodejs-full-i18n.sha256sum] = "33b5700e9b2260fda63f209e45dedd469610a5709291f2412a3ccf2c2744d508"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-libs-22.23.2-3.el10_2.aarch64.rpm;name=aarch64_nodejs-libs;unpack=0"
SRC_URI[aarch64_nodejs-libs.sha256sum] = "e0eee12c4bb3baa58dadc5207f45d95ce0f14e9c8cd61e3dc4dd9752299e3021"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-npm-10.9.8-1.22.23.2.3.el10_2.aarch64.rpm;name=aarch64_nodejs-npm;unpack=0"
SRC_URI[aarch64_nodejs-npm.sha256sum] = "54068d320825bfd3177544be30d1d66b264141da7a840bce81be71b3c3988d8b"

RDEPENDS:nodejs = " \
 ca-certificates \
 glibc \
 libuv \
 nodejs-libs \
 openssl \
 "
RDEPENDS:nodejs-devel = " \
 bash \
 brotli-devel \
 libuv-devel \
 nodejs \
 nodejs-libs \
 nodejs-packaging \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:nodejs-docs = " \
 nodejs \
 "
RDEPENDS:nodejs-full-i18n = " \
 nodejs \
 "
RDEPENDS:nodejs-libs = " \
 c-ares \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 libuv \
 openssl-libs \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:nodejs-npm = " \
 bash \
 nodejs \
 "
