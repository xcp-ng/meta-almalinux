# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Config-Perl-V"
PV = "0.36"
PR = "512.el10"
PACKAGES = " \
 perl-Config-Perl-V \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Config-Perl-V-0.36-512.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ffc14fc6240ecfc893776f91e9855b8a047d2cf7bb26794d9a35ff66ff1f5779"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Config-Perl-V-0.36-512.el10.noarch.rpm;name=x86_64_v2_perl-Config-Perl-V;unpack=0"
SRC_URI[x86_64_v2_perl-Config-Perl-V.sha256sum] = "762b3771c54f9523b873f07e5b034be70f92a09c9db386a99ed8212aae9c608e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Config-Perl-V-0.36-512.el10.noarch.rpm;name=aarch64_perl-Config-Perl-V;unpack=0"
SRC_URI[aarch64_perl-Config-Perl-V.sha256sum] = "762b3771c54f9523b873f07e5b034be70f92a09c9db386a99ed8212aae9c608e"

RDEPENDS:perl-Config-Perl-V = " \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
