# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pathable"
PV = "0.4.4"
PR = "5.el10_2"
PACKAGES = " \
 python3-pathable \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pathable-0.4.4-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26160aa2f82ae4cf6a17fd4902d1c088b014662dd24c116031b61fecb4716be7"

URI_x86_64_v2_python3-pathable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pathable-0.4.4-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pathable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pathable}"
SRC_URI[x86_64_v2_python3-pathable.sha256sum] = "c0b6f2cede8c4db4ac659a87f313f1255891507417e6b0fc11aa4261e6fe39df"

URI_aarch64_python3-pathable = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pathable-0.4.4-5.el10_2.noarch.rpm;name=aarch64_python3-pathable;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pathable}"
SRC_URI[aarch64_python3-pathable.sha256sum] = "569de3bfc7492253860f039658f3397d869716d91e53d99e8a4c9707e2ac0837"

RDEPENDS:python3-pathable = " \
 python3 \
 "
