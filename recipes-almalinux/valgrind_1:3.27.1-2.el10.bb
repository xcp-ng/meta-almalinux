# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "valgrind"
PE = "1"
PV = "3.27.1"
PR = "2.el10"
PACKAGES = " \
 valgrind \
 valgrind-devel \
 valgrind-docs \
 valgrind-gdb \
 valgrind-scripts \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/valgrind-3.27.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "699417a7ad3932f4fe3dd8c0277516601fef4079e98d8b0d5883a8dc59014073"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-3.27.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind;unpack=0"
SRC_URI[x86_64_v2_valgrind.sha256sum] = "f22ac0c3b75dc85ed28891e6de9df87f0d4faabce03285b35fde8f60175de61d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-devel-3.27.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-devel;unpack=0"
SRC_URI[x86_64_v2_valgrind-devel.sha256sum] = "1a799de315dc03e0eb6216015d33d6e07e648470875a0451c393c157afafb751"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-docs-3.27.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-docs;unpack=0"
SRC_URI[x86_64_v2_valgrind-docs.sha256sum] = "6cded7e560f9f11a08b40ac3033709ccc60eb261ebf37efc49841e2baf4e622b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-gdb-3.27.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-gdb;unpack=0"
SRC_URI[x86_64_v2_valgrind-gdb.sha256sum] = "72902c10dcbe5e9070a3f50965a62f51558f27363e235394bad5fd2b25b73e64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-scripts-3.27.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-scripts;unpack=0"
SRC_URI[x86_64_v2_valgrind-scripts.sha256sum] = "5b143c4492dd043242a726e88704c0997de9693d45f8f41d7d6cc26978583778"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-3.27.1-2.el10.aarch64.rpm;name=aarch64_valgrind;unpack=0"
SRC_URI[aarch64_valgrind.sha256sum] = "e9ca391f967e899d8fbab16239e1b85a6290eb8bbedd932acf7c9ad543151952"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-devel-3.27.1-2.el10.aarch64.rpm;name=aarch64_valgrind-devel;unpack=0"
SRC_URI[aarch64_valgrind-devel.sha256sum] = "9578a0867f1a9f64bcb05ba283840801b55eeda0157f4a250c1e378ae7a8e763"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-docs-3.27.1-2.el10.aarch64.rpm;name=aarch64_valgrind-docs;unpack=0"
SRC_URI[aarch64_valgrind-docs.sha256sum] = "3604673bb8fab3f0051241e329916c740b52e801cfcc0b59088b815dbc1b1a51"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-gdb-3.27.1-2.el10.aarch64.rpm;name=aarch64_valgrind-gdb;unpack=0"
SRC_URI[aarch64_valgrind-gdb.sha256sum] = "258c109a3f3249e598cfe0ad703a57f0b353e926b30cd3621d7dd64316e73d42"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-scripts-3.27.1-2.el10.aarch64.rpm;name=aarch64_valgrind-scripts;unpack=0"
SRC_URI[aarch64_valgrind-scripts.sha256sum] = "d3318b69916e3daa8adc1fcc174a75c648ca1c56623e48e275f48c158f296bcb"

RDEPENDS:valgrind = " \
 glibc \
 "
RDEPENDS:valgrind-devel = " \
 pkgconf-pkg-config \
 "
RDEPENDS:valgrind-docs = " \
 "
RDEPENDS:valgrind-gdb = " \
 bash \
 glibc \
 libgcc \
 valgrind \
 "
RDEPENDS:valgrind-scripts = " \
 perl-interpreter \
 python3 \
 "
