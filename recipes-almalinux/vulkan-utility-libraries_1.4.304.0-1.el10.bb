# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-utility-libraries"
PV = "1.4.304.0"
PR = "1.el10"
PACKAGES = " \
 vulkan-utility-libraries-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/vulkan-utility-libraries-1.4.304.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01ee72f5b42a9953835b3443fd1199265078f1a0ab2fbb205139ac7c06eba42e"

URI_x86_64_v2_vulkan-utility-libraries-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/vulkan-utility-libraries-devel-1.4.304.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-utility-libraries-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-utility-libraries-devel}"
SRC_URI[x86_64_v2_vulkan-utility-libraries-devel.sha256sum] = "9e257957c3b4d3b9fd80417c6e2aed29b7758ffbbeb326b3644ca88146adab8b"

URI_aarch64_vulkan-utility-libraries-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/vulkan-utility-libraries-devel-1.4.304.0-1.el10.aarch64.rpm;name=aarch64_vulkan-utility-libraries-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-utility-libraries-devel}"
SRC_URI[aarch64_vulkan-utility-libraries-devel.sha256sum] = "74be7999df36fe0d7e921768f47b1f97dec9b1f99c80a0f6a84ad4417452de7b"

RDEPENDS:vulkan-utility-libraries-devel = " \
 cmake-filesystem \
 vulkan-headers \
 "
