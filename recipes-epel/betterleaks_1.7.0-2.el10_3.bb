# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "betterleaks"
PV = "1.7.0"
PR = "2.el10_3"
PACKAGES = " \
 betterleaks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/betterleaks-1.7.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddef1f720bd1944443e360fa1d234a37c246d5c22c09482f4699b7a2ae7ff356"

URI_x86_64_v2_betterleaks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/betterleaks-1.7.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_betterleaks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_betterleaks}"
SRC_URI[x86_64_v2_betterleaks.sha256sum] = "0a22f51106428f5c79bcb1be9789ea4ceb743f9dba447c64f4f816bcd7dbb9a4"

URI_aarch64_betterleaks = "${EPEL_MIRROR}/aarch64/Packages/b/betterleaks-1.7.0-2.el10_3.aarch64.rpm;name=aarch64_betterleaks;unpack=0"
SRC_URI:append = " ${URI_aarch64_betterleaks}"
SRC_URI[aarch64_betterleaks.sha256sum] = "aaf6ce07af28603fb8d857da1a4b149d1305abb337c3f8bc3ce0cfed1e7edde6"

RDEPENDS:betterleaks = " \
 git-core \
 glibc \
 "
