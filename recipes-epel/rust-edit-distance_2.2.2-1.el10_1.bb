# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-edit-distance"
PV = "2.2.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-edit-distance+default-devel \
 rust-edit-distance-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-edit-distance-2.2.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e05306f7e707d27c300dc082fe173f9a079c1d5dde31532bf8cc49024affa468"

URI_x86_64_v2_rust-edit-distance+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-edit-distance+default-devel-2.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-edit-distance+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-edit-distance+default-devel}"
SRC_URI[x86_64_v2_rust-edit-distance+default-devel.sha256sum] = "a805cd22b5e80d4a52adb8d07f94a2d9d629875f73766a069bfa2a169064755e"

URI_x86_64_v2_rust-edit-distance-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-edit-distance-devel-2.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-edit-distance-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-edit-distance-devel}"
SRC_URI[x86_64_v2_rust-edit-distance-devel.sha256sum] = "62a8246bfc1fab2f22508d31cb131eed766fa53ccbf29e2a26410a5139b57586"

URI_aarch64_rust-edit-distance+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-edit-distance+default-devel-2.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-edit-distance+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-edit-distance+default-devel}"
SRC_URI[aarch64_rust-edit-distance+default-devel.sha256sum] = "b9db85ee273b812f92afcf2c780c7b3f474a83c66fa3383851ad54443a89241c"

URI_aarch64_rust-edit-distance-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-edit-distance-devel-2.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-edit-distance-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-edit-distance-devel}"
SRC_URI[aarch64_rust-edit-distance-devel.sha256sum] = "af3d5afa26c6717b32c0e593df5557e8c4c7921148ef32d2bb39e2df65549219"

RDEPENDS:rust-edit-distance+default-devel = " \
 cargo \
 rust-edit-distance-devel \
 "
RDEPENDS:rust-edit-distance-devel = " \
 cargo \
 rust \
 "
