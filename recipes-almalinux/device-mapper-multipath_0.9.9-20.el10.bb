# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "device-mapper-multipath"
PV = "0.9.9"
PR = "20.el10"
PACKAGES = " \
 device-mapper-multipath \
 device-mapper-multipath-devel \
 device-mapper-multipath-libs \
 kpartx \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/device-mapper-multipath-0.9.9-20.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9ee699153761087e3978c01f67d9caf0af1b885e19295f75ab7129bcc1912ac6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-multipath-0.9.9-20.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath;unpack=0"
SRC_URI[x86_64_v2_device-mapper-multipath.sha256sum] = "e8a925d881030027acbf26af39e7463f42a01d039b4ee861b66b70cc373d4749"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/device-mapper-multipath-devel-0.9.9-20.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath-devel;unpack=0"
SRC_URI[x86_64_v2_device-mapper-multipath-devel.sha256sum] = "5e8668f4e6a9276a986a759f3cefca5cbf2b622bcba1f7d6d2c26b9305d53ba8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-multipath-libs-0.9.9-20.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath-libs;unpack=0"
SRC_URI[x86_64_v2_device-mapper-multipath-libs.sha256sum] = "90b7596ec84024307fcde84b7262665fab9c10dd8811bcfab6d30c274f005584"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kpartx-0.9.9-20.el10.x86_64_v2.rpm;name=x86_64_v2_kpartx;unpack=0"
SRC_URI[x86_64_v2_kpartx.sha256sum] = "83ecbbbe49ccdad9e79e287bdb0cfd22944cc5b980551dc8a12c0c28e1d53955"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-multipath-0.9.9-20.el10.aarch64.rpm;name=aarch64_device-mapper-multipath;unpack=0"
SRC_URI[aarch64_device-mapper-multipath.sha256sum] = "5693862aeb12740c7b23807394811f67fe5bf6d772726ac17127dbfae233e433"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/device-mapper-multipath-devel-0.9.9-20.el10.aarch64.rpm;name=aarch64_device-mapper-multipath-devel;unpack=0"
SRC_URI[aarch64_device-mapper-multipath-devel.sha256sum] = "29db3477ab2e9844f9bc62b440f8c8792120b50ec7752d1d60b03ea0bb4aa901"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-multipath-libs-0.9.9-20.el10.aarch64.rpm;name=aarch64_device-mapper-multipath-libs;unpack=0"
SRC_URI[aarch64_device-mapper-multipath-libs.sha256sum] = "514a943dd6a71c7fd8ad869bf8758680d12889aad73fdca4d089184b0d0ca921"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kpartx-0.9.9-20.el10.aarch64.rpm;name=aarch64_kpartx;unpack=0"
SRC_URI[aarch64_kpartx.sha256sum] = "adf8c236f5184bb43b56ac7c8f6af1fcf25fb4b5e3859898d6a299a5f80df124"

RDEPENDS:device-mapper-multipath = " \
 bash \
 device-mapper \
 device-mapper-libs \
 device-mapper-multipath-libs \
 glibc \
 kpartx \
 libgcc \
 libmount \
 readline \
 systemd \
 systemd-libs \
 userspace-rcu \
 "
RDEPENDS:device-mapper-multipath-devel = " \
 device-mapper-multipath \
 device-mapper-multipath-libs \
 "
RDEPENDS:device-mapper-multipath-libs = " \
 device-mapper-libs \
 glibc \
 libaio \
 libgcc \
 libmount \
 systemd-libs \
 userspace-rcu \
 "
RDEPENDS:kpartx = " \
 bash \
 device-mapper-libs \
 glibc \
 "
