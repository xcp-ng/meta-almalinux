# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Business-ISMN"
PV = "1.205"
PR = "3.el10_3"
PACKAGES = " \
 perl-Business-ISMN \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Business-ISMN-1.205-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "57e259b39f85e5a9788a4ada39f9806bbb364c98c80fa5bc691039ff7d63b152"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Business-ISMN-1.205-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Business-ISMN;unpack=0"
SRC_URI[x86_64_v2_perl-Business-ISMN.sha256sum] = "b8bd6ef72eb5f0a74e00dee2b291bfdfac783aec61e3c80c4b7eaab749d0e2b2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Business-ISMN-1.205-3.el10_3.noarch.rpm;name=aarch64_perl-Business-ISMN;unpack=0"
SRC_URI[aarch64_perl-Business-ISMN.sha256sum] = "d2a88be9bf0aa3f6b7c764990a7fc20e8584dc40c3d9b234d4c8aad3f0e352d8"

RDEPENDS:perl-Business-ISMN = " \
 perl-Business-ISMN \
 perl-Carp \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-Tie-Cycle \
 perl-libs \
 perl-subs \
 perl-vars \
 "
