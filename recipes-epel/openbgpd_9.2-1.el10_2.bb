# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openbgpd"
PV = "9.2"
PR = "1.el10_2"
PACKAGES = " \
 openbgpd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openbgpd-9.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "381b080b77c21b00fd55f8b25e33a1a9459a1d2be5c755a4029b1a7d6bfa19f9"

URI_x86_64_v2_openbgpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbgpd-9.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbgpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openbgpd}"
SRC_URI[x86_64_v2_openbgpd.sha256sum] = "d895aa3079a4598f47650abb28bca76e258abcbcc07807272750e162bd92a2aa"

URI_aarch64_openbgpd = "${EPEL_MIRROR}/aarch64/Packages/o/openbgpd-9.2-1.el10_2.aarch64.rpm;name=aarch64_openbgpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_openbgpd}"
SRC_URI[aarch64_openbgpd.sha256sum] = "9b3e55ac47ed1039d84d72d9fa3b9e364b13a58db21b05e911a206b16f3e5dc7"

RDEPENDS:openbgpd = " \
 bash \
 glibc \
 libmnl \
 shadow-utils \
 systemd \
 "
