# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-appender"
PV = "0.2.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-tracing-appender+default-devel \
 rust-tracing-appender+parking_lot-devel \
 rust-tracing-appender-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-appender-0.2.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1d81f8e631e7cd59f47b0371cf5c002ad1dacba1d2c1fc5b6bdd93b46dd115b"

URI_x86_64_v2_rust-tracing-appender+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-appender+default-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-appender+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-appender+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-appender+default-devel.sha256sum] = "3d7907face5672e8c0f1dc13774949ea1ba90c18080d3badef1a9d71266dca04"

URI_x86_64_v2_rust-tracing-appender+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-appender+parking_lot-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-appender+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-appender+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-tracing-appender+parking_lot-devel.sha256sum] = "373c3ebe9e8e6684785c6d6eb136805df0c8f03680020521849c8c181507a5b8"

URI_x86_64_v2_rust-tracing-appender-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-appender-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-appender-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-appender-devel}"
SRC_URI[x86_64_v2_rust-tracing-appender-devel.sha256sum] = "7e1f8422ce2b9707f87b597be71fe136716ed6bbd04a3e75b7b1078e9571e2be"

URI_aarch64_rust-tracing-appender+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-appender+default-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-appender+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-appender+default-devel}"
SRC_URI[aarch64_rust-tracing-appender+default-devel.sha256sum] = "0a5da9977fca100e226d978a1df4bd908f352003a0881cdd866e895219998b36"

URI_aarch64_rust-tracing-appender+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-appender+parking_lot-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-appender+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-appender+parking_lot-devel}"
SRC_URI[aarch64_rust-tracing-appender+parking_lot-devel.sha256sum] = "e02b3b044e2107457ff3454bbcad05d9ff3ada8b4e786aba6fe94984e382c4fe"

URI_aarch64_rust-tracing-appender-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-appender-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-appender-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-appender-devel}"
SRC_URI[aarch64_rust-tracing-appender-devel.sha256sum] = "8b890007fe77eac9f521be1691dd283129928291607b09ecad8ce1db1b5b6c37"

RDEPENDS:rust-tracing-appender+default-devel = " \
 cargo \
 rust-tracing-appender-devel \
 "
RDEPENDS:rust-tracing-appender+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-tracing-appender-devel \
 "
RDEPENDS:rust-tracing-appender-devel = " \
 cargo \
 rust \
 rust-crossbeam-channel+default-devel \
 rust-thiserror+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber-devel \
 "
