# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14"
PV = "3.14.5"
PR = "1.el10_2.1"
PACKAGES = " \
 python3.14 \
 python3.14-debug \
 python3.14-devel \
 python3.14-freethreading \
 python3.14-freethreading-debug \
 python3.14-freethreading-devel \
 python3.14-freethreading-idle \
 python3.14-freethreading-libs \
 python3.14-freethreading-test \
 python3.14-freethreading-tkinter \
 python3.14-idle \
 python3.14-libs \
 python3.14-test \
 python3.14-tkinter \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-3.14.5-1.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e8b4b3b94361872a857972ff8e019b9218aeddb8cc939dd42386ab1107226f1"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3.14-freethreading-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)
# - python3.14-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - python3.14-freethreading-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)
# - python3.14-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)

URI_x86_64_v2_python3.14 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-3.14.5-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3.14;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14}"
SRC_URI[x86_64_v2_python3.14.sha256sum] = "03e493c9eff5a45c6ae9336101f91df59fc4df5a7aa4ed8d64552bdc1a2464a7"

URI_x86_64_v2_python3.14-debug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-debug-3.14.5-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3.14-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-debug}"
SRC_URI[x86_64_v2_python3.14-debug.sha256sum] = "d7ffdbbd09148d4db803ddb43fdb93a75a8b56ad077b2792215d1b2829c6bebf"

URI_x86_64_v2_python3.14-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-devel-3.14.5-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3.14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-devel}"
SRC_URI[x86_64_v2_python3.14-devel.sha256sum] = "0e641d8847270e0e79c852c705e529badf283fd3e7a795468bd996b40ea3a7b5"

URI_x86_64_v2_python3.14-freethreading = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-3.14.5-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-freethreading}"
SRC_URI[x86_64_v2_python3.14-freethreading.sha256sum] = "09ea278580b65eb799a05ba47e27f3547df0710612aa48e46550ea76ce7527c6"

URI_x86_64_v2_python3.14-freethreading-debug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-debug-3.14.5-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-freethreading-debug}"
SRC_URI[x86_64_v2_python3.14-freethreading-debug.sha256sum] = "00178f7d4c5cedd1e9989a6f36d57742500760ff99f37dc197eb329026cd5495"

URI_x86_64_v2_python3.14-freethreading-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-devel-3.14.5-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-freethreading-devel}"
SRC_URI[x86_64_v2_python3.14-freethreading-devel.sha256sum] = "5a3a0cac47c4ba958ab90b5adb58e572725f93aeae55650120862c088f03b562"

URI_x86_64_v2_python3.14-freethreading-idle = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-idle-3.14.5-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-idle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-freethreading-idle}"
SRC_URI[x86_64_v2_python3.14-freethreading-idle.sha256sum] = "b643775b809063ec120a38088b1a1c741f88b921214ebf89ff7f84141d29d584"

URI_x86_64_v2_python3.14-freethreading-libs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-libs-3.14.5-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-freethreading-libs}"
SRC_URI[x86_64_v2_python3.14-freethreading-libs.sha256sum] = "9343578e52665d364a162d792377ef933a1a9c4882de0568dcea0ffb2097b0ca"

URI_x86_64_v2_python3.14-freethreading-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-test-3.14.5-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-freethreading-test}"
SRC_URI[x86_64_v2_python3.14-freethreading-test.sha256sum] = "431172b3feac32a158a44d3cc14b0df0fa8852089da422dfff5c52a895002c2c"

URI_x86_64_v2_python3.14-freethreading-tkinter = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-tkinter-3.14.5-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-tkinter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-freethreading-tkinter}"
SRC_URI[x86_64_v2_python3.14-freethreading-tkinter.sha256sum] = "4e7fb85a9845c234d1313c665b016ba0e7b9e4c31eda3a6b7aaa31a96a37ed24"

URI_x86_64_v2_python3.14-idle = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-idle-3.14.5-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3.14-idle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-idle}"
SRC_URI[x86_64_v2_python3.14-idle.sha256sum] = "e6eabd607052e27fcea19c63b7123171ebaa3f2488b6a55c153dfd446f012dd9"

URI_x86_64_v2_python3.14-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-libs-3.14.5-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3.14-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-libs}"
SRC_URI[x86_64_v2_python3.14-libs.sha256sum] = "eb97b7254d358fc5ad83da9e62df20a3b35fcc3d6378a8ec44c1d840677e782b"

URI_x86_64_v2_python3.14-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-test-3.14.5-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3.14-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-test}"
SRC_URI[x86_64_v2_python3.14-test.sha256sum] = "581d8059bafbe709319803176328831066c46f3efca6d75783faa99f3534a8e4"

URI_x86_64_v2_python3.14-tkinter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-tkinter-3.14.5-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3.14-tkinter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-tkinter}"
SRC_URI[x86_64_v2_python3.14-tkinter.sha256sum] = "c8dfe8822fb76a11d968e0a636c69fa4bd43ca9bf6f1ea3e46aad50deb2c24e0"

URI_aarch64_python3.14 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-3.14.5-1.el10_2.1.aarch64.rpm;name=aarch64_python3.14;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14}"
SRC_URI[aarch64_python3.14.sha256sum] = "a2dfc6af87223b86473cc8d883b49c1ae8da28531f41320bfc6fad0d23b73dd9"

URI_aarch64_python3.14-debug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-debug-3.14.5-1.el10_2.1.aarch64.rpm;name=aarch64_python3.14-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-debug}"
SRC_URI[aarch64_python3.14-debug.sha256sum] = "02544715a81a13c002789dc0b233894b3fe2abfc56968e8bfb3750d80719f0a2"

URI_aarch64_python3.14-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-devel-3.14.5-1.el10_2.1.aarch64.rpm;name=aarch64_python3.14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-devel}"
SRC_URI[aarch64_python3.14-devel.sha256sum] = "356bcf92e59f6b9669f9ea80211b42473af5f02a7515298a3e52e70aae7369fc"

URI_aarch64_python3.14-freethreading = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-3.14.5-1.el10_2.1.aarch64.rpm;name=aarch64_python3.14-freethreading;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-freethreading}"
SRC_URI[aarch64_python3.14-freethreading.sha256sum] = "b32d1abc205da6ad13ad29e2806d69ba93ac4d038a713cd556e6e33b80f91aec"

URI_aarch64_python3.14-freethreading-debug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-debug-3.14.5-1.el10_2.1.aarch64.rpm;name=aarch64_python3.14-freethreading-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-freethreading-debug}"
SRC_URI[aarch64_python3.14-freethreading-debug.sha256sum] = "79313f1ce3f94bdb4005b5f9a45d4e5df0c5b73ec1266a81ed0b1419111e14bf"

URI_aarch64_python3.14-freethreading-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-devel-3.14.5-1.el10_2.1.aarch64.rpm;name=aarch64_python3.14-freethreading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-freethreading-devel}"
SRC_URI[aarch64_python3.14-freethreading-devel.sha256sum] = "8f03fc42e155e514af0839bfdb60d45d44485b11f71073850c338824699a141c"

URI_aarch64_python3.14-freethreading-idle = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-idle-3.14.5-1.el10_2.1.aarch64.rpm;name=aarch64_python3.14-freethreading-idle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-freethreading-idle}"
SRC_URI[aarch64_python3.14-freethreading-idle.sha256sum] = "6dd41ccef4e85d99c4d2f4aa392f974b651e5990b74fb0f564e0908e9c2c8857"

URI_aarch64_python3.14-freethreading-libs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-libs-3.14.5-1.el10_2.1.aarch64.rpm;name=aarch64_python3.14-freethreading-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-freethreading-libs}"
SRC_URI[aarch64_python3.14-freethreading-libs.sha256sum] = "07c76f98287110c4a4124fa4d75dfc8d3271098b1b606b77272664a9096c4a8e"

URI_aarch64_python3.14-freethreading-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-test-3.14.5-1.el10_2.1.aarch64.rpm;name=aarch64_python3.14-freethreading-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-freethreading-test}"
SRC_URI[aarch64_python3.14-freethreading-test.sha256sum] = "6d0e5ee0442ac3d68561d2fe73ab6a9fcacf928bda6898a2460e548327d8eda6"

URI_aarch64_python3.14-freethreading-tkinter = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-tkinter-3.14.5-1.el10_2.1.aarch64.rpm;name=aarch64_python3.14-freethreading-tkinter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-freethreading-tkinter}"
SRC_URI[aarch64_python3.14-freethreading-tkinter.sha256sum] = "25583081d9a72227dd8b7336d0dfd971d61dbd3abbc12bf2fadc77fb89d11c6e"

URI_aarch64_python3.14-idle = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-idle-3.14.5-1.el10_2.1.aarch64.rpm;name=aarch64_python3.14-idle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-idle}"
SRC_URI[aarch64_python3.14-idle.sha256sum] = "8d2030f69a028c37b6ccd09f457f028b724ccc878bc485a5454314822352e0c1"

URI_aarch64_python3.14-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-libs-3.14.5-1.el10_2.1.aarch64.rpm;name=aarch64_python3.14-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-libs}"
SRC_URI[aarch64_python3.14-libs.sha256sum] = "55fffe0ad60f99841571efdf7051c66ada40381804ec5df54404b70e0291eeae"

URI_aarch64_python3.14-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-test-3.14.5-1.el10_2.1.aarch64.rpm;name=aarch64_python3.14-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-test}"
SRC_URI[aarch64_python3.14-test.sha256sum] = "3919eace31c1f9e934698e094ad206b439ced045aa98c12dcfa85c614dc22dc1"

URI_aarch64_python3.14-tkinter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-tkinter-3.14.5-1.el10_2.1.aarch64.rpm;name=aarch64_python3.14-tkinter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-tkinter}"
SRC_URI[aarch64_python3.14-tkinter.sha256sum] = "56b32b1df280839a48cef729e85f469809b55bb08eddc08ddcb0d322ff717be5"

RDEPENDS:python3.14 = " \
 glibc \
 python3.14-libs \
 "
RDEPENDS:python3.14-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.14 \
 python3.14-devel \
 python3.14-idle \
 python3.14-libs \
 python3.14-test \
 python3.14-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-devel = " \
 bash \
 pkgconf-pkg-config \
 python-rpm-macros \
 python3-rpm-generators \
 python3-rpm-macros \
 python3.14 \
 python3.14-libs \
 "
RDEPENDS:python3.14-freethreading = " \
 glibc \
 python3.14-freethreading-libs \
 "
RDEPENDS:python3.14-freethreading-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.14-freethreading \
 python3.14-freethreading-devel \
 python3.14-freethreading-idle \
 python3.14-freethreading-libs \
 python3.14-freethreading-test \
 python3.14-freethreading-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-freethreading-devel = " \
 bash \
 pkgconf-pkg-config \
 python3.14-freethreading \
 python3.14-freethreading-libs \
 "
RDEPENDS:python3.14-freethreading-idle = " \
 python3.14-freethreading \
 python3.14-freethreading-tkinter \
 "
RDEPENDS:python3.14-freethreading-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3.14-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-freethreading-test = " \
 bash \
 glibc \
 libgcc \
 python3.14-freethreading \
 python3.14-freethreading-libs \
 python3.14-setuptools-wheel \
 "
RDEPENDS:python3.14-freethreading-tkinter = " \
 glibc \
 python3.14-freethreading \
 tcl \
 tk \
 "
RDEPENDS:python3.14-idle = " \
 python3.14 \
 python3.14-tkinter \
 "
RDEPENDS:python3.14-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3.14-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-test = " \
 bash \
 glibc \
 libgcc \
 python3.14 \
 python3.14-libs \
 python3.14-setuptools-wheel \
 "
RDEPENDS:python3.14-tkinter = " \
 glibc \
 python3.14 \
 tcl \
 tk \
 "
