# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "calendarsupport"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 calendarsupport \
 calendarsupport-devel \
 calendarsupport-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/calendarsupport-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6f53fc2df80e1839590591a4b7a39b0ee5ea8f008627570391369fcac7c5d7c"

URI_x86_64_v2_calendarsupport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calendarsupport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calendarsupport}"
SRC_URI[x86_64_v2_calendarsupport.sha256sum] = "1accc73703b9816b7b9670c25027a603259938ff67adf47ceb850fc86baa4f9e"

URI_x86_64_v2_calendarsupport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calendarsupport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calendarsupport-devel}"
SRC_URI[x86_64_v2_calendarsupport-devel.sha256sum] = "efa475090d15b25ba95a0839cfdadcf98157bd1299708f481af6e7d6836e7d8b"

URI_x86_64_v2_calendarsupport-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_calendarsupport-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calendarsupport-doc}"
SRC_URI[x86_64_v2_calendarsupport-doc.sha256sum] = "e8f67bade1fee64cd808251a99b19606f7a4056726fbd205898a574ea3549a60"

URI_aarch64_calendarsupport = "${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_calendarsupport;unpack=0"
SRC_URI:append = " ${URI_aarch64_calendarsupport}"
SRC_URI[aarch64_calendarsupport.sha256sum] = "d8617b57156f7147acbe0568c00c4c82b1390e26f432f3f8bba65494ce612e0d"

URI_aarch64_calendarsupport-devel = "${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_calendarsupport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_calendarsupport-devel}"
SRC_URI[aarch64_calendarsupport-devel.sha256sum] = "cbaa32e71636ff40ebc3c2030b7c6e0b546264d81a3a78ae605394d94dd01101"

URI_aarch64_calendarsupport-doc = "${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_calendarsupport-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_calendarsupport-doc}"
SRC_URI[aarch64_calendarsupport-doc.sha256sum] = "c135e4a26134492037bd2988677f9ba1a60e8ebf93107e38669ea3cc8d3ec766"

RDEPENDS:calendarsupport = " \
 akonadi-calendar \
 akonadi-server \
 glibc \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:calendarsupport-devel = " \
 akonadi-calendar-devel \
 calendarsupport \
 cmake-filesystem \
 kidentitymanagement-devel \
 kmime-devel \
 "
RDEPENDS:calendarsupport-doc = " \
 "
