# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "neochat"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 neochat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/neochat-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd7f78b13d49f257afd4045860e37c0a44be8da0eb0ea0bef1d0b3faf188fe9f"

URI_x86_64_v2_neochat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/neochat-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_neochat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_neochat}"
SRC_URI[x86_64_v2_neochat.sha256sum] = "2701b8971f9ce856d0c8452cecdb6fbc7a39d6831184716e10d6ff2ba4483317"

URI_aarch64_neochat = "${EPEL_MIRROR}/aarch64/Packages/n/neochat-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_neochat;unpack=0"
SRC_URI:append = " ${URI_aarch64_neochat}"
SRC_URI[aarch64_neochat.sha256sum] = "740cd68d883461e52f339377ba75d41f03cfbbe17aaaf6c323609544834565d5"

RDEPENDS:neochat = " \
 breeze-icon-theme \
 cmark-lib \
 glibc \
 hicolor-icon-theme \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kquickcharts \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kf6-prison \
 kf6-purpose \
 kf6-qqc2-desktop-style \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kquickimageeditor-qt6 \
 kunifiedpush \
 libicu \
 libquotient-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qt6-qtspeech \
 qt6-qtwebview \
 qtkeychain-qt6 \
 "
