# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-html5ever"
PV = "0.39.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-html5ever+default-devel \
 rust-html5ever+serde-devel \
 rust-html5ever+trace_tokenizer-devel \
 rust-html5ever-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-html5ever-0.39.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de8f74df820fa5b422911da0372caa7f8e50988298134f38871544369ad906bd"

URI_x86_64_v2_rust-html5ever+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever+default-devel-0.39.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever+default-devel}"
SRC_URI[x86_64_v2_rust-html5ever+default-devel.sha256sum] = "f898ea1f21d41c487d15e4f23bba73ddbf322c1789a0e551831519bd2cb37709"

URI_x86_64_v2_rust-html5ever+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever+serde-devel-0.39.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever+serde-devel}"
SRC_URI[x86_64_v2_rust-html5ever+serde-devel.sha256sum] = "aec3d0f8bddc1316993a3bbafadb19d3f13a2386f9f0a930556e2af882fc4301"

URI_x86_64_v2_rust-html5ever+trace_tokenizer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever+trace_tokenizer-devel-0.39.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever+trace_tokenizer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever+trace_tokenizer-devel}"
SRC_URI[x86_64_v2_rust-html5ever+trace_tokenizer-devel.sha256sum] = "9a16981b55a354206e5397d03275a5938ba3fa0caedc6206a561fae2399571d6"

URI_x86_64_v2_rust-html5ever-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever-devel-0.39.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever-devel}"
SRC_URI[x86_64_v2_rust-html5ever-devel.sha256sum] = "a65caa3621503a3171af70221eaf7592b1b4539f35291ed8f8165bd323e4be26"

URI_aarch64_rust-html5ever+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever+default-devel-0.39.0-1.el10_3.noarch.rpm;name=aarch64_rust-html5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever+default-devel}"
SRC_URI[aarch64_rust-html5ever+default-devel.sha256sum] = "4a71c152479724ad04ba65e20392a6d8ee15e8732ef7f818c426b1a54d3e8e60"

URI_aarch64_rust-html5ever+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever+serde-devel-0.39.0-1.el10_3.noarch.rpm;name=aarch64_rust-html5ever+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever+serde-devel}"
SRC_URI[aarch64_rust-html5ever+serde-devel.sha256sum] = "f54de8982d9bcedc2197dbf43365e35e7100399d26c90b2bcf6aa32109d6e60d"

URI_aarch64_rust-html5ever+trace_tokenizer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever+trace_tokenizer-devel-0.39.0-1.el10_3.noarch.rpm;name=aarch64_rust-html5ever+trace_tokenizer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever+trace_tokenizer-devel}"
SRC_URI[aarch64_rust-html5ever+trace_tokenizer-devel.sha256sum] = "b9750da06e10084fcf5ab99415d41975b32cb00d4296625c5117dac7c76545b2"

URI_aarch64_rust-html5ever-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever-devel-0.39.0-1.el10_3.noarch.rpm;name=aarch64_rust-html5ever-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever-devel}"
SRC_URI[aarch64_rust-html5ever-devel.sha256sum] = "c361011273ab8b959ccba342f1b457520776391697a4208149727fb363a9cb9a"

RDEPENDS:rust-html5ever+default-devel = " \
 cargo \
 rust-html5ever-devel \
 "
RDEPENDS:rust-html5ever+serde-devel = " \
 cargo \
 rust-html5ever-devel \
 rust-markup5ever+serde-devel \
 "
RDEPENDS:rust-html5ever+trace_tokenizer-devel = " \
 cargo \
 rust-html5ever-devel \
 "
RDEPENDS:rust-html5ever-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-markup5ever+default-devel \
 "
