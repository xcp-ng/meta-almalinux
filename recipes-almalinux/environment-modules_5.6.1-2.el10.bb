# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "environment-modules"
PV = "5.6.1"
PR = "2.el10"
PACKAGES = " \
 environment-modules \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/environment-modules-5.6.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ff780a1743aa0273f288795c1a57a5c0e5799f358b9bac5e52c0350063d85347"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/environment-modules-5.6.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_environment-modules;unpack=0"
SRC_URI[x86_64_v2_environment-modules.sha256sum] = "049b2369409aace692efa32bbd8c209e3b9f1205ce3b05342be30f3fc3bf3e55"
RPROVIDES:environment-modules:append:x86_64_v2 = " virtual/environment_modules_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/environment-modules-5.6.1-2.el10.aarch64.rpm;name=aarch64_environment-modules;unpack=0"
SRC_URI[aarch64_environment-modules.sha256sum] = "0d9bbfcc459d81d1301ae9e97da0d4329123c4e102c59be03f15845b0c8a5c22"
RPROVIDES:environment-modules:append:aarch64 = " virtual/environment_modules_"

RDEPENDS:environment-modules = " \
 alternatives \
 bash \
 emacs-filesystem \
 glibc \
 less \
 man-db \
 procps-ng \
 sed \
 tcl \
 util-linux-core \
 vim-filesystem \
 virtual/coreutils \
 "
