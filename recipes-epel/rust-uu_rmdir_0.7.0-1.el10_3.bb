# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_rmdir"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_rmdir+default-devel \
 rust-uu_rmdir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_rmdir-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3380ed26d1ba03efb1e6ae3a9ba4dc2f849053451b21ae4a2389e448b5469340"

URI_x86_64_v2_rust-uu_rmdir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_rmdir+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_rmdir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_rmdir+default-devel}"
SRC_URI[x86_64_v2_rust-uu_rmdir+default-devel.sha256sum] = "7241ac366c39d081024fc7576e23ffc10dd6c8197926feaa10b43d0a15b9afcc"

URI_x86_64_v2_rust-uu_rmdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_rmdir-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_rmdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_rmdir-devel}"
SRC_URI[x86_64_v2_rust-uu_rmdir-devel.sha256sum] = "4af57105f33d8f695538fa512c8a99df5ee572da125bd6f97f68fe6fba6dc4f4"

URI_aarch64_rust-uu_rmdir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_rmdir+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_rmdir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_rmdir+default-devel}"
SRC_URI[aarch64_rust-uu_rmdir+default-devel.sha256sum] = "7e50d0e6be69fb9b2d88f7ba00b344ab42cbf27430d063b8467bfe9537cf9e9c"

URI_aarch64_rust-uu_rmdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_rmdir-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_rmdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_rmdir-devel}"
SRC_URI[aarch64_rust-uu_rmdir-devel.sha256sum] = "94afe4301375c1e13e18e2575d54433b2920e50f4c9722a99057953c77b3b8cb"

RDEPENDS:rust-uu_rmdir+default-devel = " \
 cargo \
 rust-uu_rmdir-devel \
 "
RDEPENDS:rust-uu_rmdir-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-libc+default-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 "
