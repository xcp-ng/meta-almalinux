# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-owning_ref"
PV = "0.4.1"
PR = "12.el10_0"
PACKAGES = " \
 rust-owning_ref+default-devel \
 rust-owning_ref-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-owning_ref-0.4.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c617022f50bb2413688af1650ea73e7785e8d1797fd75ac0405703709b70c824"

URI_x86_64_v2_rust-owning_ref+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owning_ref+default-devel-0.4.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owning_ref+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owning_ref+default-devel}"
SRC_URI[x86_64_v2_rust-owning_ref+default-devel.sha256sum] = "a548d04f9b20cb3dbeb61674c0c6e9cf7c7458332936831105173bf9ccf9d396"

URI_x86_64_v2_rust-owning_ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owning_ref-devel-0.4.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owning_ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owning_ref-devel}"
SRC_URI[x86_64_v2_rust-owning_ref-devel.sha256sum] = "7679f536bbf2e2f9f444121ec55e7bcb6bfbbc26f75fd185e60f7c7025c0608b"

URI_aarch64_rust-owning_ref+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owning_ref+default-devel-0.4.1-12.el10_0.noarch.rpm;name=aarch64_rust-owning_ref+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owning_ref+default-devel}"
SRC_URI[aarch64_rust-owning_ref+default-devel.sha256sum] = "85d6a74f6f1f405f269cd3df9f1ff1a92132b185e67e2427844904716fbb4090"

URI_aarch64_rust-owning_ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owning_ref-devel-0.4.1-12.el10_0.noarch.rpm;name=aarch64_rust-owning_ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owning_ref-devel}"
SRC_URI[aarch64_rust-owning_ref-devel.sha256sum] = "78811b9ed2da6a1826eef978365b345c023f8dc9458c1a1c57de0c0242feffb1"

RDEPENDS:rust-owning_ref+default-devel = " \
 cargo \
 rust-owning_ref-devel \
 "
RDEPENDS:rust-owning_ref-devel = " \
 cargo \
 rust-stable_deref_trait+default-devel \
 "
