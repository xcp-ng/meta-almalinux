# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-gitrev"
PV = "1.3.1"
PR = "32.el10_0"
PACKAGES = " \
 ghc-gitrev \
 ghc-gitrev-devel \
 ghc-gitrev-doc \
 ghc-gitrev-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-gitrev-1.3.1-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78c105209bb54b48072b9485bda2ef61739968dd6aabaa5ee59f6b3769823a2e"

URI_x86_64_v2_ghc-gitrev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gitrev-1.3.1-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gitrev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gitrev}"
SRC_URI[x86_64_v2_ghc-gitrev.sha256sum] = "4ff290a3fca3d4916b35e90be2375de834e07977d1f4891b069c6adbe23faf4e"

URI_x86_64_v2_ghc-gitrev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gitrev-devel-1.3.1-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gitrev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gitrev-devel}"
SRC_URI[x86_64_v2_ghc-gitrev-devel.sha256sum] = "600a18a047ef05687ebf8d1420cb927b101a5f458205c22cb789e56e34a271cc"

URI_x86_64_v2_ghc-gitrev-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gitrev-doc-1.3.1-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-gitrev-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gitrev-doc}"
SRC_URI[x86_64_v2_ghc-gitrev-doc.sha256sum] = "8fbf6ffaa0c2f925e6001f6526303281a38d3ed950c619135b9ac18622c401bf"

URI_x86_64_v2_ghc-gitrev-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gitrev-prof-1.3.1-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gitrev-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gitrev-prof}"
SRC_URI[x86_64_v2_ghc-gitrev-prof.sha256sum] = "49fd360706a9f87ea0b8c24f283b2deed64ba7a6be3f96007723a83bc58218c8"

URI_aarch64_ghc-gitrev = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gitrev-1.3.1-32.el10_0.aarch64.rpm;name=aarch64_ghc-gitrev;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gitrev}"
SRC_URI[aarch64_ghc-gitrev.sha256sum] = "5c7163143a1e388424662756c5f0cb9388fb25fe1b94653fb3816885b7fae1de"

URI_aarch64_ghc-gitrev-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gitrev-devel-1.3.1-32.el10_0.aarch64.rpm;name=aarch64_ghc-gitrev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gitrev-devel}"
SRC_URI[aarch64_ghc-gitrev-devel.sha256sum] = "8cc08fbfc257c172e5b6da332881b44f7ca70d3d7c9eb9b55c97fc155fd2bc8c"

URI_aarch64_ghc-gitrev-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gitrev-doc-1.3.1-32.el10_0.noarch.rpm;name=aarch64_ghc-gitrev-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gitrev-doc}"
SRC_URI[aarch64_ghc-gitrev-doc.sha256sum] = "79dfaec590238661b824f3135c8bffbffd5c2416f5a2ef34cd5d81c05593f220"

URI_aarch64_ghc-gitrev-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gitrev-prof-1.3.1-32.el10_0.aarch64.rpm;name=aarch64_ghc-gitrev-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gitrev-prof}"
SRC_URI[aarch64_ghc-gitrev-prof.sha256sum] = "bb3aaa46e5b31d9d75b5bffb3962a5ff9c013fd55ceff65d6636d93c41cca69a"

RDEPENDS:ghc-gitrev = " \
 ghc-array \
 ghc-base \
 ghc-base-compat \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-gitrev-devel = " \
 ghc-base-compat-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-gitrev \
 ghc-process-devel \
 ghc-template-haskell-devel \
 "
RDEPENDS:ghc-gitrev-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-gitrev-prof = " \
 ghc-base-compat-prof \
 ghc-base-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-gitrev-devel \
 ghc-process-prof \
 ghc-template-haskell-prof \
 "
