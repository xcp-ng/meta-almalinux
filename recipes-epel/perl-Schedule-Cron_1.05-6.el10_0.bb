# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Schedule-Cron"
PV = "1.05"
PR = "6.el10_0"
PACKAGES = " \
 perl-Schedule-Cron \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Schedule-Cron-1.05-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6e40e417a09bb921213f8706ff1699a326164a584f43845fa66a493a4a45234"

URI_x86_64_v2_perl-Schedule-Cron = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Schedule-Cron-1.05-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Schedule-Cron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Schedule-Cron}"
SRC_URI[x86_64_v2_perl-Schedule-Cron.sha256sum] = "0199754d11178600a2bb61ee353bab42d31d04aa3cf249760026c571c0346d96"

URI_aarch64_perl-Schedule-Cron = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Schedule-Cron-1.05-6.el10_0.noarch.rpm;name=aarch64_perl-Schedule-Cron;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Schedule-Cron}"
SRC_URI[aarch64_perl-Schedule-Cron.sha256sum] = "dff1efb8c7e83f2636fe1fa77883306fea14d41a1d7d3a46505cba4a3324c3f4"

RDEPENDS:perl-Schedule-Cron = " \
 perl-Data-Dumper \
 perl-POSIX \
 perl-Term-ReadLine \
 perl-Time-ParseDate \
 perl-libs \
 perl-subs \
 perl-vars \
 "
