# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "magma"
PV = "2.9.0"
PR = "9.el10_2"
PACKAGES:x86_64_v2 = " \
 magma \
 magma-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/m/magma-2.9.0-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8a7bb63e01b818e84f0069945308a91ef83e826d56d67591069480d5bd1f706"

URI_x86_64_v2_magma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/magma-2.9.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_magma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_magma}"
SRC_URI[x86_64_v2_magma.sha256sum] = "70875066475055911bd17ffec84b29b140ac16f83bc73eadeaa769765a389d8b"

URI_x86_64_v2_magma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/magma-devel-2.9.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_magma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_magma-devel}"
SRC_URI[x86_64_v2_magma-devel.sha256sum] = "3334e6e1fa26ac656b0d1af6c38eb7cc3901f7a957e471bc96e0b8812b08882e"

RDEPENDS:magma = " \
 flexiblas-netlib \
 glibc \
 hipblas \
 hipsparse \
 libgcc \
 libstdc++ \
 rocm-hip \
 "
RDEPENDS:magma-devel = " \
 magma \
 pkgconf-pkg-config \
 "
