# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsodium"
PV = "1.0.21"
PR = "3.el10_1"
PACKAGES = " \
 libsodium \
 libsodium-devel \
 libsodium-static \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libsodium-1.0.21-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1f01d87532b199e6de7ff77fe7481e46699b0f22e055736d45024065bfaaa4e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsodium-1.0.21-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsodium;unpack=0"
SRC_URI[x86_64_v2_libsodium.sha256sum] = "df934a0d20bc21013ae79908f1efd4579bd70bdef4717589a038d23f24f81d41"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsodium-devel-1.0.21-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsodium-devel;unpack=0"
SRC_URI[x86_64_v2_libsodium-devel.sha256sum] = "444e1bd51637d8fc2413e0c60afe7364454c528029d436a5fe48be339b300370"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsodium-static-1.0.21-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsodium-static;unpack=0"
SRC_URI[x86_64_v2_libsodium-static.sha256sum] = "ed8e65eff1d601d33826263465300f5f0aa79c742822f4c9ed5188b415bafb05"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libsodium-1.0.21-3.el10_1.aarch64.rpm;name=aarch64_libsodium;unpack=0"
SRC_URI[aarch64_libsodium.sha256sum] = "d2f17e1623affabdd1e574534259579060394fa6ae1f7620b72457193b3b1dd7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libsodium-devel-1.0.21-3.el10_1.aarch64.rpm;name=aarch64_libsodium-devel;unpack=0"
SRC_URI[aarch64_libsodium-devel.sha256sum] = "f9ca2fe551c732c474c94dcb1e8277bd2baf9049ba673089b960d844c955f38e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libsodium-static-1.0.21-3.el10_1.aarch64.rpm;name=aarch64_libsodium-static;unpack=0"
SRC_URI[aarch64_libsodium-static.sha256sum] = "2bc0571456d1bb470db1d62e1b7994489b605f0e0f7510dc3bddcfc2d4f8877e"

RDEPENDS:libsodium = " \
 glibc \
 "
RDEPENDS:libsodium-devel = " \
 libsodium \
 pkgconf-pkg-config \
 "
RDEPENDS:libsodium-static = " \
 libsodium-devel \
 "
