# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-paste"
PV = "1.0.15"
PR = "2.el10_0"
PACKAGES = " \
 rust-paste+default-devel \
 rust-paste-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-paste-1.0.15-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "55bb372112459cc5c013ee8f9343f593bc84819c63b7afb2dcc6f7ad745917cc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-paste+default-devel-1.0.15-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-paste+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-paste+default-devel.sha256sum] = "611082416f08d9ae550c844eba9fde4b2c943f1086759692acdbf64dbc7b1942"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-paste-devel-1.0.15-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-paste-devel;unpack=0"
SRC_URI[x86_64_v2_rust-paste-devel.sha256sum] = "d0ad1420258381e08513b7c850de1f9c16c0f819da0888d892bf9386eba9dd97"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-paste+default-devel-1.0.15-2.el10_0.noarch.rpm;name=aarch64_rust-paste+default-devel;unpack=0"
SRC_URI[aarch64_rust-paste+default-devel.sha256sum] = "5a4982f646c53b78be356bf0b5713330be46e5b00454b8e8c0d2a82e5eabed1b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-paste-devel-1.0.15-2.el10_0.noarch.rpm;name=aarch64_rust-paste-devel;unpack=0"
SRC_URI[aarch64_rust-paste-devel.sha256sum] = "44394505303ce6bb2c93d493ba6b30bdadcaa72fe9f29ae3d62ed41f08ea0c12"

RDEPENDS:rust-paste+default-devel = " \
 cargo \
 rust-paste-devel \
 "
RDEPENDS:rust-paste-devel = " \
 cargo \
 rust \
 "
