# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "txt2man"
PV = "1.7.1"
PR = "12.el10_3"
PACKAGES = " \
 txt2man \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/txt2man-1.7.1-12.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "146bf99934b1b066a15d7bf21e80651ea1a90399dbaefc6f6e6ba222b8f68f2e"

URI_x86_64_v2_txt2man = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/txt2man-1.7.1-12.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_txt2man;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_txt2man}"
SRC_URI[x86_64_v2_txt2man.sha256sum] = "90df3a4a00ed556ef333fa9727a6b1013534986f4b9e46fb32f7c02710ae6c92"

URI_aarch64_txt2man = "${EPEL_MIRROR}/aarch64/Packages/t/txt2man-1.7.1-12.el10_3.noarch.rpm;name=aarch64_txt2man;unpack=0"
SRC_URI:append = " ${URI_aarch64_txt2man}"
SRC_URI[aarch64_txt2man.sha256sum] = "15941256cc7a9679741c9c15009ce529ba708f700afabf248ea37702c601d58c"

RDEPENDS:txt2man = " \
 bash \
 gawk \
 "
