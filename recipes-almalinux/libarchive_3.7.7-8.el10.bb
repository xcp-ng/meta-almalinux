# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libarchive"
PV = "3.7.7"
PR = "8.el10"
PACKAGES = " \
 bsdtar \
 libarchive \
 libarchive-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libarchive-3.7.7-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "992f9d2288c799d5fb3772fcbb168ae986e494efb6f4d7819ed3ec050c5b24cc"

URI_x86_64_v2_bsdtar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bsdtar-3.7.7-8.el10.x86_64_v2.rpm;name=x86_64_v2_bsdtar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bsdtar}"
SRC_URI[x86_64_v2_bsdtar.sha256sum] = "fee2600d9beaf9d006d41fa694c058ce3f3ef7e9e805ff82696d526c408ed130"

URI_x86_64_v2_libarchive = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libarchive-3.7.7-8.el10.x86_64_v2.rpm;name=x86_64_v2_libarchive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarchive}"
SRC_URI[x86_64_v2_libarchive.sha256sum] = "7e85c37d9b21e81aeb0c8450a1510fe291540e61519207acbd14176a03ad1178"

URI_x86_64_v2_libarchive-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libarchive-devel-3.7.7-8.el10.x86_64_v2.rpm;name=x86_64_v2_libarchive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarchive-devel}"
SRC_URI[x86_64_v2_libarchive-devel.sha256sum] = "025fe8511737da9a388c1b7ef87f563fbd5bdc7a3e96a910b1d14a441b81676f"

URI_aarch64_bsdtar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bsdtar-3.7.7-8.el10.aarch64.rpm;name=aarch64_bsdtar;unpack=0"
SRC_URI:append = " ${URI_aarch64_bsdtar}"
SRC_URI[aarch64_bsdtar.sha256sum] = "56c6ed465d45e1722ece5e3c9ee93331faa9f6141a170d228dd10c87e3cd1c0d"

URI_aarch64_libarchive = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libarchive-3.7.7-8.el10.aarch64.rpm;name=aarch64_libarchive;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarchive}"
SRC_URI[aarch64_libarchive.sha256sum] = "012d1f9f82af982e7da4b7723b866256af777f6c093145e56d18329804227dc8"

URI_aarch64_libarchive-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libarchive-devel-3.7.7-8.el10.aarch64.rpm;name=aarch64_libarchive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarchive-devel}"
SRC_URI[aarch64_libarchive-devel.sha256sum] = "b29c916044ac241f8f0e6e2835c24cf970b6d740ce80d4f5b80f76933470f023"

RDEPENDS:bsdtar = " \
 glibc \
 libarchive \
 "
RDEPENDS:libarchive = " \
 bzip2-libs \
 glibc \
 libacl \
 libxml2 \
 libzstd \
 lz4-libs \
 openssl-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libarchive-devel = " \
 libarchive \
 openssl-devel \
 pkgconf-pkg-config \
 "
