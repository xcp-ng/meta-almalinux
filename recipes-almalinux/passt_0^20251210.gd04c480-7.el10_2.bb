# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "passt"
PV = "0^20251210.gd04c480"
PR = "7.el10_2"
PACKAGES = " \
 passt \
 passt-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/passt-0^20251210.gd04c480-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "98aa6df6f0eaf274c43144e5a379257e61658bc611a58d34f67f0712b1523812"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/passt-0^20251210.gd04c480-7.el10_2.x86_64_v2.rpm;name=x86_64_v2_passt;unpack=0"
SRC_URI[x86_64_v2_passt.sha256sum] = "7d025379b2badd06c512681bfc4f359eeea22623f7ca84ac4ce17f29e559259b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/passt-selinux-0^20251210.gd04c480-7.el10_2.noarch.rpm;name=x86_64_v2_passt-selinux;unpack=0"
SRC_URI[x86_64_v2_passt-selinux.sha256sum] = "c6c7771aa779cd498cf983dea88c9b2739f443a7b201732ea481da7f131ea166"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/passt-0^20251210.gd04c480-7.el10_2.aarch64.rpm;name=aarch64_passt;unpack=0"
SRC_URI[aarch64_passt.sha256sum] = "4410964ec12d34f82bcb615d0dca398b1cb8de3c78135ed3ef0d0ba1b7f72613"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/passt-selinux-0^20251210.gd04c480-7.el10_2.noarch.rpm;name=aarch64_passt-selinux;unpack=0"
SRC_URI[aarch64_passt-selinux.sha256sum] = "c6c7771aa779cd498cf983dea88c9b2739f443a7b201732ea481da7f131ea166"

RDEPENDS:passt = " \
 glibc \
 passt-selinux \
 "
RDEPENDS:passt-selinux = " \
 bash \
 container-selinux \
 libselinux-utils \
 policycoreutils \
 selinux-policy-targeted \
 "
