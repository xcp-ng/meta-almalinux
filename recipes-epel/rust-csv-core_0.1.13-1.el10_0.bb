# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-csv-core"
PV = "0.1.13"
PR = "1.el10_0"
PACKAGES = " \
 rust-csv-core+default-devel \
 rust-csv-core+libc-devel \
 rust-csv-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-csv-core-0.1.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "871007c10b83aa8090ad62481d8f36b5ecad6caca692afe3d1374578a3f66f16"

URI_x86_64_v2_rust-csv-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv-core+default-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv-core+default-devel}"
SRC_URI[x86_64_v2_rust-csv-core+default-devel.sha256sum] = "e9c24cbcb9ea32ffa7dbf6c859349e666bae1c8395f42ffe861ad8a23a73f2b4"

URI_x86_64_v2_rust-csv-core+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv-core+libc-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv-core+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv-core+libc-devel}"
SRC_URI[x86_64_v2_rust-csv-core+libc-devel.sha256sum] = "604a3710c30b7424ee4816172174a012262b99555836d467736899835dd4c044"

URI_x86_64_v2_rust-csv-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv-core-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv-core-devel}"
SRC_URI[x86_64_v2_rust-csv-core-devel.sha256sum] = "4028f2693a23e788fb95cad1a5fea67edcd4a2d86a479e03851f00e68b5ccfff"

URI_aarch64_rust-csv-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv-core+default-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-csv-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv-core+default-devel}"
SRC_URI[aarch64_rust-csv-core+default-devel.sha256sum] = "b20906d98f6bb290334df2cfb848b51ef73d56437f9df8ec951a825e1903a4da"

URI_aarch64_rust-csv-core+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv-core+libc-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-csv-core+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv-core+libc-devel}"
SRC_URI[aarch64_rust-csv-core+libc-devel.sha256sum] = "6ae861fdd90d531ea340767c1bb1a94465754475badd4de4ab87eaa824664df4"

URI_aarch64_rust-csv-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv-core-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-csv-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv-core-devel}"
SRC_URI[aarch64_rust-csv-core-devel.sha256sum] = "4e9331bd048635aa4676591f253dbe8e7ce125dcfd7dc7208b674ad2a9cb5464"

RDEPENDS:rust-csv-core+default-devel = " \
 cargo \
 rust-csv-core-devel \
 "
RDEPENDS:rust-csv-core+libc-devel = " \
 cargo \
 rust-csv-core-devel \
 rust-memchr+libc-devel \
 "
RDEPENDS:rust-csv-core-devel = " \
 cargo \
 rust-memchr-devel \
 "
