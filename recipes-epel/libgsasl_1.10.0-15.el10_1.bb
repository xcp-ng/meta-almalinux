# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgsasl"
PV = "1.10.0"
PR = "15.el10_1"
PACKAGES = " \
 libgsasl \
 libgsasl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgsasl-1.10.0-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "816ff91c5ff03204dd027a57cfebec1e6d6d4fced1751d520317f9e9c15753ba"

URI_x86_64_v2_libgsasl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgsasl-1.10.0-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgsasl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgsasl}"
SRC_URI[x86_64_v2_libgsasl.sha256sum] = "2929a946445885245f8c89d55e42300829943aae98613fa2c4351c53c1fa3f27"

URI_x86_64_v2_libgsasl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgsasl-devel-1.10.0-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgsasl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgsasl-devel}"
SRC_URI[x86_64_v2_libgsasl-devel.sha256sum] = "624aa62e7340720f0b25f00e6fd363444bf9e77f768e1e4282e8011fd037df63"

URI_aarch64_libgsasl = "${EPEL_MIRROR}/aarch64/Packages/l/libgsasl-1.10.0-15.el10_1.aarch64.rpm;name=aarch64_libgsasl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgsasl}"
SRC_URI[aarch64_libgsasl.sha256sum] = "7eea454dd897ad0f45fa590678452aaff2838bfc00436484447e56afa2908fb5"

URI_aarch64_libgsasl-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgsasl-devel-1.10.0-15.el10_1.aarch64.rpm;name=aarch64_libgsasl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgsasl-devel}"
SRC_URI[aarch64_libgsasl-devel.sha256sum] = "8f83d7fc541bb4f70f66c92ae9ee898095eecae77789bda127d953007ee79320"

RDEPENDS:libgsasl = " \
 glibc \
 krb5-libs \
 libcom_err \
 libidn \
 libntlm \
 "
RDEPENDS:libgsasl-devel = " \
 libgsasl \
 pkgconf-pkg-config \
 "
