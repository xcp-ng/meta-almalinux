# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "WALinuxAgent"
PV = "2.14.0.1"
PR = "3.el10"
PACKAGES = " \
 WALinuxAgent \
 WALinuxAgent-udev \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/WALinuxAgent-2.14.0.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b218190827c92409fbc218627b227dfb7102e535e1859ffd57d0b38bf1147a7c"

URI_x86_64_v2_WALinuxAgent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/WALinuxAgent-2.14.0.1-3.el10.noarch.rpm;name=x86_64_v2_WALinuxAgent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_WALinuxAgent}"
SRC_URI[x86_64_v2_WALinuxAgent.sha256sum] = "91710a319fa61a1b5d90601e01c77682c74226d61d4e1f619d94d2a2b17fb98a"

URI_x86_64_v2_WALinuxAgent-udev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/WALinuxAgent-udev-2.14.0.1-3.el10.noarch.rpm;name=x86_64_v2_WALinuxAgent-udev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_WALinuxAgent-udev}"
SRC_URI[x86_64_v2_WALinuxAgent-udev.sha256sum] = "139bfed16626b7d4f88ba83430adfce4cbac86bc58e7149edbb7cc595baf9d51"

URI_aarch64_WALinuxAgent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/WALinuxAgent-2.14.0.1-3.el10.noarch.rpm;name=aarch64_WALinuxAgent;unpack=0"
SRC_URI:append = " ${URI_aarch64_WALinuxAgent}"
SRC_URI[aarch64_WALinuxAgent.sha256sum] = "91710a319fa61a1b5d90601e01c77682c74226d61d4e1f619d94d2a2b17fb98a"

URI_aarch64_WALinuxAgent-udev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/WALinuxAgent-udev-2.14.0.1-3.el10.noarch.rpm;name=aarch64_WALinuxAgent-udev;unpack=0"
SRC_URI:append = " ${URI_aarch64_WALinuxAgent-udev}"
SRC_URI[aarch64_WALinuxAgent-udev.sha256sum] = "139bfed16626b7d4f88ba83430adfce4cbac86bc58e7149edbb7cc595baf9d51"

RDEPENDS:WALinuxAgent = " \
 WALinuxAgent-udev \
 azure-vm-utils \
 bash \
 iptables-nft \
 openssh \
 openssh-server \
 openssl \
 parted \
 python3 \
 python3-distro \
 python3-pyasn1 \
 systemd \
 "
RDEPENDS:WALinuxAgent-udev = " \
 bash \
 "
