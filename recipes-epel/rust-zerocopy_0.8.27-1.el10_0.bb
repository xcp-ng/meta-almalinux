# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerocopy"
PV = "0.8.27"
PR = "1.el10_0"
PACKAGES = " \
 rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel \
 rust-zerocopy+alloc-devel \
 rust-zerocopy+default-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+float-nightly-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy+simd-nightly-devel \
 rust-zerocopy+std-devel \
 rust-zerocopy+zerocopy-derive-devel \
 rust-zerocopy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerocopy-0.8.27-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4514937f12d062d7e70a0ff5e68c496f1481023eab5e733d29ddf6c40df7624b"

URI_x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel-0.8.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel.sha256sum] = "1c433dc7d639db8f9a92f597e633810c860a3de4b938f1ab4d6a92d1102db628"

URI_x86_64_v2_rust-zerocopy+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+alloc-devel-0.8.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+alloc-devel.sha256sum] = "aedf3b0075843910b3e4c500c7c6c5129311a26eddaf956cc72b95185d3b3904"

URI_x86_64_v2_rust-zerocopy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+default-devel-0.8.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+default-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+default-devel.sha256sum] = "fbb04553a9b7f61032ee980f75f3cf68c32fecfd7ac08fd232158e5ac0cdc3de"

URI_x86_64_v2_rust-zerocopy+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+derive-devel-0.8.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+derive-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+derive-devel.sha256sum] = "ca40e78d218c071032992f0ea56d27d0cbb8ffb78b30948b53e20d87486c4a11"

URI_x86_64_v2_rust-zerocopy+float-nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+float-nightly-devel-0.8.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+float-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+float-nightly-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+float-nightly-devel.sha256sum] = "17c99f0ade944763a7110e8914df5d103a6884752332d277ddf59d23eae36778"

URI_x86_64_v2_rust-zerocopy+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+simd-devel-0.8.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+simd-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+simd-devel.sha256sum] = "09d0e60815f6011a7366e51dc1d9fbdfcc80aee6cb6143f8e28dab7e7bc64041"

URI_x86_64_v2_rust-zerocopy+simd-nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+simd-nightly-devel-0.8.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+simd-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+simd-nightly-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+simd-nightly-devel.sha256sum] = "cbb0ff3b5bfd5790e4a9a37415d1c1c8b210241aa23dc37295d6dc75bb528960"

URI_x86_64_v2_rust-zerocopy+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+std-devel-0.8.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+std-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+std-devel.sha256sum] = "5b9b1e3ec2a5cc532c93109a4a31312263f44d46b6972781bfb1bbb2845076ad"

URI_x86_64_v2_rust-zerocopy+zerocopy-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+zerocopy-derive-devel-0.8.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+zerocopy-derive-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+zerocopy-derive-devel.sha256sum] = "61c73f00d7784178c8c1a86a6b80c2ecbb24d29f154729b2fc6a6f43c4348d4d"

URI_x86_64_v2_rust-zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-devel-0.8.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy-devel}"
SRC_URI[x86_64_v2_rust-zerocopy-devel.sha256sum] = "59d081dc30ee2b9adb2fe45b9e037208c3e01d36a8cad9f31fd3d36bdfdd6546"

URI_aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel-0.8.27-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel}"
SRC_URI[aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel.sha256sum] = "9a84fd3af13b109a1acc3d1dd07f6cf6ac94c2ce46aa1c377601be32c2ca0a61"

URI_aarch64_rust-zerocopy+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+alloc-devel-0.8.27-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+alloc-devel}"
SRC_URI[aarch64_rust-zerocopy+alloc-devel.sha256sum] = "422e461587f40a8fce4b4e530e1aa58e3c8b256367210c71375f6bddeb5c506b"

URI_aarch64_rust-zerocopy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+default-devel-0.8.27-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+default-devel}"
SRC_URI[aarch64_rust-zerocopy+default-devel.sha256sum] = "82eec8b83e671a6ae63f8f5628b6ed5f98642b5698c314eee48659609dc29489"

URI_aarch64_rust-zerocopy+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+derive-devel-0.8.27-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+derive-devel}"
SRC_URI[aarch64_rust-zerocopy+derive-devel.sha256sum] = "b8c6996f4ade433fb31126ee0ccbc6beea7c62ca18ae46774cadd0d680b01cb2"

URI_aarch64_rust-zerocopy+float-nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+float-nightly-devel-0.8.27-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy+float-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+float-nightly-devel}"
SRC_URI[aarch64_rust-zerocopy+float-nightly-devel.sha256sum] = "5147014f610e9125d824f12213623fd0a06a6a925576070a65fe4f90e2a2f296"

URI_aarch64_rust-zerocopy+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+simd-devel-0.8.27-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+simd-devel}"
SRC_URI[aarch64_rust-zerocopy+simd-devel.sha256sum] = "f081d8e0c32264684730cd2f29e54019ecd1308a28d594d4a4a4306bd5093c01"

URI_aarch64_rust-zerocopy+simd-nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+simd-nightly-devel-0.8.27-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy+simd-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+simd-nightly-devel}"
SRC_URI[aarch64_rust-zerocopy+simd-nightly-devel.sha256sum] = "0a99bb6863e235d562f8a1d24c08e73e02475dd8d70e3dd6e7072cf9681a1305"

URI_aarch64_rust-zerocopy+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+std-devel-0.8.27-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+std-devel}"
SRC_URI[aarch64_rust-zerocopy+std-devel.sha256sum] = "cc2b6d8098f9f51e885ad59b69dce2a2ec6d19a6d075616b32d6383c88dd36ae"

URI_aarch64_rust-zerocopy+zerocopy-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+zerocopy-derive-devel-0.8.27-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy+zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+zerocopy-derive-devel}"
SRC_URI[aarch64_rust-zerocopy+zerocopy-derive-devel.sha256sum] = "75476641555f01f15a2cfe1779893a4564992729276eef94f287728138679f8b"

URI_aarch64_rust-zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-devel-0.8.27-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy-devel}"
SRC_URI[aarch64_rust-zerocopy-devel.sha256sum] = "15b5226689a50a6ae3e87162361e9853b08ab442c6fe97eaca5a6f8bfb9fe598"

RDEPENDS:rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel = " \
 cargo \
 rust-zerocopy+alloc-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy+std-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+alloc-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+default-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+derive-devel = " \
 cargo \
 rust-zerocopy+zerocopy-derive-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+float-nightly-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+simd-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+simd-nightly-devel = " \
 cargo \
 rust-zerocopy+simd-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+std-devel = " \
 cargo \
 rust-zerocopy+alloc-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+zerocopy-derive-devel = " \
 cargo \
 rust-zerocopy-derive+default-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy-devel = " \
 cargo \
 rust \
 rust-zerocopy-derive+default-devel \
 "
