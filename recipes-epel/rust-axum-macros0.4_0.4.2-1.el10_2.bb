# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-axum-macros0.4"
PV = "0.4.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-axum-macros0.4+__private-devel \
 rust-axum-macros0.4+default-devel \
 rust-axum-macros0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-axum-macros0.4-0.4.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c089643ce5d8289d49dd7546d5c1e77a1a4609e04c0fa7cc586a07cfc71a6093"

URI_x86_64_v2_rust-axum-macros0.4+__private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-macros0.4+__private-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-macros0.4+__private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-macros0.4+__private-devel}"
SRC_URI[x86_64_v2_rust-axum-macros0.4+__private-devel.sha256sum] = "c2f4a6cdb1787d70f2856d2a08659ad81dc0d04289d1d4d658b55aa6b0610bff"

URI_x86_64_v2_rust-axum-macros0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-macros0.4+default-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-macros0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-macros0.4+default-devel}"
SRC_URI[x86_64_v2_rust-axum-macros0.4+default-devel.sha256sum] = "e86c0a68ed43cf8200059bd6e1ed3b64706ea6111c7f24a1f47f546c8e96c660"

URI_x86_64_v2_rust-axum-macros0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-macros0.4-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-macros0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-macros0.4-devel}"
SRC_URI[x86_64_v2_rust-axum-macros0.4-devel.sha256sum] = "3dbae849d33125987cbe1919541f0a16f2f80b8d9a6f0e6e7f1089f811aab4f7"

URI_aarch64_rust-axum-macros0.4+__private-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-macros0.4+__private-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-axum-macros0.4+__private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-macros0.4+__private-devel}"
SRC_URI[aarch64_rust-axum-macros0.4+__private-devel.sha256sum] = "20024af2e852cb9493d40ad9103bd08295810cf8b9a016adba4b2dae139e6f3b"

URI_aarch64_rust-axum-macros0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-macros0.4+default-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-axum-macros0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-macros0.4+default-devel}"
SRC_URI[aarch64_rust-axum-macros0.4+default-devel.sha256sum] = "2eb1c6b687b5609244525b4eb6978228deaa65513180aa11a1b6df29295d0258"

URI_aarch64_rust-axum-macros0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-macros0.4-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-axum-macros0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-macros0.4-devel}"
SRC_URI[aarch64_rust-axum-macros0.4-devel.sha256sum] = "cea2391c6d211e5756cb75c07e83bbec396243b49033e9bf4f61c506f4cc9cc9"

RDEPENDS:rust-axum-macros0.4+__private-devel = " \
 cargo \
 rust-axum-macros0.4-devel \
 rust-syn+visit-mut-devel \
 "
RDEPENDS:rust-axum-macros0.4+default-devel = " \
 cargo \
 rust-axum-macros0.4-devel \
 "
RDEPENDS:rust-axum-macros0.4-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 "
