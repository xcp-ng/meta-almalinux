# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls"
PV = "0.23.43"
PR = "1.el10_3"
PACKAGES = " \
 rust-rustls+brotli-devel \
 rust-rustls+custom-provider-devel \
 rust-rustls+default-devel \
 rust-rustls+hashbrown-devel \
 rust-rustls+log-devel \
 rust-rustls+logging-devel \
 rust-rustls+read_buf-devel \
 rust-rustls+ring-devel \
 rust-rustls+rustversion-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls+zlib-devel \
 rust-rustls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-0.23.43-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a84c8ec7e330e86c004105b05a9dc581f2101fe6d8ce7412fe3ff96f265358d1"

URI_x86_64_v2_rust-rustls+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+brotli-devel-0.23.43-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+brotli-devel}"
SRC_URI[x86_64_v2_rust-rustls+brotli-devel.sha256sum] = "85c92f9c50f5ca48a99c1f9bf42c6fb0fd61b0b80aee402b14bc62331ad55efb"

URI_x86_64_v2_rust-rustls+custom-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+custom-provider-devel-0.23.43-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+custom-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+custom-provider-devel}"
SRC_URI[x86_64_v2_rust-rustls+custom-provider-devel.sha256sum] = "6381ae688f8ed249e62e9b8950782e51aec8180ece9b003ec7d3d25857e97cc9"

URI_x86_64_v2_rust-rustls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+default-devel-0.23.43-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+default-devel}"
SRC_URI[x86_64_v2_rust-rustls+default-devel.sha256sum] = "522c5299475a938eb04da9fc61bedae4b0fd72ba1f1771ea732ab8072a03422f"

URI_x86_64_v2_rust-rustls+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+hashbrown-devel-0.23.43-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-rustls+hashbrown-devel.sha256sum] = "880ea53cb585143260ca56a4cdee4a993a23cdb59e0478faeb7bfda11eed49df"

URI_x86_64_v2_rust-rustls+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+log-devel-0.23.43-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+log-devel}"
SRC_URI[x86_64_v2_rust-rustls+log-devel.sha256sum] = "1ec196262fbf163c8655518b2cfe9bd28ef1130ca95562b5d81f23d101b7ee93"

URI_x86_64_v2_rust-rustls+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+logging-devel-0.23.43-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+logging-devel}"
SRC_URI[x86_64_v2_rust-rustls+logging-devel.sha256sum] = "d30ebecb260f20e5c24fe00b7f5c2ebd7b35ce40d0951f6d98e73a5dbc561456"

URI_x86_64_v2_rust-rustls+read_buf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+read_buf-devel-0.23.43-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+read_buf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+read_buf-devel}"
SRC_URI[x86_64_v2_rust-rustls+read_buf-devel.sha256sum] = "b6e94b3ab443066c7828954fd4f6c2ad15df8eb0e34a9c76d9b1589a982f4aac"

URI_x86_64_v2_rust-rustls+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+ring-devel-0.23.43-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+ring-devel}"
SRC_URI[x86_64_v2_rust-rustls+ring-devel.sha256sum] = "f0bfedeaab05e8cce08afce2c0bb97d421a2295cb407ed91fd2405ef94c4c26d"

URI_x86_64_v2_rust-rustls+rustversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+rustversion-devel-0.23.43-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+rustversion-devel}"
SRC_URI[x86_64_v2_rust-rustls+rustversion-devel.sha256sum] = "e6fdc876c97bc31820b546dfff33fa5337908271c9b2be243ab8cc4290350c15"

URI_x86_64_v2_rust-rustls+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+std-devel-0.23.43-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+std-devel}"
SRC_URI[x86_64_v2_rust-rustls+std-devel.sha256sum] = "9f97a5d5a9924af592080641fd04620d8813fecf455ed5ffb254c028ab0ba95b"

URI_x86_64_v2_rust-rustls+tls12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+tls12-devel-0.23.43-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+tls12-devel}"
SRC_URI[x86_64_v2_rust-rustls+tls12-devel.sha256sum] = "bc836cd684d839ef0b0f50027e3df1ffec1dfd8b63f5e12e2eacd8cffbd65bf8"

URI_x86_64_v2_rust-rustls+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+zlib-devel-0.23.43-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+zlib-devel}"
SRC_URI[x86_64_v2_rust-rustls+zlib-devel.sha256sum] = "b0960c8bdf7a7de6db8bdf7c5a0abbce9128a3020f5b453bf324f14d351cfa2e"

URI_x86_64_v2_rust-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-devel-0.23.43-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-devel}"
SRC_URI[x86_64_v2_rust-rustls-devel.sha256sum] = "1447fcd9f250cc16aaa0ed6920aa8ac5a2ed1d1973573f5cb27ba019108c3ca1"

URI_aarch64_rust-rustls+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+brotli-devel-0.23.43-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+brotli-devel}"
SRC_URI[aarch64_rust-rustls+brotli-devel.sha256sum] = "cde9b320fc0dc3c8093cdeba71ebf66ac010d2d5d882f7ba3af5cb6fc8045839"

URI_aarch64_rust-rustls+custom-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+custom-provider-devel-0.23.43-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+custom-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+custom-provider-devel}"
SRC_URI[aarch64_rust-rustls+custom-provider-devel.sha256sum] = "d4bc1eb897bb70c518e8c9cb06cbac4829571058efe7e11fb5866e7d323f3003"

URI_aarch64_rust-rustls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+default-devel-0.23.43-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+default-devel}"
SRC_URI[aarch64_rust-rustls+default-devel.sha256sum] = "f1aab7b30c33a362e7226ef9d050c6160b8d3eef316e0608aacafa7d0c8dca18"

URI_aarch64_rust-rustls+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+hashbrown-devel-0.23.43-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+hashbrown-devel}"
SRC_URI[aarch64_rust-rustls+hashbrown-devel.sha256sum] = "af32689e8d01fd243bef83e2dcb3958c2c6d33ba45e887894d528f6fbe2a38a3"

URI_aarch64_rust-rustls+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+log-devel-0.23.43-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+log-devel}"
SRC_URI[aarch64_rust-rustls+log-devel.sha256sum] = "3a14f2b0c6c9b491cd8097a5bd7876b528aed8a16e5c36f5865e7ad98fd57716"

URI_aarch64_rust-rustls+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+logging-devel-0.23.43-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+logging-devel}"
SRC_URI[aarch64_rust-rustls+logging-devel.sha256sum] = "dd49c07a776310e46d8b7c012577c4082c11e4f483bf8c6ffc9fd745404ae58c"

URI_aarch64_rust-rustls+read_buf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+read_buf-devel-0.23.43-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+read_buf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+read_buf-devel}"
SRC_URI[aarch64_rust-rustls+read_buf-devel.sha256sum] = "d3db8fa87cf7b8f08de8fc1a5e9d818f334fe13c7dde311a9936c7134e59d3b8"

URI_aarch64_rust-rustls+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+ring-devel-0.23.43-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+ring-devel}"
SRC_URI[aarch64_rust-rustls+ring-devel.sha256sum] = "b0fbc4e9cd12b279dcab7f2dec712971b34fbb4726c45e49fe1acd352d4830b5"

URI_aarch64_rust-rustls+rustversion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+rustversion-devel-0.23.43-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+rustversion-devel}"
SRC_URI[aarch64_rust-rustls+rustversion-devel.sha256sum] = "dacc93698e838f6097c621276e06bec42066a06f2fc3fc6d4795aa14ed74160a"

URI_aarch64_rust-rustls+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+std-devel-0.23.43-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+std-devel}"
SRC_URI[aarch64_rust-rustls+std-devel.sha256sum] = "52843113f8bba96142e26c0c607486611114c92d77a764968a16dd45ae831856"

URI_aarch64_rust-rustls+tls12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+tls12-devel-0.23.43-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+tls12-devel}"
SRC_URI[aarch64_rust-rustls+tls12-devel.sha256sum] = "71ee32aa84881958d2859e9447e7c412b0a3ea664820c3e58a480ee1fdc1b0ea"

URI_aarch64_rust-rustls+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+zlib-devel-0.23.43-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+zlib-devel}"
SRC_URI[aarch64_rust-rustls+zlib-devel.sha256sum] = "09be9edd9af4448934ba413389ba106559f348b96a71cf38256fcc0e907ec9d9"

URI_aarch64_rust-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-devel-0.23.43-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-devel}"
SRC_URI[aarch64_rust-rustls-devel.sha256sum] = "7edf554485843156a36a9ed4808b9ebefa798ae9de191490d1ed676eafa82b72"

RDEPENDS:rust-rustls+brotli-devel = " \
 cargo \
 rust-brotli+std-devel \
 rust-brotli-decompressor+default-devel \
 rust-brotli-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+custom-provider-devel = " \
 cargo \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+default-devel = " \
 cargo \
 rust-rustls+logging-devel \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.15+default-hasher-devel \
 rust-hashbrown0.15+inline-more-devel \
 rust-hashbrown0.15-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+logging-devel = " \
 cargo \
 rust-rustls+log-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+read_buf-devel = " \
 cargo \
 rust-rustls+rustversion-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+ring-devel = " \
 cargo \
 rust-ring+default-devel \
 rust-rustls-devel \
 rust-rustls-webpki+ring-devel \
 "
RDEPENDS:rust-rustls+rustversion-devel = " \
 cargo \
 rust-rustls-devel \
 rust-rustversion+default-devel \
 "
RDEPENDS:rust-rustls+std-devel = " \
 cargo \
 rust-once_cell+std-devel \
 rust-rustls-devel \
 rust-rustls-pki-types+std-devel \
 rust-rustls-webpki+std-devel \
 "
RDEPENDS:rust-rustls+tls12-devel = " \
 cargo \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+zlib-devel = " \
 cargo \
 rust-rustls-devel \
 rust-zlib-rs+default-devel \
 "
RDEPENDS:rust-rustls-devel = " \
 cargo \
 rust \
 rust-once_cell+alloc-devel \
 rust-once_cell+race-devel \
 rust-once_cell-devel \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki-devel \
 rust-subtle-devel \
 rust-zeroize+default-devel \
 "
