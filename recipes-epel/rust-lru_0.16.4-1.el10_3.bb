# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lru"
PV = "0.16.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-lru+default-devel \
 rust-lru+hashbrown-devel \
 rust-lru-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lru-0.16.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c46b6efc001e66f316a8fe50c868eb805255aa845b440359483a24d6cff34a9a"

URI_x86_64_v2_rust-lru+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru+default-devel-0.16.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru+default-devel}"
SRC_URI[x86_64_v2_rust-lru+default-devel.sha256sum] = "c8f20b2e6b6c62008bbe5bb6d5ccbd70ad7ea819127b617a6c5b0bbb8e2c4d25"

URI_x86_64_v2_rust-lru+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru+hashbrown-devel-0.16.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-lru+hashbrown-devel.sha256sum] = "02efe503cf31b76ef990f073762cda7c9256ed3a79aee58f26bd67c632d283c6"

URI_x86_64_v2_rust-lru-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru-devel-0.16.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru-devel}"
SRC_URI[x86_64_v2_rust-lru-devel.sha256sum] = "6a901aee5652b771ba7afd2b8c01df71dd388ce483bfdf8d8e2aec7b5f42b3c0"

URI_aarch64_rust-lru+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru+default-devel-0.16.4-1.el10_3.noarch.rpm;name=aarch64_rust-lru+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru+default-devel}"
SRC_URI[aarch64_rust-lru+default-devel.sha256sum] = "0ad85dbe5729509c3ff472de391eb2895ee69e30176acf030b2919689df365a6"

URI_aarch64_rust-lru+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru+hashbrown-devel-0.16.4-1.el10_3.noarch.rpm;name=aarch64_rust-lru+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru+hashbrown-devel}"
SRC_URI[aarch64_rust-lru+hashbrown-devel.sha256sum] = "170d5cfb55d662d889199c3d0b16b409a4785c8e64d2d1ea2687e09a44b6fd04"

URI_aarch64_rust-lru-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru-devel-0.16.4-1.el10_3.noarch.rpm;name=aarch64_rust-lru-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru-devel}"
SRC_URI[aarch64_rust-lru-devel.sha256sum] = "3674ec8e2fbba31ce6393540995d1057e39f2ba0b2d030d11b5af84a15b6b069"

RDEPENDS:rust-lru+default-devel = " \
 cargo \
 rust-lru+hashbrown-devel \
 rust-lru-devel \
 "
RDEPENDS:rust-lru+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.16+default-devel \
 rust-lru-devel \
 "
RDEPENDS:rust-lru-devel = " \
 cargo \
 rust \
 "
