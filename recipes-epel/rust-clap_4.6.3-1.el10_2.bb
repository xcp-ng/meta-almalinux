# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap"
PV = "4.6.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+debug-devel \
 rust-clap+default-devel \
 rust-clap+deprecated-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+error-context-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+string-devel \
 rust-clap+suggestions-devel \
 rust-clap+unicode-devel \
 rust-clap+unstable-doc-devel \
 rust-clap+unstable-ext-devel \
 rust-clap+unstable-markdown-devel \
 rust-clap+unstable-styles-devel \
 rust-clap+unstable-v5-devel \
 rust-clap+usage-devel \
 rust-clap+wrap_help-devel \
 rust-clap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap-4.6.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef6ac7ea444bf4b13c4714ba1c2592286de609857b1d256ad894a0e0475a621a"

URI_x86_64_v2_rust-clap+cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+cargo-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+cargo-devel}"
SRC_URI[x86_64_v2_rust-clap+cargo-devel.sha256sum] = "53642adbb9ff5e6786ec760e48c168d73aafcbbe98ad43ec1b381e53016bfa11"

URI_x86_64_v2_rust-clap+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+color-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+color-devel}"
SRC_URI[x86_64_v2_rust-clap+color-devel.sha256sum] = "c20afb105bede2f7321ad4d5a9c0bbee66ae410f69c3e87c2d08daa2b3eaa668"

URI_x86_64_v2_rust-clap+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+debug-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+debug-devel}"
SRC_URI[x86_64_v2_rust-clap+debug-devel.sha256sum] = "27da6805c561f41ce79d136c3e153f35ee592b210e56cc7259c428f076a530e4"

URI_x86_64_v2_rust-clap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+default-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+default-devel}"
SRC_URI[x86_64_v2_rust-clap+default-devel.sha256sum] = "4b007d8808d06425762be35bcc17f7694e8a44c96eb7729e416f2f7ec20ad90a"

URI_x86_64_v2_rust-clap+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+deprecated-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap+deprecated-devel.sha256sum] = "815935804bb17c4e0ffef48a4b75c733747a7e49209e2a2dfd6961278de13f56"

URI_x86_64_v2_rust-clap+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+derive-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+derive-devel}"
SRC_URI[x86_64_v2_rust-clap+derive-devel.sha256sum] = "78d12c30e055fb49c9013fcd3e3932f87c837f333f0452826b5339bc0388040a"

URI_x86_64_v2_rust-clap+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+env-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+env-devel}"
SRC_URI[x86_64_v2_rust-clap+env-devel.sha256sum] = "4f1b62902e4138fd9b576966dd1ad50a7bc2a46b724e75c1fe4c2daa742c2460"

URI_x86_64_v2_rust-clap+error-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+error-context-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+error-context-devel}"
SRC_URI[x86_64_v2_rust-clap+error-context-devel.sha256sum] = "a282bc64d9bb1e0cb58903aae52836b79b1f6dab36a9e242b93af21e3c7e9766"

URI_x86_64_v2_rust-clap+help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+help-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+help-devel}"
SRC_URI[x86_64_v2_rust-clap+help-devel.sha256sum] = "8c325d5aa3aefeadaa131d7a3796a3f9d290a14d83dbf764b505b52162f02ab0"

URI_x86_64_v2_rust-clap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+std-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+std-devel}"
SRC_URI[x86_64_v2_rust-clap+std-devel.sha256sum] = "460e106f0abc1152713b0f0badb486930dd1680339627194631ab025cc4fc084"

URI_x86_64_v2_rust-clap+string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+string-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+string-devel}"
SRC_URI[x86_64_v2_rust-clap+string-devel.sha256sum] = "905f16af941daa7aa4a31b0bc58ffee5dc71c003fe57b0ae37b34a4f3e44700d"

URI_x86_64_v2_rust-clap+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+suggestions-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+suggestions-devel}"
SRC_URI[x86_64_v2_rust-clap+suggestions-devel.sha256sum] = "4f68f0cdc6ea6164072f8941d371cd431bedf5610646906aee6321c2f0488be3"

URI_x86_64_v2_rust-clap+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unicode-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unicode-devel}"
SRC_URI[x86_64_v2_rust-clap+unicode-devel.sha256sum] = "7feba294e2ed3e0d05da3bece4d8929ea2d5851a751d760ef6ede322ef442126"

URI_x86_64_v2_rust-clap+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-doc-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-doc-devel.sha256sum] = "2ae31fe981a705346bdefce8f318bc7f1b4d040ee758d6cc8e65529be07545e1"

URI_x86_64_v2_rust-clap+unstable-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-ext-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-ext-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-ext-devel.sha256sum] = "653ce7a90135373e7080ad0b684f23ace35b0df94037ccf200bc758a3035f668"

URI_x86_64_v2_rust-clap+unstable-markdown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-markdown-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-markdown-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-markdown-devel.sha256sum] = "1fd049f3475924d2cd857d695f6b0943941311866fd2330a78c0c75bb8f92891"

URI_x86_64_v2_rust-clap+unstable-styles-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-styles-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-styles-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-styles-devel.sha256sum] = "c0c2afbc6d30b11c75e2c819127a07c7dc7d63b0e3fe28292ee2bf494ccc0804"

URI_x86_64_v2_rust-clap+unstable-v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-v5-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-v5-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-v5-devel.sha256sum] = "6f8c56051d0b442637b24a825549aef42a9c5925320278f9a75bb20742682efb"

URI_x86_64_v2_rust-clap+usage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+usage-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+usage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+usage-devel}"
SRC_URI[x86_64_v2_rust-clap+usage-devel.sha256sum] = "a8b55d5b2e508a47e7a6f4aa79f86dc3a9a92b620bdc3d63a4bcd4a8d006fca3"

URI_x86_64_v2_rust-clap+wrap_help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+wrap_help-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+wrap_help-devel}"
SRC_URI[x86_64_v2_rust-clap+wrap_help-devel.sha256sum] = "5abe78fd978d97553bb76f11de2229581224226bd57d595802d2355d20b1b41e"

URI_x86_64_v2_rust-clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-devel}"
SRC_URI[x86_64_v2_rust-clap-devel.sha256sum] = "98e8a6152be1e4e7680417d07dd68ec6deb24a13caf4f22c128133d0cd9b9ece"

URI_aarch64_rust-clap+cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+cargo-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+cargo-devel}"
SRC_URI[aarch64_rust-clap+cargo-devel.sha256sum] = "f5b49cdde83366460f710fe6a791f2875014da69d3f04b104cb70df65ede9f4e"

URI_aarch64_rust-clap+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+color-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+color-devel}"
SRC_URI[aarch64_rust-clap+color-devel.sha256sum] = "187e1d475af749895bb00150c2edfc41ba2f335a5b9df9174079441f13868b46"

URI_aarch64_rust-clap+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+debug-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+debug-devel}"
SRC_URI[aarch64_rust-clap+debug-devel.sha256sum] = "aa750bfafef7b97c74774798757d3a9e8be835aee2f4d78462ba0e80b6709cc9"

URI_aarch64_rust-clap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+default-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+default-devel}"
SRC_URI[aarch64_rust-clap+default-devel.sha256sum] = "74d23757528c4b76674ca6ed51ee291b4567de49c0295c0f475e191ac633711f"

URI_aarch64_rust-clap+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+deprecated-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+deprecated-devel}"
SRC_URI[aarch64_rust-clap+deprecated-devel.sha256sum] = "8a696ad363bb34457eec25e43f977e8997dd91ebeefb7804fcf39c88f118e2d8"

URI_aarch64_rust-clap+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+derive-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+derive-devel}"
SRC_URI[aarch64_rust-clap+derive-devel.sha256sum] = "3d153e668de7ce789c1c26a68f324f8f6156fba14578bc36b4a318e29759041c"

URI_aarch64_rust-clap+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+env-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+env-devel}"
SRC_URI[aarch64_rust-clap+env-devel.sha256sum] = "ec1e259b1d28c508efe7097d31966278c04592407a3e182537481307c6ff1837"

URI_aarch64_rust-clap+error-context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+error-context-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+error-context-devel}"
SRC_URI[aarch64_rust-clap+error-context-devel.sha256sum] = "fd280cb4c0487030a61360ef1ce34d98a70cff65695ed1057329224121376644"

URI_aarch64_rust-clap+help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+help-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+help-devel}"
SRC_URI[aarch64_rust-clap+help-devel.sha256sum] = "acec0a4a669ee4df77a0933096e67db4c16bab1dc753bbdef7457d347688d80c"

URI_aarch64_rust-clap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+std-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+std-devel}"
SRC_URI[aarch64_rust-clap+std-devel.sha256sum] = "635ad46b65232a611b4bbb3a4f1977c9e065e860d4d748d9fc92fd816a2d5835"

URI_aarch64_rust-clap+string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+string-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+string-devel}"
SRC_URI[aarch64_rust-clap+string-devel.sha256sum] = "3350fae0fb4e3de27f883735ae4c641463baf05263f776be5902883f0a19edbc"

URI_aarch64_rust-clap+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+suggestions-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+suggestions-devel}"
SRC_URI[aarch64_rust-clap+suggestions-devel.sha256sum] = "be8fdc49a3aba17476f4f529c0ba0ea468992aaf458e3b6936ca30c53377f8a4"

URI_aarch64_rust-clap+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unicode-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unicode-devel}"
SRC_URI[aarch64_rust-clap+unicode-devel.sha256sum] = "b0c243fb087e8c63f76f8319304884119bd61fce3cdf5476137cb51f983f82fc"

URI_aarch64_rust-clap+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-doc-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-doc-devel}"
SRC_URI[aarch64_rust-clap+unstable-doc-devel.sha256sum] = "55c0f913e01d12b7e4eb1881d9e02e5eb37a01d72fe17ecfe310fe42f3576db8"

URI_aarch64_rust-clap+unstable-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-ext-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-ext-devel}"
SRC_URI[aarch64_rust-clap+unstable-ext-devel.sha256sum] = "fbec8152cbccfebaf6857ae95f3c31abae2d4104b5d320f8cbf4b97470173cc5"

URI_aarch64_rust-clap+unstable-markdown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-markdown-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-markdown-devel}"
SRC_URI[aarch64_rust-clap+unstable-markdown-devel.sha256sum] = "464606e0a6880aeb4aa45f0b5e435d3da27d7ade8bdd9b1a97404ebe390228b0"

URI_aarch64_rust-clap+unstable-styles-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-styles-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-styles-devel}"
SRC_URI[aarch64_rust-clap+unstable-styles-devel.sha256sum] = "6c294e7e597ccb6f4d75d458a8ba20dfb089a97b02bb06136cc88ee848b84ec9"

URI_aarch64_rust-clap+unstable-v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-v5-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-v5-devel}"
SRC_URI[aarch64_rust-clap+unstable-v5-devel.sha256sum] = "486e0675e5b21f3809f73893a2cd1eb93ce27ea689e01b1b8353db2078541b40"

URI_aarch64_rust-clap+usage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+usage-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+usage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+usage-devel}"
SRC_URI[aarch64_rust-clap+usage-devel.sha256sum] = "12c002b700e803d990689a0cd669431c830e724dea1c8577d7ca94753ea15d00"

URI_aarch64_rust-clap+wrap_help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+wrap_help-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+wrap_help-devel}"
SRC_URI[aarch64_rust-clap+wrap_help-devel.sha256sum] = "dba6542f5c71a95006302e479a8a6f8e541646547e211cf457466eddeb133071"

URI_aarch64_rust-clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-devel}"
SRC_URI[aarch64_rust-clap-devel.sha256sum] = "cf28eafe8b240bf9af04243cd8c796c26f4180db60d6231d0698ea953344ba6c"

RDEPENDS:rust-clap+cargo-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+cargo-devel \
 "
RDEPENDS:rust-clap+color-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+color-devel \
 "
RDEPENDS:rust-clap+debug-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+debug-devel \
 rust-clap_derive+debug-devel \
 rust-clap_derive+default-devel \
 "
RDEPENDS:rust-clap+default-devel = " \
 cargo \
 rust-clap+color-devel \
 rust-clap+error-context-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+suggestions-devel \
 rust-clap+usage-devel \
 rust-clap-devel \
 "
RDEPENDS:rust-clap+deprecated-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+deprecated-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+deprecated-devel \
 "
RDEPENDS:rust-clap+derive-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_derive+default-devel \
 "
RDEPENDS:rust-clap+env-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+env-devel \
 "
RDEPENDS:rust-clap+error-context-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+error-context-devel \
 "
RDEPENDS:rust-clap+help-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+help-devel \
 "
RDEPENDS:rust-clap+std-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+std-devel \
 "
RDEPENDS:rust-clap+string-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+string-devel \
 "
RDEPENDS:rust-clap+suggestions-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+suggestions-devel \
 "
RDEPENDS:rust-clap+unicode-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unicode-devel \
 "
RDEPENDS:rust-clap+unstable-doc-devel = " \
 cargo \
 rust-clap+derive-devel \
 rust-clap-devel \
 rust-clap_builder+unstable-doc-devel \
 "
RDEPENDS:rust-clap+unstable-ext-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unstable-ext-devel \
 "
RDEPENDS:rust-clap+unstable-markdown-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+unstable-markdown-devel \
 "
RDEPENDS:rust-clap+unstable-styles-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unstable-styles-devel \
 "
RDEPENDS:rust-clap+unstable-v5-devel = " \
 cargo \
 rust-clap+deprecated-devel \
 rust-clap-devel \
 rust-clap_builder+unstable-v5-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+unstable-v5-devel \
 "
RDEPENDS:rust-clap+usage-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+usage-devel \
 "
RDEPENDS:rust-clap+wrap_help-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+wrap_help-devel \
 "
RDEPENDS:rust-clap-devel = " \
 cargo \
 rust \
 rust-clap_builder-devel \
 "
