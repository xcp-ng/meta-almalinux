# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knotifications"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-knotifications \
 kf6-knotifications-devel \
 kf6-knotifications-doc \
 kf6-knotifications-html \
 python3-kf6-knotifications \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-knotifications-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b10c1bb212495ab4c6225bf86c70e197cd44829db7589e5f4b72c460b1843f07"

URI_x86_64_v2_kf6-knotifications = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifications;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications}"
SRC_URI[x86_64_v2_kf6-knotifications.sha256sum] = "e383115208029714498fd6e14d32043cd0aa9fbad100f6136d830bfdfede244f"

URI_x86_64_v2_kf6-knotifications-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifications-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications-devel}"
SRC_URI[x86_64_v2_kf6-knotifications-devel.sha256sum] = "ae261e5253b8e1d1b783fe6ff59fc590287c258a205bf058308b38a1b096be2f"

URI_x86_64_v2_kf6-knotifications-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifications-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications-doc}"
SRC_URI[x86_64_v2_kf6-knotifications-doc.sha256sum] = "0043121ba1f97a13c5e6e6c7d4870634e8354cb50e1a8d9f4f1f01031953701f"

URI_x86_64_v2_kf6-knotifications-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifications-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications-html}"
SRC_URI[x86_64_v2_kf6-knotifications-html.sha256sum] = "3d3d41d6405dbd0352f0ace93e06b1a0f236063a9b074d793bf1de41cbf1eaf9"

URI_x86_64_v2_python3-kf6-knotifications = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-knotifications-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-knotifications;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-knotifications}"
SRC_URI[x86_64_v2_python3-kf6-knotifications.sha256sum] = "6df5742205168add06104e0059fcbe28161ff5ec66ec9c4494bf203a0f57133d"

URI_aarch64_kf6-knotifications = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-knotifications;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications}"
SRC_URI[aarch64_kf6-knotifications.sha256sum] = "c91211d2f6e95697a763af5664555bde3e8d2a519da0240304a6a09955514cf2"

URI_aarch64_kf6-knotifications-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-knotifications-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications-devel}"
SRC_URI[aarch64_kf6-knotifications-devel.sha256sum] = "bb0513cb47c179838ea958fc3d9d9b7eb87e78be892a0d4ca323a2a80149aa99"

URI_aarch64_kf6-knotifications-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-knotifications-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications-doc}"
SRC_URI[aarch64_kf6-knotifications-doc.sha256sum] = "6c1551ff30a31331f5145872fb8109c5617f15f012fc09280a18199ebf829ac9"

URI_aarch64_kf6-knotifications-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-knotifications-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications-html}"
SRC_URI[aarch64_kf6-knotifications-html.sha256sum] = "9ea09fd9d977ec0f8a48b603b3e8934cf5f246542b85b76e3e6c42d42afe3d49"

URI_aarch64_python3-kf6-knotifications = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-knotifications-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_python3-kf6-knotifications;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-knotifications}"
SRC_URI[aarch64_python3-kf6-knotifications.sha256sum] = "6dc30f0b2824186efec5987c0c587995c2e78456eb696782fd70d96b3c5d4349"

RDEPENDS:kf6-knotifications = " \
 glibc \
 kf6-kconfig \
 libcanberra \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-knotifications-devel = " \
 cmake-filesystem \
 kf6-knotifications \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-knotifications-doc = " \
 "
RDEPENDS:kf6-knotifications-html = " \
 "
RDEPENDS:python3-kf6-knotifications = " \
 glibc \
 kf6-knotifications \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
