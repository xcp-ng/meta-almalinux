# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdbusaddons"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kdbusaddons \
 kf6-kdbusaddons-devel \
 kf6-kdbusaddons-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdbusaddons-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83bd7301640941fcd13c777795c38c37a0f703093a8f2fa0b89c428b15fc1882"

URI_x86_64_v2_kf6-kdbusaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdbusaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons}"
SRC_URI[x86_64_v2_kf6-kdbusaddons.sha256sum] = "6383c589a94a2dd9c4730dd744e7ab225febce3c9c12d0c7fde02a486c0ca435"

URI_x86_64_v2_kf6-kdbusaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdbusaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons-devel}"
SRC_URI[x86_64_v2_kf6-kdbusaddons-devel.sha256sum] = "81e97b33e8bc18f587e9239ad814bb7a7dae96fe483e23a938d9ea13faf96d4f"

URI_x86_64_v2_kf6-kdbusaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdbusaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons-doc}"
SRC_URI[x86_64_v2_kf6-kdbusaddons-doc.sha256sum] = "79ac14a52a1dfcbca6b29f6c4915cf95fdfacfbb464cae768d41877a9601e2fb"

URI_aarch64_kf6-kdbusaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kdbusaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons}"
SRC_URI[aarch64_kf6-kdbusaddons.sha256sum] = "eb1bea3332c58219809e707588a9f22a59fb28ab5db3af2f15b95ee6470d9620"

URI_aarch64_kf6-kdbusaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kdbusaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons-devel}"
SRC_URI[aarch64_kf6-kdbusaddons-devel.sha256sum] = "5e170f52ebcb54086b391134acac32ad110155f16e15b0b343de24679d839624"

URI_aarch64_kf6-kdbusaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kdbusaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons-doc}"
SRC_URI[aarch64_kf6-kdbusaddons-doc.sha256sum] = "eabeed8147cd0d92d22bc9a61d2c5b046d198980d4f388fa076191ba0b9ca55c"

RDEPENDS:kf6-kdbusaddons = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kdbusaddons-devel = " \
 cmake-filesystem \
 kf6-kdbusaddons \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdbusaddons-doc = " \
 "
