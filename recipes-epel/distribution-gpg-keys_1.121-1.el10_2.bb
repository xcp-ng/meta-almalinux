# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "distribution-gpg-keys"
PV = "1.121"
PR = "1.el10_2"
PACKAGES = " \
 distribution-gpg-keys \
 distribution-gpg-keys-copr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/distribution-gpg-keys-1.121-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ec39f9b3a6270866feddf0010df88893b29f1ae107283a8ffedafad9063f474"

URI_x86_64_v2_distribution-gpg-keys = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distribution-gpg-keys-1.121-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_distribution-gpg-keys;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_distribution-gpg-keys}"
SRC_URI[x86_64_v2_distribution-gpg-keys.sha256sum] = "2f4c436a2e4c1772d7140154d7a8d56c27b6f98a0f0350c647d27d70877fcc6c"

URI_x86_64_v2_distribution-gpg-keys-copr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distribution-gpg-keys-copr-1.121-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_distribution-gpg-keys-copr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_distribution-gpg-keys-copr}"
SRC_URI[x86_64_v2_distribution-gpg-keys-copr.sha256sum] = "2cdc366a00564572a8758aaed811836dfe44e8dfa5ceec43f08ecce4ae759fce"

URI_aarch64_distribution-gpg-keys = "${EPEL_MIRROR}/aarch64/Packages/d/distribution-gpg-keys-1.121-1.el10_2.noarch.rpm;name=aarch64_distribution-gpg-keys;unpack=0"
SRC_URI:append = " ${URI_aarch64_distribution-gpg-keys}"
SRC_URI[aarch64_distribution-gpg-keys.sha256sum] = "db95cbe4fe9f84b8edea40809b57c2917de41c0ab38a679c8b21a6812ff8549b"

URI_aarch64_distribution-gpg-keys-copr = "${EPEL_MIRROR}/aarch64/Packages/d/distribution-gpg-keys-copr-1.121-1.el10_2.noarch.rpm;name=aarch64_distribution-gpg-keys-copr;unpack=0"
SRC_URI:append = " ${URI_aarch64_distribution-gpg-keys-copr}"
SRC_URI[aarch64_distribution-gpg-keys-copr.sha256sum] = "69e58b2af7b8d8453e25356841fc11b3ee5fbeafa4408421df75385f985ba9c0"

RDEPENDS:distribution-gpg-keys = " \
 "
RDEPENDS:distribution-gpg-keys-copr = " \
 "
