# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libchewing"
PV = "0.9.1"
PR = "1.el10_0"
PACKAGES = " \
 libchewing \
 libchewing-devel \
 python3-libchewing \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libchewing-0.9.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0424013dff047841488c24a4f9d922ed6ea4c6505f9389e54f1d681942193abf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libchewing-0.9.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libchewing;unpack=0"
SRC_URI[x86_64_v2_libchewing.sha256sum] = "e2d809526aa93b2919de02933a5fbe6d5ef541bb92ba47e0592a046ca39d4459"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libchewing-devel-0.9.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libchewing-devel;unpack=0"
SRC_URI[x86_64_v2_libchewing-devel.sha256sum] = "5a88e3bf834d37dcedf59bc7902117ae8fa12314507b346cb7d4d6c8ac5375a6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libchewing-0.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-libchewing;unpack=0"
SRC_URI[x86_64_v2_python3-libchewing.sha256sum] = "fe47c4356e1faeac22295b53310e3ab3bd0e334e6ebac31c728907393d0adeaa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libchewing-0.9.1-1.el10_0.aarch64.rpm;name=aarch64_libchewing;unpack=0"
SRC_URI[aarch64_libchewing.sha256sum] = "7bd3491564035e0ab15c63d6226d56fbdcdd3346c0e66b483f6c657f27334ea3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libchewing-devel-0.9.1-1.el10_0.aarch64.rpm;name=aarch64_libchewing-devel;unpack=0"
SRC_URI[aarch64_libchewing-devel.sha256sum] = "55701aba94ba0f90624022dc9ae3cad069b2a92a301f29dcedfc68a4c110578d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-libchewing-0.9.1-1.el10_0.noarch.rpm;name=aarch64_python3-libchewing;unpack=0"
SRC_URI[aarch64_python3-libchewing.sha256sum] = "dc6bb3d3b0d9a40662afd4360d1352e4d26bb8d15189b6785f50175c9450e0f3"

RDEPENDS:libchewing = " \
 glibc \
 libgcc \
 sqlite-libs \
 "
RDEPENDS:libchewing-devel = " \
 cmake-filesystem \
 libchewing \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libchewing = " \
 libchewing \
 python3 \
 "
