# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hdrhistogram"
PV = "1.0.1"
PR = "12.el10_0"
PACKAGES = " \
 compat-golang-github-codahale-hdrhistogram-devel \
 golang-github-hdrhistogram-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-hdrhistogram-1.0.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b83c78ca8d1ea6e88c4a58d7ef8bc5c1b4d6d60bb85c26e36ecd0bc4ea6343ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-codahale-hdrhistogram-devel-1.0.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-codahale-hdrhistogram-devel;unpack=0"
SRC_URI[x86_64_v2_compat-golang-github-codahale-hdrhistogram-devel.sha256sum] = "fe36fc55fce42c499c922badefce39f2fd4a80b0e4319bebe0da651777c90510"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hdrhistogram-devel-1.0.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hdrhistogram-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-hdrhistogram-devel.sha256sum] = "ab4a0fcaf90b28c56a72776f900ca09a3129b4035824eeadb48ca0aebcc9c0c5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-codahale-hdrhistogram-devel-1.0.1-12.el10_0.noarch.rpm;name=aarch64_compat-golang-github-codahale-hdrhistogram-devel;unpack=0"
SRC_URI[aarch64_compat-golang-github-codahale-hdrhistogram-devel.sha256sum] = "b6a1feac3b7e63020a1dbed8aef3a3c9f520cbdfa2e7a011a2f9ecfa08d47dce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hdrhistogram-devel-1.0.1-12.el10_0.noarch.rpm;name=aarch64_golang-github-hdrhistogram-devel;unpack=0"
SRC_URI[aarch64_golang-github-hdrhistogram-devel.sha256sum] = "64bc73541d119935f26234ecc6d15ef51f6f3a487209d1ac23f408331ee3718e"

RDEPENDS:compat-golang-github-codahale-hdrhistogram-devel = " \
 go-filesystem \
 golang-github-hdrhistogram-devel \
 "
RDEPENDS:golang-github-hdrhistogram-devel = " \
 go-filesystem \
 "
