# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-content-range"
PV = "0.2.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-http-content-range+default-devel \
 rust-http-content-range-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-content-range-0.2.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76b12bca28432690fd71368a6375713b35c14ceb37b43ad72c27165cd0a7f442"

URI_x86_64_v2_rust-http-content-range+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-content-range+default-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-content-range+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-content-range+default-devel}"
SRC_URI[x86_64_v2_rust-http-content-range+default-devel.sha256sum] = "37d7d2f57743c874a99bedc555778a7e261035af3361e1e2a5a4cec4f84ec0ca"

URI_x86_64_v2_rust-http-content-range-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-content-range-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-content-range-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-content-range-devel}"
SRC_URI[x86_64_v2_rust-http-content-range-devel.sha256sum] = "72426d1d7ac887856377ef7fd13d335126e01cecb98be3687cd14de626c28754"

URI_aarch64_rust-http-content-range+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-content-range+default-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-http-content-range+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-content-range+default-devel}"
SRC_URI[aarch64_rust-http-content-range+default-devel.sha256sum] = "c721cd3e6d7708298972152f8da87be0e9b8b73f4fa4c7fcde7976d2dc29713b"

URI_aarch64_rust-http-content-range-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-content-range-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-http-content-range-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-content-range-devel}"
SRC_URI[aarch64_rust-http-content-range-devel.sha256sum] = "c1a91bcf12f33bbd0bf3755fb623f1adb19afef64f90772ace62611bd61d4188"

RDEPENDS:rust-http-content-range+default-devel = " \
 cargo \
 rust-http-content-range-devel \
 "
RDEPENDS:rust-http-content-range-devel = " \
 cargo \
 rust \
 "
