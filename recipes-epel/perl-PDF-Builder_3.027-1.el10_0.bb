# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-PDF-Builder"
PV = "3.027"
PR = "1.el10_0"
PACKAGES = " \
 perl-PDF-Builder \
 perl-PDF-Builder-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-PDF-Builder-3.027-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f027657f11c770eb9bb933b63b8da7ecc8ebd3d8f6498ca13f54d59b8ea6686e"

URI_x86_64_v2_perl-PDF-Builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-PDF-Builder-3.027-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-PDF-Builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PDF-Builder}"
SRC_URI[x86_64_v2_perl-PDF-Builder.sha256sum] = "f2a93687498cb7735facf8488d77aa57250a71e9223bdfe07d6e434adef00958"

URI_x86_64_v2_perl-PDF-Builder-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-PDF-Builder-tests-3.027-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-PDF-Builder-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PDF-Builder-tests}"
SRC_URI[x86_64_v2_perl-PDF-Builder-tests.sha256sum] = "326e51cafce14dc8caf3bc7e7de3542c787a3047892d4658560a19b3e2368eee"

URI_aarch64_perl-PDF-Builder = "${EPEL_MIRROR}/aarch64/Packages/p/perl-PDF-Builder-3.027-1.el10_0.noarch.rpm;name=aarch64_perl-PDF-Builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PDF-Builder}"
SRC_URI[aarch64_perl-PDF-Builder.sha256sum] = "37adf2ab3e95945ed2f385a6d3e78fef7c191cf13a4c6fae32da1f4c90a2dd9e"

URI_aarch64_perl-PDF-Builder-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-PDF-Builder-tests-3.027-1.el10_0.noarch.rpm;name=aarch64_perl-PDF-Builder-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PDF-Builder-tests}"
SRC_URI[aarch64_perl-PDF-Builder-tests.sha256sum] = "c0ab762b47b2cd47c417fd9c2bb5fed7586520fad26245cef21001c8af1a966e"

RDEPENDS:perl-PDF-Builder = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Encode \
 perl-English \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Temp \
 perl-FileHandle \
 perl-Font-TTF \
 perl-IO \
 perl-IO-Compress \
 perl-Math-Complex \
 perl-PDF-Builder \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-Unicode-UCD \
 perl-base \
 perl-constant \
 perl-libs \
 perl-vars \
 perl-version \
 "
RDEPENDS:perl-PDF-Builder-tests = " \
 ImageMagick \
 bash \
 dejavu-sans-fonts \
 ghostscript \
 libtiff-tools \
 perl-English \
 perl-File-Temp \
 perl-GD \
 perl-IPC-Cmd \
 perl-PDF-Builder \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Test-Exception \
 perl-Test-Harness \
 perl-Test-Memory-Cycle \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 perl-version \
 urw-base35-gothic-fonts \
 "
