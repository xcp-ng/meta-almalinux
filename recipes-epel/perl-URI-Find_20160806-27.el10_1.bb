# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-URI-Find"
PV = "20160806"
PR = "27.el10_1"
PACKAGES = " \
 perl-URI-Find \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-URI-Find-20160806-27.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0e963a07a2c365e684b0a87af1cc3ba36f7ee7efe4b4bf87f540568b00998c3d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-URI-Find-20160806-27.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-URI-Find;unpack=0"
SRC_URI[x86_64_v2_perl-URI-Find.sha256sum] = "4af1bf811285b0f451161191cc4a63d1663b0507702d14e33a1496e0c0f60378"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-URI-Find-20160806-27.el10_1.noarch.rpm;name=aarch64_perl-URI-Find;unpack=0"
SRC_URI[aarch64_perl-URI-Find.sha256sum] = "a68795ef3f059da06c106cf96a3d5a3f781ade83b7a2c8b5ba536d2d7c1b43b8"

RDEPENDS:perl-URI-Find = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-IO \
 perl-URI \
 perl-URI-Find \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
