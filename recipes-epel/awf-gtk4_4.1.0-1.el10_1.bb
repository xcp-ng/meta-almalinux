# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "awf-gtk4"
PV = "4.1.0"
PR = "1.el10_1"
PACKAGES = " \
 awf-gtk4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/awf-gtk4-4.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5df844fde0710bfcea8d9314d89beda57975c9550c2ca7f57b0a2daecc11df20"

URI_x86_64_v2_awf-gtk4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/awf-gtk4-4.1.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_awf-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_awf-gtk4}"
SRC_URI[x86_64_v2_awf-gtk4.sha256sum] = "aa9292b51efba6eab6d24d61ea929b0318a577b7bf47a32f37ee98f243d74637"

URI_aarch64_awf-gtk4 = "${EPEL_MIRROR}/aarch64/Packages/a/awf-gtk4-4.1.0-1.el10_1.aarch64.rpm;name=aarch64_awf-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_awf-gtk4}"
SRC_URI[aarch64_awf-gtk4.sha256sum] = "27df5f8b6a8ed5e99cf9265d34873a3861fcc145c49ff379c9d4b7a7acea12b6"

RDEPENDS:awf-gtk4 = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk4 \
 hicolor-icon-theme \
 libnotify \
 pango \
 "
