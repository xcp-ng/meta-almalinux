# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral_async_zip"
PV = "0.0.17"
PR = "1.el10_2"
PACKAGES = " \
 rust-astral_async_zip+async-compression-devel \
 rust-astral_async_zip+bzip2-devel \
 rust-astral_async_zip+default-devel \
 rust-astral_async_zip+deflate-devel \
 rust-astral_async_zip+deflate64-devel \
 rust-astral_async_zip+full-devel \
 rust-astral_async_zip+lzma-devel \
 rust-astral_async_zip+tokio-devel \
 rust-astral_async_zip+tokio-fs-devel \
 rust-astral_async_zip+tokio-util-devel \
 rust-astral_async_zip+xz-devel \
 rust-astral_async_zip+zstd-devel \
 rust-astral_async_zip-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-astral_async_zip-0.0.17-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b80374499cf25bbbccab1a16d117ccb87afe7121212744a3eb97dcc5b2b85d8b"

URI_x86_64_v2_rust-astral_async_zip+async-compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+async-compression-devel-0.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+async-compression-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+async-compression-devel.sha256sum] = "6ba3340c3768f85042366375c2f82f2e6fc4603d5a3c91c4ded2a62ab1bc91a7"

URI_x86_64_v2_rust-astral_async_zip+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+bzip2-devel-0.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+bzip2-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+bzip2-devel.sha256sum] = "29332032dea6f1335daa66c8f5cf97fd27e9f839752237e59b5513453aadf11d"

URI_x86_64_v2_rust-astral_async_zip+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+default-devel-0.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+default-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+default-devel.sha256sum] = "522a09cf77b2af4ebb16a44a847cc11a36d271116966aa4325093804953cffe7"

URI_x86_64_v2_rust-astral_async_zip+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+deflate-devel-0.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+deflate-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+deflate-devel.sha256sum] = "0641977ae39300b4e059c126a47906c15d11af5491c42d455b11b5a8b9c5813c"

URI_x86_64_v2_rust-astral_async_zip+deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+deflate64-devel-0.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+deflate64-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+deflate64-devel.sha256sum] = "f4168feb294cf044f9b2f76c4b45c72cfe7095cb610d36bdbdf83ab10591b06c"

URI_x86_64_v2_rust-astral_async_zip+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+full-devel-0.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+full-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+full-devel.sha256sum] = "3dfa19b911c27c98d8247b92ee8fbe0576b494050a6fd541c10f9dae7833bc85"

URI_x86_64_v2_rust-astral_async_zip+lzma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+lzma-devel-0.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+lzma-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+lzma-devel.sha256sum] = "a49f9eb3d21b8c54ad37d69049f3b8febfb89bdb6b1eb3fbd41cadb8e75f8627"

URI_x86_64_v2_rust-astral_async_zip+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+tokio-devel-0.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+tokio-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+tokio-devel.sha256sum] = "e610f67dbe05dae11cc9337def1deea055518cfc28f7296752e8e390f8d77551"

URI_x86_64_v2_rust-astral_async_zip+tokio-fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+tokio-fs-devel-0.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+tokio-fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+tokio-fs-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+tokio-fs-devel.sha256sum] = "29266a49af42ca991efdb44a2469a157f9059180a65c48db3bea1c7fcada162c"

URI_x86_64_v2_rust-astral_async_zip+tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+tokio-util-devel-0.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+tokio-util-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+tokio-util-devel.sha256sum] = "29567c530734e3b4228d919d011c4eed31ffa0edccb37b731aaa72ce6b9f057b"

URI_x86_64_v2_rust-astral_async_zip+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+xz-devel-0.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+xz-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+xz-devel.sha256sum] = "3722150ab71c23825a146613441441c6c4fd0eacaea2428f51e735d835137824"

URI_x86_64_v2_rust-astral_async_zip+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+zstd-devel-0.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+zstd-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+zstd-devel.sha256sum] = "69276d598cea2bbe849deb6ece56571f5488721fab260e327234eff1320d6d12"

URI_x86_64_v2_rust-astral_async_zip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip-devel-0.0.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip-devel.sha256sum] = "98daac2cd2fcc421ec86c7e69c33a8b8a0e06a1a4ac06d8a0c9de0d1338b3cc6"

URI_aarch64_rust-astral_async_zip+async-compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+async-compression-devel-0.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_zip+async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+async-compression-devel}"
SRC_URI[aarch64_rust-astral_async_zip+async-compression-devel.sha256sum] = "4d35cfa3bb31454c42f3e1f1afbb7364714a172650c80d7771b6b0a33c84144e"

URI_aarch64_rust-astral_async_zip+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+bzip2-devel-0.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_zip+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+bzip2-devel}"
SRC_URI[aarch64_rust-astral_async_zip+bzip2-devel.sha256sum] = "e226b325c0e1408dd6d56e125ffd9abf8501b042a9965f9e9c97b2f64867dbd6"

URI_aarch64_rust-astral_async_zip+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+default-devel-0.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_zip+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+default-devel}"
SRC_URI[aarch64_rust-astral_async_zip+default-devel.sha256sum] = "92c405fdd0658efd8e9a63995cae1340e2ce704a13e927743ab09ecc73f48e95"

URI_aarch64_rust-astral_async_zip+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+deflate-devel-0.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_zip+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+deflate-devel}"
SRC_URI[aarch64_rust-astral_async_zip+deflate-devel.sha256sum] = "70d49312b5472e0cd8fcefb7fca9a15f0bee242cde6a408679215659e199b099"

URI_aarch64_rust-astral_async_zip+deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+deflate64-devel-0.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_zip+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+deflate64-devel}"
SRC_URI[aarch64_rust-astral_async_zip+deflate64-devel.sha256sum] = "2a7e52965285ba6e4bc086f66e3f1feeaab312010e8368c43bf54d457e055e2f"

URI_aarch64_rust-astral_async_zip+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+full-devel-0.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_zip+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+full-devel}"
SRC_URI[aarch64_rust-astral_async_zip+full-devel.sha256sum] = "546aaa04b9b30c4097352dd07cd996d2b0f50a55495c9c9498d29c32a2295e63"

URI_aarch64_rust-astral_async_zip+lzma-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+lzma-devel-0.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_zip+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+lzma-devel}"
SRC_URI[aarch64_rust-astral_async_zip+lzma-devel.sha256sum] = "5556b64f846c98b03b82accf884ed6601f2071c3301ad80752d3d9396382f5ab"

URI_aarch64_rust-astral_async_zip+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+tokio-devel-0.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_zip+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+tokio-devel}"
SRC_URI[aarch64_rust-astral_async_zip+tokio-devel.sha256sum] = "eb88bd0e306a3e6d01bc641683a6518347079f5ed00fdb7c24ed8bf36f5ed849"

URI_aarch64_rust-astral_async_zip+tokio-fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+tokio-fs-devel-0.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_zip+tokio-fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+tokio-fs-devel}"
SRC_URI[aarch64_rust-astral_async_zip+tokio-fs-devel.sha256sum] = "7f1b343ba8671b5db65b06431e9b9e60cc53ccd6c78f96de5cf87445bfa3ff51"

URI_aarch64_rust-astral_async_zip+tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+tokio-util-devel-0.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_zip+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+tokio-util-devel}"
SRC_URI[aarch64_rust-astral_async_zip+tokio-util-devel.sha256sum] = "dd0c2611059e5bef6dc6fdf5bddba6ddf389b8eb852c99796378f49e05a85499"

URI_aarch64_rust-astral_async_zip+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+xz-devel-0.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_zip+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+xz-devel}"
SRC_URI[aarch64_rust-astral_async_zip+xz-devel.sha256sum] = "37bc72ee87b2fb786647debbd8d8629c48d59f8faab3858e0ff479215cf6e014"

URI_aarch64_rust-astral_async_zip+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+zstd-devel-0.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_zip+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+zstd-devel}"
SRC_URI[aarch64_rust-astral_async_zip+zstd-devel.sha256sum] = "2a7e3c5b310ed0f995f7cb4f9d628df26bc52caad1ff00add05932c9b11d9dda"

URI_aarch64_rust-astral_async_zip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip-devel-0.0.17-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_zip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip-devel}"
SRC_URI[aarch64_rust-astral_async_zip-devel.sha256sum] = "898262ec15babcc02f277565dfd39e14d3bbda1d8c59950a550b4f974ca3f88e"

RDEPENDS:rust-astral_async_zip+async-compression-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-astral_async_zip+bzip2-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-async-compression+bzip2-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-astral_async_zip+default-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 "
RDEPENDS:rust-astral_async_zip+deflate-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-async-compression+deflate-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-astral_async_zip+deflate64-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-async-compression+deflate64-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-astral_async_zip+full-devel = " \
 cargo \
 rust-astral_async_zip+bzip2-devel \
 rust-astral_async_zip+deflate-devel \
 rust-astral_async_zip+deflate64-devel \
 rust-astral_async_zip+lzma-devel \
 rust-astral_async_zip+tokio-fs-devel \
 rust-astral_async_zip+xz-devel \
 rust-astral_async_zip+zstd-devel \
 rust-astral_async_zip-devel \
 "
RDEPENDS:rust-astral_async_zip+lzma-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression+lzma-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-astral_async_zip+tokio-devel = " \
 cargo \
 rust-astral_async_zip+tokio-util-devel \
 rust-astral_async_zip-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-astral_async_zip+tokio-fs-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-tokio+fs-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-astral_async_zip+tokio-util-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-tokio-util+compat-devel \
 rust-tokio-util+default-devel \
 "
RDEPENDS:rust-astral_async_zip+xz-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression+xz-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-astral_async_zip+zstd-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression+zstd-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-astral_async_zip-devel = " \
 cargo \
 rust-crc32fast+default-devel \
 rust-futures-lite+std-devel \
 rust-futures-lite-devel \
 rust-pin-project+default-devel \
 rust-thiserror1+default-devel \
 "
