# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "redisx"
PV = "1.0.4"
PR = "1.el10_3"
PACKAGES = " \
 redisx \
 redisx-devel \
 redisx-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/redisx-1.0.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2b1aae7430dc963698f4392b2b24361495ec8bb3204a97d1244b86cce2912e4"

URI_x86_64_v2_redisx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/redisx-1.0.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_redisx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redisx}"
SRC_URI[x86_64_v2_redisx.sha256sum] = "5ba5087d67144f9eca47c13e385094485c0e63e2a62ba454b0647921337d438d"

URI_x86_64_v2_redisx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/redisx-devel-1.0.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_redisx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redisx-devel}"
SRC_URI[x86_64_v2_redisx-devel.sha256sum] = "a3917a7a6392f5c9c5f68fe57c876182a733f9ae144a72ad801e7567ed96148d"

URI_x86_64_v2_redisx-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/redisx-doc-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_redisx-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redisx-doc}"
SRC_URI[x86_64_v2_redisx-doc.sha256sum] = "42f69362c20f1a9b0ce948a22155a8335138efd73f46bd7176f149667bfb496c"

URI_aarch64_redisx = "${EPEL_MIRROR}/aarch64/Packages/r/redisx-1.0.4-1.el10_3.aarch64.rpm;name=aarch64_redisx;unpack=0"
SRC_URI:append = " ${URI_aarch64_redisx}"
SRC_URI[aarch64_redisx.sha256sum] = "f4fc963be0576a5c6f30e44baa8890f4933dca177912c5dd01976c38e958afc3"

URI_aarch64_redisx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/redisx-devel-1.0.4-1.el10_3.aarch64.rpm;name=aarch64_redisx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_redisx-devel}"
SRC_URI[aarch64_redisx-devel.sha256sum] = "048a9b2369fa18b50b3563cddbbc41ad9e3c2d57bc8c0ad8a1e318cfae2bc308"

URI_aarch64_redisx-doc = "${EPEL_MIRROR}/aarch64/Packages/r/redisx-doc-1.0.4-1.el10_3.noarch.rpm;name=aarch64_redisx-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_redisx-doc}"
SRC_URI[aarch64_redisx-doc.sha256sum] = "ca215b97dd929662e6244976fc8a47a79d54e88e34e4272a94bb6ec08c857764"

RDEPENDS:redisx = " \
 glibc \
 libbsd \
 libgcc \
 libgomp \
 libxchange \
 openssl-libs \
 popt \
 readline \
 "
RDEPENDS:redisx-devel = " \
 cmake-filesystem \
 libbsd-devel \
 libomp-devel \
 libxchange-devel \
 openssl-devel \
 pkgconf-pkg-config \
 popt-devel \
 readline-devel \
 redisx \
 "
RDEPENDS:redisx-doc = " \
 "
