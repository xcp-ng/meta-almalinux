# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-etcetera"
PV = "0.11.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-etcetera+default-devel \
 rust-etcetera-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-etcetera-0.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddcbb2f479169c220079daa2ccd23a056214b5a07a855c8b6a490cfb7e34861e"

URI_x86_64_v2_rust-etcetera+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-etcetera+default-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-etcetera+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-etcetera+default-devel}"
SRC_URI[x86_64_v2_rust-etcetera+default-devel.sha256sum] = "bfa4bf66f1fb81374820d9e30bbde0bd3db639bd383c5d5fa7af15085dca74ad"

URI_x86_64_v2_rust-etcetera-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-etcetera-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-etcetera-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-etcetera-devel}"
SRC_URI[x86_64_v2_rust-etcetera-devel.sha256sum] = "65f4628b78815538fc1780b6907a522844147117a13767c950843711be6da31e"

URI_aarch64_rust-etcetera+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-etcetera+default-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-etcetera+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-etcetera+default-devel}"
SRC_URI[aarch64_rust-etcetera+default-devel.sha256sum] = "21cdf0b58ebeeab1fccda0c3c1fca400824ab4742bfae6ded2346550fba8ccdf"

URI_aarch64_rust-etcetera-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-etcetera-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-etcetera-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-etcetera-devel}"
SRC_URI[aarch64_rust-etcetera-devel.sha256sum] = "72ff89756fdc3a12fadf083b79896af46b831ea5ad7a1083877725457e1f4a5e"

RDEPENDS:rust-etcetera+default-devel = " \
 cargo \
 rust-etcetera-devel \
 "
RDEPENDS:rust-etcetera-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "
