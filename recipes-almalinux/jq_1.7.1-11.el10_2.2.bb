# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jq"
PV = "1.7.1"
PR = "11.el10_2.2"
PACKAGES = " \
 jq \
 jq-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/jq-1.7.1-11.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5682f4b5bb43a80947c6221f047702f9b6b3de8dd035375c1163e4fe7ca08f8"

URI_x86_64_v2_jq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/jq-1.7.1-11.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_jq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jq}"
SRC_URI[x86_64_v2_jq.sha256sum] = "6ac7a32fb9c9fd2cf757f63d15bb91f17ed34988bdf76ec041824f2624354268"

URI_x86_64_v2_jq-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jq-devel-1.7.1-11.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_jq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jq-devel}"
SRC_URI[x86_64_v2_jq-devel.sha256sum] = "8bc066c4e711e0ed434a94bf07491caa52962579bedd2c17ca53ba811c000d0e"

URI_aarch64_jq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/jq-1.7.1-11.el10_2.2.aarch64.rpm;name=aarch64_jq;unpack=0"
SRC_URI:append = " ${URI_aarch64_jq}"
SRC_URI[aarch64_jq.sha256sum] = "f846066ca97440866c1a5bbfe2110b7ce4910c6da7bc2e37882a9f03ec38bb1c"

URI_aarch64_jq-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jq-devel-1.7.1-11.el10_2.2.aarch64.rpm;name=aarch64_jq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jq-devel}"
SRC_URI[aarch64_jq-devel.sha256sum] = "db7a5d14780498ffc3ddc074b7076b3fd6e734fdc8853f76706b0024e29882be"

RDEPENDS:jq = " \
 glibc \
 oniguruma \
 "
RDEPENDS:jq-devel = " \
 jq \
 pkgconf-pkg-config \
 "
