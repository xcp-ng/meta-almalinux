# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mokutil"
PE = "2"
PV = "0.7.2"
PR = "8.el10.alma.1"
PACKAGES = " \
 mokutil \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mokutil-0.7.2-8.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f89329c43455fbd85d51fa0a3e6115f78303d1b6b86b6cd81efb766044ad2b1a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mokutil-0.7.2-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mokutil;unpack=0"
SRC_URI[x86_64_v2_mokutil.sha256sum] = "85690d8a7e75574b59f82df2d04473c63f64acb060101c2ca71a2321bac93431"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mokutil-0.7.2-8.el10.alma.1.aarch64.rpm;name=aarch64_mokutil;unpack=0"
SRC_URI[aarch64_mokutil.sha256sum] = "1d196dec5b3b25a998e10d7c3dab7c4589bf49e16901bbdf4c62f25a5d20db86"

RDEPENDS:mokutil = " \
 efivar-libs \
 glibc \
 keyutils-libs \
 libxcrypt \
 openssl-libs \
 "
