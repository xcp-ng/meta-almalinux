# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-equivalent"
PV = "1.0.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-equivalent+default-devel \
 rust-equivalent-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-equivalent-1.0.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69a4b856a780860c820a033ae3f11903d19ba278b1bd40d828d894f4a767f918"

URI_x86_64_v2_rust-equivalent+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-equivalent+default-devel-1.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-equivalent+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-equivalent+default-devel}"
SRC_URI[x86_64_v2_rust-equivalent+default-devel.sha256sum] = "6d788af65fcbb20416e71fc7f45235822db278f83f8090b54b09a1fe501b410a"

URI_x86_64_v2_rust-equivalent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-equivalent-devel-1.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-equivalent-devel}"
SRC_URI[x86_64_v2_rust-equivalent-devel.sha256sum] = "937bd8839484eb3e58104fe315bceea36692f71db208ec2db782602fb728fb01"

URI_aarch64_rust-equivalent+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-equivalent+default-devel-1.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-equivalent+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-equivalent+default-devel}"
SRC_URI[aarch64_rust-equivalent+default-devel.sha256sum] = "0e952ea6b90fb1ed61a31022f0e191c05a40502a1b61b38837d1a368ee0470b2"

URI_aarch64_rust-equivalent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-equivalent-devel-1.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-equivalent-devel}"
SRC_URI[aarch64_rust-equivalent-devel.sha256sum] = "3bd5927b96bbece15fcd99f1e9518b756e1bee95d34bf495d59c12240ee04024"

RDEPENDS:rust-equivalent+default-devel = " \
 cargo \
 rust-equivalent-devel \
 "
RDEPENDS:rust-equivalent-devel = " \
 cargo \
 rust \
 "
