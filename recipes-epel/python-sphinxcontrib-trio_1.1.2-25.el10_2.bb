# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinxcontrib-trio"
PV = "1.1.2"
PR = "25.el10_2"
PACKAGES = " \
 python3-sphinxcontrib-trio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinxcontrib-trio-1.1.2-25.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a010dd1c7c75cf7248b701be76ec218c809920f8a3095dfc9b8ae62130ecbb74"

URI_x86_64_v2_python3-sphinxcontrib-trio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinxcontrib-trio-1.1.2-25.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinxcontrib-trio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinxcontrib-trio}"
SRC_URI[x86_64_v2_python3-sphinxcontrib-trio.sha256sum] = "b43707b7276de10649794fbbce2b1eb240cd82dc6e7943fefe219abcc94ed659"

URI_aarch64_python3-sphinxcontrib-trio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinxcontrib-trio-1.1.2-25.el10_2.noarch.rpm;name=aarch64_python3-sphinxcontrib-trio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinxcontrib-trio}"
SRC_URI[aarch64_python3-sphinxcontrib-trio.sha256sum] = "f7c2cbbd25b7c788086ca964f1e7fbc29dd28f263d3996a003ac34b48376532b"

RDEPENDS:python3-sphinxcontrib-trio = " \
 python3 \
 python3-sphinx \
 "
