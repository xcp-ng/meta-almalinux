# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mattn-sqlite3"
PV = "1.14.14"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-mattn-sqlite3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mattn-sqlite3-1.14.14-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fb7ad0b2e1fe290245ed3844a37229d04e8f9607b7d712c5581bee9b2abf43f"

URI_x86_64_v2_golang-github-mattn-sqlite3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-mattn-sqlite3-devel-1.14.14-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-mattn-sqlite3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-mattn-sqlite3-devel}"
SRC_URI[x86_64_v2_golang-github-mattn-sqlite3-devel.sha256sum] = "940148be083ddbdb83312c08b88999d4cde6584b456aa4fd2d28d2bd41e468be"

URI_aarch64_golang-github-mattn-sqlite3-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mattn-sqlite3-devel-1.14.14-6.el10_0.noarch.rpm;name=aarch64_golang-github-mattn-sqlite3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mattn-sqlite3-devel}"
SRC_URI[aarch64_golang-github-mattn-sqlite3-devel.sha256sum] = "05065432c5151d56ca5ad953d50689ce3c4098fe5e92b55defefb9eaed8b95b2"

RDEPENDS:golang-github-mattn-sqlite3-devel = " \
 go-filesystem \
 "
