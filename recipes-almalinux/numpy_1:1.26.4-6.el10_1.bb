# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "numpy"
PE = "1"
PV = "1.26.4"
PR = "6.el10_1"
PACKAGES = " \
 python3-numpy \
 python3-numpy-f2py \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/numpy-1.26.4-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae86e2a214f0f68e7ec25235fbd44b1d36ac15b7c6ee90712f0b205213f13173"

URI_x86_64_v2_python3-numpy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-numpy-1.26.4-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-numpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-numpy}"
SRC_URI[x86_64_v2_python3-numpy.sha256sum] = "a8d89a39474f3e58e4fedb3e0292bb724f908c0d1c7a796977a458d13d1cf395"

URI_x86_64_v2_python3-numpy-f2py = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-numpy-f2py-1.26.4-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-numpy-f2py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-numpy-f2py}"
SRC_URI[x86_64_v2_python3-numpy-f2py.sha256sum] = "31f11ee7f95d743789c097997ac17ac8f371356a2357a972f71cd73f2e9db894"

URI_aarch64_python3-numpy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-numpy-1.26.4-6.el10_1.aarch64.rpm;name=aarch64_python3-numpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-numpy}"
SRC_URI[aarch64_python3-numpy.sha256sum] = "ebfa4af8a0ffa48b98441904b25f33693e82fb9230218df75432b34281717ceb"

URI_aarch64_python3-numpy-f2py = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-numpy-f2py-1.26.4-6.el10_1.aarch64.rpm;name=aarch64_python3-numpy-f2py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-numpy-f2py}"
SRC_URI[aarch64_python3-numpy-f2py.sha256sum] = "13f874cb64187b655b6e0540024bcfe1727a2bf5b1e9e71c3582ff5a081e9788"

RDEPENDS:python3-numpy:x86_64_v2 = " \
 flexiblas-netlib \
 glibc \
 libstdc++ \
 python3 \
"
RDEPENDS:python3-numpy:aarch64 = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
"
RDEPENDS:python3-numpy-f2py = " \
 python3 \
 python3-devel \
 python3-numpy \
 "
