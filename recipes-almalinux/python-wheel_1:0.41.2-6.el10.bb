# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-wheel"
PE = "1"
PV = "0.41.2"
PR = "6.el10"
PACKAGES = " \
 python3-wheel \
 python3-wheel-wheel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python-wheel-0.41.2-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbd0f9215cb0ac63f7f82962665ef26a370b2e7e64b449ae77d93eabac81c1e5"

URI_x86_64_v2_python3-wheel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-wheel-0.41.2-6.el10.noarch.rpm;name=x86_64_v2_python3-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wheel}"
SRC_URI[x86_64_v2_python3-wheel.sha256sum] = "2cf92db93dee3bb0b3ff7fae7b6e8b6c102f6f953dc0a24f9158dc511211e8b2"

URI_x86_64_v2_python3-wheel-wheel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-wheel-wheel-0.41.2-6.el10.noarch.rpm;name=x86_64_v2_python3-wheel-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wheel-wheel}"
SRC_URI[x86_64_v2_python3-wheel-wheel.sha256sum] = "842662b2c5054c7462b3afe36eefc0a71294b5e5f4901e4c4cec8a49a3336642"

URI_aarch64_python3-wheel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-wheel-0.41.2-6.el10.noarch.rpm;name=aarch64_python3-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wheel}"
SRC_URI[aarch64_python3-wheel.sha256sum] = "2cf92db93dee3bb0b3ff7fae7b6e8b6c102f6f953dc0a24f9158dc511211e8b2"

URI_aarch64_python3-wheel-wheel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-wheel-wheel-0.41.2-6.el10.noarch.rpm;name=aarch64_python3-wheel-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wheel-wheel}"
SRC_URI[aarch64_python3-wheel-wheel.sha256sum] = "842662b2c5054c7462b3afe36eefc0a71294b5e5f4901e4c4cec8a49a3336642"

RDEPENDS:python3-wheel = " \
 python3 \
 "
RDEPENDS:python3-wheel-wheel = " \
 "
