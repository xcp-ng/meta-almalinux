# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-ianbruene-difflib"
PV = "1.2.0"
PR = "15.el10_0"
PACKAGES = " \
 golang-github-ianbruene-difflib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-ianbruene-difflib-1.2.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "409d0ce7ede90b5be4cad4e45190954b8f2d5085649335f9f69c828694b2d03a"

URI_x86_64_v2_golang-github-ianbruene-difflib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-ianbruene-difflib-devel-1.2.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-ianbruene-difflib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-ianbruene-difflib-devel}"
SRC_URI[x86_64_v2_golang-github-ianbruene-difflib-devel.sha256sum] = "292eb749c05846db97a2804b55cdbc3d5fe104c6ebb89529539b2388ee4adda4"

URI_aarch64_golang-github-ianbruene-difflib-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-ianbruene-difflib-devel-1.2.0-15.el10_0.noarch.rpm;name=aarch64_golang-github-ianbruene-difflib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-ianbruene-difflib-devel}"
SRC_URI[aarch64_golang-github-ianbruene-difflib-devel.sha256sum] = "b80098317692cb2e1c5cbd1901b88c0bc696e247b89c70ff7d0379161811c3ea"

RDEPENDS:golang-github-ianbruene-difflib-devel = " \
 go-filesystem \
 "
