# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros0.25"
PV = "0.25.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-pyo3-macros0.25+default-devel \
 rust-pyo3-macros0.25+experimental-async-devel \
 rust-pyo3-macros0.25+experimental-inspect-devel \
 rust-pyo3-macros0.25+multiple-pymethods-devel \
 rust-pyo3-macros0.25-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros0.25-0.25.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc04cf6969b492e8496755994bd906db9c399dbf5e619432fd66bfa42f5fe6bd"

URI_x86_64_v2_rust-pyo3-macros0.25+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.25+default-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.25+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.25+default-devel.sha256sum] = "b1cebaa727ae3c53c3d68516abc3418d91da109beab2dbf903475455017e03fa"

URI_x86_64_v2_rust-pyo3-macros0.25+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.25+experimental-async-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.25+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.25+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.25+experimental-async-devel.sha256sum] = "e5c7e6a6d9a4ac3f0ffb5df0ee5512e8b0e2347dd267109a9a7f65e0a0a4870c"

URI_x86_64_v2_rust-pyo3-macros0.25+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.25+experimental-inspect-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.25+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.25+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.25+experimental-inspect-devel.sha256sum] = "f21e168fc269c77d4de508e4749bd4c8d52cf9f49e046ae6458d86434b510895"

URI_x86_64_v2_rust-pyo3-macros0.25+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.25+multiple-pymethods-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.25+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.25+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.25+multiple-pymethods-devel.sha256sum] = "0af17f1a232b7fa49646519133e417a793bcb2825f35a0004043c562a23fbf30"

URI_x86_64_v2_rust-pyo3-macros0.25-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.25-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.25-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.25-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.25-devel.sha256sum] = "ad28002ff7f7d35ccfdb1471746d67821d2ff9974cd833d4333b7b5a8ab3a238"

URI_aarch64_rust-pyo3-macros0.25+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.25+default-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.25+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.25+default-devel.sha256sum] = "3ff0001a9a870ff293c692ce2d13f19781d3d837f3ccc7c19bc6ba67e0a254af"

URI_aarch64_rust-pyo3-macros0.25+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.25+experimental-async-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros0.25+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.25+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.25+experimental-async-devel.sha256sum] = "473b6e0f04d42114e84beb30f54be213302ec5453ee78a86ef118797c77dc1fb"

URI_aarch64_rust-pyo3-macros0.25+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.25+experimental-inspect-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros0.25+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.25+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.25+experimental-inspect-devel.sha256sum] = "6458f848ac9fab0e8cf3c00720488d990b06a10d1d0c1e8c9f9ae10ebcc97724"

URI_aarch64_rust-pyo3-macros0.25+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.25+multiple-pymethods-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros0.25+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.25+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.25+multiple-pymethods-devel.sha256sum] = "023b8791f36e8948484a532116b9630acc18856f5a6186428bd3323bb3a59921"

URI_aarch64_rust-pyo3-macros0.25-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.25-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros0.25-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.25-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.25-devel.sha256sum] = "210ec312fb653bee45882c93148123dd58d9f951e631d45b12febfd1b74bad6a"

RDEPENDS:rust-pyo3-macros0.25+default-devel = " \
 cargo \
 rust-pyo3-macros0.25-devel \
 "
RDEPENDS:rust-pyo3-macros0.25+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend0.25+experimental-async-devel \
 rust-pyo3-macros0.25-devel \
 "
RDEPENDS:rust-pyo3-macros0.25+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros-backend0.25+experimental-inspect-devel \
 rust-pyo3-macros0.25-devel \
 "
RDEPENDS:rust-pyo3-macros0.25+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros0.25-devel \
 "
RDEPENDS:rust-pyo3-macros0.25-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-pyo3-macros-backend0.25+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 "
