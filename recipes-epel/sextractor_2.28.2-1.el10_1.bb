# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sextractor"
PV = "2.28.2"
PR = "1.el10_1"
PACKAGES = " \
 sextractor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sextractor-2.28.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bed9f1dacd2e34f5f9cde71662f3b483d016f9286f2645e67083fa8490eba00f"

URI_x86_64_v2_sextractor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sextractor-2.28.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sextractor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sextractor}"
SRC_URI[x86_64_v2_sextractor.sha256sum] = "0b044d8ce62dbcb6452661480dc399a99dfd674806fe7e1248644fa03284eb17"

URI_aarch64_sextractor = "${EPEL_MIRROR}/aarch64/Packages/s/sextractor-2.28.2-1.el10_1.aarch64.rpm;name=aarch64_sextractor;unpack=0"
SRC_URI:append = " ${URI_aarch64_sextractor}"
SRC_URI[aarch64_sextractor.sha256sum] = "7a008e5997802c1558690e23e263d9a83f8daed7fcdf6262d0d454e3dfb3c987"

RDEPENDS:sextractor = " \
 cfitsio \
 fftw-libs-single \
 glibc \
 openblas-threads \
 "
