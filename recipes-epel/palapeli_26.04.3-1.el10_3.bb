# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "palapeli"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 palapeli \
 palapeli-devel \
 palapeli-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/palapeli-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2da90d2c6625b5a58ffbebf8e88c4a6501bbfb8273951d9d85b0ae26767af255"

URI_x86_64_v2_palapeli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/palapeli-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_palapeli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_palapeli}"
SRC_URI[x86_64_v2_palapeli.sha256sum] = "60b69fca055ebf3f0dbdd24c487edd1cc5813f5051ccc578bc6eb4dae1d11952"

URI_x86_64_v2_palapeli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/palapeli-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_palapeli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_palapeli-devel}"
SRC_URI[x86_64_v2_palapeli-devel.sha256sum] = "8446bb3efce596e880d685d34e443f77fd3578eeff805415e50c02b4746dfe1e"

URI_x86_64_v2_palapeli-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/palapeli-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_palapeli-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_palapeli-libs}"
SRC_URI[x86_64_v2_palapeli-libs.sha256sum] = "ae0b756e4d89d6265f760f1e9f7b0cdfd37b7723c12db319dd6333771e73df53"

URI_aarch64_palapeli = "${EPEL_MIRROR}/aarch64/Packages/p/palapeli-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_palapeli;unpack=0"
SRC_URI:append = " ${URI_aarch64_palapeli}"
SRC_URI[aarch64_palapeli.sha256sum] = "1dbb3307824ad34ccde415412ede6c1fad836465dbe81eb90a789d6832ecc825"

URI_aarch64_palapeli-devel = "${EPEL_MIRROR}/aarch64/Packages/p/palapeli-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_palapeli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_palapeli-devel}"
SRC_URI[aarch64_palapeli-devel.sha256sum] = "0a18d1c27e258c33939b4ce6d48c93ef862ddb32e08f3e8bb3270e6bc8222926"

URI_aarch64_palapeli-libs = "${EPEL_MIRROR}/aarch64/Packages/p/palapeli-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_palapeli-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_palapeli-libs}"
SRC_URI[aarch64_palapeli-libs.sha256sum] = "5bc8ac52a1f1c3b885a093c9cd371ceda7d2cb902e949502a186c965b200ff09"

RDEPENDS:palapeli = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 palapeli-libs \
 qhull \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:palapeli-devel = " \
 cmake-filesystem \
 palapeli-libs \
 "
RDEPENDS:palapeli-libs = " \
 glibc \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 libstdc++ \
 palapeli \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
