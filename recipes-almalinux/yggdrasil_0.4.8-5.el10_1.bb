# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yggdrasil"
PV = "0.4.8"
PR = "5.el10_1"
PACKAGES = " \
 yggdrasil \
 yggdrasil-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yggdrasil-0.4.8-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7c82e6e9718b5ada4ca2da267fa4b2d879a9e86f7e9de13d759055b6a1d2a64"

URI_x86_64_v2_yggdrasil = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yggdrasil-0.4.8-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_yggdrasil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yggdrasil}"
SRC_URI[x86_64_v2_yggdrasil.sha256sum] = "bfaa15c3a4e85ea349f19abce70435202c0ea16194a061a13b2e49890263190f"

URI_x86_64_v2_yggdrasil-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/yggdrasil-devel-0.4.8-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_yggdrasil-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yggdrasil-devel}"
SRC_URI[x86_64_v2_yggdrasil-devel.sha256sum] = "1508412950898b216f1f936ba49fab51929ebf5c8df33b0312db39494f40d2af"

URI_aarch64_yggdrasil = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yggdrasil-0.4.8-5.el10_1.aarch64.rpm;name=aarch64_yggdrasil;unpack=0"
SRC_URI:append = " ${URI_aarch64_yggdrasil}"
SRC_URI[aarch64_yggdrasil.sha256sum] = "37a22eb622ef51ca31762f2f0979716e9fa051cc37d993a983bf5d8191263754"

URI_aarch64_yggdrasil-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/yggdrasil-devel-0.4.8-5.el10_1.aarch64.rpm;name=aarch64_yggdrasil-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yggdrasil-devel}"
SRC_URI[aarch64_yggdrasil-devel.sha256sum] = "7784054f4ebbe5fab3429b4e3b67e5845b69da57d28e11fe4fb4ccf7ca7f5aea"

RDEPENDS:yggdrasil = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:yggdrasil-devel = " \
 pkgconf-pkg-config \
 "
