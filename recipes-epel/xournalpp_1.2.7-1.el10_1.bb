# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xournalpp"
PV = "1.2.7"
PR = "1.el10_1"
PACKAGES = " \
 xournalpp \
 xournalpp-plugins \
 xournalpp-ui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xournalpp-1.2.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9407c6eea5caa2b0edfaa6c24e9333c7f7f33f904e116584fecb232b706c01ae"

URI_x86_64_v2_xournalpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xournalpp-1.2.7-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xournalpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xournalpp}"
SRC_URI[x86_64_v2_xournalpp.sha256sum] = "9ee968fb35539a43bbb61f7f605731a4cd2e2ceecb0034a8e4e2b41dfab18521"

URI_x86_64_v2_xournalpp-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xournalpp-plugins-1.2.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_xournalpp-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xournalpp-plugins}"
SRC_URI[x86_64_v2_xournalpp-plugins.sha256sum] = "df0142c1056604409bc5e4361307d86acb95ab533dd1287a8f65773dc74a2d7e"

URI_x86_64_v2_xournalpp-ui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xournalpp-ui-1.2.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_xournalpp-ui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xournalpp-ui}"
SRC_URI[x86_64_v2_xournalpp-ui.sha256sum] = "1ca1752673402548704fd22b13fc4c931304a3379f012c9e3bf09f3a4964a2f1"

URI_aarch64_xournalpp = "${EPEL_MIRROR}/aarch64/Packages/x/xournalpp-1.2.7-1.el10_1.aarch64.rpm;name=aarch64_xournalpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_xournalpp}"
SRC_URI[aarch64_xournalpp.sha256sum] = "47b49550a1a3be3f0fab6a5b34aee7a922e9346f9b7e96aa3e42a90dcd17e7a3"

URI_aarch64_xournalpp-plugins = "${EPEL_MIRROR}/aarch64/Packages/x/xournalpp-plugins-1.2.7-1.el10_1.noarch.rpm;name=aarch64_xournalpp-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_xournalpp-plugins}"
SRC_URI[aarch64_xournalpp-plugins.sha256sum] = "40223e412d4cb9ff661c6f97b36dd65191ee1f5fa3d137919aef8f840d055128"

URI_aarch64_xournalpp-ui = "${EPEL_MIRROR}/aarch64/Packages/x/xournalpp-ui-1.2.7-1.el10_1.noarch.rpm;name=aarch64_xournalpp-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_xournalpp-ui}"
SRC_URI[aarch64_xournalpp-ui.sha256sum] = "a08931786622abb44b5201df448f14ee4aed0f2dfb39aebfe4cf1eef8c1adc58"

RDEPENDS:xournalpp = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gperftools-libs \
 gtk3 \
 gtksourceview4 \
 hicolor-icon-theme \
 libX11 \
 libXi \
 libgcc \
 librsvg2 \
 libsndfile \
 libstdc++ \
 libxml2 \
 libzip \
 lua-libs \
 pango \
 poppler-glib \
 portaudio \
 xournalpp-plugins \
 xournalpp-ui \
 zlib-ng-compat \
 "
RDEPENDS:xournalpp-plugins = " \
 "
RDEPENDS:xournalpp-ui = " \
 "
