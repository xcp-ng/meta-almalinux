# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-uglymemo"
PV = "0.1.0.1"
PR = "40.el10_0"
PACKAGES = " \
 ghc-uglymemo \
 ghc-uglymemo-devel \
 ghc-uglymemo-doc \
 ghc-uglymemo-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-uglymemo-0.1.0.1-40.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a197ac4fc72d0e21b48e33149a9d409ce9b78bbf4b5570c80e6dc6c85cdd9fe"

URI_x86_64_v2_ghc-uglymemo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uglymemo-0.1.0.1-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uglymemo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uglymemo}"
SRC_URI[x86_64_v2_ghc-uglymemo.sha256sum] = "bb0729b136e72c141371ad22bbfd662adb42e8faf807050494208e309d1069c0"

URI_x86_64_v2_ghc-uglymemo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uglymemo-devel-0.1.0.1-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uglymemo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uglymemo-devel}"
SRC_URI[x86_64_v2_ghc-uglymemo-devel.sha256sum] = "238bd2072b47358fd9fbc6ecd08cd5e9f32c972a153a4cad55c8228c339c9b3b"

URI_x86_64_v2_ghc-uglymemo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uglymemo-doc-0.1.0.1-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-uglymemo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uglymemo-doc}"
SRC_URI[x86_64_v2_ghc-uglymemo-doc.sha256sum] = "fbae654ac0739c0ec6f19def632cde829354ef3f975a76fcdbefdf0f8410ee2b"

URI_x86_64_v2_ghc-uglymemo-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uglymemo-prof-0.1.0.1-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uglymemo-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uglymemo-prof}"
SRC_URI[x86_64_v2_ghc-uglymemo-prof.sha256sum] = "15d26e8fe8b201ab89711d77e2ba1d6f8ef45b52c5f399f41840601989bc696b"

URI_aarch64_ghc-uglymemo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uglymemo-0.1.0.1-40.el10_0.aarch64.rpm;name=aarch64_ghc-uglymemo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uglymemo}"
SRC_URI[aarch64_ghc-uglymemo.sha256sum] = "351bc06d2c7403cd0ae2c996a36f1c710bae74275688771af1d3219c8340db08"

URI_aarch64_ghc-uglymemo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uglymemo-devel-0.1.0.1-40.el10_0.aarch64.rpm;name=aarch64_ghc-uglymemo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uglymemo-devel}"
SRC_URI[aarch64_ghc-uglymemo-devel.sha256sum] = "0cb8500d045d11ebc3154fa1a3e6f425b2ab96926adca140922c9e50facf2433"

URI_aarch64_ghc-uglymemo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uglymemo-doc-0.1.0.1-40.el10_0.noarch.rpm;name=aarch64_ghc-uglymemo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uglymemo-doc}"
SRC_URI[aarch64_ghc-uglymemo-doc.sha256sum] = "86bd4e0ea28ff8c71912c724a1bf5268970d68827974e817ee87b8e89bc7ffc0"

URI_aarch64_ghc-uglymemo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uglymemo-prof-0.1.0.1-40.el10_0.aarch64.rpm;name=aarch64_ghc-uglymemo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uglymemo-prof}"
SRC_URI[aarch64_ghc-uglymemo-prof.sha256sum] = "7f5c7f0598336ded3728d15ab1c8c193cc43a527aa665b4e0d1ef5dd59a61c9f"

RDEPENDS:ghc-uglymemo = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-uglymemo-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-uglymemo \
 "
RDEPENDS:ghc-uglymemo-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-uglymemo-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-uglymemo-devel \
 "
