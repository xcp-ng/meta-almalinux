# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-vcr"
PV = "1.0.2"
PR = "22.el10_1"
PACKAGES = " \
 python3-pytest-vcr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-vcr-1.0.2-22.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe9ba8d7ce18103342a4049842c8f7c4514bdebcbc88120708fa89f4488cbc17"

URI_x86_64_v2_python3-pytest-vcr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-vcr-1.0.2-22.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-vcr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-vcr}"
SRC_URI[x86_64_v2_python3-pytest-vcr.sha256sum] = "0da1a7b3572236a2094b5186c7cbbb9f2fdf560a11d8b257a92a0ce21871a771"

URI_aarch64_python3-pytest-vcr = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-vcr-1.0.2-22.el10_1.noarch.rpm;name=aarch64_python3-pytest-vcr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-vcr}"
SRC_URI[aarch64_python3-pytest-vcr.sha256sum] = "68df60d240ecaa3e7ffb05f913d7ab1b204e5615d0901e6e2a9849644474d57c"

RDEPENDS:python3-pytest-vcr = " \
 python3 \
 python3-pytest \
 python3-vcrpy \
 "
