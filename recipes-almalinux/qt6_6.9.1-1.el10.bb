# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6"
PV = "6.9.1"
PR = "1.el10"
PACKAGES = " \
 qt6-filesystem \
 qt6-rpm-macros \
 qt6-srpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-6.9.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70255057a34dcb5fcd7a901bf89774c2252755c12c6e834ea1013a80302fcf4d"

URI_x86_64_v2_qt6-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-filesystem-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-filesystem}"
SRC_URI[x86_64_v2_qt6-filesystem.sha256sum] = "0e00699588387301aa32882e1605460a759a21bde55168c80ba182cb0e0a9675"

URI_x86_64_v2_qt6-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-rpm-macros-6.9.1-1.el10.noarch.rpm;name=x86_64_v2_qt6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-rpm-macros}"
SRC_URI[x86_64_v2_qt6-rpm-macros.sha256sum] = "8a479016f1bc4de028db971d851aa34889fc22db3c86ac21181b3155e53d5dc7"

URI_x86_64_v2_qt6-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-srpm-macros-6.9.1-1.el10.noarch.rpm;name=x86_64_v2_qt6-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-srpm-macros}"
SRC_URI[x86_64_v2_qt6-srpm-macros.sha256sum] = "ec1e2ca0cda52e4246ce587213c0b7b53042d24a259e4f3fb66b85a249b432e5"

URI_aarch64_qt6-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-filesystem-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-filesystem}"
SRC_URI[aarch64_qt6-filesystem.sha256sum] = "cfb567e4ddbe51c4db84bef747953bbb0ad172fd6bfe906607f3ccdf362e00c4"

URI_aarch64_qt6-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-rpm-macros-6.9.1-1.el10.noarch.rpm;name=aarch64_qt6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-rpm-macros}"
SRC_URI[aarch64_qt6-rpm-macros.sha256sum] = "8a479016f1bc4de028db971d851aa34889fc22db3c86ac21181b3155e53d5dc7"

URI_aarch64_qt6-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-srpm-macros-6.9.1-1.el10.noarch.rpm;name=aarch64_qt6-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-srpm-macros}"
SRC_URI[aarch64_qt6-srpm-macros.sha256sum] = "ec1e2ca0cda52e4246ce587213c0b7b53042d24a259e4f3fb66b85a249b432e5"

RDEPENDS:qt6-filesystem = " \
 "
RDEPENDS:qt6-rpm-macros = " \
 bash \
 chrpath \
 cmake \
 gcc-c++ \
 "
RDEPENDS:qt6-srpm-macros = " \
 "
