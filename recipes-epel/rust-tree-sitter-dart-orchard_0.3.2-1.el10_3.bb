# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-dart-orchard"
PV = "0.3.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-dart-orchard+default-devel \
 rust-tree-sitter-dart-orchard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-dart-orchard-0.3.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a09adafeb081536e75d03f129c85701aee5f06f33856b8da06358f141a536457"

URI_x86_64_v2_rust-tree-sitter-dart-orchard+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-dart-orchard+default-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-dart-orchard+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-dart-orchard+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-dart-orchard+default-devel.sha256sum] = "74bef378bff44f9a8aac2506fc23be8fa27b9de0b2f95fc1aff59c59980b0d6f"

URI_x86_64_v2_rust-tree-sitter-dart-orchard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-dart-orchard-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-dart-orchard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-dart-orchard-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-dart-orchard-devel.sha256sum] = "c8af22ad50e9aeb2ccaeaa0f1782a77183d98b64e53ab6f79f2402860cef978c"

URI_aarch64_rust-tree-sitter-dart-orchard+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-dart-orchard+default-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-dart-orchard+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-dart-orchard+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-dart-orchard+default-devel.sha256sum] = "d4a3731b68b6679d29f791ec786176a47947a36429ab56b618de406bc731849a"

URI_aarch64_rust-tree-sitter-dart-orchard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-dart-orchard-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-dart-orchard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-dart-orchard-devel}"
SRC_URI[aarch64_rust-tree-sitter-dart-orchard-devel.sha256sum] = "1a0753f76e85682f855c654fe5cb318d38885c20fb76bc90348f5c10a37172f6"

RDEPENDS:rust-tree-sitter-dart-orchard+default-devel = " \
 cargo \
 rust-tree-sitter-dart-orchard-devel \
 "
RDEPENDS:rust-tree-sitter-dart-orchard-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
