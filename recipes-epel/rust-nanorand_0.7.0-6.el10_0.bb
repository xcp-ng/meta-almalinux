# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nanorand"
PV = "0.7.0"
PR = "6.el10_0"
PACKAGES = " \
 rust-nanorand+alloc-devel \
 rust-nanorand+chacha-devel \
 rust-nanorand+default-devel \
 rust-nanorand+getrandom-devel \
 rust-nanorand+pcg64-devel \
 rust-nanorand+rdseed-devel \
 rust-nanorand+std-devel \
 rust-nanorand+tls-devel \
 rust-nanorand+wyrand-devel \
 rust-nanorand+zeroize-devel \
 rust-nanorand-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nanorand-0.7.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "725f41bdd046f26168e7cfafb586bf4ed781022556e70e7ad56e28680222b7e5"

URI_x86_64_v2_rust-nanorand+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nanorand+alloc-devel-0.7.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nanorand+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nanorand+alloc-devel}"
SRC_URI[x86_64_v2_rust-nanorand+alloc-devel.sha256sum] = "346819e8695268316193aa2677e54a282433f778bacb371eab2e4353c6f8c4e4"

URI_x86_64_v2_rust-nanorand+chacha-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nanorand+chacha-devel-0.7.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nanorand+chacha-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nanorand+chacha-devel}"
SRC_URI[x86_64_v2_rust-nanorand+chacha-devel.sha256sum] = "d243ddf7644d7204682c28c65e9b489c1da39958975aa788a7a5762dee95c4fd"

URI_x86_64_v2_rust-nanorand+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nanorand+default-devel-0.7.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nanorand+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nanorand+default-devel}"
SRC_URI[x86_64_v2_rust-nanorand+default-devel.sha256sum] = "5f63a46fa7cd71675d29c3cbecb127dc4face164f8bb8249d3f3b8f352b95707"

URI_x86_64_v2_rust-nanorand+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nanorand+getrandom-devel-0.7.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nanorand+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nanorand+getrandom-devel}"
SRC_URI[x86_64_v2_rust-nanorand+getrandom-devel.sha256sum] = "7b3dc9a2e08a91e70d01db219266ef6873b028c41b11a7d844d6bbcd58343a93"

URI_x86_64_v2_rust-nanorand+pcg64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nanorand+pcg64-devel-0.7.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nanorand+pcg64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nanorand+pcg64-devel}"
SRC_URI[x86_64_v2_rust-nanorand+pcg64-devel.sha256sum] = "d20591c9c9fe04f5b961d8c2bee491df7d266d861cfa926669e048bd3b5ffaeb"

URI_x86_64_v2_rust-nanorand+rdseed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nanorand+rdseed-devel-0.7.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nanorand+rdseed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nanorand+rdseed-devel}"
SRC_URI[x86_64_v2_rust-nanorand+rdseed-devel.sha256sum] = "5165805691d49a570581d14fdf0cc15f033a2e6f2667ecf7ccd62d1e6e2430f7"

URI_x86_64_v2_rust-nanorand+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nanorand+std-devel-0.7.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nanorand+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nanorand+std-devel}"
SRC_URI[x86_64_v2_rust-nanorand+std-devel.sha256sum] = "265e3ad76771df7e361f2cc3e31129983dcb927c7f811d248979b27ae581197a"

URI_x86_64_v2_rust-nanorand+tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nanorand+tls-devel-0.7.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nanorand+tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nanorand+tls-devel}"
SRC_URI[x86_64_v2_rust-nanorand+tls-devel.sha256sum] = "ba0cd64656858fe124b8a6c08aa565c82533fc5d4fcbc3eccf2946459947c5d4"

URI_x86_64_v2_rust-nanorand+wyrand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nanorand+wyrand-devel-0.7.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nanorand+wyrand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nanorand+wyrand-devel}"
SRC_URI[x86_64_v2_rust-nanorand+wyrand-devel.sha256sum] = "2e939afb662e1fa5f2cc0628564bd5cf6a734971d96a69bbff55a7f2ed5e61b1"

URI_x86_64_v2_rust-nanorand+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nanorand+zeroize-devel-0.7.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nanorand+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nanorand+zeroize-devel}"
SRC_URI[x86_64_v2_rust-nanorand+zeroize-devel.sha256sum] = "5ae394578eb2990335796033bbc7d8100495cd29de896f762d96ea5a5e72d958"

URI_x86_64_v2_rust-nanorand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nanorand-devel-0.7.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nanorand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nanorand-devel}"
SRC_URI[x86_64_v2_rust-nanorand-devel.sha256sum] = "eb6658d407ac57f92289a610cc88254d30bb2fdbc2cc1d0d4e1f3202ba839270"

URI_aarch64_rust-nanorand+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nanorand+alloc-devel-0.7.0-6.el10_0.noarch.rpm;name=aarch64_rust-nanorand+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nanorand+alloc-devel}"
SRC_URI[aarch64_rust-nanorand+alloc-devel.sha256sum] = "2a4138fc1ffcf33103daa3807da8962f5a2ac200c12bcbbcaf89d54d27b68303"

URI_aarch64_rust-nanorand+chacha-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nanorand+chacha-devel-0.7.0-6.el10_0.noarch.rpm;name=aarch64_rust-nanorand+chacha-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nanorand+chacha-devel}"
SRC_URI[aarch64_rust-nanorand+chacha-devel.sha256sum] = "2fbc27059b58be8c7d5042de04ba054921dece7ebd33dbd90705848f72a328f0"

URI_aarch64_rust-nanorand+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nanorand+default-devel-0.7.0-6.el10_0.noarch.rpm;name=aarch64_rust-nanorand+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nanorand+default-devel}"
SRC_URI[aarch64_rust-nanorand+default-devel.sha256sum] = "51bfe44e3d134feb548eeb54748ac7524b1783f01b533ad5685ed26109199d94"

URI_aarch64_rust-nanorand+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nanorand+getrandom-devel-0.7.0-6.el10_0.noarch.rpm;name=aarch64_rust-nanorand+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nanorand+getrandom-devel}"
SRC_URI[aarch64_rust-nanorand+getrandom-devel.sha256sum] = "d3d2b154d219784443bc28501203b85332d2147246869453629a5199911bf6a2"

URI_aarch64_rust-nanorand+pcg64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nanorand+pcg64-devel-0.7.0-6.el10_0.noarch.rpm;name=aarch64_rust-nanorand+pcg64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nanorand+pcg64-devel}"
SRC_URI[aarch64_rust-nanorand+pcg64-devel.sha256sum] = "880aa2245231dd368873f620f84e27c5ec0e3a80c0f42e3c61470c0edeaa31e3"

URI_aarch64_rust-nanorand+rdseed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nanorand+rdseed-devel-0.7.0-6.el10_0.noarch.rpm;name=aarch64_rust-nanorand+rdseed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nanorand+rdseed-devel}"
SRC_URI[aarch64_rust-nanorand+rdseed-devel.sha256sum] = "226091c7d74bf886ef313c2c3044b91e670b474a55dd509505374cec4f9665b3"

URI_aarch64_rust-nanorand+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nanorand+std-devel-0.7.0-6.el10_0.noarch.rpm;name=aarch64_rust-nanorand+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nanorand+std-devel}"
SRC_URI[aarch64_rust-nanorand+std-devel.sha256sum] = "8193c2ff211d4100960e10682452b9790e1189ac284edef3f4c22651436fdef6"

URI_aarch64_rust-nanorand+tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nanorand+tls-devel-0.7.0-6.el10_0.noarch.rpm;name=aarch64_rust-nanorand+tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nanorand+tls-devel}"
SRC_URI[aarch64_rust-nanorand+tls-devel.sha256sum] = "cc7cc29fc17745d387733c7b89561445ba21a35532002a6fbd5c03b2d8954e39"

URI_aarch64_rust-nanorand+wyrand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nanorand+wyrand-devel-0.7.0-6.el10_0.noarch.rpm;name=aarch64_rust-nanorand+wyrand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nanorand+wyrand-devel}"
SRC_URI[aarch64_rust-nanorand+wyrand-devel.sha256sum] = "2dcbb67cda09f03dbd2e42c3c16c65fbb028e616f462aad7b7b7602bca42a161"

URI_aarch64_rust-nanorand+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nanorand+zeroize-devel-0.7.0-6.el10_0.noarch.rpm;name=aarch64_rust-nanorand+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nanorand+zeroize-devel}"
SRC_URI[aarch64_rust-nanorand+zeroize-devel.sha256sum] = "02fd25916f6cb8d851dceff5500417b5dbe5ed7496830b3ff7268cb3f3396c7c"

URI_aarch64_rust-nanorand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nanorand-devel-0.7.0-6.el10_0.noarch.rpm;name=aarch64_rust-nanorand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nanorand-devel}"
SRC_URI[aarch64_rust-nanorand-devel.sha256sum] = "2b4b0a9e09c779215a429e62ef5120d9e3b10fc9e548e5c9faa6df0476e8be45"

RDEPENDS:rust-nanorand+alloc-devel = " \
 cargo \
 rust-nanorand-devel \
 "
RDEPENDS:rust-nanorand+chacha-devel = " \
 cargo \
 rust-nanorand-devel \
 "
RDEPENDS:rust-nanorand+default-devel = " \
 cargo \
 rust-nanorand+chacha-devel \
 rust-nanorand+pcg64-devel \
 rust-nanorand+std-devel \
 rust-nanorand+tls-devel \
 rust-nanorand+wyrand-devel \
 rust-nanorand-devel \
 "
RDEPENDS:rust-nanorand+getrandom-devel = " \
 cargo \
 rust-getrandom0.2+default-devel \
 rust-getrandom0.2+rdrand-devel \
 rust-nanorand-devel \
 "
RDEPENDS:rust-nanorand+pcg64-devel = " \
 cargo \
 rust-nanorand-devel \
 "
RDEPENDS:rust-nanorand+rdseed-devel = " \
 cargo \
 rust-nanorand+std-devel \
 rust-nanorand-devel \
 "
RDEPENDS:rust-nanorand+std-devel = " \
 cargo \
 rust-nanorand+alloc-devel \
 rust-nanorand-devel \
 "
RDEPENDS:rust-nanorand+tls-devel = " \
 cargo \
 rust-nanorand+std-devel \
 rust-nanorand+wyrand-devel \
 rust-nanorand-devel \
 "
RDEPENDS:rust-nanorand+wyrand-devel = " \
 cargo \
 rust-nanorand-devel \
 "
RDEPENDS:rust-nanorand+zeroize-devel = " \
 cargo \
 rust-nanorand-devel \
 rust-zeroize+default-devel \
 rust-zeroize+zeroize_derive-devel \
 "
RDEPENDS:rust-nanorand-devel = " \
 cargo \
 "
