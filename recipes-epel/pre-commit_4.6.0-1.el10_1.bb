# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pre-commit"
PV = "4.6.0"
PR = "1.el10_1"
PACKAGES = " \
 pre-commit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pre-commit-4.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39bded5afce01b26571ca32d5f246246c5a79645e5885bca0249f8d63d33ee4b"

URI_x86_64_v2_pre-commit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pre-commit-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pre-commit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pre-commit}"
SRC_URI[x86_64_v2_pre-commit.sha256sum] = "94676f2f12a55f0c3ce510e00480555e456d2de28731c06dcb8989e41f35db0d"

URI_aarch64_pre-commit = "${EPEL_MIRROR}/aarch64/Packages/p/pre-commit-4.6.0-1.el10_1.noarch.rpm;name=aarch64_pre-commit;unpack=0"
SRC_URI:append = " ${URI_aarch64_pre-commit}"
SRC_URI[aarch64_pre-commit.sha256sum] = "3e66cd0a212fe7710f2d557b8fcefd33518eeaac7740581cbd04253e0eccd649"

RDEPENDS:pre-commit = " \
 bash \
 git-core \
 python3 \
 python3-cfgv \
 python3-identify \
 python3-nodeenv \
 python3-pyyaml \
 python3-virtualenv \
 "
