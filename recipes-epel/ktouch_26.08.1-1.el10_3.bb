# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktouch"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ktouch \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ktouch-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "219e3a8ff8b8a57439ec1e537c3c8cde4b38e0cdc1b838cef340ec2db2da2ce3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktouch-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktouch;unpack=0"
SRC_URI[x86_64_v2_ktouch.sha256sum] = "80b3c10f75755a804ae5eedaa5fb0becc87d1734d35161c340ac7e6803fc89ba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktouch-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ktouch;unpack=0"
SRC_URI[aarch64_ktouch.sha256sum] = "7e16dd3ac0d7c3baa5f31d4c61ebf6514b08bd26ef23328eff1d6be144cae942"

RDEPENDS:ktouch = " \
 glibc \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kqtquickcharts \
 libX11 \
 libstdc++ \
 libxcb \
 libxml2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
