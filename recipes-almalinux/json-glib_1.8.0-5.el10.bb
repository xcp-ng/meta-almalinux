# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "json-glib"
PV = "1.8.0"
PR = "5.el10"
PACKAGES = " \
 json-glib \
 json-glib-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/json-glib-1.8.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db16f45898306d4599ed7bd29bc676b02450143b9fa04ede24d1edc83807494d"

URI_x86_64_v2_json-glib = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/json-glib-1.8.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_json-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_json-glib}"
SRC_URI[x86_64_v2_json-glib.sha256sum] = "0b98294e2a47b9341fe46ca49ea61bbae49e0088c3742849adc6108f922adc0f"

URI_x86_64_v2_json-glib-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/json-glib-devel-1.8.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_json-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_json-glib-devel}"
SRC_URI[x86_64_v2_json-glib-devel.sha256sum] = "589b72e6170166653c1bb730f69f19c7c73528fee2f70837e921fa734c3f93bd"

URI_aarch64_json-glib = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/json-glib-1.8.0-5.el10.aarch64.rpm;name=aarch64_json-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_json-glib}"
SRC_URI[aarch64_json-glib.sha256sum] = "937ba36283b77af460b1a63d8c4731ab5c6f7be18c633ee3fbed82dc64c5234f"

URI_aarch64_json-glib-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/json-glib-devel-1.8.0-5.el10.aarch64.rpm;name=aarch64_json-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_json-glib-devel}"
SRC_URI[aarch64_json-glib-devel.sha256sum] = "87943de99bf6b62505f51dc621aa86682aea3a204fb0a3b047debccd62ac08a0"

RDEPENDS:json-glib = " \
 glib2 \
 glibc \
 "
RDEPENDS:json-glib-devel = " \
 glib2 \
 glib2-devel \
 glibc \
 json-glib \
 pkgconf-pkg-config \
 "
