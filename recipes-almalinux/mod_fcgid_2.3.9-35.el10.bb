# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_fcgid"
PV = "2.3.9"
PR = "35.el10"
PACKAGES = " \
 mod_fcgid \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_fcgid-2.3.9-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44a1cc808951df88a5c56485e21eb0ea8660a581eba93894ada1f2e9bfec3723"

URI_x86_64_v2_mod_fcgid = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_fcgid-2.3.9-35.el10.x86_64_v2.rpm;name=x86_64_v2_mod_fcgid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_fcgid}"
SRC_URI[x86_64_v2_mod_fcgid.sha256sum] = "7563976a9ca377ddffaddf546b78cca2f56d8e029cc17991d5f1dbbb6788c43e"

URI_aarch64_mod_fcgid = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_fcgid-2.3.9-35.el10.aarch64.rpm;name=aarch64_mod_fcgid;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_fcgid}"
SRC_URI[aarch64_mod_fcgid.sha256sum] = "94db1c91aa41005062d5d55c0bb3721d29fa0e144ae83c3c1ab87c9aaf5339c4"

RDEPENDS:mod_fcgid = " \
 glibc \
 httpd-core \
 systemd \
 "
