# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blowfish"
PV = "0.9.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-blowfish+bcrypt-devel \
 rust-blowfish+default-devel \
 rust-blowfish+zeroize-devel \
 rust-blowfish-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blowfish-0.9.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b00c57eb7e3abacf9d412e56fb10da7d03dfed4b1ca4129793e25f6250e1723"

URI_x86_64_v2_rust-blowfish+bcrypt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blowfish+bcrypt-devel-0.9.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blowfish+bcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blowfish+bcrypt-devel}"
SRC_URI[x86_64_v2_rust-blowfish+bcrypt-devel.sha256sum] = "48fe14c57fabdeb59acb925865bf7ba42d767661a7c56869dba0ab88de3551bd"

URI_x86_64_v2_rust-blowfish+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blowfish+default-devel-0.9.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blowfish+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blowfish+default-devel}"
SRC_URI[x86_64_v2_rust-blowfish+default-devel.sha256sum] = "ddd9b0b3f9afb94a4bcbe474bec92cea5ef486eed6125c2691d25c20ef577c81"

URI_x86_64_v2_rust-blowfish+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blowfish+zeroize-devel-0.9.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blowfish+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blowfish+zeroize-devel}"
SRC_URI[x86_64_v2_rust-blowfish+zeroize-devel.sha256sum] = "f05e7cbd6e674ebfa4776285dce7a6147a83738e67677332bcc23788b9d2b36b"

URI_x86_64_v2_rust-blowfish-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blowfish-devel-0.9.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blowfish-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blowfish-devel}"
SRC_URI[x86_64_v2_rust-blowfish-devel.sha256sum] = "0883359113270a24a03268e665210e78840d31c00bcae4e8399b5d69f1770be5"

URI_aarch64_rust-blowfish+bcrypt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blowfish+bcrypt-devel-0.9.1-4.el10_0.noarch.rpm;name=aarch64_rust-blowfish+bcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blowfish+bcrypt-devel}"
SRC_URI[aarch64_rust-blowfish+bcrypt-devel.sha256sum] = "35c2acbb96b177085a595e0e7cef34ee8770764ef05ffccc44df15af3a8d59d7"

URI_aarch64_rust-blowfish+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blowfish+default-devel-0.9.1-4.el10_0.noarch.rpm;name=aarch64_rust-blowfish+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blowfish+default-devel}"
SRC_URI[aarch64_rust-blowfish+default-devel.sha256sum] = "260b3ba60e1c33045f51b9e5e3182c5c4b758cecac4c9c72b06969f3d391941f"

URI_aarch64_rust-blowfish+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blowfish+zeroize-devel-0.9.1-4.el10_0.noarch.rpm;name=aarch64_rust-blowfish+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blowfish+zeroize-devel}"
SRC_URI[aarch64_rust-blowfish+zeroize-devel.sha256sum] = "09f3c9f2059400279109420f606f2b32d2e995dc53dc78d1a4540cd6d8d62482"

URI_aarch64_rust-blowfish-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blowfish-devel-0.9.1-4.el10_0.noarch.rpm;name=aarch64_rust-blowfish-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blowfish-devel}"
SRC_URI[aarch64_rust-blowfish-devel.sha256sum] = "989f6e7c2478ad55fd82766420cce8e5ce14487c78ea66545ae58bdd41f4634a"

RDEPENDS:rust-blowfish+bcrypt-devel = " \
 cargo \
 rust-blowfish-devel \
 "
RDEPENDS:rust-blowfish+default-devel = " \
 cargo \
 rust-blowfish-devel \
 "
RDEPENDS:rust-blowfish+zeroize-devel = " \
 cargo \
 rust-blowfish-devel \
 rust-cipher0.4+zeroize-devel \
 "
RDEPENDS:rust-blowfish-devel = " \
 cargo \
 rust \
 rust-byteorder-devel \
 rust-cipher0.4+default-devel \
 "
