# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ktexteditor"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-ktexteditor \
 kf6-ktexteditor-devel \
 kf6-ktexteditor-doc \
 kf6-ktexteditor-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-ktexteditor-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e34ab75c82ad90a01670a08a754f0c8500f134f6d3145574d524d89fbc782a61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexteditor;unpack=0"
SRC_URI[x86_64_v2_kf6-ktexteditor.sha256sum] = "bda4f74974373a8cd658d5aeb0e2435a0af54b9a1ef9f7c4970620f7dbff20a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexteditor-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-ktexteditor-devel.sha256sum] = "15bd62972e0996f0f4fbe9c1986ce9a486cd7303e5d52a14aaa1c3741f3d79a5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexteditor-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-ktexteditor-doc.sha256sum] = "47812c2e29ff9ae1767d4ad24e71f7f9a7c2c3ee075bccd14c23b4e55c3facd6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexteditor-html;unpack=0"
SRC_URI[x86_64_v2_kf6-ktexteditor-html.sha256sum] = "4f71b5208b89eccd2f45d90626e91cac988b7f370bfc746da46fc039a1137ace"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ktexteditor;unpack=0"
SRC_URI[aarch64_kf6-ktexteditor.sha256sum] = "e3b3ac79e8bba48a0cae321f4272def96d8394b5a8b2a56ffcbe3a18e3afb454"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ktexteditor-devel;unpack=0"
SRC_URI[aarch64_kf6-ktexteditor-devel.sha256sum] = "bd021362fe84977cc28ce5fd5d6d75aa984c7e777462b4b67088f70b04c6acc0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ktexteditor-doc;unpack=0"
SRC_URI[aarch64_kf6-ktexteditor-doc.sha256sum] = "566aadf40567f08930cebc5cd96c61882a96ac19d90e6273abc1e7284ddc5e57"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ktexteditor-html;unpack=0"
SRC_URI[aarch64_kf6-ktexteditor-html.sha256sum] = "03fed3c2221864c0e34e770d08fc65ec426e3245c21b45bb05a200d19d6a45d7"

RDEPENDS:kf6-ktexteditor = " \
 editorconfig-libs \
 git-core \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kauth \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtspeech \
 "
RDEPENDS:kf6-ktexteditor-devel = " \
 cmake-filesystem \
 kf6-kparts-devel \
 kf6-ktexteditor \
 kf6-syntax-highlighting-devel \
 "
RDEPENDS:kf6-ktexteditor-doc = " \
 "
RDEPENDS:kf6-ktexteditor-html = " \
 "
