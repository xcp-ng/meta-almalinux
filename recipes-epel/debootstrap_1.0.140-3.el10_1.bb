# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "debootstrap"
PV = "1.0.140"
PR = "3.el10_1"
PACKAGES = " \
 debootstrap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/debootstrap-1.0.140-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7a1563f1a1b61664873a79f00326bb6228bea83a1ac4b1798ed86c57a87e6bf"

URI_x86_64_v2_debootstrap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debootstrap-1.0.140-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_debootstrap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debootstrap}"
SRC_URI[x86_64_v2_debootstrap.sha256sum] = "6abaabbcf6853f294864432a385138424e36546a38630d1446f1de41c15d442a"

URI_aarch64_debootstrap = "${EPEL_MIRROR}/aarch64/Packages/d/debootstrap-1.0.140-3.el10_1.noarch.rpm;name=aarch64_debootstrap;unpack=0"
SRC_URI:append = " ${URI_aarch64_debootstrap}"
SRC_URI[aarch64_debootstrap.sha256sum] = "198aa37e2032de238186416a98241b04ad7d4f448f229d20f9eb6b6f3ed97adc"

RDEPENDS:debootstrap = " \
 bash \
 dpkg \
 gzip \
 perl-interpreter \
 tar \
 wget \
 xz \
 "
