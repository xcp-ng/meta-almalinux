# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-utf8-width"
PV = "0.1.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-utf8-width+default-devel \
 rust-utf8-width-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-utf8-width-0.1.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ef82553d7e79afb6d280b5257650f499139edfd2914513ae21a34b5dc9f454d"

URI_x86_64_v2_rust-utf8-width+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf8-width+default-devel-0.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf8-width+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf8-width+default-devel}"
SRC_URI[x86_64_v2_rust-utf8-width+default-devel.sha256sum] = "a343088b7f5e8fd79f088bcac2a3eae169ff77796bef834b50690531867d4e3c"

URI_x86_64_v2_rust-utf8-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf8-width-devel-0.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf8-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf8-width-devel}"
SRC_URI[x86_64_v2_rust-utf8-width-devel.sha256sum] = "64b953fe6fc327785e6aa7be8d540f060611b93507eda047f46d46d2076075cd"

URI_aarch64_rust-utf8-width+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf8-width+default-devel-0.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-utf8-width+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf8-width+default-devel}"
SRC_URI[aarch64_rust-utf8-width+default-devel.sha256sum] = "b0ec2735a1f754e186877d1c2ce932746e0b7f01b360e19ec4076134223b347f"

URI_aarch64_rust-utf8-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf8-width-devel-0.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-utf8-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf8-width-devel}"
SRC_URI[aarch64_rust-utf8-width-devel.sha256sum] = "8950036348520e2580655ca5c484f6141967b574f48d71cb7eeae78f22c03518"

RDEPENDS:rust-utf8-width+default-devel = " \
 cargo \
 rust-utf8-width-devel \
 "
RDEPENDS:rust-utf8-width-devel = " \
 cargo \
 rust \
 "
