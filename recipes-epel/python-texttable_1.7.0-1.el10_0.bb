# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-texttable"
PV = "1.7.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-texttable \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-texttable-1.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43f29bb990c952827eddc6150d3f6b38840f59c9d120fb2b40846b9758347843"

URI_x86_64_v2_python3-texttable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-texttable-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-texttable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-texttable}"
SRC_URI[x86_64_v2_python3-texttable.sha256sum] = "a4efb9426bb5f207e75e826005dc2d0e1855abb87ce670fd6001cba276b08d72"

URI_aarch64_python3-texttable = "${EPEL_MIRROR}/aarch64/Packages/p/python3-texttable-1.7.0-1.el10_0.noarch.rpm;name=aarch64_python3-texttable;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-texttable}"
SRC_URI[aarch64_python3-texttable.sha256sum] = "30b1ff7d61d671493d443b98ff1b5ca90f5e9ee76f6e7c207106954a43c8e612"

RDEPENDS:python3-texttable = " \
 python3 \
 "
