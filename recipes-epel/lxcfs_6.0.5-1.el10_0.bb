# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lxcfs"
PV = "6.0.5"
PR = "1.el10_0"
PACKAGES = " \
 lxcfs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/lxcfs-6.0.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4e91d20e05c14a2f35f1ce3ee34734f93dfd24d421b9c04331be424bd8b0322d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxcfs-6.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxcfs;unpack=0"
SRC_URI[x86_64_v2_lxcfs.sha256sum] = "70d46fda81de7bac4b58fb5b93a9012de90e7fc93aea5b96cc251989e52f5076"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lxcfs-6.0.5-1.el10_0.aarch64.rpm;name=aarch64_lxcfs;unpack=0"
SRC_URI[aarch64_lxcfs.sha256sum] = "86086e2bcab88a73533181dfbc1249a4c412a9d7b741cc8986dda216ca5a9946"

RDEPENDS:lxcfs = " \
 bash \
 fuse-libs \
 glibc \
 libgcc \
 lxc-templates \
 systemd \
 "
