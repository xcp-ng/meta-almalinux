# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-imara-diff"
PV = "0.2.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-imara-diff+default-devel \
 rust-imara-diff+unified_diff-devel \
 rust-imara-diff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-imara-diff-0.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a455446eac8d0f5898baf439c3ef289029cbd7da0d9d78a18622f53ae139c494"

URI_x86_64_v2_rust-imara-diff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imara-diff+default-devel-0.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imara-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imara-diff+default-devel}"
SRC_URI[x86_64_v2_rust-imara-diff+default-devel.sha256sum] = "1d8a51fd1e8906f2b4923dff548dc9b8c03afa2f4a82e5e7db6800f3fc2221ef"

URI_x86_64_v2_rust-imara-diff+unified_diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imara-diff+unified_diff-devel-0.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imara-diff+unified_diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imara-diff+unified_diff-devel}"
SRC_URI[x86_64_v2_rust-imara-diff+unified_diff-devel.sha256sum] = "3da0eb594eecc7e81a5116ec2d547753c10656fcb08676a3fc4278727155607f"

URI_x86_64_v2_rust-imara-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imara-diff-devel-0.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imara-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imara-diff-devel}"
SRC_URI[x86_64_v2_rust-imara-diff-devel.sha256sum] = "2fc919da8bacb5a6f2ace64f8e7034ac8ba9340ce646799771ebd55ed755c84a"

URI_aarch64_rust-imara-diff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imara-diff+default-devel-0.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-imara-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imara-diff+default-devel}"
SRC_URI[aarch64_rust-imara-diff+default-devel.sha256sum] = "383fa92691aab9b40e1b50caa9a71431fda414e886ba8b71d5a7991eccc52c18"

URI_aarch64_rust-imara-diff+unified_diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imara-diff+unified_diff-devel-0.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-imara-diff+unified_diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imara-diff+unified_diff-devel}"
SRC_URI[aarch64_rust-imara-diff+unified_diff-devel.sha256sum] = "00d61476f94cb2a2f485d8e50d2f4b873784eb751121171d0c3fe91636e9b02a"

URI_aarch64_rust-imara-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imara-diff-devel-0.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-imara-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imara-diff-devel}"
SRC_URI[aarch64_rust-imara-diff-devel.sha256sum] = "8f5723838083bb742f6644a496644b18c0df93cb1344e4a804e42605e750d2ad"

RDEPENDS:rust-imara-diff+default-devel = " \
 cargo \
 rust-imara-diff+unified_diff-devel \
 rust-imara-diff-devel \
 "
RDEPENDS:rust-imara-diff+unified_diff-devel = " \
 cargo \
 rust-imara-diff-devel \
 "
RDEPENDS:rust-imara-diff-devel = " \
 cargo \
 rust \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown-devel \
 rust-memchr+default-devel \
 "
