# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dfuzzer"
PV = "2.3"
PR = "1.el10_0"
PACKAGES = " \
 dfuzzer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dfuzzer-2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51ca865fb64951d45433436e40df78f7001587edb801659d0b9fd551f89fc02f"

URI_x86_64_v2_dfuzzer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dfuzzer-2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dfuzzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dfuzzer}"
SRC_URI[x86_64_v2_dfuzzer.sha256sum] = "2c07c2114f500673a5c34806fb3ff5730923c3053d4e303f6d7d931f01aad1f5"

URI_aarch64_dfuzzer = "${EPEL_MIRROR}/aarch64/Packages/d/dfuzzer-2.3-1.el10_0.aarch64.rpm;name=aarch64_dfuzzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_dfuzzer}"
SRC_URI[aarch64_dfuzzer.sha256sum] = "74be4a2fb0131e5b7c42d8108234ab90b971ecf36fd5241f2519a834fd7090af"

RDEPENDS:dfuzzer = " \
 glib2 \
 glibc \
 libgcc \
 "
