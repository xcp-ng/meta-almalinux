# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xxhash"
PV = "0.8.3"
PR = "1.el10_0"
PACKAGES = " \
 xxhash \
 xxhash-devel \
 xxhash-doc \
 xxhash-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/x/xxhash-0.8.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2c3112ae8d30ae7f78457eb1231edcfc24d051865bfac075b0d5916e7110c758"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xxhash-0.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xxhash;unpack=0"
SRC_URI[x86_64_v2_xxhash.sha256sum] = "f17da4f2225bc54645fcdf21eba43ada89c9bdc534275f5b2ecd44871c59fb22"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xxhash-devel-0.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xxhash-devel;unpack=0"
SRC_URI[x86_64_v2_xxhash-devel.sha256sum] = "cf327566af5286d0e000fbeff5586bfee20d09397d90cbb47eee91a036a11b7e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xxhash-doc-0.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_xxhash-doc;unpack=0"
SRC_URI[x86_64_v2_xxhash-doc.sha256sum] = "d76618fce5f5bc4317d4ac49dff27c5f090524291498349cfb2c70628391df3b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xxhash-libs-0.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xxhash-libs;unpack=0"
SRC_URI[x86_64_v2_xxhash-libs.sha256sum] = "3d184e56f385de6907b6e61019ea859c045441cd2f7c62b969b08d0198c32b13"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xxhash-0.8.3-1.el10_0.aarch64.rpm;name=aarch64_xxhash;unpack=0"
SRC_URI[aarch64_xxhash.sha256sum] = "16e0b7d81be1f0ed1da910d3a75cdcae45955e5f6c641dc5ae50ec7ae63f421e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xxhash-devel-0.8.3-1.el10_0.aarch64.rpm;name=aarch64_xxhash-devel;unpack=0"
SRC_URI[aarch64_xxhash-devel.sha256sum] = "1a38db4de12eedb2c62f1ed091159040e30d1823d8f47b14ad26fec9b37089e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xxhash-doc-0.8.3-1.el10_0.noarch.rpm;name=aarch64_xxhash-doc;unpack=0"
SRC_URI[aarch64_xxhash-doc.sha256sum] = "7bf8f63b40affe7f26295f4915f033a0065a8d0c9c3ade0e13dd89128b6516f8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xxhash-libs-0.8.3-1.el10_0.aarch64.rpm;name=aarch64_xxhash-libs;unpack=0"
SRC_URI[aarch64_xxhash-libs.sha256sum] = "8135d391089887c1faad7efd81bc44e3d9b171841046f7a4c74b0bef90c2333e"

RDEPENDS:xxhash = " \
 glibc \
 "
RDEPENDS:xxhash-devel = " \
 pkgconf-pkg-config \
 xxhash-libs \
 "
RDEPENDS:xxhash-doc = " \
 "
RDEPENDS:xxhash-libs = " \
 glibc \
 "
