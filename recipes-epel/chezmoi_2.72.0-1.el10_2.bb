# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chezmoi"
PV = "2.72.0"
PR = "1.el10_2"
PACKAGES = " \
 chezmoi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/chezmoi-2.72.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0c9f672b4d9e3e47b788d30b78d0b84769fcbf07408714aa83dac7091141462"

URI_x86_64_v2_chezmoi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chezmoi-2.72.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chezmoi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chezmoi}"
SRC_URI[x86_64_v2_chezmoi.sha256sum] = "935b42a3525642a2660a75ef61a83c0bfe0ed8cd48c1b7408b5666e0ef62df1a"

URI_aarch64_chezmoi = "${EPEL_MIRROR}/aarch64/Packages/c/chezmoi-2.72.0-1.el10_2.aarch64.rpm;name=aarch64_chezmoi;unpack=0"
SRC_URI:append = " ${URI_aarch64_chezmoi}"
SRC_URI[aarch64_chezmoi.sha256sum] = "d28480bb2e11bf8adf780d0077e72a9e2d59a4792b8f529ee70ba1e3fd866f4e"

RDEPENDS:chezmoi = " \
 glibc \
 "
