# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opencc"
PV = "1.1.7"
PR = "1.el10_3"
PACKAGES = " \
 opencc \
 opencc-devel \
 opencc-doc \
 opencc-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opencc-1.1.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f957fbf7151e061b46d2a7ad10d8150ba1eef0ef27eba91b26ac27ad9e469312"

URI_x86_64_v2_opencc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencc-1.1.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencc}"
SRC_URI[x86_64_v2_opencc.sha256sum] = "4c06236f8a8e9fb732c3d69bb0182f7e4dabb4e4a85f5962003ef396855e777f"

URI_x86_64_v2_opencc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencc-devel-1.1.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencc-devel}"
SRC_URI[x86_64_v2_opencc-devel.sha256sum] = "668e50a954c69f5245361367631d6ba626524a8ef71e47c6d9b28a27d362e776"

URI_x86_64_v2_opencc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencc-doc-1.1.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencc-doc}"
SRC_URI[x86_64_v2_opencc-doc.sha256sum] = "72349016ffc5546e08a63b8463a954316e5927f430197d92441af278bf3acf7f"

URI_x86_64_v2_opencc-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencc-tools-1.1.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencc-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencc-tools}"
SRC_URI[x86_64_v2_opencc-tools.sha256sum] = "1d0126f001b94d78cc633e9ffa58d274f5580ff623f655fcd6539c32c3047546"

URI_aarch64_opencc = "${EPEL_MIRROR}/aarch64/Packages/o/opencc-1.1.7-1.el10_3.aarch64.rpm;name=aarch64_opencc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencc}"
SRC_URI[aarch64_opencc.sha256sum] = "84b2a6c5f20a9dc2a35272efcfa3fe61cd87e67a56f6789f853e52d24e141695"

URI_aarch64_opencc-devel = "${EPEL_MIRROR}/aarch64/Packages/o/opencc-devel-1.1.7-1.el10_3.aarch64.rpm;name=aarch64_opencc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencc-devel}"
SRC_URI[aarch64_opencc-devel.sha256sum] = "ff4858fa960a6b871378996fc67c04c8282aa31dc2cdc7cea9fbece42c3b76bf"

URI_aarch64_opencc-doc = "${EPEL_MIRROR}/aarch64/Packages/o/opencc-doc-1.1.7-1.el10_3.aarch64.rpm;name=aarch64_opencc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencc-doc}"
SRC_URI[aarch64_opencc-doc.sha256sum] = "0fa82f01e41490d06e32d178285f71a72f9de18cba21a97acdc48ba99c6fec47"

URI_aarch64_opencc-tools = "${EPEL_MIRROR}/aarch64/Packages/o/opencc-tools-1.1.7-1.el10_3.aarch64.rpm;name=aarch64_opencc-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencc-tools}"
SRC_URI[aarch64_opencc-tools.sha256sum] = "25024d3b39eda7aec362040dadeff0710ab1f087dfded632fa45f46d58e7a726"

RDEPENDS:opencc = " \
 glibc \
 libgcc \
 libstdc++ \
 marisa \
 "
RDEPENDS:opencc-devel = " \
 cmake-filesystem \
 opencc \
 pkgconf-pkg-config \
 "
RDEPENDS:opencc-doc = " \
 opencc \
 "
RDEPENDS:opencc-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 opencc \
 "
