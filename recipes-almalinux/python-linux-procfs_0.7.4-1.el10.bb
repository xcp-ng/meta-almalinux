# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-linux-procfs"
PV = "0.7.4"
PR = "1.el10"
PACKAGES = " \
 python3-linux-procfs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-linux-procfs-0.7.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "805ab8ba2a61594c9526b6584e6cb00ccd85416c9770d94db90ce1696151427f"

URI_x86_64_v2_python3-linux-procfs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-linux-procfs-0.7.4-1.el10.noarch.rpm;name=x86_64_v2_python3-linux-procfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-linux-procfs}"
SRC_URI[x86_64_v2_python3-linux-procfs.sha256sum] = "e11597971144a1e850cb5320a3b6816ee8af89e4b2c57da21d7f02c1448ee0e9"

URI_aarch64_python3-linux-procfs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-linux-procfs-0.7.4-1.el10.noarch.rpm;name=aarch64_python3-linux-procfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-linux-procfs}"
SRC_URI[aarch64_python3-linux-procfs.sha256sum] = "e11597971144a1e850cb5320a3b6816ee8af89e4b2c57da21d7f02c1448ee0e9"

RDEPENDS:python3-linux-procfs = " \
 python3 \
 "
