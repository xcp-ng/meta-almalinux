# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "guestfs-tools"
PV = "1.54.0"
PR = "11.el10_2.alma.1"
PACKAGES = " \
 guestfs-tools \
 virt-win-reg \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/guestfs-tools-1.54.0-11.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "876f13592d757df9aa0347b1f406f622f704011707f088673dcb7e2eee857ecc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/guestfs-tools-1.54.0-11.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_guestfs-tools;unpack=0"
SRC_URI[x86_64_v2_guestfs-tools.sha256sum] = "9e6286ce026aacc80a88fb65ba0c5e570bf050f354ba9188645a6b0ac61a8497"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-win-reg-1.54.0-11.el10_2.alma.1.noarch.rpm;name=x86_64_v2_virt-win-reg;unpack=0"
SRC_URI[x86_64_v2_virt-win-reg.sha256sum] = "4351851d15dc83d66e8cc8f53f0781cc7731cb9b07c539afbf0fbca2ac132a12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/guestfs-tools-1.54.0-11.el10_2.alma.1.aarch64.rpm;name=aarch64_guestfs-tools;unpack=0"
SRC_URI[aarch64_guestfs-tools.sha256sum] = "5cf92e6472daa3a369a807099016c7e00fbaf517a315dda093e75a353fd0048e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-win-reg-1.54.0-11.el10_2.alma.1.noarch.rpm;name=aarch64_virt-win-reg;unpack=0"
SRC_URI[aarch64_virt-win-reg.sha256sum] = "4351851d15dc83d66e8cc8f53f0781cc7731cb9b07c539afbf0fbca2ac132a12"

RDEPENDS:guestfs-tools = " \
 curl \
 glib2 \
 glibc \
 gnupg2 \
 json-c \
 libgcc \
 libguestfs \
 libosinfo \
 libvirt-libs \
 libxcrypt \
 libxml2 \
 ncurses-libs \
 pcre2 \
 qemu-img \
 xz \
 xz-libs \
 "
RDEPENDS:virt-win-reg = " \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Pod-Usage \
 perl-Sys-Guestfs \
 perl-hivex \
 perl-interpreter \
 perl-libintl-perl \
 perl-libs \
 "
