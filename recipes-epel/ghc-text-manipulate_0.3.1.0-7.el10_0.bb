# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-text-manipulate"
PV = "0.3.1.0"
PR = "7.el10_0"
PACKAGES = " \
 ghc-text-manipulate \
 ghc-text-manipulate-devel \
 ghc-text-manipulate-doc \
 ghc-text-manipulate-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-text-manipulate-0.3.1.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "764ce3e61307b792c65f2158bc1f9d437bedf91bdc6f9212253be41c89a0ad6a"

URI_x86_64_v2_ghc-text-manipulate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-manipulate-0.3.1.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-manipulate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-manipulate}"
SRC_URI[x86_64_v2_ghc-text-manipulate.sha256sum] = "9782c9157c9da00f0a619f2761739f94956ee2743d6ee73a93071144caee8501"

URI_x86_64_v2_ghc-text-manipulate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-manipulate-devel-0.3.1.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-manipulate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-manipulate-devel}"
SRC_URI[x86_64_v2_ghc-text-manipulate-devel.sha256sum] = "f5ec21dc18a03e4897f41097a0541b8edb5e4bc909367855285f8db5b3c49187"

URI_x86_64_v2_ghc-text-manipulate-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-manipulate-doc-0.3.1.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-text-manipulate-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-manipulate-doc}"
SRC_URI[x86_64_v2_ghc-text-manipulate-doc.sha256sum] = "88df2b7c6a65a1d568a2b4500723e83f0d54cd7cd8ba5bb9b3a7c44ce1799ca0"

URI_x86_64_v2_ghc-text-manipulate-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-manipulate-prof-0.3.1.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-manipulate-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-manipulate-prof}"
SRC_URI[x86_64_v2_ghc-text-manipulate-prof.sha256sum] = "8f229a287e5f56bd631a0cf82ef742fbf4ab61f078ca4104971f36c3ef72edc2"

URI_aarch64_ghc-text-manipulate = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-manipulate-0.3.1.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-text-manipulate;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-manipulate}"
SRC_URI[aarch64_ghc-text-manipulate.sha256sum] = "be57c46f228e212268d79689d20055732c2ed6656bdd9d062b5d5aa3bdb1bc03"

URI_aarch64_ghc-text-manipulate-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-manipulate-devel-0.3.1.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-text-manipulate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-manipulate-devel}"
SRC_URI[aarch64_ghc-text-manipulate-devel.sha256sum] = "0a8b4dce02d2dc75140899ff2a98e151fd2133b6c13f4cf354ebe8554026cadb"

URI_aarch64_ghc-text-manipulate-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-manipulate-doc-0.3.1.0-7.el10_0.noarch.rpm;name=aarch64_ghc-text-manipulate-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-manipulate-doc}"
SRC_URI[aarch64_ghc-text-manipulate-doc.sha256sum] = "815fbeed2aec594dbf31b77c05873fb5b15d8c18551eb68bd84af1126c6c1742"

URI_aarch64_ghc-text-manipulate-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-manipulate-prof-0.3.1.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-text-manipulate-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-manipulate-prof}"
SRC_URI[aarch64_ghc-text-manipulate-prof.sha256sum] = "8df6957125dab0d0dc6e66c8b0480dcb533f5e91dc765b51b90419f962b0c767"

RDEPENDS:ghc-text-manipulate = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-text-manipulate-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-text-devel \
 ghc-text-manipulate \
 "
RDEPENDS:ghc-text-manipulate-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-text-manipulate-prof = " \
 ghc-base-prof \
 ghc-text-manipulate-devel \
 ghc-text-prof \
 "
