# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-detect-secrets"
PV = "1.5.0"
PR = "7.el10_2"
PACKAGES = " \
 python3-detect-secrets \
 python3-detect-secrets+word_list \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-detect-secrets-1.5.0-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7af8988b8e857c65753b7a8c15288a1e8ee234e13b47d9ec663edf996d9a9b5e"

URI_x86_64_v2_python3-detect-secrets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-detect-secrets-1.5.0-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-detect-secrets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-detect-secrets}"
SRC_URI[x86_64_v2_python3-detect-secrets.sha256sum] = "5c83ab0d7dca0605327a14cb595216539ffd4f9cade8312b48c1f23ad6b5b0a9"

URI_x86_64_v2_python3-detect-secrets+word_list = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-detect-secrets+word_list-1.5.0-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-detect-secrets+word_list;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-detect-secrets+word_list}"
SRC_URI[x86_64_v2_python3-detect-secrets+word_list.sha256sum] = "97a99b248f2fbd1fe2c7f13b9bd0b732911dfd942b17b4daf0d57f7289513987"

URI_aarch64_python3-detect-secrets = "${EPEL_MIRROR}/aarch64/Packages/p/python3-detect-secrets-1.5.0-7.el10_2.noarch.rpm;name=aarch64_python3-detect-secrets;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-detect-secrets}"
SRC_URI[aarch64_python3-detect-secrets.sha256sum] = "e779f4099092bc0f2319290aa77deb9a29b52969fe4d4687b834c5bab8129469"

URI_aarch64_python3-detect-secrets+word_list = "${EPEL_MIRROR}/aarch64/Packages/p/python3-detect-secrets+word_list-1.5.0-7.el10_2.noarch.rpm;name=aarch64_python3-detect-secrets+word_list;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-detect-secrets+word_list}"
SRC_URI[aarch64_python3-detect-secrets+word_list.sha256sum] = "cd0175fc6d4bbb1955bbeacb02210badda5be1e2a0bbcb076880684a1435525f"

RDEPENDS:python3-detect-secrets = " \
 python3 \
 python3-pyyaml \
 python3-requests \
 "
RDEPENDS:python3-detect-secrets+word_list = " \
 python3 \
 python3-detect-secrets \
 python3-pyahocorasick \
 "
