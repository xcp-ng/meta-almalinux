# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enum-map"
PV = "2.7.3"
PR = "2.el10_0"
PACKAGES = " \
 rust-enum-map+arbitrary-devel \
 rust-enum-map+default-devel \
 rust-enum-map+serde-devel \
 rust-enum-map-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enum-map-2.7.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da90b15f12ec9128aea0a7c392ee3e79145ad74e9a02038f2425778488724683"

URI_x86_64_v2_rust-enum-map+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-map+arbitrary-devel-2.7.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-map+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-map+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-enum-map+arbitrary-devel.sha256sum] = "91fdf34a512f090c973252e5a9cd8cacc9e3d6ea65e0edcbe48e1337c94b348f"

URI_x86_64_v2_rust-enum-map+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-map+default-devel-2.7.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-map+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-map+default-devel}"
SRC_URI[x86_64_v2_rust-enum-map+default-devel.sha256sum] = "c2a5241d2351ca09a563b17158f04614b34fa8abcc28107d427f87d6e5aaf28c"

URI_x86_64_v2_rust-enum-map+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-map+serde-devel-2.7.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-map+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-map+serde-devel}"
SRC_URI[x86_64_v2_rust-enum-map+serde-devel.sha256sum] = "6b7cfd9ed2634204915086f8d0404d8759840f2ab2dd52e98f2eb68f311c5d34"

URI_x86_64_v2_rust-enum-map-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-map-devel-2.7.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-map-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-map-devel}"
SRC_URI[x86_64_v2_rust-enum-map-devel.sha256sum] = "baffd8f22e41931f5d6fef3e6ac9e5d5b2c0f56229a51b86b28e04249aea18c7"

URI_aarch64_rust-enum-map+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-map+arbitrary-devel-2.7.3-2.el10_0.noarch.rpm;name=aarch64_rust-enum-map+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-map+arbitrary-devel}"
SRC_URI[aarch64_rust-enum-map+arbitrary-devel.sha256sum] = "ae6f36145f47e52ed44ee150f35c1572fec8f94574b1820836f991178d81a09b"

URI_aarch64_rust-enum-map+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-map+default-devel-2.7.3-2.el10_0.noarch.rpm;name=aarch64_rust-enum-map+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-map+default-devel}"
SRC_URI[aarch64_rust-enum-map+default-devel.sha256sum] = "9a2f6a20544a2069a6a5907603ed851306eb3abd197ffc76fcc03c06275751e9"

URI_aarch64_rust-enum-map+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-map+serde-devel-2.7.3-2.el10_0.noarch.rpm;name=aarch64_rust-enum-map+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-map+serde-devel}"
SRC_URI[aarch64_rust-enum-map+serde-devel.sha256sum] = "325c30ad5c398e72bc0fe1bf9739592fe7c17bc0165443a74e38859338de9cae"

URI_aarch64_rust-enum-map-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-map-devel-2.7.3-2.el10_0.noarch.rpm;name=aarch64_rust-enum-map-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-map-devel}"
SRC_URI[aarch64_rust-enum-map-devel.sha256sum] = "6840ff33f68fce7c32f610db5b13e7224fe4b25f7ba4e33b58e3a29a6a74b467"

RDEPENDS:rust-enum-map+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-enum-map-devel \
 "
RDEPENDS:rust-enum-map+default-devel = " \
 cargo \
 rust-enum-map-devel \
 "
RDEPENDS:rust-enum-map+serde-devel = " \
 cargo \
 rust-enum-map-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-enum-map-devel = " \
 cargo \
 rust \
 rust-enum-map-derive+default-devel \
 "
