# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dnslib"
PV = "0.9.26"
PR = "1.el10_2"
PACKAGES = " \
 python3-dnslib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-dnslib-0.9.26-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff805a4ad5924cc10bfa36cceeb4ae955e5a8850a73523e0132baeeccdaadc1d"

URI_x86_64_v2_python3-dnslib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dnslib-0.9.26-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dnslib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnslib}"
SRC_URI[x86_64_v2_python3-dnslib.sha256sum] = "cf9d561ae27b451f868e0cdda8af697f7911637df0b870adec08b7455d23562b"

URI_aarch64_python3-dnslib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dnslib-0.9.26-1.el10_2.noarch.rpm;name=aarch64_python3-dnslib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnslib}"
SRC_URI[aarch64_python3-dnslib.sha256sum] = "572961ca0c893b2a6224ee648814f8f98110859cb25eaf102d7b35202471fa62"

RDEPENDS:python3-dnslib = " \
 python3 \
 "
