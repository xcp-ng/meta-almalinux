# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git"
PV = "2.47.3"
PR = "1.el10_0"
PACKAGES = " \
 git \
 git-all \
 git-core \
 git-core-doc \
 git-credential-libsecret \
 git-daemon \
 git-email \
 git-gui \
 git-instaweb \
 git-subtree \
 git-svn \
 gitk \
 gitweb \
 perl-Git \
 perl-Git-SVN \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/git-2.47.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edd4aa82bf84ea4df11700abc7cd0345678773cc7c81166166485f31324bd94c"

URI_x86_64_v2_git = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-2.47.3-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_git;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git}"
SRC_URI[x86_64_v2_git.sha256sum] = "be3360cfafbe8899efe5121b660421c3f6f62d5658c0a99e4a5bb0f430bfa660"

URI_x86_64_v2_git-all = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-all-2.47.3-1.el10_0.noarch.rpm;name=x86_64_v2_git-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-all}"
SRC_URI[x86_64_v2_git-all.sha256sum] = "d18356a77f1c0ea93db48cc41c978d11b621759efb33568d42448ef856940306"

URI_x86_64_v2_git-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-core-2.47.3-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_git-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-core}"
SRC_URI[x86_64_v2_git-core.sha256sum] = "d39f90d1f07abe1b04067332c7edc9f43316ef084afdd605dbadc50e5558f978"

URI_x86_64_v2_git-core-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-core-doc-2.47.3-1.el10_0.noarch.rpm;name=x86_64_v2_git-core-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-core-doc}"
SRC_URI[x86_64_v2_git-core-doc.sha256sum] = "74ec60b957467d9c227b9503693515cf269aeecc5ccd030e1e02e5913c4e2949"

URI_x86_64_v2_git-credential-libsecret = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-credential-libsecret-2.47.3-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_git-credential-libsecret;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-credential-libsecret}"
SRC_URI[x86_64_v2_git-credential-libsecret.sha256sum] = "f820d4df6b2915129acecc82ea49e63ca648e5e1b8cffb9701b848ea507026f8"

URI_x86_64_v2_git-daemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-daemon-2.47.3-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_git-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-daemon}"
SRC_URI[x86_64_v2_git-daemon.sha256sum] = "53a1b2b43d3a5f342f7afd69393c5543587ea12e9d208de673f316babde74f20"

URI_x86_64_v2_git-email = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-email-2.47.3-1.el10_0.noarch.rpm;name=x86_64_v2_git-email;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-email}"
SRC_URI[x86_64_v2_git-email.sha256sum] = "8c6984e7dc61795c0870984cc9f56616b5ea2e74d31d9f795df350e7465cce7f"

URI_x86_64_v2_git-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-gui-2.47.3-1.el10_0.noarch.rpm;name=x86_64_v2_git-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-gui}"
SRC_URI[x86_64_v2_git-gui.sha256sum] = "1ddc3746ab181b75687c192d57a522284b6042b46727713358699f2ed009f147"

URI_x86_64_v2_git-instaweb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-instaweb-2.47.3-1.el10_0.noarch.rpm;name=x86_64_v2_git-instaweb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-instaweb}"
SRC_URI[x86_64_v2_git-instaweb.sha256sum] = "9336710adff149893d5fb11465f959a725fb9a2d4c88e9911f579a3ebad5c4ce"

URI_x86_64_v2_git-subtree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-subtree-2.47.3-1.el10_0.noarch.rpm;name=x86_64_v2_git-subtree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-subtree}"
SRC_URI[x86_64_v2_git-subtree.sha256sum] = "d5cc2602c6b1745bb0817accb8a6f3adf42cd1df35802ccd94f74176f2a92bc4"

URI_x86_64_v2_git-svn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-svn-2.47.3-1.el10_0.noarch.rpm;name=x86_64_v2_git-svn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-svn}"
SRC_URI[x86_64_v2_git-svn.sha256sum] = "d3c0fcf8f98a83aab5ebed395f26b8fedc8742621c9a9c058c90921514c627bb"

URI_x86_64_v2_gitk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gitk-2.47.3-1.el10_0.noarch.rpm;name=x86_64_v2_gitk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gitk}"
SRC_URI[x86_64_v2_gitk.sha256sum] = "45b3df6f789bdd8577a3cda2cabfe33d9d436b67ef01025b46453d25439e4bd1"

URI_x86_64_v2_gitweb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gitweb-2.47.3-1.el10_0.noarch.rpm;name=x86_64_v2_gitweb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gitweb}"
SRC_URI[x86_64_v2_gitweb.sha256sum] = "23d2b1db94ddd27d46c82479a53f3df13c755aac952eb0817e96b4a39b09dc24"

URI_x86_64_v2_perl-Git = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Git-2.47.3-1.el10_0.noarch.rpm;name=x86_64_v2_perl-Git;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Git}"
SRC_URI[x86_64_v2_perl-Git.sha256sum] = "934646f94c5315391d63ca73fefc0531bff234037a9006f559229915493a9f09"

URI_x86_64_v2_perl-Git-SVN = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Git-SVN-2.47.3-1.el10_0.noarch.rpm;name=x86_64_v2_perl-Git-SVN;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Git-SVN}"
SRC_URI[x86_64_v2_perl-Git-SVN.sha256sum] = "21b6dc7fbfc8c031a7a3b2b04927bbfcbdcbd090ccc316f89472284e816bda72"

URI_aarch64_git = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-2.47.3-1.el10_0.aarch64.rpm;name=aarch64_git;unpack=0"
SRC_URI:append = " ${URI_aarch64_git}"
SRC_URI[aarch64_git.sha256sum] = "ffdee8201fa49a710da4659bf1b70b9967fa50e595c2a372ed9b787c70c055e6"

URI_aarch64_git-all = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-all-2.47.3-1.el10_0.noarch.rpm;name=aarch64_git-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-all}"
SRC_URI[aarch64_git-all.sha256sum] = "d18356a77f1c0ea93db48cc41c978d11b621759efb33568d42448ef856940306"

URI_aarch64_git-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-core-2.47.3-1.el10_0.aarch64.rpm;name=aarch64_git-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-core}"
SRC_URI[aarch64_git-core.sha256sum] = "65ce03bb453c6892017682c3c6952e249f27710bdfed0d886a8b8dee13343bdd"

URI_aarch64_git-core-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-core-doc-2.47.3-1.el10_0.noarch.rpm;name=aarch64_git-core-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-core-doc}"
SRC_URI[aarch64_git-core-doc.sha256sum] = "74ec60b957467d9c227b9503693515cf269aeecc5ccd030e1e02e5913c4e2949"

URI_aarch64_git-credential-libsecret = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-credential-libsecret-2.47.3-1.el10_0.aarch64.rpm;name=aarch64_git-credential-libsecret;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-credential-libsecret}"
SRC_URI[aarch64_git-credential-libsecret.sha256sum] = "35f2f8ef0c8cbee0b7e471e79137d201d8905bd839ced8deb01ccedc92f191e0"

URI_aarch64_git-daemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-daemon-2.47.3-1.el10_0.aarch64.rpm;name=aarch64_git-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-daemon}"
SRC_URI[aarch64_git-daemon.sha256sum] = "b612059af88c92336d2a0fc37aae1ca190910e0fcb4cea045215b374ba512101"

URI_aarch64_git-email = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-email-2.47.3-1.el10_0.noarch.rpm;name=aarch64_git-email;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-email}"
SRC_URI[aarch64_git-email.sha256sum] = "8c6984e7dc61795c0870984cc9f56616b5ea2e74d31d9f795df350e7465cce7f"

URI_aarch64_git-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-gui-2.47.3-1.el10_0.noarch.rpm;name=aarch64_git-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-gui}"
SRC_URI[aarch64_git-gui.sha256sum] = "1ddc3746ab181b75687c192d57a522284b6042b46727713358699f2ed009f147"

URI_aarch64_git-instaweb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-instaweb-2.47.3-1.el10_0.noarch.rpm;name=aarch64_git-instaweb;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-instaweb}"
SRC_URI[aarch64_git-instaweb.sha256sum] = "9336710adff149893d5fb11465f959a725fb9a2d4c88e9911f579a3ebad5c4ce"

URI_aarch64_git-subtree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-subtree-2.47.3-1.el10_0.noarch.rpm;name=aarch64_git-subtree;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-subtree}"
SRC_URI[aarch64_git-subtree.sha256sum] = "d5cc2602c6b1745bb0817accb8a6f3adf42cd1df35802ccd94f74176f2a92bc4"

URI_aarch64_git-svn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-svn-2.47.3-1.el10_0.noarch.rpm;name=aarch64_git-svn;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-svn}"
SRC_URI[aarch64_git-svn.sha256sum] = "d3c0fcf8f98a83aab5ebed395f26b8fedc8742621c9a9c058c90921514c627bb"

URI_aarch64_gitk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gitk-2.47.3-1.el10_0.noarch.rpm;name=aarch64_gitk;unpack=0"
SRC_URI:append = " ${URI_aarch64_gitk}"
SRC_URI[aarch64_gitk.sha256sum] = "45b3df6f789bdd8577a3cda2cabfe33d9d436b67ef01025b46453d25439e4bd1"

URI_aarch64_gitweb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gitweb-2.47.3-1.el10_0.noarch.rpm;name=aarch64_gitweb;unpack=0"
SRC_URI:append = " ${URI_aarch64_gitweb}"
SRC_URI[aarch64_gitweb.sha256sum] = "23d2b1db94ddd27d46c82479a53f3df13c755aac952eb0817e96b4a39b09dc24"

URI_aarch64_perl-Git = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Git-2.47.3-1.el10_0.noarch.rpm;name=aarch64_perl-Git;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Git}"
SRC_URI[aarch64_perl-Git.sha256sum] = "934646f94c5315391d63ca73fefc0531bff234037a9006f559229915493a9f09"

URI_aarch64_perl-Git-SVN = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Git-SVN-2.47.3-1.el10_0.noarch.rpm;name=aarch64_perl-Git-SVN;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Git-SVN}"
SRC_URI[aarch64_perl-Git-SVN.sha256sum] = "21b6dc7fbfc8c031a7a3b2b04927bbfcbdcbd090ccc316f89472284e816bda72"

RDEPENDS:git = " \
 bash \
 git-core \
 git-core-doc \
 perl-File-Basename \
 perl-File-Find \
 perl-Getopt-Long \
 perl-Git \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-TermReadKey \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
RDEPENDS:git-all = " \
 git \
 git-credential-libsecret \
 git-daemon \
 git-email \
 git-gui \
 git-instaweb \
 git-subtree \
 git-svn \
 gitk \
 perl-Git \
 perl-TermReadKey \
 "
RDEPENDS:git-core = " \
 bash \
 expat \
 glibc \
 less \
 openssh-clients \
 openssl-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:git-core-doc = " \
 git-core \
 "
RDEPENDS:git-credential-libsecret = " \
 git \
 glib2 \
 glibc \
 libsecret \
 "
RDEPENDS:git-daemon = " \
 bash \
 git-core \
 glibc \
 pcre2 \
 systemd \
 zlib-ng-compat \
 "
RDEPENDS:git-email = " \
 git \
 perl-Authen-SASL \
 perl-Error \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Git \
 perl-IO-Socket-SSL \
 perl-MIME-Base64 \
 perl-MailTools \
 perl-Net-SMTP-SSL \
 perl-POSIX \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Term-ReadLine \
 perl-Text-ParseWords \
 perl-interpreter \
 perl-lib \
 perl-libnet \
 perl-libs \
 "
RDEPENDS:git-gui = " \
 bash \
 gitk \
 tk \
 "
RDEPENDS:git-instaweb = " \
 bash \
 git \
 gitweb \
 httpd \
 "
RDEPENDS:git-subtree = " \
 bash \
 git-core \
 "
RDEPENDS:git-svn = " \
 git \
 perl-Carp \
 perl-Digest-MD5 \
 perl-File-Basename \
 perl-File-Path \
 perl-Getopt-Long \
 perl-Git \
 perl-Git-SVN \
 perl-Memoize \
 perl-PathTools \
 perl-TermReadKey \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 subversion \
 "
RDEPENDS:gitk = " \
 bash \
 git \
 git-gui \
 tk \
 "
RDEPENDS:gitweb = " \
 git \
 perl-CGI \
 perl-Digest-MD5 \
 perl-Encode \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Find \
 perl-Time-HiRes \
 perl-constant \
 perl-filetest \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-Git = " \
 git \
 perl-Error \
 perl-Exporter \
 perl-Git \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Git-SVN = " \
 git \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Path \
 perl-Git \
 perl-IPC-Open3 \
 perl-Memoize \
 perl-POSIX \
 perl-Storable \
 perl-Time-Local \
 perl-YAML \
 perl-base \
 perl-constant \
 perl-libs \
 perl-vars \
 subversion-perl \
 "
