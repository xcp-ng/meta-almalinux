# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-slab"
PV = "0.4.12"
PR = "1.el10_2"
PACKAGES = " \
 rust-slab+default-devel \
 rust-slab+serde-devel \
 rust-slab+std-devel \
 rust-slab-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-slab-0.4.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c551601c660741774536dfb75998f945b3004884fc1c9c7a1b1a645c38cc767"

URI_x86_64_v2_rust-slab+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slab+default-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slab+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slab+default-devel}"
SRC_URI[x86_64_v2_rust-slab+default-devel.sha256sum] = "55d89abf9bc6429f37750f83123c88596bc4db96d53e8c3675a52fbcfe460f8d"

URI_x86_64_v2_rust-slab+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slab+serde-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slab+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slab+serde-devel}"
SRC_URI[x86_64_v2_rust-slab+serde-devel.sha256sum] = "eb7d201122970fd767e5616f70f1d96dfde9306a71d1e9395787caf997c2c9ba"

URI_x86_64_v2_rust-slab+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slab+std-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slab+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slab+std-devel}"
SRC_URI[x86_64_v2_rust-slab+std-devel.sha256sum] = "5d5c18ab3607dc958b35e05894c862e8b4a51bf34d904e8fea6b15a2eb4a173e"

URI_x86_64_v2_rust-slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slab-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slab-devel}"
SRC_URI[x86_64_v2_rust-slab-devel.sha256sum] = "1c0cbbe50ab30ce1a9fc0246c6b2190f24561b5671293ac274e8c1071ef26d78"

URI_aarch64_rust-slab+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slab+default-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-slab+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slab+default-devel}"
SRC_URI[aarch64_rust-slab+default-devel.sha256sum] = "6027b927b32b4df984aa58afcdb36d1386ecbbeaef2b7a6f45b190df1143e5eb"

URI_aarch64_rust-slab+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slab+serde-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-slab+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slab+serde-devel}"
SRC_URI[aarch64_rust-slab+serde-devel.sha256sum] = "8573221f0eeeadf7a97377c5028f628ab3fde26f203a46821de94c9e7088d46f"

URI_aarch64_rust-slab+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slab+std-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-slab+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slab+std-devel}"
SRC_URI[aarch64_rust-slab+std-devel.sha256sum] = "c67ebe46840434e74435218d61de0b11e725eae8fb5b74c932c215072e0fcf0d"

URI_aarch64_rust-slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slab-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slab-devel}"
SRC_URI[aarch64_rust-slab-devel.sha256sum] = "a309945c33070e44125fc0c5da0964124162a9ca67ccd6a066a4004c1f9dc011"

RDEPENDS:rust-slab+default-devel = " \
 cargo \
 rust-slab+std-devel \
 rust-slab-devel \
 "
RDEPENDS:rust-slab+serde-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-slab-devel \
 "
RDEPENDS:rust-slab+std-devel = " \
 cargo \
 rust-slab-devel \
 "
RDEPENDS:rust-slab-devel = " \
 cargo \
 rust \
 "
