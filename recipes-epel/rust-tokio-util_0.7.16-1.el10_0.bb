# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-util"
PV = "0.7.16"
PR = "1.el10_0"
PACKAGES = " \
 rust-tokio-util+codec-devel \
 rust-tokio-util+compat-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+full-devel \
 rust-tokio-util+futures-io-devel \
 rust-tokio-util+futures-util-devel \
 rust-tokio-util+hashbrown-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util+io-util-devel \
 rust-tokio-util+join-map-devel \
 rust-tokio-util+net-devel \
 rust-tokio-util+rt-devel \
 rust-tokio-util+slab-devel \
 rust-tokio-util+time-devel \
 rust-tokio-util+tracing-devel \
 rust-tokio-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-util-0.7.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a2306252efce2c60197a5734169bc89593683070eac61dedeac1bb950f74f74"

URI_x86_64_v2_rust-tokio-util+codec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+codec-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+codec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+codec-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+codec-devel.sha256sum] = "f13bb2e0be1b2df2e5164c1cb53ba6956a3ba49b3a5ceb2cab5d74c18d8a4942"

URI_x86_64_v2_rust-tokio-util+compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+compat-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+compat-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+compat-devel.sha256sum] = "081ff95a9534ecaf519ef6d5561d8d788253847dd81d8de84703ae6f2b040097"

URI_x86_64_v2_rust-tokio-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+default-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+default-devel.sha256sum] = "52cd485b9d62bce848e6c5ccc45709c1e1bda24f836532159b14710dd420a71b"

URI_x86_64_v2_rust-tokio-util+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+full-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+full-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+full-devel.sha256sum] = "9b5bbcfc4242b84b05154274a6358b9f5c2c565cb5201351c62707f7caa9292b"

URI_x86_64_v2_rust-tokio-util+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+futures-io-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+futures-io-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+futures-io-devel.sha256sum] = "97fef637318bac1b97b9c18a2f70720770f7a0bdf0a00550096c8d1cf2f29a0c"

URI_x86_64_v2_rust-tokio-util+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+futures-util-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+futures-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+futures-util-devel.sha256sum] = "6b121034fd06d1dc2757889ea3ae40500ab687bb2b485cba162f5010dfbbf0bb"

URI_x86_64_v2_rust-tokio-util+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+hashbrown-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+hashbrown-devel.sha256sum] = "bc62599e8f408e5b7044c2d0dc49cfe772888204936e7c722fabccbe6682163b"

URI_x86_64_v2_rust-tokio-util+io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+io-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+io-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+io-devel.sha256sum] = "31b140767fa5e6b49c945b27f245006557222a95f78f2e9dd990646a8cba879f"

URI_x86_64_v2_rust-tokio-util+io-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+io-util-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+io-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+io-util-devel.sha256sum] = "581bc8dde99e5bb2099b1fdc9b0638568000b51b72ac3a9c0cce010ea4413158"

URI_x86_64_v2_rust-tokio-util+join-map-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+join-map-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+join-map-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+join-map-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+join-map-devel.sha256sum] = "fca197b92b313f34f85b13f93fba4f828d6f0dc788059f3b1390475efbca3938"

URI_x86_64_v2_rust-tokio-util+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+net-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+net-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+net-devel.sha256sum] = "654cfc8becf7cdc19ab4159539231ada598f447a1f7618b6359dba35c9dd3ddb"

URI_x86_64_v2_rust-tokio-util+rt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+rt-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+rt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+rt-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+rt-devel.sha256sum] = "a6eef6f94aa6f3b887953d4b5c860e78455949f4f3698c208d2c032c1d975490"

URI_x86_64_v2_rust-tokio-util+slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+slab-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+slab-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+slab-devel.sha256sum] = "3dd7dfb16bdf58b98d23f5b0905c0ccbd7fd15caa892aa170fdbe9d61fa6f924"

URI_x86_64_v2_rust-tokio-util+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+time-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+time-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+time-devel.sha256sum] = "e8650a1f8a7204cae8506c74c165a8fe0f08c4c05a020cb46eec2d902af16fd2"

URI_x86_64_v2_rust-tokio-util+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+tracing-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+tracing-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+tracing-devel.sha256sum] = "b357a09466ef781511477c485a5f2b658f6bbf0c4b42e61be0d6af1447e9d743"

URI_x86_64_v2_rust-tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util-devel-0.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-util-devel.sha256sum] = "5dee2821cfe9737728e8b777f99d367aaab15e7fbda558cc1e44a2ea45f9d065"

URI_aarch64_rust-tokio-util+codec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+codec-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+codec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+codec-devel}"
SRC_URI[aarch64_rust-tokio-util+codec-devel.sha256sum] = "16766c4772274f95e07cbdc59965e6a00921642a4f329be6f168d2ea3118c39e"

URI_aarch64_rust-tokio-util+compat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+compat-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+compat-devel}"
SRC_URI[aarch64_rust-tokio-util+compat-devel.sha256sum] = "cac0555e0523b8aa383e4fdcf2244d4bfeb847ab220571e407387ba7e821a89d"

URI_aarch64_rust-tokio-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+default-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+default-devel}"
SRC_URI[aarch64_rust-tokio-util+default-devel.sha256sum] = "b80c29d9285bba17b7478a08381cd373298363492e9645e6a35f301841fe6e33"

URI_aarch64_rust-tokio-util+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+full-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+full-devel}"
SRC_URI[aarch64_rust-tokio-util+full-devel.sha256sum] = "b17a2353ee5f022d300201b9e7516b5259fe2a0990210efdb9b664a88d3ad324"

URI_aarch64_rust-tokio-util+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+futures-io-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+futures-io-devel}"
SRC_URI[aarch64_rust-tokio-util+futures-io-devel.sha256sum] = "6c48d728c1d79da421aa598b191ee777e686134a95ded4acd6e4bae3c46b13e4"

URI_aarch64_rust-tokio-util+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+futures-util-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+futures-util-devel}"
SRC_URI[aarch64_rust-tokio-util+futures-util-devel.sha256sum] = "934ae001e1ee9637a59a9f008f13de0166e6101d7ffb8a0e78015c129d321319"

URI_aarch64_rust-tokio-util+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+hashbrown-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+hashbrown-devel}"
SRC_URI[aarch64_rust-tokio-util+hashbrown-devel.sha256sum] = "aba111a121bd304fcf3de1c386d64be7c3851747d833867536767178938dd47a"

URI_aarch64_rust-tokio-util+io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+io-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+io-devel}"
SRC_URI[aarch64_rust-tokio-util+io-devel.sha256sum] = "1bc7bf998c42d95149b6536f446c88d3841706444f41d8b70335c76d4903d642"

URI_aarch64_rust-tokio-util+io-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+io-util-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+io-util-devel}"
SRC_URI[aarch64_rust-tokio-util+io-util-devel.sha256sum] = "17a482718f05d0e3b711e97729fff6ef3e9b577a55c996e453e67b91d993f6c7"

URI_aarch64_rust-tokio-util+join-map-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+join-map-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+join-map-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+join-map-devel}"
SRC_URI[aarch64_rust-tokio-util+join-map-devel.sha256sum] = "4f494babb4644b4c76b143573aad8205370f201d78566769b53a0193e60e70fd"

URI_aarch64_rust-tokio-util+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+net-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+net-devel}"
SRC_URI[aarch64_rust-tokio-util+net-devel.sha256sum] = "8b502585b1c59bc3d28e15d4c624ad777532c36679185822f1ce993fd68a5808"

URI_aarch64_rust-tokio-util+rt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+rt-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+rt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+rt-devel}"
SRC_URI[aarch64_rust-tokio-util+rt-devel.sha256sum] = "5fc4a20902d8097a22724c992f243cbc232f19f086c59f2a8bf6192a1ba9da16"

URI_aarch64_rust-tokio-util+slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+slab-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+slab-devel}"
SRC_URI[aarch64_rust-tokio-util+slab-devel.sha256sum] = "ba06f02b22eced11a25756fcf84565c6c3b7cdea5e68eb07b5d7442756880a76"

URI_aarch64_rust-tokio-util+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+time-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+time-devel}"
SRC_URI[aarch64_rust-tokio-util+time-devel.sha256sum] = "2b80bd11cd107c01e3b1d232f166ee5e86b032499f13c92810c66442cc203666"

URI_aarch64_rust-tokio-util+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+tracing-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+tracing-devel}"
SRC_URI[aarch64_rust-tokio-util+tracing-devel.sha256sum] = "4fe3f2cf191165ac9177fab95dbb894e40a495bf95def0a1c694fde647cc2db3"

URI_aarch64_rust-tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util-devel-0.7.16-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util-devel}"
SRC_URI[aarch64_rust-tokio-util-devel.sha256sum] = "ab3ea166fc8cd8c6aba1006f4b57dafaf75d5e7de6dc3004f4edd9f71741c26d"

RDEPENDS:rust-tokio-util+codec-devel = " \
 cargo \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+compat-devel = " \
 cargo \
 rust-tokio-util+futures-io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+default-devel = " \
 cargo \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+full-devel = " \
 cargo \
 rust-tokio-util+codec-devel \
 rust-tokio-util+compat-devel \
 rust-tokio-util+io-util-devel \
 rust-tokio-util+join-map-devel \
 rust-tokio-util+net-devel \
 rust-tokio-util+rt-devel \
 rust-tokio-util+time-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+futures-util-devel = " \
 cargo \
 rust-futures-util+default-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+hashbrown-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+io-devel = " \
 cargo \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+io-util-devel = " \
 cargo \
 rust-tokio+io-util-devel \
 rust-tokio+rt-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+join-map-devel = " \
 cargo \
 rust-tokio-util+hashbrown-devel \
 rust-tokio-util+rt-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+net-devel = " \
 cargo \
 rust-tokio+net-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+rt-devel = " \
 cargo \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio-util+futures-util-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+slab-devel = " \
 cargo \
 rust-slab+default-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+time-devel = " \
 cargo \
 rust-tokio+time-devel \
 rust-tokio-util+slab-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+tracing-devel = " \
 cargo \
 rust-tokio-util-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tokio-util-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-futures-core+default-devel \
 rust-futures-sink+default-devel \
 rust-pin-project-lite+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
