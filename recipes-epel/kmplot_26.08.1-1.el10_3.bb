# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmplot"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kmplot \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmplot-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4b609fe3863ce48caad1a72ffa4501df9dbcc0b7c1adae965f12e2d8046b28e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmplot-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmplot;unpack=0"
SRC_URI[x86_64_v2_kmplot.sha256sum] = "418617052339762349020452cfc42cc48dfc8ae74bfd6bfb8c5cfca3c54aa853"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmplot-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kmplot;unpack=0"
SRC_URI[aarch64_kmplot.sha256sum] = "472564b34845f2615a8dc0e66c21d1ed81e7a3d2703d335ebd458deca2c1c4b8"

RDEPENDS:kmplot = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
