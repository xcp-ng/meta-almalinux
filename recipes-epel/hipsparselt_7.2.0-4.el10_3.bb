# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipsparselt"
PV = "7.2.0"
PR = "4.el10_3"
PACKAGES:x86_64_v2 = " \
 hipsparselt \
 hipsparselt-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipsparselt-7.2.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "498664b846f1b100ba95aa244f9210810b73d7fa7119febd70b293fd40b26292"

URI_x86_64_v2_hipsparselt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsparselt-7.2.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsparselt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsparselt}"
SRC_URI[x86_64_v2_hipsparselt.sha256sum] = "26f10bf91e02d310ed964b842a3123917d678da7bb87ddb4eb45ab786c6a5fbb"

URI_x86_64_v2_hipsparselt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsparselt-devel-7.2.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsparselt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsparselt-devel}"
SRC_URI[x86_64_v2_hipsparselt-devel.sha256sum] = "6b0576a953a468bdb3a994210f2c3e470757b06c0d3e6a303b869f7617f704a7"

RDEPENDS:hipsparselt = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 rocm-origami \
 roctracer \
 "
RDEPENDS:hipsparselt-devel = " \
 cmake-filesystem \
 hipsparselt \
 "
