# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libz-sys"
PV = "1.1.22"
PR = "1.el10_0"
PACKAGES = " \
 rust-libz-sys+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys+stock-zlib-devel \
 rust-libz-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libz-sys-1.1.22-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "deae19cae832b0e017bbe58820a1d3bfd5fe7967794f5aee54027fdaed19a622"

URI_x86_64_v2_rust-libz-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys+default-devel-1.1.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libz-sys+default-devel.sha256sum] = "6f9ba25e373e3b79b3f8791699113977982b75227a447f3b3f64dc4f1c381f56"

URI_x86_64_v2_rust-libz-sys+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys+libc-devel-1.1.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-sys+libc-devel}"
SRC_URI[x86_64_v2_rust-libz-sys+libc-devel.sha256sum] = "2f11f379b964d6b0d99ff01f8a50e752adb0d968846a6faa7eb9584fdd9181e3"

URI_x86_64_v2_rust-libz-sys+stock-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys+stock-zlib-devel-1.1.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys+stock-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-sys+stock-zlib-devel}"
SRC_URI[x86_64_v2_rust-libz-sys+stock-zlib-devel.sha256sum] = "e09d881bc293cf3d3cb34f99857af61eeefd0ab824ffa582212a2bca5587d092"

URI_x86_64_v2_rust-libz-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys-devel-1.1.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-sys-devel}"
SRC_URI[x86_64_v2_rust-libz-sys-devel.sha256sum] = "cc6adecc98b26a83c6929edba85033c9b975d91b36c4b96f658704c3a9195248"

URI_aarch64_rust-libz-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys+default-devel-1.1.22-1.el10_0.noarch.rpm;name=aarch64_rust-libz-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-sys+default-devel}"
SRC_URI[aarch64_rust-libz-sys+default-devel.sha256sum] = "8c13bd172f4ce0e8f46794523856e8f5281d08527c8570141e2abaeaaa83ceb2"

URI_aarch64_rust-libz-sys+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys+libc-devel-1.1.22-1.el10_0.noarch.rpm;name=aarch64_rust-libz-sys+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-sys+libc-devel}"
SRC_URI[aarch64_rust-libz-sys+libc-devel.sha256sum] = "dbe09bc6850b4df8d075e9116a987b39755107a9620e2f7726a7fa5513f8bc42"

URI_aarch64_rust-libz-sys+stock-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys+stock-zlib-devel-1.1.22-1.el10_0.noarch.rpm;name=aarch64_rust-libz-sys+stock-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-sys+stock-zlib-devel}"
SRC_URI[aarch64_rust-libz-sys+stock-zlib-devel.sha256sum] = "757569517497617038925490c23877cc2a9965051cc003c7861ebeb0c2cc317d"

URI_aarch64_rust-libz-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys-devel-1.1.22-1.el10_0.noarch.rpm;name=aarch64_rust-libz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-sys-devel}"
SRC_URI[aarch64_rust-libz-sys-devel.sha256sum] = "16353a7848415be082664937de6b2bba43f6a84cbdf426afad301e0840f74f8a"

RDEPENDS:rust-libz-sys+default-devel = " \
 cargo \
 rust-libz-sys+libc-devel \
 rust-libz-sys+stock-zlib-devel \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-libz-sys+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-libz-sys+stock-zlib-devel = " \
 cargo \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-libz-sys-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-pkg-config+default-devel \
 zlib-ng-compat-devel \
 "
