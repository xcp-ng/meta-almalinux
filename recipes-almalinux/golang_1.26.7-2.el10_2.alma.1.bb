# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang"
PV = "1.26.7"
PR = "2.el10_2.alma.1"
PACKAGES = " \
 go-toolset \
 golang \
 golang-bin \
 golang-docs \
 golang-misc \
 golang-race \
 golang-src \
 golang-tests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/golang-1.26.7-2.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7704b05cd9ca5451ad0ff369f1500b60ec1a2ebecbca49b14898edef3d85e12b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-toolset-1.26.7-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_go-toolset;unpack=0"
SRC_URI[x86_64_v2_go-toolset.sha256sum] = "dd3008357020ca31c520b0f3eb2790ede47aad34e77d0f2a68bb1492109a4c9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-1.26.7-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang;unpack=0"
SRC_URI[x86_64_v2_golang.sha256sum] = "4753564fbf75c773aa42214a7f8f983ca2af1835c575adfddef8155d214e6dd2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-bin-1.26.7-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang-bin;unpack=0"
SRC_URI[x86_64_v2_golang-bin.sha256sum] = "088ad2ec66874cb0bdebec645ba8b2cace1b00e26822cad5f4248b0a8cb9930a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-docs-1.26.7-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_golang-docs;unpack=0"
SRC_URI[x86_64_v2_golang-docs.sha256sum] = "98815341eb7c92ee93fedb4d2cd0042267c76b4248fbd8926f9047e2d4194cf1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-misc-1.26.7-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_golang-misc;unpack=0"
SRC_URI[x86_64_v2_golang-misc.sha256sum] = "543c442cbab6042f02f887fd7221682258dbfd4b3c48a757c661504d76e35b5a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-race-1.26.7-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang-race;unpack=0"
SRC_URI[x86_64_v2_golang-race.sha256sum] = "205869c367745fcc2eaf8eec9f90c24d609091beaab8c571e330f1f57eb543ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-src-1.26.7-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_golang-src;unpack=0"
SRC_URI[x86_64_v2_golang-src.sha256sum] = "f8ff38bd0f0facf6cafab19b087b0b33a9463732fe64c6d30c57d7961163b1a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-tests-1.26.7-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_golang-tests;unpack=0"
SRC_URI[x86_64_v2_golang-tests.sha256sum] = "770491058a1341cf44600394a56cfc60861fcca5a03dcfbf3ed1d3a468f3c4b4"
RPROVIDES:golang-tests:append:x86_64_v2 = " virtual/libtiffxx.so.6___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-toolset-1.26.7-2.el10_2.alma.1.aarch64.rpm;name=aarch64_go-toolset;unpack=0"
SRC_URI[aarch64_go-toolset.sha256sum] = "575a50c55b4bb47aef6a7c71a51ac70aab31ae5f319366a100781de0bd546714"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-1.26.7-2.el10_2.alma.1.aarch64.rpm;name=aarch64_golang;unpack=0"
SRC_URI[aarch64_golang.sha256sum] = "d68641cdd1966b2d58007e53b3975f666670ba3b1f017bd684985d24214356fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-bin-1.26.7-2.el10_2.alma.1.aarch64.rpm;name=aarch64_golang-bin;unpack=0"
SRC_URI[aarch64_golang-bin.sha256sum] = "0de527d310935ee554955e2c415b6b2cc0f6edf6722c8680cc821fbdab5056b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-docs-1.26.7-2.el10_2.alma.1.noarch.rpm;name=aarch64_golang-docs;unpack=0"
SRC_URI[aarch64_golang-docs.sha256sum] = "98815341eb7c92ee93fedb4d2cd0042267c76b4248fbd8926f9047e2d4194cf1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-misc-1.26.7-2.el10_2.alma.1.noarch.rpm;name=aarch64_golang-misc;unpack=0"
SRC_URI[aarch64_golang-misc.sha256sum] = "543c442cbab6042f02f887fd7221682258dbfd4b3c48a757c661504d76e35b5a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-race-1.26.7-2.el10_2.alma.1.aarch64.rpm;name=aarch64_golang-race;unpack=0"
SRC_URI[aarch64_golang-race.sha256sum] = "7a8a9931a4be75f15288a03e10e00932efecd52d804abad26ace939c71beaf19"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-src-1.26.7-2.el10_2.alma.1.noarch.rpm;name=aarch64_golang-src;unpack=0"
SRC_URI[aarch64_golang-src.sha256sum] = "f8ff38bd0f0facf6cafab19b087b0b33a9463732fe64c6d30c57d7961163b1a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-tests-1.26.7-2.el10_2.alma.1.noarch.rpm;name=aarch64_golang-tests;unpack=0"
SRC_URI[aarch64_golang-tests.sha256sum] = "770491058a1341cf44600394a56cfc60861fcca5a03dcfbf3ed1d3a468f3c4b4"
RPROVIDES:golang-tests:append:aarch64 = " virtual/libtiffxx.so.6___64bit_"

RDEPENDS:go-toolset = " \
 delve \
 golang \
 "
RDEPENDS:golang = " \
 golang-bin \
 golang-race \
 golang-src \
 openssl-devel \
 "
RDEPENDS:golang-bin = " \
 alternatives \
 bash \
 gcc \
 glibc \
 golang \
 "
RDEPENDS:golang-docs = " \
 golang \
 "
RDEPENDS:golang-misc = " \
 golang \
 "
RDEPENDS:golang-race = " \
 golang \
 "
RDEPENDS:golang-src = " \
 "
RDEPENDS:golang-tests = " \
 golang \
 "
