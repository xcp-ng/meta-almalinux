# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-compression"
PV = "0.4.19"
PR = "1.el10_1"
PACKAGES = " \
 rust-async-compression+all-algorithms-devel \
 rust-async-compression+all-devel \
 rust-async-compression+all-implementations-devel \
 rust-async-compression+brotli-devel \
 rust-async-compression+bzip2-devel \
 rust-async-compression+default-devel \
 rust-async-compression+deflate-devel \
 rust-async-compression+deflate64-devel \
 rust-async-compression+flate2-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression+gzip-devel \
 rust-async-compression+libzstd-devel \
 rust-async-compression+lzma-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+xz-devel \
 rust-async-compression+xz2-devel \
 rust-async-compression+zlib-devel \
 rust-async-compression+zstd-devel \
 rust-async-compression+zstd-safe-devel \
 rust-async-compression+zstdmt-devel \
 rust-async-compression-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-compression-0.4.19-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d29fee35cb1f2b3ef8ef1c5a9a32898220489ff9d5fdac47a84e41452a5f715f"

URI_x86_64_v2_rust-async-compression+all-algorithms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+all-algorithms-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+all-algorithms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+all-algorithms-devel}"
SRC_URI[x86_64_v2_rust-async-compression+all-algorithms-devel.sha256sum] = "22d250424b33e2986f7cea66dba2b50f28910b7851c435dcde07e752c5ed3b12"

URI_x86_64_v2_rust-async-compression+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+all-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+all-devel}"
SRC_URI[x86_64_v2_rust-async-compression+all-devel.sha256sum] = "2646998ef15a2bf48fefbcb22e7e0c46a657c2add8bf746c04a7765a6d1dfa45"

URI_x86_64_v2_rust-async-compression+all-implementations-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+all-implementations-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+all-implementations-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+all-implementations-devel}"
SRC_URI[x86_64_v2_rust-async-compression+all-implementations-devel.sha256sum] = "414da02b5817150564f8a6c82b609eb825dc894e65a0e93a3e38cbd8be282ebd"

URI_x86_64_v2_rust-async-compression+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+brotli-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+brotli-devel}"
SRC_URI[x86_64_v2_rust-async-compression+brotli-devel.sha256sum] = "3582ecf3e1803d086584d156042dd775b0c3b2d7f14ff37904dfd22063ecee08"

URI_x86_64_v2_rust-async-compression+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+bzip2-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+bzip2-devel}"
SRC_URI[x86_64_v2_rust-async-compression+bzip2-devel.sha256sum] = "279ced8f2b15a4e512692497d24075a5d8fb65889b894962c9bbf432b9c38e12"

URI_x86_64_v2_rust-async-compression+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+default-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+default-devel}"
SRC_URI[x86_64_v2_rust-async-compression+default-devel.sha256sum] = "05902ce86bb8e0eb07fed9bda99721559a164634dd8031008323e075075d536b"

URI_x86_64_v2_rust-async-compression+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+deflate-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+deflate-devel}"
SRC_URI[x86_64_v2_rust-async-compression+deflate-devel.sha256sum] = "542c226ed5aa33d21f71df81ad7afd8cb3a1966b4f7d51e9f33e2f07496338d9"

URI_x86_64_v2_rust-async-compression+deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+deflate64-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+deflate64-devel}"
SRC_URI[x86_64_v2_rust-async-compression+deflate64-devel.sha256sum] = "4279c5a6e9a3c057fff958dd07fa414ad62227cc5d16f507cff955e85431dc5f"

URI_x86_64_v2_rust-async-compression+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+flate2-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+flate2-devel}"
SRC_URI[x86_64_v2_rust-async-compression+flate2-devel.sha256sum] = "08fd90a6bac661fdd43634f87b9abce4b32900dd2b1b7604360a0ac3082d0f9f"

URI_x86_64_v2_rust-async-compression+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+futures-io-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+futures-io-devel}"
SRC_URI[x86_64_v2_rust-async-compression+futures-io-devel.sha256sum] = "b6590eaf8b26b0575d578061fb2aabe05921a16f137ae402b5af284cf6d18943"

URI_x86_64_v2_rust-async-compression+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+gzip-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+gzip-devel}"
SRC_URI[x86_64_v2_rust-async-compression+gzip-devel.sha256sum] = "7d9b68c69daa05edd2604ed3bdad5543f617d1fb9bdee06a33fb71680da26469"

URI_x86_64_v2_rust-async-compression+libzstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+libzstd-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+libzstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+libzstd-devel}"
SRC_URI[x86_64_v2_rust-async-compression+libzstd-devel.sha256sum] = "41e0618bc7b89129ad694c4ee81436637e9a3ca231839c1c781904b94fa6cc81"

URI_x86_64_v2_rust-async-compression+lzma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+lzma-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+lzma-devel}"
SRC_URI[x86_64_v2_rust-async-compression+lzma-devel.sha256sum] = "f47dca7d75b7e3e4efcccb1aab461465f33214128e334e63e9a89e0e303a59a5"

URI_x86_64_v2_rust-async-compression+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+tokio-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+tokio-devel}"
SRC_URI[x86_64_v2_rust-async-compression+tokio-devel.sha256sum] = "d0ca5a595bffe614c862111062a265e24f772ee879779adb70d2a05d4c0b130e"

URI_x86_64_v2_rust-async-compression+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+xz-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+xz-devel}"
SRC_URI[x86_64_v2_rust-async-compression+xz-devel.sha256sum] = "4f477c2944f0b45e1a00daf3bfb07303efe75018bbb249e4613c672740cc6a6b"

URI_x86_64_v2_rust-async-compression+xz2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+xz2-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+xz2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+xz2-devel}"
SRC_URI[x86_64_v2_rust-async-compression+xz2-devel.sha256sum] = "ecdf36be5d331c79c4b4ccf80105d93a03a2253e42a4e7df52bc26134744787f"

URI_x86_64_v2_rust-async-compression+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+zlib-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+zlib-devel}"
SRC_URI[x86_64_v2_rust-async-compression+zlib-devel.sha256sum] = "e89cfa470471ab19e13bdad600938fa94bbbc7da16da58eae5900d3e4dde9036"

URI_x86_64_v2_rust-async-compression+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+zstd-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+zstd-devel}"
SRC_URI[x86_64_v2_rust-async-compression+zstd-devel.sha256sum] = "e80866e6422001079a910612030059fb3b4211288d8680af1d75b4bf4bdb11f7"

URI_x86_64_v2_rust-async-compression+zstd-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+zstd-safe-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+zstd-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+zstd-safe-devel}"
SRC_URI[x86_64_v2_rust-async-compression+zstd-safe-devel.sha256sum] = "4a0ffb4dd50dc549709d23477ccf6f87e3341eef501a2d0afa3035c60cf0717d"

URI_x86_64_v2_rust-async-compression+zstdmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+zstdmt-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+zstdmt-devel}"
SRC_URI[x86_64_v2_rust-async-compression+zstdmt-devel.sha256sum] = "00e85d31131720ce0581afaac9c6550b52f0e7734a9090ead5751a26e74b0da8"

URI_x86_64_v2_rust-async-compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression-devel-0.4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression-devel}"
SRC_URI[x86_64_v2_rust-async-compression-devel.sha256sum] = "9a1d4a8ae81d108f0c8ebed30a889e5ae4557e501929243d034c82db460a6b6f"

URI_aarch64_rust-async-compression+all-algorithms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+all-algorithms-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+all-algorithms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+all-algorithms-devel}"
SRC_URI[aarch64_rust-async-compression+all-algorithms-devel.sha256sum] = "81b5330806d480c037d921f2d5178a819dca38a9d71fd010e8634a6186e9041f"

URI_aarch64_rust-async-compression+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+all-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+all-devel}"
SRC_URI[aarch64_rust-async-compression+all-devel.sha256sum] = "944109db7b2897ef8d54ec968004b0fb108f28cfb5ec67d7f775f8cc2e781e1e"

URI_aarch64_rust-async-compression+all-implementations-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+all-implementations-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+all-implementations-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+all-implementations-devel}"
SRC_URI[aarch64_rust-async-compression+all-implementations-devel.sha256sum] = "d0abf351aba587d556aad34d236557f8998c3fe96d3ec564f4acd4c065363a4e"

URI_aarch64_rust-async-compression+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+brotli-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+brotli-devel}"
SRC_URI[aarch64_rust-async-compression+brotli-devel.sha256sum] = "b87b211c206e8c6116efe2837f640c322e84593b188ec632fdd40138572a0848"

URI_aarch64_rust-async-compression+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+bzip2-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+bzip2-devel}"
SRC_URI[aarch64_rust-async-compression+bzip2-devel.sha256sum] = "1adc3b80af17d26c21b8d32fca279472d605a71c3153cfea814c20fb08bd2627"

URI_aarch64_rust-async-compression+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+default-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+default-devel}"
SRC_URI[aarch64_rust-async-compression+default-devel.sha256sum] = "0ad59cc5dd7fc40b4f466f3934f70df9d5d4021398cec03fee9152730e09f897"

URI_aarch64_rust-async-compression+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+deflate-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+deflate-devel}"
SRC_URI[aarch64_rust-async-compression+deflate-devel.sha256sum] = "5ed5b8aa26c2da4c1796b1c0638538f86d4f679f9538e1b98858f22a7ffa4d6b"

URI_aarch64_rust-async-compression+deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+deflate64-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+deflate64-devel}"
SRC_URI[aarch64_rust-async-compression+deflate64-devel.sha256sum] = "94fad32dd0d8eaa8e039f94bc96e09e49ac76ac551959187992504c6b5ad7891"

URI_aarch64_rust-async-compression+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+flate2-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+flate2-devel}"
SRC_URI[aarch64_rust-async-compression+flate2-devel.sha256sum] = "8c1dcadf13406e14ac81379e78a091777facf6b81d5040bc17841af95fa6ff71"

URI_aarch64_rust-async-compression+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+futures-io-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+futures-io-devel}"
SRC_URI[aarch64_rust-async-compression+futures-io-devel.sha256sum] = "289397a384f730aa59415930f05e9df0b7f4cce199340d2e9484a8a7c3f3a88d"

URI_aarch64_rust-async-compression+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+gzip-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+gzip-devel}"
SRC_URI[aarch64_rust-async-compression+gzip-devel.sha256sum] = "95be2701eac9d59cdea7f43ae03a547c9ff7e72116c7e5031069d02fb568c2a6"

URI_aarch64_rust-async-compression+libzstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+libzstd-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+libzstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+libzstd-devel}"
SRC_URI[aarch64_rust-async-compression+libzstd-devel.sha256sum] = "664ee91ed417e38ee84d95672238801c511ae466521a6b5e6b515364ca6d61e1"

URI_aarch64_rust-async-compression+lzma-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+lzma-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+lzma-devel}"
SRC_URI[aarch64_rust-async-compression+lzma-devel.sha256sum] = "4c01c0312bb1777910bab600f517d01e8cbec6ed750a1059f1aa996eacf73a15"

URI_aarch64_rust-async-compression+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+tokio-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+tokio-devel}"
SRC_URI[aarch64_rust-async-compression+tokio-devel.sha256sum] = "99f1c1d0a77c2df6fb160a47e581c781ce95e437ebf4735b7dc913a845cfaa57"

URI_aarch64_rust-async-compression+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+xz-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+xz-devel}"
SRC_URI[aarch64_rust-async-compression+xz-devel.sha256sum] = "f0f92b98ed968554508cda562032e89c522efcc2c070d86bd24dbfcd114b1bd1"

URI_aarch64_rust-async-compression+xz2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+xz2-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+xz2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+xz2-devel}"
SRC_URI[aarch64_rust-async-compression+xz2-devel.sha256sum] = "52ff05a0585b5d397aaaaea762126e337f7395a6f9fdfdae9655ac9a3fbf1515"

URI_aarch64_rust-async-compression+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+zlib-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+zlib-devel}"
SRC_URI[aarch64_rust-async-compression+zlib-devel.sha256sum] = "519395981b5a2c09c14c3b8f8ef1a143ac6257f438d598cbd54cddfc4519357c"

URI_aarch64_rust-async-compression+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+zstd-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+zstd-devel}"
SRC_URI[aarch64_rust-async-compression+zstd-devel.sha256sum] = "88e2037b9fabc10016ede8f56a630c8f68ba17e3ffa7c3c7aa0f1878b3b55cbd"

URI_aarch64_rust-async-compression+zstd-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+zstd-safe-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+zstd-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+zstd-safe-devel}"
SRC_URI[aarch64_rust-async-compression+zstd-safe-devel.sha256sum] = "1e4eda51f6dc94016b400009d08f2d8aca6d9b5b73b1d174e2cad0bb86a0f83a"

URI_aarch64_rust-async-compression+zstdmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+zstdmt-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+zstdmt-devel}"
SRC_URI[aarch64_rust-async-compression+zstdmt-devel.sha256sum] = "ad55bcacea7428ada5da2207f3d18cc60c4ec724f43f1741c051144b261f74bd"

URI_aarch64_rust-async-compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression-devel-0.4.19-1.el10_1.noarch.rpm;name=aarch64_rust-async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression-devel}"
SRC_URI[aarch64_rust-async-compression-devel.sha256sum] = "ef11bd225e7d83e896d50363d9b992fcac5971ef61cd6f076b7d92561657fa65"

RDEPENDS:rust-async-compression+all-algorithms-devel = " \
 cargo \
 rust-async-compression+brotli-devel \
 rust-async-compression+bzip2-devel \
 rust-async-compression+deflate-devel \
 rust-async-compression+deflate64-devel \
 rust-async-compression+gzip-devel \
 rust-async-compression+lzma-devel \
 rust-async-compression+xz-devel \
 rust-async-compression+zlib-devel \
 rust-async-compression+zstd-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+all-devel = " \
 cargo \
 rust-async-compression+all-algorithms-devel \
 rust-async-compression+all-implementations-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+all-implementations-devel = " \
 cargo \
 rust-async-compression+futures-io-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+brotli-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-brotli+default-devel \
 "
RDEPENDS:rust-async-compression+bzip2-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-bzip2+default-devel \
 "
RDEPENDS:rust-async-compression+default-devel = " \
 cargo \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+deflate-devel = " \
 cargo \
 rust-async-compression+flate2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+deflate64-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-deflate64+default-devel \
 "
RDEPENDS:rust-async-compression+flate2-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-flate2+default-devel \
 "
RDEPENDS:rust-async-compression+futures-io-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 "
RDEPENDS:rust-async-compression+gzip-devel = " \
 cargo \
 rust-async-compression+flate2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+libzstd-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-zstd-devel \
 "
RDEPENDS:rust-async-compression+lzma-devel = " \
 cargo \
 rust-async-compression+xz2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+tokio-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-async-compression+xz-devel = " \
 cargo \
 rust-async-compression+xz2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+xz2-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-xz2+default-devel \
 "
RDEPENDS:rust-async-compression+zlib-devel = " \
 cargo \
 rust-async-compression+flate2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+zstd-devel = " \
 cargo \
 rust-async-compression+libzstd-devel \
 rust-async-compression+zstd-safe-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+zstd-safe-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-zstd-safe-devel \
 "
RDEPENDS:rust-async-compression+zstdmt-devel = " \
 cargo \
 rust-async-compression+zstd-devel \
 rust-async-compression-devel \
 rust-zstd-safe+zstdmt-devel \
 rust-zstd-safe-devel \
 "
RDEPENDS:rust-async-compression-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-memchr+default-devel \
 rust-pin-project-lite+default-devel \
 "
