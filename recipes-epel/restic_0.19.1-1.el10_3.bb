# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "restic"
PV = "0.19.1"
PR = "1.el10_3"
PACKAGES = " \
 restic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/restic-0.19.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b6991886b0f49b86f282ac19e8d939bb6187a35804aacaf052395ad3dda9d60"

URI_x86_64_v2_restic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/restic-0.19.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_restic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_restic}"
SRC_URI[x86_64_v2_restic.sha256sum] = "1822f373765efcc03f2389d39ad06f74f6f2fa2e0747d8d394d89e9a57034a35"

URI_aarch64_restic = "${EPEL_MIRROR}/aarch64/Packages/r/restic-0.19.1-1.el10_3.aarch64.rpm;name=aarch64_restic;unpack=0"
SRC_URI:append = " ${URI_aarch64_restic}"
SRC_URI[aarch64_restic.sha256sum] = "eec64a4c7c2892adeb33a761fbe4f363a473a1529fc15dac8f90ea031e1e0ee7"

RDEPENDS:restic = " \
 glibc \
 "
