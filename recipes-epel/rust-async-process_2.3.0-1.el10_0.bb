# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-process"
PV = "2.3.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-async-process+default-devel \
 rust-async-process-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-process-2.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d101f5874dcfd2267973ebfefa33400c096f49b5e2d9fd2e5f7339aed3b5ebd7"

URI_x86_64_v2_rust-async-process+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-process+default-devel-2.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-process+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-process+default-devel}"
SRC_URI[x86_64_v2_rust-async-process+default-devel.sha256sum] = "7289c3059daae5a1c93f7c50d654d54d79f8cd282e3f730cda94fea53e360369"

URI_x86_64_v2_rust-async-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-process-devel-2.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-process-devel}"
SRC_URI[x86_64_v2_rust-async-process-devel.sha256sum] = "99f037c69538373b8f8315fd423b6200849ee66f0fe5e082012633e119f4724c"

URI_aarch64_rust-async-process+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-process+default-devel-2.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-async-process+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-process+default-devel}"
SRC_URI[aarch64_rust-async-process+default-devel.sha256sum] = "3dc632498f670e6dbb6b19ff18693f0b29a901423d661c6d9203de4a91225c38"

URI_aarch64_rust-async-process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-process-devel-2.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-async-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-process-devel}"
SRC_URI[aarch64_rust-async-process-devel.sha256sum] = "08b1f9a3adbecb67cd5f997f0066a237ce65fa61f12113c4402342ea53ba442f"

RDEPENDS:rust-async-process+default-devel = " \
 cargo \
 rust-async-process-devel \
 "
RDEPENDS:rust-async-process-devel = " \
 cargo \
 rust \
 rust-async-channel+default-devel \
 rust-async-io+default-devel \
 rust-async-lock+default-devel \
 rust-async-signal+default-devel \
 rust-async-task+default-devel \
 rust-cfg-if+default-devel \
 rust-event-listener+default-devel \
 rust-futures-lite+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 rust-tracing-devel \
 "
