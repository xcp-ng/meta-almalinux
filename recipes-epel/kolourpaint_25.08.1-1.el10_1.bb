# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kolourpaint"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kolourpaint \
 kolourpaint-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kolourpaint-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f406f6b90efd2b11e6265bb46939e189affef83c73e9d25eeb23f64bb53f1d8"

URI_x86_64_v2_kolourpaint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolourpaint-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolourpaint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kolourpaint}"
SRC_URI[x86_64_v2_kolourpaint.sha256sum] = "228ff47d48d8be6818a1a8ae27dd6886e05d7a2f3fb21cbd22115bf592d30d30"

URI_x86_64_v2_kolourpaint-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolourpaint-libs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolourpaint-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kolourpaint-libs}"
SRC_URI[x86_64_v2_kolourpaint-libs.sha256sum] = "3099e646e496536051b9bde6172b8be64e9ba7affe5585060849f3a63ec57f4b"

URI_aarch64_kolourpaint = "${EPEL_MIRROR}/aarch64/Packages/k/kolourpaint-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kolourpaint;unpack=0"
SRC_URI:append = " ${URI_aarch64_kolourpaint}"
SRC_URI[aarch64_kolourpaint.sha256sum] = "1aa45f98ca96502956c919008bdc2d19600fa908951d2ff7308aaa125731feff"

URI_aarch64_kolourpaint-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kolourpaint-libs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kolourpaint-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kolourpaint-libs}"
SRC_URI[aarch64_kolourpaint-libs.sha256sum] = "7b7b3831a4a40fc342f17cf18863199e103272ff3c052a9ebdf0d4885f8901a7"

RDEPENDS:kolourpaint = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kolourpaint-libs \
 libksane \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kolourpaint-libs = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kolourpaint \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
