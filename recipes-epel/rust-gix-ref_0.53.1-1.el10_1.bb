# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-ref"
PV = "0.53.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-ref+default-devel \
 rust-gix-ref+document-features-devel \
 rust-gix-ref+serde-devel \
 rust-gix-ref-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-ref-0.53.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23379c20da3b26914185032d41110f46ee1b9f35c6a2c30697615e2e9d56e7d8"

URI_x86_64_v2_rust-gix-ref+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+default-devel-0.53.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+default-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+default-devel.sha256sum] = "a2ac8fb76c518c6ba80193686c0fca08eb622cf4d4fb8e5ca3eaf7d3c68a73b6"

URI_x86_64_v2_rust-gix-ref+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+document-features-devel-0.53.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+document-features-devel.sha256sum] = "e5e3d28ed7c78b15a922bb2749fbb74cc0ba1a0f1025ded0e81992017292958a"

URI_x86_64_v2_rust-gix-ref+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+serde-devel-0.53.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+serde-devel.sha256sum] = "58587418ccd83d6cc5dca2c9cb9458330a08fcd959e49f2293a857115df2ab1a"

URI_x86_64_v2_rust-gix-ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref-devel-0.53.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref-devel}"
SRC_URI[x86_64_v2_rust-gix-ref-devel.sha256sum] = "c7bc4d30e16c1d869f5fc2556c02141245ad23cc5a56820414c38cc883e9b3a1"

URI_aarch64_rust-gix-ref+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+default-devel-0.53.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-ref+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+default-devel}"
SRC_URI[aarch64_rust-gix-ref+default-devel.sha256sum] = "21ff71b8c0397aad84742d1e6eeccb8b271faf407d4646bc6cbd3ca1e98b30cc"

URI_aarch64_rust-gix-ref+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+document-features-devel-0.53.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-ref+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+document-features-devel}"
SRC_URI[aarch64_rust-gix-ref+document-features-devel.sha256sum] = "96842dd0146ac31eec55d2f495a06d0bd32ffbf5c2ca430423620a5a9f645571"

URI_aarch64_rust-gix-ref+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+serde-devel-0.53.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-ref+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+serde-devel}"
SRC_URI[aarch64_rust-gix-ref+serde-devel.sha256sum] = "c978c561e89a36d0bf6f3ff844eb88fc35b187dd9a3fdebe88988d3e356b12fa"

URI_aarch64_rust-gix-ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref-devel-0.53.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref-devel}"
SRC_URI[aarch64_rust-gix-ref-devel.sha256sum] = "b39ceee5e86fe8cdc78560fb33c6bb2ce8cba6f5860a09a33cb229671c31cf2c"

RDEPENDS:rust-gix-ref+default-devel = " \
 cargo \
 rust-gix-ref-devel \
 "
RDEPENDS:rust-gix-ref+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-ref-devel \
 "
RDEPENDS:rust-gix-ref+serde-devel = " \
 cargo \
 rust-gix-actor+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-ref-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-ref-devel = " \
 cargo \
 rust \
 rust-gix-actor+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+walkdir-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-lock+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-tempfile-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-memmap2+default-devel \
 rust-thiserror+default-devel \
 rust-winnow+default-devel \
 rust-winnow+simd-devel \
 "
