# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phc"
PV = "0.6.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-phc+alloc-devel \
 rust-phc+default-devel \
 rust-phc+getrandom-devel \
 rust-phc+rand_core-devel \
 rust-phc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phc-0.6.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c84e10bfb49007adb1826fb204e020a4c4c0a9ffdf0442dc1e5464837db9a51"

URI_x86_64_v2_rust-phc+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phc+alloc-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phc+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phc+alloc-devel}"
SRC_URI[x86_64_v2_rust-phc+alloc-devel.sha256sum] = "df20882da3f5be99fbdf38af889aad4f2ac512e6225e102f21bcedfa981bfd9c"

URI_x86_64_v2_rust-phc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phc+default-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phc+default-devel}"
SRC_URI[x86_64_v2_rust-phc+default-devel.sha256sum] = "d402ec521db7d6b04d475ca90601f0419e2cf5c2fe7a248dd30a2fb6c0aee3b1"

URI_x86_64_v2_rust-phc+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phc+getrandom-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phc+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phc+getrandom-devel}"
SRC_URI[x86_64_v2_rust-phc+getrandom-devel.sha256sum] = "1856f18c9844626ba7a301e4c9c776fafc853069a93443fd5b35fab6435569d9"

URI_x86_64_v2_rust-phc+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phc+rand_core-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phc+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phc+rand_core-devel}"
SRC_URI[x86_64_v2_rust-phc+rand_core-devel.sha256sum] = "1c4aa3c4b809496b8e6eec2847d5220d63b811c6c4ff98a3a99186188feacf12"

URI_x86_64_v2_rust-phc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phc-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phc-devel}"
SRC_URI[x86_64_v2_rust-phc-devel.sha256sum] = "561ed1825baea87438c57f345db434cc23a9b6d16f56d2a65fedb2789201d92a"

URI_aarch64_rust-phc+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phc+alloc-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-phc+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phc+alloc-devel}"
SRC_URI[aarch64_rust-phc+alloc-devel.sha256sum] = "c01fb8d85b76537be50bc1babb96c0b593d4305e082ab998ef0e2494031c6b76"

URI_aarch64_rust-phc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phc+default-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-phc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phc+default-devel}"
SRC_URI[aarch64_rust-phc+default-devel.sha256sum] = "6c5f330bd125bd0f69b99fa3ea3a6f45677b6c6517b57cd3bf5af1917b50f6f9"

URI_aarch64_rust-phc+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phc+getrandom-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-phc+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phc+getrandom-devel}"
SRC_URI[aarch64_rust-phc+getrandom-devel.sha256sum] = "622e7a77061d818b24093d9da27d7d5ba4953699b77333a1c543a07daf2fdba9"

URI_aarch64_rust-phc+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phc+rand_core-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-phc+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phc+rand_core-devel}"
SRC_URI[aarch64_rust-phc+rand_core-devel.sha256sum] = "b97c3ed20f1fe91863a0615ce2ae06ff658bf4ea1d153d91069c692f1317f37d"

URI_aarch64_rust-phc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phc-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-phc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phc-devel}"
SRC_URI[aarch64_rust-phc-devel.sha256sum] = "a642797d76ebd31d419b50ad4f86f5d9e7e09a4a22df6faf5d3791d8abf2ec76"

RDEPENDS:rust-phc+alloc-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-phc-devel \
 "
RDEPENDS:rust-phc+default-devel = " \
 cargo \
 rust-phc+rand_core-devel \
 rust-phc-devel \
 "
RDEPENDS:rust-phc+getrandom-devel = " \
 cargo \
 rust-getrandom-devel \
 rust-phc-devel \
 "
RDEPENDS:rust-phc+rand_core-devel = " \
 cargo \
 rust-phc-devel \
 rust-rand_core-devel \
 "
RDEPENDS:rust-phc-devel = " \
 cargo \
 rust \
 rust-base64ct+default-devel \
 rust-ctutils+default-devel \
 "
