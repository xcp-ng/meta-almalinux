# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kshisen"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kshisen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kshisen-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "667aaa26b8449ff95857706a23caab60385944978b7a71a6ffdd818ef941dc27"

URI_x86_64_v2_kshisen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kshisen-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kshisen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kshisen}"
SRC_URI[x86_64_v2_kshisen.sha256sum] = "96e744f4418e29e967db949ecc10225ee9637eea065f525f60c8b3054c95409e"

URI_aarch64_kshisen = "${EPEL_MIRROR}/aarch64/Packages/k/kshisen-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kshisen;unpack=0"
SRC_URI:append = " ${URI_aarch64_kshisen}"
SRC_URI[aarch64_kshisen.sha256sum] = "ce3b76791813cb0367248a445b4d8c83d4bb5425eeaa66a8773daf9ac211a27b"

RDEPENDS:kshisen = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libkmahjongg \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
