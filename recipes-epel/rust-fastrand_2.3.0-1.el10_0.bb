# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fastrand"
PV = "2.3.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-fastrand+alloc-devel \
 rust-fastrand+default-devel \
 rust-fastrand+std-devel \
 rust-fastrand-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-fastrand-2.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "da44db93801fc00073920f02d1b8025f3a4f9b0c13dde4c96090266ca3730319"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fastrand+alloc-devel-2.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fastrand+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fastrand+alloc-devel.sha256sum] = "6cdf6e9d27dcca45795fb0b38de955a5e15063c58af6176f62aca7d8a07b020c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fastrand+default-devel-2.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fastrand+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fastrand+default-devel.sha256sum] = "5b0e7bd7926bc693819d1c681089b192eb0d4a746b4745482a9b0767940b010f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fastrand+std-devel-2.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fastrand+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fastrand+std-devel.sha256sum] = "48e9f6a91bcf2c2747c78dc41518e0920a5da2dd90dd33ec545840a4979a34d7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fastrand-devel-2.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fastrand-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fastrand-devel.sha256sum] = "6098e880f6987542ba96777391b1bab478cb2a76429b806ae8ae407ab5cff45e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fastrand+alloc-devel-2.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-fastrand+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-fastrand+alloc-devel.sha256sum] = "b04cbc1febb1631d6b4393f3573ad701bd8ceb464f322724c3a4f715267d174e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fastrand+default-devel-2.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-fastrand+default-devel;unpack=0"
SRC_URI[aarch64_rust-fastrand+default-devel.sha256sum] = "630f2215afada7a25bef485aaea6e65206abd9d9a2d3ff6ab0430a49f6105c1e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fastrand+std-devel-2.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-fastrand+std-devel;unpack=0"
SRC_URI[aarch64_rust-fastrand+std-devel.sha256sum] = "643e75d10a6b8eca1a756d868c6eb7dad04cb5565d72ccec59d8f7137f7cfce5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fastrand-devel-2.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-fastrand-devel;unpack=0"
SRC_URI[aarch64_rust-fastrand-devel.sha256sum] = "171dbd6d555499639d3afeddfb44723771dc6040ea35f5b3e425ff1da17fcc2d"

RDEPENDS:rust-fastrand+alloc-devel = " \
 cargo \
 rust-fastrand-devel \
 "
RDEPENDS:rust-fastrand+default-devel = " \
 cargo \
 rust-fastrand+std-devel \
 rust-fastrand-devel \
 "
RDEPENDS:rust-fastrand+std-devel = " \
 cargo \
 rust-fastrand+alloc-devel \
 rust-fastrand-devel \
 "
RDEPENDS:rust-fastrand-devel = " \
 cargo \
 rust \
 "
