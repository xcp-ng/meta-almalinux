# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha3"
PV = "0.10.8"
PR = "4.el10_0"
PACKAGES = " \
 rust-sha3+asm-devel \
 rust-sha3+default-devel \
 rust-sha3+oid-devel \
 rust-sha3+reset-devel \
 rust-sha3+std-devel \
 rust-sha3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sha3-0.10.8-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68562ed0edd5d7fa5973bf82efda38a4f0c4f07e43112cc8810b4e3971243139"

URI_x86_64_v2_rust-sha3+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha3+asm-devel-0.10.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha3+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha3+asm-devel}"
SRC_URI[x86_64_v2_rust-sha3+asm-devel.sha256sum] = "57480f72898f5ea7b628d02db339039877f56ef43f9945f3d9f021a9b0800459"

URI_x86_64_v2_rust-sha3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha3+default-devel-0.10.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha3+default-devel}"
SRC_URI[x86_64_v2_rust-sha3+default-devel.sha256sum] = "3f4e4dadebc57b955223f92764104bea45af8b520b06e4cf4f12e7f973600eee"

URI_x86_64_v2_rust-sha3+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha3+oid-devel-0.10.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha3+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha3+oid-devel}"
SRC_URI[x86_64_v2_rust-sha3+oid-devel.sha256sum] = "3b407f4ac03b76d3448e8868ca3aa35281be82558fa487937762ad471c2726de"

URI_x86_64_v2_rust-sha3+reset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha3+reset-devel-0.10.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha3+reset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha3+reset-devel}"
SRC_URI[x86_64_v2_rust-sha3+reset-devel.sha256sum] = "6dae36601b2a9bae07c168e544a8958632e2a0da40276de5df8ec0e883da5aed"

URI_x86_64_v2_rust-sha3+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha3+std-devel-0.10.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha3+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha3+std-devel}"
SRC_URI[x86_64_v2_rust-sha3+std-devel.sha256sum] = "91d34e9c6af6c4f660e3dbdd5c0786e7139469052173b285d67f37f2cc92edc9"

URI_x86_64_v2_rust-sha3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha3-devel-0.10.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha3-devel}"
SRC_URI[x86_64_v2_rust-sha3-devel.sha256sum] = "8885a1af236eadeb9ce4eec3ced94698aaf4d608c2271f2a569a1b5d1d07b218"

URI_aarch64_rust-sha3+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha3+asm-devel-0.10.8-4.el10_0.noarch.rpm;name=aarch64_rust-sha3+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha3+asm-devel}"
SRC_URI[aarch64_rust-sha3+asm-devel.sha256sum] = "9089a32cd4437222e8fed3ce16b3cba3b4e306283095c4305c370f98cb8ceafd"

URI_aarch64_rust-sha3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha3+default-devel-0.10.8-4.el10_0.noarch.rpm;name=aarch64_rust-sha3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha3+default-devel}"
SRC_URI[aarch64_rust-sha3+default-devel.sha256sum] = "3e9484ebd6c3c5fae401c804c01ebf395923d101424aa9637750138efa257491"

URI_aarch64_rust-sha3+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha3+oid-devel-0.10.8-4.el10_0.noarch.rpm;name=aarch64_rust-sha3+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha3+oid-devel}"
SRC_URI[aarch64_rust-sha3+oid-devel.sha256sum] = "9c016f0256573ac1300d12c39f2877f774f950c0567d3e2b444b47b2a2611ae6"

URI_aarch64_rust-sha3+reset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha3+reset-devel-0.10.8-4.el10_0.noarch.rpm;name=aarch64_rust-sha3+reset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha3+reset-devel}"
SRC_URI[aarch64_rust-sha3+reset-devel.sha256sum] = "3e2942821c4f167fea1e7561b950edc11d62c4b78e36591ff91f18fde59f1f5f"

URI_aarch64_rust-sha3+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha3+std-devel-0.10.8-4.el10_0.noarch.rpm;name=aarch64_rust-sha3+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha3+std-devel}"
SRC_URI[aarch64_rust-sha3+std-devel.sha256sum] = "1ce227226a6973a3103f5fa45d346ea6234ef05f23a16b99bf4be0006583a086"

URI_aarch64_rust-sha3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha3-devel-0.10.8-4.el10_0.noarch.rpm;name=aarch64_rust-sha3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha3-devel}"
SRC_URI[aarch64_rust-sha3-devel.sha256sum] = "c43210f46cd88d2e2a1ae9643958ff968330399f6c6e0ebf5ed01ea671cc70e7"

RDEPENDS:rust-sha3+asm-devel = " \
 cargo \
 rust-keccak+asm-devel \
 rust-sha3-devel \
 "
RDEPENDS:rust-sha3+default-devel = " \
 cargo \
 rust-sha3+std-devel \
 rust-sha3-devel \
 "
RDEPENDS:rust-sha3+oid-devel = " \
 cargo \
 rust-digest+oid-devel \
 rust-sha3-devel \
 "
RDEPENDS:rust-sha3+reset-devel = " \
 cargo \
 rust-sha3-devel \
 "
RDEPENDS:rust-sha3+std-devel = " \
 cargo \
 rust-digest+std-devel \
 rust-sha3-devel \
 "
RDEPENDS:rust-sha3-devel = " \
 cargo \
 rust-digest+default-devel \
 rust-keccak+default-devel \
 "
