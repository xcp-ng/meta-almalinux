# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgpg"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kgpg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgpg-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4533c1bc8b19d41e6d5f17661e36774039acd733007c537717a7c9710174a3f"

URI_x86_64_v2_kgpg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgpg-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgpg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgpg}"
SRC_URI[x86_64_v2_kgpg.sha256sum] = "6c69e12ff1291b75c5f6bd0b6c89f44ae552831d1b0beb9cf21c240e0b0cad9d"

URI_aarch64_kgpg = "${EPEL_MIRROR}/aarch64/Packages/k/kgpg-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kgpg;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgpg}"
SRC_URI[aarch64_kgpg.sha256sum] = "f0c0c0045e10839693e01c0a3e27c665ca36a94f05ce19ce63e6130e1150ddd3"

RDEPENDS:kgpg = " \
 akonadi-contacts \
 akonadi-server \
 glibc \
 gnupg2 \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
