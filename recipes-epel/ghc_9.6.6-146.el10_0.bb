# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc"
PV = "9.6.6"
PR = "146.el10_0"
PACKAGES = " \
 ghc \
 ghc-Cabal \
 ghc-Cabal-devel \
 ghc-Cabal-doc \
 ghc-Cabal-prof \
 ghc-Cabal-syntax \
 ghc-Cabal-syntax-devel \
 ghc-Cabal-syntax-doc \
 ghc-Cabal-syntax-prof \
 ghc-array \
 ghc-array-devel \
 ghc-array-doc \
 ghc-array-prof \
 ghc-base \
 ghc-base-devel \
 ghc-base-doc \
 ghc-base-prof \
 ghc-binary \
 ghc-binary-devel \
 ghc-binary-doc \
 ghc-binary-prof \
 ghc-bytestring \
 ghc-bytestring-devel \
 ghc-bytestring-doc \
 ghc-bytestring-prof \
 ghc-compiler \
 ghc-containers \
 ghc-containers-devel \
 ghc-containers-doc \
 ghc-containers-prof \
 ghc-deepseq \
 ghc-deepseq-devel \
 ghc-deepseq-doc \
 ghc-deepseq-prof \
 ghc-devel \
 ghc-directory \
 ghc-directory-devel \
 ghc-directory-doc \
 ghc-directory-prof \
 ghc-doc \
 ghc-doc-index \
 ghc-exceptions \
 ghc-exceptions-devel \
 ghc-exceptions-doc \
 ghc-exceptions-prof \
 ghc-filepath \
 ghc-filepath-devel \
 ghc-filepath-doc \
 ghc-filepath-prof \
 ghc-filesystem \
 ghc-ghc \
 ghc-ghc-bignum \
 ghc-ghc-bignum-devel \
 ghc-ghc-bignum-doc \
 ghc-ghc-bignum-prof \
 ghc-ghc-boot \
 ghc-ghc-boot-devel \
 ghc-ghc-boot-doc \
 ghc-ghc-boot-prof \
 ghc-ghc-boot-th \
 ghc-ghc-boot-th-devel \
 ghc-ghc-boot-th-doc \
 ghc-ghc-boot-th-prof \
 ghc-ghc-compact \
 ghc-ghc-compact-devel \
 ghc-ghc-compact-doc \
 ghc-ghc-compact-prof \
 ghc-ghc-devel \
 ghc-ghc-doc \
 ghc-ghc-heap \
 ghc-ghc-heap-devel \
 ghc-ghc-heap-doc \
 ghc-ghc-heap-prof \
 ghc-ghc-prof \
 ghc-ghci \
 ghc-ghci-devel \
 ghc-ghci-doc \
 ghc-ghci-prof \
 ghc-hadrian \
 ghc-haskeline \
 ghc-haskeline-devel \
 ghc-haskeline-doc \
 ghc-haskeline-prof \
 ghc-hpc \
 ghc-hpc-devel \
 ghc-hpc-doc \
 ghc-hpc-prof \
 ghc-libiserv \
 ghc-libiserv-devel \
 ghc-libiserv-doc \
 ghc-libiserv-prof \
 ghc-manual \
 ghc-mtl \
 ghc-mtl-devel \
 ghc-mtl-doc \
 ghc-mtl-prof \
 ghc-parsec \
 ghc-parsec-devel \
 ghc-parsec-doc \
 ghc-parsec-prof \
 ghc-pretty \
 ghc-pretty-devel \
 ghc-pretty-doc \
 ghc-pretty-prof \
 ghc-process \
 ghc-process-devel \
 ghc-process-doc \
 ghc-process-prof \
 ghc-prof \
 ghc-stm \
 ghc-stm-devel \
 ghc-stm-doc \
 ghc-stm-prof \
 ghc-template-haskell \
 ghc-template-haskell-devel \
 ghc-template-haskell-doc \
 ghc-template-haskell-prof \
 ghc-terminfo \
 ghc-terminfo-devel \
 ghc-terminfo-doc \
 ghc-terminfo-prof \
 ghc-text \
 ghc-text-devel \
 ghc-text-doc \
 ghc-text-prof \
 ghc-time \
 ghc-time-devel \
 ghc-time-doc \
 ghc-time-prof \
 ghc-transformers \
 ghc-transformers-devel \
 ghc-transformers-doc \
 ghc-transformers-prof \
 ghc-unix \
 ghc-unix-devel \
 ghc-unix-doc \
 ghc-unix-prof \
 ghc-xhtml \
 ghc-xhtml-devel \
 ghc-xhtml-doc \
 ghc-xhtml-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-9.6.6-146.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ff5052c1853dda82e8c86439bdf50b0ce44335e7f528fe202870ed93aef0d5a"

URI_x86_64_v2_ghc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc}"
SRC_URI[x86_64_v2_ghc.sha256sum] = "1e2d19d1d771ce96a09a849c15e1a6881cf8d465af6f4e88d314357e2afe5d97"

URI_x86_64_v2_ghc-Cabal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Cabal-3.10.3.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Cabal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Cabal}"
SRC_URI[x86_64_v2_ghc-Cabal.sha256sum] = "4308160b165ad849331e1cc8d2a70f180112143ae39a1cb131c38643af66c657"

URI_x86_64_v2_ghc-Cabal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Cabal-devel-3.10.3.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Cabal-devel}"
SRC_URI[x86_64_v2_ghc-Cabal-devel.sha256sum] = "3f273d2fc1f55ca346f726aee2f587ed1358ce864543d3db935bc5035bf5ad72"

URI_x86_64_v2_ghc-Cabal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Cabal-doc-3.10.3.0-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Cabal-doc}"
SRC_URI[x86_64_v2_ghc-Cabal-doc.sha256sum] = "f9a880884dffe291f8a84badf4970ddcfef135725d345c926fb0c28437d6a091"

URI_x86_64_v2_ghc-Cabal-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Cabal-prof-3.10.3.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Cabal-prof}"
SRC_URI[x86_64_v2_ghc-Cabal-prof.sha256sum] = "f8760ff8ea0110b9af84d0a3d954e04cb33e05cc474568828760e4f7aeb35852"

URI_x86_64_v2_ghc-Cabal-syntax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Cabal-syntax-3.10.3.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Cabal-syntax}"
SRC_URI[x86_64_v2_ghc-Cabal-syntax.sha256sum] = "022badd86fd34ed4d437c706c83b56ef83fac054a0b4f1a83ead1c0da95bea60"

URI_x86_64_v2_ghc-Cabal-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Cabal-syntax-devel-3.10.3.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Cabal-syntax-devel}"
SRC_URI[x86_64_v2_ghc-Cabal-syntax-devel.sha256sum] = "bec50b55cfeae6eae814694959090c14588b37ec2a07f2e911c7ba5f089fb37b"

URI_x86_64_v2_ghc-Cabal-syntax-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Cabal-syntax-doc-3.10.3.0-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Cabal-syntax-doc}"
SRC_URI[x86_64_v2_ghc-Cabal-syntax-doc.sha256sum] = "ffc392c0ca0757e5ed6c7d0224a259cd6ebf82f5a57140d2a4c09dc92d05c23c"

URI_x86_64_v2_ghc-Cabal-syntax-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Cabal-syntax-prof-3.10.3.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Cabal-syntax-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Cabal-syntax-prof}"
SRC_URI[x86_64_v2_ghc-Cabal-syntax-prof.sha256sum] = "f1a80fbbd582ac00de9cc066e3ea886085809ebc417afcca24441f3feeabf195"

URI_x86_64_v2_ghc-array = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-array-0.5.6.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-array}"
SRC_URI[x86_64_v2_ghc-array.sha256sum] = "fc7b2bca79d255e074b21033c594cc00fc7f1d07b6ef91bd57d7f8a8ff4bf38d"

URI_x86_64_v2_ghc-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-array-devel-0.5.6.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-array-devel}"
SRC_URI[x86_64_v2_ghc-array-devel.sha256sum] = "793bea554b6ec7d0b14985ad48a7450801ed8002f2af0a4ae48519fff55881e9"

URI_x86_64_v2_ghc-array-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-array-doc-0.5.6.0-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-array-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-array-doc}"
SRC_URI[x86_64_v2_ghc-array-doc.sha256sum] = "296160d5af0c602b58394ea1a6ad9cb571edd0a67e9fe7bb32b06f8ed985aff1"

URI_x86_64_v2_ghc-array-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-array-prof-0.5.6.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-array-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-array-prof}"
SRC_URI[x86_64_v2_ghc-array-prof.sha256sum] = "3a789c818e237536dab11eb5a37d64cdb27277ce3019d99312d3349e487d79a3"

URI_x86_64_v2_ghc-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-4.18.2.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base}"
SRC_URI[x86_64_v2_ghc-base.sha256sum] = "fa2581c101fd9b6b97cf53922cc4736539a99787f75c09145a84102d2d5accd7"

URI_x86_64_v2_ghc-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-devel-4.18.2.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-devel}"
SRC_URI[x86_64_v2_ghc-base-devel.sha256sum] = "07dd71986472ae0b33097ed00da4e3701b09d3f8a9ec90f85c05738f7b710987"

URI_x86_64_v2_ghc-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-doc-4.18.2.1-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-doc}"
SRC_URI[x86_64_v2_ghc-base-doc.sha256sum] = "b9d67c525c9a448a3fa8beee1c2703f346402e140067a2e12cabe84a86f68d2d"

URI_x86_64_v2_ghc-base-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-prof-4.18.2.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-prof}"
SRC_URI[x86_64_v2_ghc-base-prof.sha256sum] = "ee3d37b531666db6b41f94c004da78bfa42dedf7870e10cd87eff540497038b3"

URI_x86_64_v2_ghc-binary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-binary-0.8.9.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-binary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-binary}"
SRC_URI[x86_64_v2_ghc-binary.sha256sum] = "32d2d58fb93f7c4fa3f2516daec6cfcfb1c9e709f211c3ba04247a96d98a148e"

URI_x86_64_v2_ghc-binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-binary-devel-0.8.9.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-binary-devel}"
SRC_URI[x86_64_v2_ghc-binary-devel.sha256sum] = "7b530fd158bcff3de93c1b36ca85e065720bc58fd322c8a7f653eb3863bcb3fc"

URI_x86_64_v2_ghc-binary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-binary-doc-0.8.9.1-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-binary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-binary-doc}"
SRC_URI[x86_64_v2_ghc-binary-doc.sha256sum] = "721811ad8be17c75873bbcccb735fcc3b093c5ecf8975578af5a63b89c0ed8df"

URI_x86_64_v2_ghc-binary-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-binary-prof-0.8.9.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-binary-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-binary-prof}"
SRC_URI[x86_64_v2_ghc-binary-prof.sha256sum] = "aca44015953cb6599d834d30a04be35d49b04510f8f8f5b7d7c4275465dc16c0"

URI_x86_64_v2_ghc-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bytestring-0.11.5.3-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bytestring}"
SRC_URI[x86_64_v2_ghc-bytestring.sha256sum] = "ae1137834167b95cf80dd87dab1301b992df54f6fc7af497bdc9a4b8853df911"

URI_x86_64_v2_ghc-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bytestring-devel-0.11.5.3-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bytestring-devel}"
SRC_URI[x86_64_v2_ghc-bytestring-devel.sha256sum] = "367825916046b3f288d5efeb65df7dd3c441da3ce7bee043a95593dbd0ec49cd"

URI_x86_64_v2_ghc-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bytestring-doc-0.11.5.3-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bytestring-doc}"
SRC_URI[x86_64_v2_ghc-bytestring-doc.sha256sum] = "e22a8514babf7d49aa3266d8ed2834bf9cc68f8b3f3d6fbbb38af67f802e2c0d"

URI_x86_64_v2_ghc-bytestring-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bytestring-prof-0.11.5.3-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bytestring-prof}"
SRC_URI[x86_64_v2_ghc-bytestring-prof.sha256sum] = "7dc76e5eda555bb024e5bdece29821c72e84bd11e35e57f0124b7fc4ef288bac"

URI_x86_64_v2_ghc-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-compiler-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-compiler}"
SRC_URI[x86_64_v2_ghc-compiler.sha256sum] = "3790b6169554eb607bff6c5f955b3b498f06b76a877703f1c73939a546868433"

URI_x86_64_v2_ghc-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-containers-0.6.7-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-containers}"
SRC_URI[x86_64_v2_ghc-containers.sha256sum] = "6adbd0910468a6afda5f8994da266de27766f0bb77651d27e715f95f0da8a24d"

URI_x86_64_v2_ghc-containers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-containers-devel-0.6.7-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-containers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-containers-devel}"
SRC_URI[x86_64_v2_ghc-containers-devel.sha256sum] = "d38d91fa2ac45a503d101a0f1e8730f32d97bbdb467a048555dfe363ffc69b41"

URI_x86_64_v2_ghc-containers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-containers-doc-0.6.7-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-containers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-containers-doc}"
SRC_URI[x86_64_v2_ghc-containers-doc.sha256sum] = "70f32cdeb504fb9e43f8b2f2c33791c82bd2b61dba295a792858c5d0f2c03495"

URI_x86_64_v2_ghc-containers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-containers-prof-0.6.7-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-containers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-containers-prof}"
SRC_URI[x86_64_v2_ghc-containers-prof.sha256sum] = "a544934746d95d1fc7cfe8d8261927946037d8b18f7661e19ea60136b9f3de96"

URI_x86_64_v2_ghc-deepseq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deepseq-1.4.8.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-deepseq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deepseq}"
SRC_URI[x86_64_v2_ghc-deepseq.sha256sum] = "d9f77dc888f255bbd167b1b83e3d1121d8f0f5b4432092e2984de988c1db5af1"

URI_x86_64_v2_ghc-deepseq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deepseq-devel-1.4.8.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deepseq-devel}"
SRC_URI[x86_64_v2_ghc-deepseq-devel.sha256sum] = "94905355d2cca4744122cb52000acf71791dc32da6c1e3de7fa872ba4b0a9fe1"

URI_x86_64_v2_ghc-deepseq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deepseq-doc-1.4.8.1-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deepseq-doc}"
SRC_URI[x86_64_v2_ghc-deepseq-doc.sha256sum] = "c852177e9d542397adfcec65bf1a7cf8ac9945d43be7b8682f75ac71206e791b"

URI_x86_64_v2_ghc-deepseq-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deepseq-prof-1.4.8.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deepseq-prof}"
SRC_URI[x86_64_v2_ghc-deepseq-prof.sha256sum] = "0ceef948271ad1cc5ecac82aa2a7a6ff196a684c06d02e18dd3c20aaaee1a94c"

URI_x86_64_v2_ghc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-devel-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-devel}"
SRC_URI[x86_64_v2_ghc-devel.sha256sum] = "043c8e9d26b6af33865a15237f13d252472a55359d101824ce7f4bc819258012"

URI_x86_64_v2_ghc-directory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-directory-1.3.8.5-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-directory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-directory}"
SRC_URI[x86_64_v2_ghc-directory.sha256sum] = "63cbc8c21eec6f70dbd9ad71b1cf5520302e969a9ebc1422a2e0479826265685"

URI_x86_64_v2_ghc-directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-directory-devel-1.3.8.5-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-directory-devel}"
SRC_URI[x86_64_v2_ghc-directory-devel.sha256sum] = "fe64a2e1f97d7d20d0581f88684dc07c2877d3fdf33c8a91b135f678a905a684"

URI_x86_64_v2_ghc-directory-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-directory-doc-1.3.8.5-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-directory-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-directory-doc}"
SRC_URI[x86_64_v2_ghc-directory-doc.sha256sum] = "47ef989dd7464975d34e1edf46e2f35cdb5966e7bf9b07c3b022f3b1bdaf261d"

URI_x86_64_v2_ghc-directory-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-directory-prof-1.3.8.5-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-directory-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-directory-prof}"
SRC_URI[x86_64_v2_ghc-directory-prof.sha256sum] = "318559c454e4b9ceb8d94f7d0005d8010c55a77453d4f83a4df01e723c043d1b"

URI_x86_64_v2_ghc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-doc-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-doc}"
SRC_URI[x86_64_v2_ghc-doc.sha256sum] = "e33eb7e71814db788a8fb83dc8c235c6e9e7a9dc0c79d41ee5a3e3166179026a"

URI_x86_64_v2_ghc-doc-index = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-doc-index-9.6.6-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-doc-index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-doc-index}"
SRC_URI[x86_64_v2_ghc-doc-index.sha256sum] = "7e4bb4ee7ac68a8e8425fd0380850fe77efd2b4b6636c2b425b9c90be2dfd647"

URI_x86_64_v2_ghc-exceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-exceptions-0.10.7-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-exceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-exceptions}"
SRC_URI[x86_64_v2_ghc-exceptions.sha256sum] = "86626fe127d6ffb46a87bf69b5992151cbb62d24b03e740848cfe1da42ff0ba0"

URI_x86_64_v2_ghc-exceptions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-exceptions-devel-0.10.7-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-exceptions-devel}"
SRC_URI[x86_64_v2_ghc-exceptions-devel.sha256sum] = "48c9b641a59833d929cb64e7e18eae22d264cb57ae66833098aa5837178e6358"

URI_x86_64_v2_ghc-exceptions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-exceptions-doc-0.10.7-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-exceptions-doc}"
SRC_URI[x86_64_v2_ghc-exceptions-doc.sha256sum] = "aa7202b7cab91018bf1e1364b3bcbca0e8e5f7e401b7a803ca7ae09feedc5990"

URI_x86_64_v2_ghc-exceptions-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-exceptions-prof-0.10.7-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-exceptions-prof}"
SRC_URI[x86_64_v2_ghc-exceptions-prof.sha256sum] = "2ead72fff420c769740ed68730feed0ca475691414898e01cbadb930a7670de1"

URI_x86_64_v2_ghc-filepath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filepath-1.4.300.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-filepath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filepath}"
SRC_URI[x86_64_v2_ghc-filepath.sha256sum] = "b2254a10c855a627bd63054724274c28c423a50d9cf386ac90c0d97735f0b1c1"

URI_x86_64_v2_ghc-filepath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filepath-devel-1.4.300.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filepath-devel}"
SRC_URI[x86_64_v2_ghc-filepath-devel.sha256sum] = "c1e4ab23b48a9012e7759d29e010448c6134b5969a3a6381c6ead951debf4a15"

URI_x86_64_v2_ghc-filepath-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filepath-doc-1.4.300.1-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filepath-doc}"
SRC_URI[x86_64_v2_ghc-filepath-doc.sha256sum] = "fbf2d2d4ae40ac1aa2c3ec40eaad58991ed80088217391f468641d323c38eddf"

URI_x86_64_v2_ghc-filepath-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filepath-prof-1.4.300.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filepath-prof}"
SRC_URI[x86_64_v2_ghc-filepath-prof.sha256sum] = "1d0afc31b22b59e16d1068f5bd281b9c99db361602cad33420d0b0cc77282f81"

URI_x86_64_v2_ghc-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filesystem-9.6.6-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filesystem}"
SRC_URI[x86_64_v2_ghc-filesystem.sha256sum] = "112ebe12faef5acb7c110b4c619e5638333b36fcbeecd35b17621e56d5b0190d"

URI_x86_64_v2_ghc-ghc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc}"
SRC_URI[x86_64_v2_ghc-ghc.sha256sum] = "b47971b81f03615169680c079c2cb05516b40b1f2b4c70650ccc51d7348f4937"

URI_x86_64_v2_ghc-ghc-bignum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-bignum-1.3-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-bignum}"
SRC_URI[x86_64_v2_ghc-ghc-bignum.sha256sum] = "bc852fcd5622b2a70526de0b4ac2cd5aab66a5e69177c5c9b77e1cbe540f63a6"

URI_x86_64_v2_ghc-ghc-bignum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-bignum-devel-1.3-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-bignum-devel}"
SRC_URI[x86_64_v2_ghc-ghc-bignum-devel.sha256sum] = "724cca0a2e5d1470ff6b053432bc2ae87fdd41c9a9f516340297dbc2b4bbe1d4"

URI_x86_64_v2_ghc-ghc-bignum-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-bignum-doc-1.3-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-bignum-doc}"
SRC_URI[x86_64_v2_ghc-ghc-bignum-doc.sha256sum] = "3f4f28387a11df06fc0e62801c3860dfd8037e2c4c4a15a98d063189fbc39fca"

URI_x86_64_v2_ghc-ghc-bignum-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-bignum-prof-1.3-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-bignum-prof}"
SRC_URI[x86_64_v2_ghc-ghc-bignum-prof.sha256sum] = "89049371b37c336660b14d9b1ce780a05ebee4f2314a30555e6c51f90be2b9b8"

URI_x86_64_v2_ghc-ghc-boot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-boot-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-boot}"
SRC_URI[x86_64_v2_ghc-ghc-boot.sha256sum] = "b891c26fd24c0fc173630bfda969d80e096d0a26fb1c9b14b5c8f764eea3e9fd"

URI_x86_64_v2_ghc-ghc-boot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-boot-devel-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-boot-devel}"
SRC_URI[x86_64_v2_ghc-ghc-boot-devel.sha256sum] = "8af46edc36538d3ec563cd8c6d8a7d82b27900b3f989472c682d664010eeaeef"

URI_x86_64_v2_ghc-ghc-boot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-boot-doc-9.6.6-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-boot-doc}"
SRC_URI[x86_64_v2_ghc-ghc-boot-doc.sha256sum] = "c5e4f68f52823adcfa545f9a703b5ed6b7945b2e4a9f520a27ae2975fc2a5380"

URI_x86_64_v2_ghc-ghc-boot-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-boot-prof-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-boot-prof}"
SRC_URI[x86_64_v2_ghc-ghc-boot-prof.sha256sum] = "1e5163ed18ea755c850ec5936e1bd389fb28c29343a7d12a4968a7c7fa753a03"

URI_x86_64_v2_ghc-ghc-boot-th = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-boot-th-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-boot-th}"
SRC_URI[x86_64_v2_ghc-ghc-boot-th.sha256sum] = "f9cf0a27c46f555eada5d943df8b1ab53c40d7c4f47a762b83d84f656bcaf4e4"

URI_x86_64_v2_ghc-ghc-boot-th-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-boot-th-devel-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-boot-th-devel}"
SRC_URI[x86_64_v2_ghc-ghc-boot-th-devel.sha256sum] = "2ddd3d76a8c062361f4761898b107a6f5f572fb90d68af534699ec9e2c25ca9b"

URI_x86_64_v2_ghc-ghc-boot-th-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-boot-th-doc-9.6.6-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-boot-th-doc}"
SRC_URI[x86_64_v2_ghc-ghc-boot-th-doc.sha256sum] = "75b420862b64f3c81c39d115de33258eb6c6427376b46c9101c86ba0619a01e7"

URI_x86_64_v2_ghc-ghc-boot-th-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-boot-th-prof-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-boot-th-prof}"
SRC_URI[x86_64_v2_ghc-ghc-boot-th-prof.sha256sum] = "53f9da7a6b5c90deebe700806f97311ab33f960fd2361b3104075220dda9a634"

URI_x86_64_v2_ghc-ghc-compact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-compact-0.1.0.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-compact}"
SRC_URI[x86_64_v2_ghc-ghc-compact.sha256sum] = "71d94e7d5b14d062860084a4056924050c322ae78644642dbc252e97df120857"

URI_x86_64_v2_ghc-ghc-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-compact-devel-0.1.0.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-compact-devel}"
SRC_URI[x86_64_v2_ghc-ghc-compact-devel.sha256sum] = "b2b99be1d2fa61d7119a94d085fd039ee4498de6949b2ade3a75c09854fd1377"

URI_x86_64_v2_ghc-ghc-compact-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-compact-doc-0.1.0.0-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-compact-doc}"
SRC_URI[x86_64_v2_ghc-ghc-compact-doc.sha256sum] = "e273e0c2230551d0bca79d4451979b03e3e1e230bc87cfb50df78f23c7988a81"

URI_x86_64_v2_ghc-ghc-compact-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-compact-prof-0.1.0.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-compact-prof}"
SRC_URI[x86_64_v2_ghc-ghc-compact-prof.sha256sum] = "41b7b541ec81843d15b0e662615fc0a769c78057407018e41cbfb97de6da2357"

URI_x86_64_v2_ghc-ghc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-devel-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-devel}"
SRC_URI[x86_64_v2_ghc-ghc-devel.sha256sum] = "409a1fc185e527896d0d10b14e92752f148cc03a61f746add48e6d7cf9f149ce"

URI_x86_64_v2_ghc-ghc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-doc-9.6.6-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-doc}"
SRC_URI[x86_64_v2_ghc-ghc-doc.sha256sum] = "b78e7053ed1865481527cf9f106a68c4d685767c532c34fecaa6478883b60554"

URI_x86_64_v2_ghc-ghc-heap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-heap-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-heap}"
SRC_URI[x86_64_v2_ghc-ghc-heap.sha256sum] = "2f2d8cf4a78699004ab79f5aa3e8020944cd0e082647c235b93ba56233345122"

URI_x86_64_v2_ghc-ghc-heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-heap-devel-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-heap-devel}"
SRC_URI[x86_64_v2_ghc-ghc-heap-devel.sha256sum] = "e161e38406eb79ba46a9b290149bc89ecf28267ed216a751d44e5804a586b406"

URI_x86_64_v2_ghc-ghc-heap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-heap-doc-9.6.6-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-heap-doc}"
SRC_URI[x86_64_v2_ghc-ghc-heap-doc.sha256sum] = "ae9a6144dc3e571f61d6059988991729d60c4bff9a28bbbb63f55500f22ca2f3"

URI_x86_64_v2_ghc-ghc-heap-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-heap-prof-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-heap-prof}"
SRC_URI[x86_64_v2_ghc-ghc-heap-prof.sha256sum] = "536425c7f840d0408a7cba81e5213137150dbf8745ed6f29d795f007d58d3297"

URI_x86_64_v2_ghc-ghc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-prof-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-prof}"
SRC_URI[x86_64_v2_ghc-ghc-prof.sha256sum] = "907e815964a1c887937178d30a8ff4e004034c471e738b0508351efcf8eb3a09"

URI_x86_64_v2_ghc-ghci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghci-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghci}"
SRC_URI[x86_64_v2_ghc-ghci.sha256sum] = "e2284ef4c7d66ebe0dbf4728eda83303fe420455d339f41f79fd7b94280253db"

URI_x86_64_v2_ghc-ghci-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghci-devel-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghci-devel}"
SRC_URI[x86_64_v2_ghc-ghci-devel.sha256sum] = "ccb95904be84eb03b1b76c535ede262e404efe75a4533e3dde3853fd10f676dd"

URI_x86_64_v2_ghc-ghci-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghci-doc-9.6.6-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghci-doc}"
SRC_URI[x86_64_v2_ghc-ghci-doc.sha256sum] = "215f21b6bc173e6c6411c29e83697d861e607313d2b9073c718fc5e4b65f8b2b"

URI_x86_64_v2_ghc-ghci-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghci-prof-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghci-prof}"
SRC_URI[x86_64_v2_ghc-ghci-prof.sha256sum] = "0dbb1db58300050301964a01ff2123dcaba6457055a36958ee61c2e31c41cbb3"

URI_x86_64_v2_ghc-hadrian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hadrian-0.1.0.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hadrian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hadrian}"
SRC_URI[x86_64_v2_ghc-hadrian.sha256sum] = "2b22a873bbfe22cac9469eb2d77d569901237a81112863342ee15b6ceedc7843"

URI_x86_64_v2_ghc-haskeline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskeline-0.8.2.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haskeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskeline}"
SRC_URI[x86_64_v2_ghc-haskeline.sha256sum] = "380891b817e9490785b83b3122b5e2cbac98cdd30ac529e2677e529c256224cf"

URI_x86_64_v2_ghc-haskeline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskeline-devel-0.8.2.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskeline-devel}"
SRC_URI[x86_64_v2_ghc-haskeline-devel.sha256sum] = "e630edf806e1df10117048dae3c2417b075f1a817c489a109603c688216d01de"

URI_x86_64_v2_ghc-haskeline-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskeline-doc-0.8.2.1-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskeline-doc}"
SRC_URI[x86_64_v2_ghc-haskeline-doc.sha256sum] = "c8d4c4e09a0bb097ba7b3b7feb7f205b28f17c79a9743c718e92cd85792f2411"

URI_x86_64_v2_ghc-haskeline-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskeline-prof-0.8.2.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskeline-prof}"
SRC_URI[x86_64_v2_ghc-haskeline-prof.sha256sum] = "bc0259fb059715c5b4478de301605aecce5c567aaaef6feeb4ace8516d9984b2"

URI_x86_64_v2_ghc-hpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hpc-0.6.2.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hpc}"
SRC_URI[x86_64_v2_ghc-hpc.sha256sum] = "6c524cf15093bffd24a71b052a4ba71c60c4685b74a69d901d77d423a70acf89"

URI_x86_64_v2_ghc-hpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hpc-devel-0.6.2.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hpc-devel}"
SRC_URI[x86_64_v2_ghc-hpc-devel.sha256sum] = "9646a312bc9d1d84cb145addcf37f71205a794c29339d58627549f434548aca7"

URI_x86_64_v2_ghc-hpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hpc-doc-0.6.2.0-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hpc-doc}"
SRC_URI[x86_64_v2_ghc-hpc-doc.sha256sum] = "701ab841d8679b92419bdd899baeb750fc423b563016fee0c0a7be326283b368"

URI_x86_64_v2_ghc-hpc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hpc-prof-0.6.2.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hpc-prof}"
SRC_URI[x86_64_v2_ghc-hpc-prof.sha256sum] = "a4284394feeea8a76e27a4b0daccad7cabf641b76a4d351d87ee0eefaf262f2a"

URI_x86_64_v2_ghc-libiserv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-libiserv-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-libiserv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-libiserv}"
SRC_URI[x86_64_v2_ghc-libiserv.sha256sum] = "1f925877135a3ab9c55e278cf78e11bc9421a4e474f6580013f732ad8258f4ec"

URI_x86_64_v2_ghc-libiserv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-libiserv-devel-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-libiserv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-libiserv-devel}"
SRC_URI[x86_64_v2_ghc-libiserv-devel.sha256sum] = "a34bf8d76fbcdab20ea87011c2082df8b0356b1a8a5fbc610ad049789ece71a3"

URI_x86_64_v2_ghc-libiserv-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-libiserv-doc-9.6.6-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-libiserv-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-libiserv-doc}"
SRC_URI[x86_64_v2_ghc-libiserv-doc.sha256sum] = "f614b521817eb6416e88adf6b9fb601b6234b09ce4ae86c2d35e7711428cea25"

URI_x86_64_v2_ghc-libiserv-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-libiserv-prof-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-libiserv-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-libiserv-prof}"
SRC_URI[x86_64_v2_ghc-libiserv-prof.sha256sum] = "b950893349bd07615bae37aa53452d399cca4a822309518ff42f3d3d014e3873"

URI_x86_64_v2_ghc-manual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-manual-9.6.6-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-manual}"
SRC_URI[x86_64_v2_ghc-manual.sha256sum] = "bd7c62930f42d6d43ba25d47e277d38fda66ed715a2716f0b7d659aa5c847236"

URI_x86_64_v2_ghc-mtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mtl-2.3.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mtl}"
SRC_URI[x86_64_v2_ghc-mtl.sha256sum] = "55c29c85f8afb11b269249ddf6005c7c38f4456c9e43aebdc0e4e3dce642bc2f"

URI_x86_64_v2_ghc-mtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mtl-devel-2.3.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mtl-devel}"
SRC_URI[x86_64_v2_ghc-mtl-devel.sha256sum] = "260e3146906ea49fc8448e6ac2ce24b7071ac740157a21a74b180033f41c992f"

URI_x86_64_v2_ghc-mtl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mtl-doc-2.3.1-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mtl-doc}"
SRC_URI[x86_64_v2_ghc-mtl-doc.sha256sum] = "087aa32b0694fd1b4f6ef806172d64cd0f3199f83903f59a4c53219890036e02"

URI_x86_64_v2_ghc-mtl-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mtl-prof-2.3.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mtl-prof}"
SRC_URI[x86_64_v2_ghc-mtl-prof.sha256sum] = "f3f1c112f3e1f34d8a3b7fce92a858ffb65da8e6742429f2d4599476ca29baf4"

URI_x86_64_v2_ghc-parsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parsec-3.1.16.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-parsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-parsec}"
SRC_URI[x86_64_v2_ghc-parsec.sha256sum] = "6b8e82f400779b9f1b83fffb32d66f87ebd55ca0f704e63278ca1f1cb06835ae"

URI_x86_64_v2_ghc-parsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parsec-devel-3.1.16.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-parsec-devel}"
SRC_URI[x86_64_v2_ghc-parsec-devel.sha256sum] = "0d30c0b2b7235e54a108637d26689cad8cbde15e7101a43ffd3ed183f2fa6a8a"

URI_x86_64_v2_ghc-parsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parsec-doc-3.1.16.1-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-parsec-doc}"
SRC_URI[x86_64_v2_ghc-parsec-doc.sha256sum] = "87434122821cf44a4cd92fe5a52a6fde3860f9cc6f2d9519b7b604b0ac9d2c0d"

URI_x86_64_v2_ghc-parsec-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parsec-prof-3.1.16.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-parsec-prof}"
SRC_URI[x86_64_v2_ghc-parsec-prof.sha256sum] = "d9f7828546a2a9ae22bb14ddde16d229f475246bbbd0fcd980005f6fccf6054c"

URI_x86_64_v2_ghc-pretty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pretty-1.1.3.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pretty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pretty}"
SRC_URI[x86_64_v2_ghc-pretty.sha256sum] = "dafbec94b650f127fbc1932bda272fe959baed52cf37737538471dd93f6f7af2"

URI_x86_64_v2_ghc-pretty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pretty-devel-1.1.3.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pretty-devel}"
SRC_URI[x86_64_v2_ghc-pretty-devel.sha256sum] = "66645a4a6efa82eb8c52a21c8257d8aff001bd52e8f9ba447a18c7e85477d28b"

URI_x86_64_v2_ghc-pretty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pretty-doc-1.1.3.6-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pretty-doc}"
SRC_URI[x86_64_v2_ghc-pretty-doc.sha256sum] = "2b0b08ecd828848e93b48c8bb3ec672660c7924b34d3d524486b2219905200f0"

URI_x86_64_v2_ghc-pretty-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pretty-prof-1.1.3.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pretty-prof}"
SRC_URI[x86_64_v2_ghc-pretty-prof.sha256sum] = "3b61033bb62e5b65b160059cd49d00697194fd76093180a8e16d4357907f25fd"

URI_x86_64_v2_ghc-process = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-process-1.6.19.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-process}"
SRC_URI[x86_64_v2_ghc-process.sha256sum] = "fc0b9a45812d82d8c00e2d1437c5841ae7a11bb71c2269a2668c5b725040a19a"

URI_x86_64_v2_ghc-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-process-devel-1.6.19.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-process-devel}"
SRC_URI[x86_64_v2_ghc-process-devel.sha256sum] = "c0288531479985e4fa84272135b0c314be62511e0b220283d4189cc0d7142b24"

URI_x86_64_v2_ghc-process-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-process-doc-1.6.19.0-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-process-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-process-doc}"
SRC_URI[x86_64_v2_ghc-process-doc.sha256sum] = "fbb5e2cae6655cf7d733c12cc944e43aa7851a92ce768035cec0a4348b86619c"

URI_x86_64_v2_ghc-process-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-process-prof-1.6.19.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-process-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-process-prof}"
SRC_URI[x86_64_v2_ghc-process-prof.sha256sum] = "3fb0fd9c97aee0e0e518f299877e8841ae0b64856960803632f7f13fa9d73f88"

URI_x86_64_v2_ghc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-prof-9.6.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-prof}"
SRC_URI[x86_64_v2_ghc-prof.sha256sum] = "e3ccaaade5daaec20f865172bb000701aca883f9a647729d6bfa486ebe4033a5"

URI_x86_64_v2_ghc-stm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-stm-2.5.1.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-stm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-stm}"
SRC_URI[x86_64_v2_ghc-stm.sha256sum] = "ff3c1a96f046d8e19ad14bfbd3d7636443de18c0a0488e9d180d3188edba217a"

URI_x86_64_v2_ghc-stm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-stm-devel-2.5.1.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-stm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-stm-devel}"
SRC_URI[x86_64_v2_ghc-stm-devel.sha256sum] = "12954b1a1c8f941db0754719d294d601e6fe91b18e8bebea983bc52a409c8768"

URI_x86_64_v2_ghc-stm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-stm-doc-2.5.1.0-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-stm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-stm-doc}"
SRC_URI[x86_64_v2_ghc-stm-doc.sha256sum] = "107b60bb4f371580611e8570f46de488594526a06717eef707c056b947c7b1a7"

URI_x86_64_v2_ghc-stm-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-stm-prof-2.5.1.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-stm-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-stm-prof}"
SRC_URI[x86_64_v2_ghc-stm-prof.sha256sum] = "2efa9a95800a2b0d1797289e3e11823af382746959a138bdbbafc637c9df8e69"

URI_x86_64_v2_ghc-template-haskell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-template-haskell-2.20.0.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-template-haskell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-template-haskell}"
SRC_URI[x86_64_v2_ghc-template-haskell.sha256sum] = "5e65daa6017d2760916e7e74d95f76f4e4eab698f7c88d3e538aee3c8879c931"

URI_x86_64_v2_ghc-template-haskell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-template-haskell-devel-2.20.0.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-template-haskell-devel}"
SRC_URI[x86_64_v2_ghc-template-haskell-devel.sha256sum] = "11d15aa3e25444a6e30b6cc532badf252df0b1dc7649bec1dc9c22593c7fb570"

URI_x86_64_v2_ghc-template-haskell-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-template-haskell-doc-2.20.0.0-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-template-haskell-doc}"
SRC_URI[x86_64_v2_ghc-template-haskell-doc.sha256sum] = "cc7f581a93224cda1f9855447109bcf85e5f6a6be88d4d170d0555a7af3402c6"

URI_x86_64_v2_ghc-template-haskell-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-template-haskell-prof-2.20.0.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-template-haskell-prof}"
SRC_URI[x86_64_v2_ghc-template-haskell-prof.sha256sum] = "3df999c7008b4f5025c99da28f565778b23e694432684dd1e224477990e7663f"

URI_x86_64_v2_ghc-terminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-terminfo-0.4.1.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-terminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-terminfo}"
SRC_URI[x86_64_v2_ghc-terminfo.sha256sum] = "a86d37d7280b97f94d45a3009c8edc4e36c798d8661dc0c2b8b98f068a8c7631"

URI_x86_64_v2_ghc-terminfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-terminfo-devel-0.4.1.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-terminfo-devel}"
SRC_URI[x86_64_v2_ghc-terminfo-devel.sha256sum] = "8cfd6840f41a00ccc608024b6ebd30e07322bfb7fd433f21137250ac56d9e169"

URI_x86_64_v2_ghc-terminfo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-terminfo-doc-0.4.1.6-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-terminfo-doc}"
SRC_URI[x86_64_v2_ghc-terminfo-doc.sha256sum] = "4e01f53ce80ddfb7f20fa6dd1d2305d5b4a8d9c3dcd50c4260479e35c52955c5"

URI_x86_64_v2_ghc-terminfo-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-terminfo-prof-0.4.1.6-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-terminfo-prof}"
SRC_URI[x86_64_v2_ghc-terminfo-prof.sha256sum] = "f2a45c5b0702f43847bc713ce59eb7665fb4d001cf5e14c41fea57a1e185b83e"

URI_x86_64_v2_ghc-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-2.0.2-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text}"
SRC_URI[x86_64_v2_ghc-text.sha256sum] = "64ac48dddceaf4012b8b15888bb68df5b8d68be7e23d5bf4f5a8b7064dad4687"

URI_x86_64_v2_ghc-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-devel-2.0.2-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-devel}"
SRC_URI[x86_64_v2_ghc-text-devel.sha256sum] = "431ae33432dd8dbc593934eabf78305e9b54ac62a19165c8668874c46862c9fa"

URI_x86_64_v2_ghc-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-doc-2.0.2-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-doc}"
SRC_URI[x86_64_v2_ghc-text-doc.sha256sum] = "6a84f24fe3147deaea4b5de9c1dd789e05cd6dada0241a54c3b9ea59cb768fb9"

URI_x86_64_v2_ghc-text-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-prof-2.0.2-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-prof}"
SRC_URI[x86_64_v2_ghc-text-prof.sha256sum] = "afcfe3e7ea2229a01dd7de580f0a56e55a3d4f35e1fa4902312ba973c6cc4a9d"

URI_x86_64_v2_ghc-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-1.12.2-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time}"
SRC_URI[x86_64_v2_ghc-time.sha256sum] = "32efea26c949dae16da486f6e7ab6ad21ff004bf85525948424070bd6234b979"

URI_x86_64_v2_ghc-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-devel-1.12.2-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-devel}"
SRC_URI[x86_64_v2_ghc-time-devel.sha256sum] = "b46ae0426225c962549fa69404c9e60c38deae74e46111c35f6146361ef7b788"

URI_x86_64_v2_ghc-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-doc-1.12.2-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-doc}"
SRC_URI[x86_64_v2_ghc-time-doc.sha256sum] = "95b1a815f579ee50cac19fe65737419bc94ee3bb948e551d215619e52d2ff136"

URI_x86_64_v2_ghc-time-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-prof-1.12.2-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-time-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-prof}"
SRC_URI[x86_64_v2_ghc-time-prof.sha256sum] = "2db5fcd9b846891ba3ebdbc95ae6516df6aea8f8a18e2c9986045b88735bfc55"

URI_x86_64_v2_ghc-transformers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-transformers-0.6.1.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-transformers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-transformers}"
SRC_URI[x86_64_v2_ghc-transformers.sha256sum] = "de6e364e5dba986e7d5f4eb96cf89bcb02537d4084dea04aa5c43a95d21ad5c4"

URI_x86_64_v2_ghc-transformers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-transformers-devel-0.6.1.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-transformers-devel}"
SRC_URI[x86_64_v2_ghc-transformers-devel.sha256sum] = "0021c78f7762735a02b04139a1f74e9f0014516c5b18b5d8f5c95db003670ef7"

URI_x86_64_v2_ghc-transformers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-transformers-doc-0.6.1.0-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-transformers-doc}"
SRC_URI[x86_64_v2_ghc-transformers-doc.sha256sum] = "3242030258239807cce904451882e9540f6a266447ae5bd05a7e517c878905d4"

URI_x86_64_v2_ghc-transformers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-transformers-prof-0.6.1.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-transformers-prof}"
SRC_URI[x86_64_v2_ghc-transformers-prof.sha256sum] = "898ba9fc4fce922b93afa8ffbe61e548c00078e7213ec450c5cde8b791cc2ab7"

URI_x86_64_v2_ghc-unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unix-2.8.4.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unix}"
SRC_URI[x86_64_v2_ghc-unix.sha256sum] = "7f05e8afa82e46a4f74c52ccba18032d2e9f2a70ed7a3180c374ee645bcf042c"

URI_x86_64_v2_ghc-unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unix-devel-2.8.4.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unix-devel}"
SRC_URI[x86_64_v2_ghc-unix-devel.sha256sum] = "44a19842f3650032753a7a0ff0c84b6a58a08d80dcf64c935187c138cc49b80c"

URI_x86_64_v2_ghc-unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unix-doc-2.8.4.0-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unix-doc}"
SRC_URI[x86_64_v2_ghc-unix-doc.sha256sum] = "3dc2bfea0f126a4ad17597821708afc65590646d0eb955f6cbf34c7b1febb51e"

URI_x86_64_v2_ghc-unix-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unix-prof-2.8.4.0-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unix-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unix-prof}"
SRC_URI[x86_64_v2_ghc-unix-prof.sha256sum] = "5f3979e4f9c5ed91ef315f603c50ee4e63f9a031c92d868ebee2863c33724b2d"

URI_x86_64_v2_ghc-xhtml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xhtml-3000.2.2.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xhtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xhtml}"
SRC_URI[x86_64_v2_ghc-xhtml.sha256sum] = "5b99c39a47c7f8fb0924bc8f242275f5f4d073e55f5009585d385f067f2970a7"

URI_x86_64_v2_ghc-xhtml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xhtml-devel-3000.2.2.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xhtml-devel}"
SRC_URI[x86_64_v2_ghc-xhtml-devel.sha256sum] = "39142f542c5d313e546e57d2acf5030164b5fa0821b8841bf173febf23ad77d1"

URI_x86_64_v2_ghc-xhtml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xhtml-doc-3000.2.2.1-146.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xhtml-doc}"
SRC_URI[x86_64_v2_ghc-xhtml-doc.sha256sum] = "09c3fe4438f77ee6b9c1c2ee40eb7282525f3f5c3646fe8cc385f1bd4a0928cc"

URI_x86_64_v2_ghc-xhtml-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xhtml-prof-3000.2.2.1-146.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xhtml-prof}"
SRC_URI[x86_64_v2_ghc-xhtml-prof.sha256sum] = "d699508139fe8b6972bc0abe96ed7c6efc582b71e4e3c97a84750260e62ea80c"

URI_aarch64_ghc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc}"
SRC_URI[aarch64_ghc.sha256sum] = "0d09607e1c83f662bd5962ff44b5013288cdf6318a680b85f3305ae5113cc638"

URI_aarch64_ghc-Cabal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Cabal-3.10.3.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-Cabal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Cabal}"
SRC_URI[aarch64_ghc-Cabal.sha256sum] = "d6f44ffae08cfca6f6c5f5139ff186be3a310a478bc1cdfe3ef5a9de8b9477f4"

URI_aarch64_ghc-Cabal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Cabal-devel-3.10.3.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Cabal-devel}"
SRC_URI[aarch64_ghc-Cabal-devel.sha256sum] = "8c6c91f1d411edd2988b071382cc49a86b64dfaa2d4a69830d76f929b187c0de"

URI_aarch64_ghc-Cabal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Cabal-doc-3.10.3.0-146.el10_0.noarch.rpm;name=aarch64_ghc-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Cabal-doc}"
SRC_URI[aarch64_ghc-Cabal-doc.sha256sum] = "a8a8b394513e02d8232dda37dbb39576a61a770e144ef401bd0131127647d229"

URI_aarch64_ghc-Cabal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Cabal-prof-3.10.3.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Cabal-prof}"
SRC_URI[aarch64_ghc-Cabal-prof.sha256sum] = "7dfbcede413324a8c9234f013bfb1b32f974b2cf3be596933d3cf4735972036f"

URI_aarch64_ghc-Cabal-syntax = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Cabal-syntax-3.10.3.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Cabal-syntax}"
SRC_URI[aarch64_ghc-Cabal-syntax.sha256sum] = "447d0d3ec19dc589a8ee2e5c65919a7f0232aa65060d51eb3b1c9d83c8cd903c"

URI_aarch64_ghc-Cabal-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Cabal-syntax-devel-3.10.3.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Cabal-syntax-devel}"
SRC_URI[aarch64_ghc-Cabal-syntax-devel.sha256sum] = "f902e0bb358b787370699c5a530360ceedff8b07d27630d6678789c2c40c8a91"

URI_aarch64_ghc-Cabal-syntax-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Cabal-syntax-doc-3.10.3.0-146.el10_0.noarch.rpm;name=aarch64_ghc-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Cabal-syntax-doc}"
SRC_URI[aarch64_ghc-Cabal-syntax-doc.sha256sum] = "2db6e98e4ca6854a8994f4fbefddc2bb0caf28f3d1a0dc002546c775b2b44158"

URI_aarch64_ghc-Cabal-syntax-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Cabal-syntax-prof-3.10.3.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-Cabal-syntax-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Cabal-syntax-prof}"
SRC_URI[aarch64_ghc-Cabal-syntax-prof.sha256sum] = "54f34ced17ade7b57bad5e60db78af04a9e337f8f1ffff3f64f63273ff200ab3"

URI_aarch64_ghc-array = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-array-0.5.6.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-array;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-array}"
SRC_URI[aarch64_ghc-array.sha256sum] = "710fd8e6ce2fad89c372fd49c2f0075daa39271af8253144f54b88034be499bc"

URI_aarch64_ghc-array-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-array-devel-0.5.6.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-array-devel}"
SRC_URI[aarch64_ghc-array-devel.sha256sum] = "1141b360175d7536411570d82e8818017f62d15533e7694410c4bb42fa5abd86"

URI_aarch64_ghc-array-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-array-doc-0.5.6.0-146.el10_0.noarch.rpm;name=aarch64_ghc-array-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-array-doc}"
SRC_URI[aarch64_ghc-array-doc.sha256sum] = "c5128345f8e485823a5ed9b015a97e12cb850fec193999a2fe0da85de0c103af"

URI_aarch64_ghc-array-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-array-prof-0.5.6.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-array-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-array-prof}"
SRC_URI[aarch64_ghc-array-prof.sha256sum] = "7cd5f4634f684998d9697414e81d1d4449940d69f9d2dac0a1331992ecc08ddb"

URI_aarch64_ghc-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-4.18.2.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base}"
SRC_URI[aarch64_ghc-base.sha256sum] = "c8d7e0d11d5fbeaaa237d5b050a7494a9bb3321c0b4b1bc77e9458b04714ccba"

URI_aarch64_ghc-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-devel-4.18.2.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-devel}"
SRC_URI[aarch64_ghc-base-devel.sha256sum] = "c0aafcca7d8e455cda3600edb28fe73b6766450f9a7b43913f48d42fe790126a"

URI_aarch64_ghc-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-doc-4.18.2.1-146.el10_0.noarch.rpm;name=aarch64_ghc-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-doc}"
SRC_URI[aarch64_ghc-base-doc.sha256sum] = "e60cdf9106bd541473c8fd9fdf09c1bce066ea1c0bcbe06df23534cd906e34a1"

URI_aarch64_ghc-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-prof-4.18.2.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-prof}"
SRC_URI[aarch64_ghc-base-prof.sha256sum] = "ceeb9a8a6750ef10f5e77f6f03bb32af65cd23fc4e4e09817bed146da0d3a559"

URI_aarch64_ghc-binary = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-binary-0.8.9.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-binary;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-binary}"
SRC_URI[aarch64_ghc-binary.sha256sum] = "7b62c615b2884ed11cd1fb2919c3810089c4a258bf90678dad4bcfdc10767364"

URI_aarch64_ghc-binary-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-binary-devel-0.8.9.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-binary-devel}"
SRC_URI[aarch64_ghc-binary-devel.sha256sum] = "cc5f5942ffc4fa18eb93d99e811353f184bae928293e0679600b03df77e11bff"

URI_aarch64_ghc-binary-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-binary-doc-0.8.9.1-146.el10_0.noarch.rpm;name=aarch64_ghc-binary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-binary-doc}"
SRC_URI[aarch64_ghc-binary-doc.sha256sum] = "bf73d0172d2b686982ec271b49c59ba46d80b4227f11c4cccba4dbca77555c4f"

URI_aarch64_ghc-binary-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-binary-prof-0.8.9.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-binary-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-binary-prof}"
SRC_URI[aarch64_ghc-binary-prof.sha256sum] = "d8c2922968e7cbf87cddc13aa976e190b5022a97a21d4064650842c3100ff4ca"

URI_aarch64_ghc-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bytestring-0.11.5.3-146.el10_0.aarch64.rpm;name=aarch64_ghc-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bytestring}"
SRC_URI[aarch64_ghc-bytestring.sha256sum] = "eae72558ced30110a8b62ad8848684788d396b69411978304c4eb5d640c05361"

URI_aarch64_ghc-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bytestring-devel-0.11.5.3-146.el10_0.aarch64.rpm;name=aarch64_ghc-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bytestring-devel}"
SRC_URI[aarch64_ghc-bytestring-devel.sha256sum] = "a3a95389238f1794112248847c379261f513820a1e664cee12d4944ea6e513b7"

URI_aarch64_ghc-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bytestring-doc-0.11.5.3-146.el10_0.noarch.rpm;name=aarch64_ghc-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bytestring-doc}"
SRC_URI[aarch64_ghc-bytestring-doc.sha256sum] = "84d5799d48c715c6b2a354cf5ead0afa6845053fc871c576313da572e287229e"

URI_aarch64_ghc-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bytestring-prof-0.11.5.3-146.el10_0.aarch64.rpm;name=aarch64_ghc-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bytestring-prof}"
SRC_URI[aarch64_ghc-bytestring-prof.sha256sum] = "9d482c6e196803659309b83f50a2cdc6a91fa0639f5ea962322fb9ae998683c8"

URI_aarch64_ghc-compiler = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-compiler-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-compiler}"
SRC_URI[aarch64_ghc-compiler.sha256sum] = "daa164467fa2bfc792956c0c5d700095ced38acacec4cd96732b3752160d8dae"

URI_aarch64_ghc-containers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-containers-0.6.7-146.el10_0.aarch64.rpm;name=aarch64_ghc-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-containers}"
SRC_URI[aarch64_ghc-containers.sha256sum] = "4e0aac5893a5e07df88c0854967ca073013ba14455e94e1eed7fbba1bf9763f4"

URI_aarch64_ghc-containers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-containers-devel-0.6.7-146.el10_0.aarch64.rpm;name=aarch64_ghc-containers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-containers-devel}"
SRC_URI[aarch64_ghc-containers-devel.sha256sum] = "75da13802cb219b59afd130e8eaf7229c441f32ecb2470a8727629893d3a531d"

URI_aarch64_ghc-containers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-containers-doc-0.6.7-146.el10_0.noarch.rpm;name=aarch64_ghc-containers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-containers-doc}"
SRC_URI[aarch64_ghc-containers-doc.sha256sum] = "9e60aa9ec4243d7908e0738d3fdff14a82471dfb462246dd1b812ac33e36bc9f"

URI_aarch64_ghc-containers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-containers-prof-0.6.7-146.el10_0.aarch64.rpm;name=aarch64_ghc-containers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-containers-prof}"
SRC_URI[aarch64_ghc-containers-prof.sha256sum] = "f6a24baabb41c3ae5263b8d70b35f341517cd77e7f5d8f96f672dff324fb0686"

URI_aarch64_ghc-deepseq = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deepseq-1.4.8.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-deepseq;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deepseq}"
SRC_URI[aarch64_ghc-deepseq.sha256sum] = "f52156b811d402b5e40396f20b0f1d40b7cfe9f752523689147c143728ff0907"

URI_aarch64_ghc-deepseq-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deepseq-devel-1.4.8.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deepseq-devel}"
SRC_URI[aarch64_ghc-deepseq-devel.sha256sum] = "8dc86de832c319e333dc52f2cb6ada821bedf688580996a1ca0e1b08b7c37b62"

URI_aarch64_ghc-deepseq-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deepseq-doc-1.4.8.1-146.el10_0.noarch.rpm;name=aarch64_ghc-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deepseq-doc}"
SRC_URI[aarch64_ghc-deepseq-doc.sha256sum] = "dd67bec648746398be2989215c04ab4576aadfc8820dd45a37c3ebb332382e2d"

URI_aarch64_ghc-deepseq-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deepseq-prof-1.4.8.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deepseq-prof}"
SRC_URI[aarch64_ghc-deepseq-prof.sha256sum] = "880a81535ca7cfd14ba651bbc0c4946706314c51f30e8025e1267d0c4a9910e7"

URI_aarch64_ghc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-devel-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-devel}"
SRC_URI[aarch64_ghc-devel.sha256sum] = "349add93c79e5ab794023cc724f1df12b3cd1cba66f6a180f5e3469b8f662a85"

URI_aarch64_ghc-directory = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-directory-1.3.8.5-146.el10_0.aarch64.rpm;name=aarch64_ghc-directory;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-directory}"
SRC_URI[aarch64_ghc-directory.sha256sum] = "1138c1dc0874d2e4d0e52d772ee293bd09b564173eb1605f96387c6556edda6d"

URI_aarch64_ghc-directory-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-directory-devel-1.3.8.5-146.el10_0.aarch64.rpm;name=aarch64_ghc-directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-directory-devel}"
SRC_URI[aarch64_ghc-directory-devel.sha256sum] = "8bb3fbdd42a40d947128ad7afd8783b80b2308913158d9a0534710cf964870fa"

URI_aarch64_ghc-directory-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-directory-doc-1.3.8.5-146.el10_0.noarch.rpm;name=aarch64_ghc-directory-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-directory-doc}"
SRC_URI[aarch64_ghc-directory-doc.sha256sum] = "0077e5a7ff8e1c6ec5361447e333400298d8c9d138aaf42bbbd60a60c46ab4ca"

URI_aarch64_ghc-directory-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-directory-prof-1.3.8.5-146.el10_0.aarch64.rpm;name=aarch64_ghc-directory-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-directory-prof}"
SRC_URI[aarch64_ghc-directory-prof.sha256sum] = "4354680029f342cf8e3a9e28b3a7b75b570871c47a2fc76593bd351b088e17c3"

URI_aarch64_ghc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-doc-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-doc}"
SRC_URI[aarch64_ghc-doc.sha256sum] = "f7d4de42462756b047066222ba77ce84e9377c6a63fd17d092dacfea9ce2fba8"

URI_aarch64_ghc-doc-index = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-doc-index-9.6.6-146.el10_0.noarch.rpm;name=aarch64_ghc-doc-index;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-doc-index}"
SRC_URI[aarch64_ghc-doc-index.sha256sum] = "5e2759cc8eae2c8bd7cb1940f6b91f43aae5a15727d840420af01fa191001d49"

URI_aarch64_ghc-exceptions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-exceptions-0.10.7-146.el10_0.aarch64.rpm;name=aarch64_ghc-exceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-exceptions}"
SRC_URI[aarch64_ghc-exceptions.sha256sum] = "554bdfd73cb8fdc7c1b888b97f771f55c4b87adc3dc407ad7e60fb46fa1d9d16"

URI_aarch64_ghc-exceptions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-exceptions-devel-0.10.7-146.el10_0.aarch64.rpm;name=aarch64_ghc-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-exceptions-devel}"
SRC_URI[aarch64_ghc-exceptions-devel.sha256sum] = "082ccd381a22e6c196df357df4251e4f0c50515d7b888efe1bca1e5fd1b19e5e"

URI_aarch64_ghc-exceptions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-exceptions-doc-0.10.7-146.el10_0.noarch.rpm;name=aarch64_ghc-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-exceptions-doc}"
SRC_URI[aarch64_ghc-exceptions-doc.sha256sum] = "4685915ace8d61111fd01bb7877a0d7297fe0f8d64a3c061b60b39f163ed986b"

URI_aarch64_ghc-exceptions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-exceptions-prof-0.10.7-146.el10_0.aarch64.rpm;name=aarch64_ghc-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-exceptions-prof}"
SRC_URI[aarch64_ghc-exceptions-prof.sha256sum] = "c0c66e41b08f3e809988305295dd65a2bdbcaa65e7b76d143a83a0895dbf58cb"

URI_aarch64_ghc-filepath = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filepath-1.4.300.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-filepath;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filepath}"
SRC_URI[aarch64_ghc-filepath.sha256sum] = "8925314c1f5a626388accfbab4d1c31f7ddeb5bf75f7aef54e79d728fe12a169"

URI_aarch64_ghc-filepath-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filepath-devel-1.4.300.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filepath-devel}"
SRC_URI[aarch64_ghc-filepath-devel.sha256sum] = "4fe476d641ea3cee190580b7d5ff6303cb8e1a3ec1ff9bff82706cd391f6220a"

URI_aarch64_ghc-filepath-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filepath-doc-1.4.300.1-146.el10_0.noarch.rpm;name=aarch64_ghc-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filepath-doc}"
SRC_URI[aarch64_ghc-filepath-doc.sha256sum] = "ea8997b5abb484e074c42a76465d7b2579b1336cb27edad55da60d0341fc3d4d"

URI_aarch64_ghc-filepath-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filepath-prof-1.4.300.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filepath-prof}"
SRC_URI[aarch64_ghc-filepath-prof.sha256sum] = "a6f8492c83a1d97b6ed607b7485c61533c02fd418e044f085f867426b82b81d2"

URI_aarch64_ghc-filesystem = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filesystem-9.6.6-146.el10_0.noarch.rpm;name=aarch64_ghc-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filesystem}"
SRC_URI[aarch64_ghc-filesystem.sha256sum] = "7d19a2af7d06b4e216f2d9ccd4cbc7dbe34068f0171ad5b6cadbae5708329a6c"

URI_aarch64_ghc-ghc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc}"
SRC_URI[aarch64_ghc-ghc.sha256sum] = "a5f66062464cf1ac978eb1db3881acc139a0629830d7f14050f01a6856b6e11d"

URI_aarch64_ghc-ghc-bignum = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-bignum-1.3-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-bignum}"
SRC_URI[aarch64_ghc-ghc-bignum.sha256sum] = "9b8a83367bf0d2d0d6043bc9bcd3718a1bb3d50efbeaacb6323a22ddac8f4f9b"

URI_aarch64_ghc-ghc-bignum-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-bignum-devel-1.3-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-bignum-devel}"
SRC_URI[aarch64_ghc-ghc-bignum-devel.sha256sum] = "b93db77c8f075f9f3e282c64d6f35d9dab7c588344cd1806d2ec9aa498e98829"

URI_aarch64_ghc-ghc-bignum-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-bignum-doc-1.3-146.el10_0.noarch.rpm;name=aarch64_ghc-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-bignum-doc}"
SRC_URI[aarch64_ghc-ghc-bignum-doc.sha256sum] = "38b39fe55ed1beb6129662543f96658d15f191a93e0676fedcbdbe53fb6f4649"

URI_aarch64_ghc-ghc-bignum-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-bignum-prof-1.3-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-bignum-prof}"
SRC_URI[aarch64_ghc-ghc-bignum-prof.sha256sum] = "16534ad214f5aac776a2b0eb348dc0fde3ef1f8ea1c3bfa15bdac2bf8ef1b816"

URI_aarch64_ghc-ghc-boot = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-boot-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-boot}"
SRC_URI[aarch64_ghc-ghc-boot.sha256sum] = "b26c06883d27fc5180487cd7965d5d2da30601058c4ad05710e443980e7ac453"

URI_aarch64_ghc-ghc-boot-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-boot-devel-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-boot-devel}"
SRC_URI[aarch64_ghc-ghc-boot-devel.sha256sum] = "7c7d911a6de65f12d728ca3d3f2871ae629f15a986ec32f844417a5b48571dea"

URI_aarch64_ghc-ghc-boot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-boot-doc-9.6.6-146.el10_0.noarch.rpm;name=aarch64_ghc-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-boot-doc}"
SRC_URI[aarch64_ghc-ghc-boot-doc.sha256sum] = "2e95652ac722106efd50032e97dc2386aceb593b75264557c8acc860423b6d09"

URI_aarch64_ghc-ghc-boot-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-boot-prof-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-boot-prof}"
SRC_URI[aarch64_ghc-ghc-boot-prof.sha256sum] = "db608bffa5d8da1e4f4433bc035eb45b6caaac94ca091d5f51948f1fd2ed3b6b"

URI_aarch64_ghc-ghc-boot-th = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-boot-th-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-boot-th}"
SRC_URI[aarch64_ghc-ghc-boot-th.sha256sum] = "f567f7c88c18cc6565893f663b66a405e9cc71f3690f4f274e1f6d6d566c3518"

URI_aarch64_ghc-ghc-boot-th-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-boot-th-devel-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-boot-th-devel}"
SRC_URI[aarch64_ghc-ghc-boot-th-devel.sha256sum] = "1fdd5eff36978a571602ca4dcd4722f4f7f1049e7e6c74412d3fa1d5945b6670"

URI_aarch64_ghc-ghc-boot-th-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-boot-th-doc-9.6.6-146.el10_0.noarch.rpm;name=aarch64_ghc-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-boot-th-doc}"
SRC_URI[aarch64_ghc-ghc-boot-th-doc.sha256sum] = "06138863f285db97ce35e06751bdc391effb664f00d8e9da4a1fdeef687252aa"

URI_aarch64_ghc-ghc-boot-th-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-boot-th-prof-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-boot-th-prof}"
SRC_URI[aarch64_ghc-ghc-boot-th-prof.sha256sum] = "b8826905befec4797aa9aa877b5c02715b950198a62bbd72a6f1e4564d74a9c2"

URI_aarch64_ghc-ghc-compact = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-compact-0.1.0.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-compact}"
SRC_URI[aarch64_ghc-ghc-compact.sha256sum] = "11ba875456cdbec7f66c69b7e618d6addd7e74b1416d2a07e6a069f5673b86d5"

URI_aarch64_ghc-ghc-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-compact-devel-0.1.0.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-compact-devel}"
SRC_URI[aarch64_ghc-ghc-compact-devel.sha256sum] = "5fd8878137f3c623a9c80dbe131f9c15e69224b11d2e1144b0d026921a32474f"

URI_aarch64_ghc-ghc-compact-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-compact-doc-0.1.0.0-146.el10_0.noarch.rpm;name=aarch64_ghc-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-compact-doc}"
SRC_URI[aarch64_ghc-ghc-compact-doc.sha256sum] = "12edc5cff56c4da8951242b8aae052ca2059a5e21e396fd3b866bba2cc7f7fa3"

URI_aarch64_ghc-ghc-compact-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-compact-prof-0.1.0.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-compact-prof}"
SRC_URI[aarch64_ghc-ghc-compact-prof.sha256sum] = "5ace02433c10e994a3883cd96008e61478d3dea1c518b9798d48f10286d0120f"

URI_aarch64_ghc-ghc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-devel-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-devel}"
SRC_URI[aarch64_ghc-ghc-devel.sha256sum] = "25e3252c0836b200323218fa95ef6fab87571a39cd96cae81fce2fef804fe348"

URI_aarch64_ghc-ghc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-doc-9.6.6-146.el10_0.noarch.rpm;name=aarch64_ghc-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-doc}"
SRC_URI[aarch64_ghc-ghc-doc.sha256sum] = "2e64c283020d24de779e81f059f35d25e906324d40d7124924e8c7734cf9b12e"

URI_aarch64_ghc-ghc-heap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-heap-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-heap}"
SRC_URI[aarch64_ghc-ghc-heap.sha256sum] = "1236cebc2ed37de3eb63dc88f4ba562f33979635f4bae58b9165c16ea4062070"

URI_aarch64_ghc-ghc-heap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-heap-devel-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-heap-devel}"
SRC_URI[aarch64_ghc-ghc-heap-devel.sha256sum] = "b86f5c1d6638e87a97ae165819fc81190fadc567796f3173fb735e0b8d921d18"

URI_aarch64_ghc-ghc-heap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-heap-doc-9.6.6-146.el10_0.noarch.rpm;name=aarch64_ghc-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-heap-doc}"
SRC_URI[aarch64_ghc-ghc-heap-doc.sha256sum] = "f42dc4f6b273672f9e7a4ed9c9994393b4dff575e8c7ce9eda166810abce2812"

URI_aarch64_ghc-ghc-heap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-heap-prof-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-heap-prof}"
SRC_URI[aarch64_ghc-ghc-heap-prof.sha256sum] = "cbe35448fff0f867c99d571e5519f0aa4d79278a35fe921b5e6a2c5f67892aac"

URI_aarch64_ghc-ghc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-prof-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-prof}"
SRC_URI[aarch64_ghc-ghc-prof.sha256sum] = "7bd198b0852ebaf6b4dae6318df2b10d87049338abe00b43b463323027abc249"

URI_aarch64_ghc-ghci = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghci-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghci;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghci}"
SRC_URI[aarch64_ghc-ghci.sha256sum] = "975610f48789f21c82c4259aac2d17748fa79d2b907da60f63bb2488bf9689ca"

URI_aarch64_ghc-ghci-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghci-devel-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghci-devel}"
SRC_URI[aarch64_ghc-ghci-devel.sha256sum] = "53ec4050b45011b1bd418a457fda68eecaf691e58794f2c73cec1aeb2e62dcae"

URI_aarch64_ghc-ghci-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghci-doc-9.6.6-146.el10_0.noarch.rpm;name=aarch64_ghc-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghci-doc}"
SRC_URI[aarch64_ghc-ghci-doc.sha256sum] = "ac31aac637ffcc2bff0363fa9c18922852c999b7b4a9f8b754d3add7d56963d9"

URI_aarch64_ghc-ghci-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghci-prof-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghci-prof}"
SRC_URI[aarch64_ghc-ghci-prof.sha256sum] = "d3534965729ed52b2a4397d962595cf96d34824ea05928941689c67ab0a69d39"

URI_aarch64_ghc-hadrian = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hadrian-0.1.0.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-hadrian;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hadrian}"
SRC_URI[aarch64_ghc-hadrian.sha256sum] = "7d439edbab4f07aea14524caac3e51d3c0d00d967c790ae2c04a58a75deb6d51"

URI_aarch64_ghc-haskeline = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskeline-0.8.2.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-haskeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskeline}"
SRC_URI[aarch64_ghc-haskeline.sha256sum] = "0eddc6c9140a078a14308ab3edda41d7f930ba196c5248b0f5294f0cdd5675ce"

URI_aarch64_ghc-haskeline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskeline-devel-0.8.2.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskeline-devel}"
SRC_URI[aarch64_ghc-haskeline-devel.sha256sum] = "2e91192a88b637fd9cdb27c8b4f9a6dfcc40309d64208ed57e418c37d1af91e8"

URI_aarch64_ghc-haskeline-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskeline-doc-0.8.2.1-146.el10_0.noarch.rpm;name=aarch64_ghc-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskeline-doc}"
SRC_URI[aarch64_ghc-haskeline-doc.sha256sum] = "5ebe31772b7bf75db96992abc68e58a556b9585f290c0cc2efa3f75b797550ff"

URI_aarch64_ghc-haskeline-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskeline-prof-0.8.2.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskeline-prof}"
SRC_URI[aarch64_ghc-haskeline-prof.sha256sum] = "725219d8ad4143711ac019d6e25943de7842a4ae9b4892232b7028e4c44de3cb"

URI_aarch64_ghc-hpc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hpc-0.6.2.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-hpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hpc}"
SRC_URI[aarch64_ghc-hpc.sha256sum] = "70e1f1bc3f4a43f97fcfd80e9db2268c73c829de283fae1be7082363b812c438"

URI_aarch64_ghc-hpc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hpc-devel-0.6.2.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hpc-devel}"
SRC_URI[aarch64_ghc-hpc-devel.sha256sum] = "016e0cf8f137a550acf88f74dc76e1be4bbe8e70a98142c2cbb77a48f9c57e0e"

URI_aarch64_ghc-hpc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hpc-doc-0.6.2.0-146.el10_0.noarch.rpm;name=aarch64_ghc-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hpc-doc}"
SRC_URI[aarch64_ghc-hpc-doc.sha256sum] = "25ab3608ff9692384113f88f4266558dc5e6fa6e1e6cba5c231dd31a8a3a4544"

URI_aarch64_ghc-hpc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hpc-prof-0.6.2.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hpc-prof}"
SRC_URI[aarch64_ghc-hpc-prof.sha256sum] = "d2ddb2865a026ae1b88052c0eac41bf9b6c796ca29b3e32b442fedf5037cf5c0"

URI_aarch64_ghc-libiserv = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-libiserv-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-libiserv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-libiserv}"
SRC_URI[aarch64_ghc-libiserv.sha256sum] = "d19af7a2d834bdf9bcaa33f4e3f7d1c375b1bc4c0f1b376ba52ff81d6037d521"

URI_aarch64_ghc-libiserv-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-libiserv-devel-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-libiserv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-libiserv-devel}"
SRC_URI[aarch64_ghc-libiserv-devel.sha256sum] = "32c26dc2a93de42b4699f500b7621cf9d83301304cdc80c76cb0cc2434695949"

URI_aarch64_ghc-libiserv-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-libiserv-doc-9.6.6-146.el10_0.noarch.rpm;name=aarch64_ghc-libiserv-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-libiserv-doc}"
SRC_URI[aarch64_ghc-libiserv-doc.sha256sum] = "4c9a384d456bd3b1cc1fd699eb7717fdbe721913432e58b65a964ce18a6c6be4"

URI_aarch64_ghc-libiserv-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-libiserv-prof-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-libiserv-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-libiserv-prof}"
SRC_URI[aarch64_ghc-libiserv-prof.sha256sum] = "39a5d87a45cdec95e3ab0eda74881ec8d13e5a159597bed4b8182c553eaa9bdf"

URI_aarch64_ghc-manual = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-manual-9.6.6-146.el10_0.noarch.rpm;name=aarch64_ghc-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-manual}"
SRC_URI[aarch64_ghc-manual.sha256sum] = "a0362576845927dae69595fca2b68093c1b0cc9f1835367d7050b40020d70457"

URI_aarch64_ghc-mtl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mtl-2.3.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-mtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mtl}"
SRC_URI[aarch64_ghc-mtl.sha256sum] = "6a46fafabe5a230ffdf0f4203b0d613f5becc3d77f6e8ee56aa47379e3dba1c9"

URI_aarch64_ghc-mtl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mtl-devel-2.3.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mtl-devel}"
SRC_URI[aarch64_ghc-mtl-devel.sha256sum] = "db7bdac09ffea934041033a1a45d115077c3a3fd4da9a79575ebe2a26655cd28"

URI_aarch64_ghc-mtl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mtl-doc-2.3.1-146.el10_0.noarch.rpm;name=aarch64_ghc-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mtl-doc}"
SRC_URI[aarch64_ghc-mtl-doc.sha256sum] = "85b697291ec59a79f61fbcd028c4dc8f4041c043d1ed62514487072da75fa967"

URI_aarch64_ghc-mtl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mtl-prof-2.3.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mtl-prof}"
SRC_URI[aarch64_ghc-mtl-prof.sha256sum] = "9b2a8841c40438cf50d895a0886ed74f9a35333e6badf344fcaa4066f399429b"

URI_aarch64_ghc-parsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-parsec-3.1.16.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-parsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-parsec}"
SRC_URI[aarch64_ghc-parsec.sha256sum] = "c8dd5b30693384162497a5f21ac9d3e027fa6bf9abca92a6022fc400372baf6d"

URI_aarch64_ghc-parsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-parsec-devel-3.1.16.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-parsec-devel}"
SRC_URI[aarch64_ghc-parsec-devel.sha256sum] = "7acd1f2bc3529f42bc1b536d4219bd16cf3eb6ff9a92f4b3ba10734936162533"

URI_aarch64_ghc-parsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-parsec-doc-3.1.16.1-146.el10_0.noarch.rpm;name=aarch64_ghc-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-parsec-doc}"
SRC_URI[aarch64_ghc-parsec-doc.sha256sum] = "31ef5216c06dcaa628df15c314c90b4c8bdf11ae45868916d52ad6a5a4bcbe3c"

URI_aarch64_ghc-parsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-parsec-prof-3.1.16.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-parsec-prof}"
SRC_URI[aarch64_ghc-parsec-prof.sha256sum] = "7f0c23bf0d0c8e3fa62e1be2248473421587badbe23f95f3d0e8f017fef87d4a"

URI_aarch64_ghc-pretty = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pretty-1.1.3.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-pretty;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pretty}"
SRC_URI[aarch64_ghc-pretty.sha256sum] = "88a282f580d9eba2a4245adeff16686f1467e4ceefa6c8d073dbd020551896a4"

URI_aarch64_ghc-pretty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pretty-devel-1.1.3.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pretty-devel}"
SRC_URI[aarch64_ghc-pretty-devel.sha256sum] = "ea0ca85608474697c56cf1ed9899bfcbe42de38d50e7fe2ba9318d8a3a844fc2"

URI_aarch64_ghc-pretty-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pretty-doc-1.1.3.6-146.el10_0.noarch.rpm;name=aarch64_ghc-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pretty-doc}"
SRC_URI[aarch64_ghc-pretty-doc.sha256sum] = "947bfa8079e8505b5c797ce6ff273b855c1330366c3456538894090632b6eec8"

URI_aarch64_ghc-pretty-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pretty-prof-1.1.3.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pretty-prof}"
SRC_URI[aarch64_ghc-pretty-prof.sha256sum] = "7d298c2f49035921e3ff705743b57d2dc450d1593cb972264f19dfcef7dc2aca"

URI_aarch64_ghc-process = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-process-1.6.19.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-process}"
SRC_URI[aarch64_ghc-process.sha256sum] = "7d331b9d212924b51b858b0fafdfe01082651e2ce6458118458455ede5316434"

URI_aarch64_ghc-process-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-process-devel-1.6.19.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-process-devel}"
SRC_URI[aarch64_ghc-process-devel.sha256sum] = "d567e3b3dfd745b70514330ac34445316ec0b84b8515b31c13269a3553d32f30"

URI_aarch64_ghc-process-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-process-doc-1.6.19.0-146.el10_0.noarch.rpm;name=aarch64_ghc-process-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-process-doc}"
SRC_URI[aarch64_ghc-process-doc.sha256sum] = "e0e9d27785b48f90e79f819c60644b97e99551f57ba1606089613d93bbd241e8"

URI_aarch64_ghc-process-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-process-prof-1.6.19.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-process-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-process-prof}"
SRC_URI[aarch64_ghc-process-prof.sha256sum] = "06693376ab5d8941b32d52969587d2c97d46aa1fa0e264225606cbf498e4ac6c"

URI_aarch64_ghc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-prof-9.6.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-prof}"
SRC_URI[aarch64_ghc-prof.sha256sum] = "92efbc363c95eab1482f4caa9e06c3e2b75ef6ccac12148b4b1164ece67637a5"

URI_aarch64_ghc-stm = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-stm-2.5.1.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-stm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-stm}"
SRC_URI[aarch64_ghc-stm.sha256sum] = "11d07b26fbd8e638c002f6e94d913b9166f03ceacb442822737b9f26a796e97d"

URI_aarch64_ghc-stm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-stm-devel-2.5.1.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-stm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-stm-devel}"
SRC_URI[aarch64_ghc-stm-devel.sha256sum] = "e5e251d6060ddaf384c8f5db47d9560b5cf7c6ad1603212c91539aa7efe0aec2"

URI_aarch64_ghc-stm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-stm-doc-2.5.1.0-146.el10_0.noarch.rpm;name=aarch64_ghc-stm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-stm-doc}"
SRC_URI[aarch64_ghc-stm-doc.sha256sum] = "74e3a115c2b9ca883397d19c5b1e9be15116c5b1b17bad2a2aea3f71f51ae4a5"

URI_aarch64_ghc-stm-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-stm-prof-2.5.1.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-stm-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-stm-prof}"
SRC_URI[aarch64_ghc-stm-prof.sha256sum] = "b24325b84eeac2d94d56c243ca436a27f8071e12e80f55849c761cfc95951d35"

URI_aarch64_ghc-template-haskell = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-template-haskell-2.20.0.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-template-haskell;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-template-haskell}"
SRC_URI[aarch64_ghc-template-haskell.sha256sum] = "603aa7ef0287cf2e9e33194cf9aae2782fa7abddad5c8671590cac8199dd4587"

URI_aarch64_ghc-template-haskell-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-template-haskell-devel-2.20.0.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-template-haskell-devel}"
SRC_URI[aarch64_ghc-template-haskell-devel.sha256sum] = "b9a4566dff49040eee796fe94cd566e914fd1d6e6d23584b4e8b84774a4d8cb7"

URI_aarch64_ghc-template-haskell-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-template-haskell-doc-2.20.0.0-146.el10_0.noarch.rpm;name=aarch64_ghc-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-template-haskell-doc}"
SRC_URI[aarch64_ghc-template-haskell-doc.sha256sum] = "e2c61079a13193e17a6dfd356df7c206c5572b87a94caeb6534ca354e298dd0d"

URI_aarch64_ghc-template-haskell-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-template-haskell-prof-2.20.0.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-template-haskell-prof}"
SRC_URI[aarch64_ghc-template-haskell-prof.sha256sum] = "a4428d88dbbe8cdeb58eeeaa4e29533ca386967b26a2f3eaf83dce676f1513aa"

URI_aarch64_ghc-terminfo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-terminfo-0.4.1.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-terminfo}"
SRC_URI[aarch64_ghc-terminfo.sha256sum] = "0247c8a530f3166c69786d91488da9deaa243257dfc31dfec9599f69184ecd4b"

URI_aarch64_ghc-terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-terminfo-devel-0.4.1.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-terminfo-devel}"
SRC_URI[aarch64_ghc-terminfo-devel.sha256sum] = "1e4ad558d146787b9c289be4b45fa6be4bf6bda3570a88db7a2a420b8ffc15a4"

URI_aarch64_ghc-terminfo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-terminfo-doc-0.4.1.6-146.el10_0.noarch.rpm;name=aarch64_ghc-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-terminfo-doc}"
SRC_URI[aarch64_ghc-terminfo-doc.sha256sum] = "047400ef5504082272561a0ffb65fa41de83b997f7791499bfefa6ff76a367cd"

URI_aarch64_ghc-terminfo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-terminfo-prof-0.4.1.6-146.el10_0.aarch64.rpm;name=aarch64_ghc-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-terminfo-prof}"
SRC_URI[aarch64_ghc-terminfo-prof.sha256sum] = "03420e8f55404ea72db50a8b4432ce22af93b49001b0381b88598894ec746747"

URI_aarch64_ghc-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-2.0.2-146.el10_0.aarch64.rpm;name=aarch64_ghc-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text}"
SRC_URI[aarch64_ghc-text.sha256sum] = "6a228f7193a47cc02ea2e46389df36dabdc68a404ac174827b9426b9eb6011a6"

URI_aarch64_ghc-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-devel-2.0.2-146.el10_0.aarch64.rpm;name=aarch64_ghc-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-devel}"
SRC_URI[aarch64_ghc-text-devel.sha256sum] = "2f05ac56b7ea7e9178ad73424bc328ecaf94a51999a7d908780ad8c66b08e820"

URI_aarch64_ghc-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-doc-2.0.2-146.el10_0.noarch.rpm;name=aarch64_ghc-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-doc}"
SRC_URI[aarch64_ghc-text-doc.sha256sum] = "44e0a905a7da3195d361f5d882121865d234b6ba6bcf9722b47c29a37d85aefc"

URI_aarch64_ghc-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-prof-2.0.2-146.el10_0.aarch64.rpm;name=aarch64_ghc-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-prof}"
SRC_URI[aarch64_ghc-text-prof.sha256sum] = "1309f32b7c8d0fc567c9e65197c57ff0c89b3c33775cd44bf3e8fee3ffd06684"

URI_aarch64_ghc-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-1.12.2-146.el10_0.aarch64.rpm;name=aarch64_ghc-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time}"
SRC_URI[aarch64_ghc-time.sha256sum] = "a82bfd221d5c51753b4e4f590215428f48c1c0335ae62ec0fd21258f78c7ec37"

URI_aarch64_ghc-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-devel-1.12.2-146.el10_0.aarch64.rpm;name=aarch64_ghc-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-devel}"
SRC_URI[aarch64_ghc-time-devel.sha256sum] = "b8924eec1906ba1e8f928fd52a3fe61afa3af68e7197315fb0e0fce79d8bd9da"

URI_aarch64_ghc-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-doc-1.12.2-146.el10_0.noarch.rpm;name=aarch64_ghc-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-doc}"
SRC_URI[aarch64_ghc-time-doc.sha256sum] = "b2585edff31244c80404dad30167d06bcedf0594cefbc9584ad87f87588cc696"

URI_aarch64_ghc-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-prof-1.12.2-146.el10_0.aarch64.rpm;name=aarch64_ghc-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-prof}"
SRC_URI[aarch64_ghc-time-prof.sha256sum] = "1e2694d5549f7d99a2241803867adb208e94f28286084055e2e364811caf06b1"

URI_aarch64_ghc-transformers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-transformers-0.6.1.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-transformers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-transformers}"
SRC_URI[aarch64_ghc-transformers.sha256sum] = "6bc4d279cbde24ed06731c1443a3bdc633c5f5acb4b57532f3c4c2706a68e85a"

URI_aarch64_ghc-transformers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-transformers-devel-0.6.1.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-transformers-devel}"
SRC_URI[aarch64_ghc-transformers-devel.sha256sum] = "caa7dc229aca345912a57b8a09b0a40cd344172fa4ff3d9601ecd2e6202a331c"

URI_aarch64_ghc-transformers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-transformers-doc-0.6.1.0-146.el10_0.noarch.rpm;name=aarch64_ghc-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-transformers-doc}"
SRC_URI[aarch64_ghc-transformers-doc.sha256sum] = "e49b58854cc02c7394956676639ae5dd5eacb7657af63101cd42cfe112b98b8a"

URI_aarch64_ghc-transformers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-transformers-prof-0.6.1.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-transformers-prof}"
SRC_URI[aarch64_ghc-transformers-prof.sha256sum] = "e6014683f81694002afd78eb570c76d243de90dc470e6f2b961bf4f46b08dc49"

URI_aarch64_ghc-unix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unix-2.8.4.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unix}"
SRC_URI[aarch64_ghc-unix.sha256sum] = "d39bc7b8463add5ec36e92fc5db6bb000cf1b24a21b9d99589d65065291e69dc"

URI_aarch64_ghc-unix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unix-devel-2.8.4.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unix-devel}"
SRC_URI[aarch64_ghc-unix-devel.sha256sum] = "a5605d85125933486b4a3293bd41e28af6c24535bad35c4cc74e91ed8093682e"

URI_aarch64_ghc-unix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unix-doc-2.8.4.0-146.el10_0.noarch.rpm;name=aarch64_ghc-unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unix-doc}"
SRC_URI[aarch64_ghc-unix-doc.sha256sum] = "2370489041027b424bf8a4700081cd43d1a23f182780a6ec92044f4961407671"

URI_aarch64_ghc-unix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unix-prof-2.8.4.0-146.el10_0.aarch64.rpm;name=aarch64_ghc-unix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unix-prof}"
SRC_URI[aarch64_ghc-unix-prof.sha256sum] = "1d50550eb94a0af4e02e5ecff4c97a5301d7b1d5550524bd67952b2caaecd6a9"

URI_aarch64_ghc-xhtml = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xhtml-3000.2.2.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-xhtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xhtml}"
SRC_URI[aarch64_ghc-xhtml.sha256sum] = "ed5c8f9975135772461b1eb2cc26cee4f3d038cd219a6009435f0262d542ae31"

URI_aarch64_ghc-xhtml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xhtml-devel-3000.2.2.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xhtml-devel}"
SRC_URI[aarch64_ghc-xhtml-devel.sha256sum] = "56ee32a0b56594d2cfdc77527ce06f5f63e2b98cc6cd857f84823f220d2f567d"

URI_aarch64_ghc-xhtml-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xhtml-doc-3000.2.2.1-146.el10_0.noarch.rpm;name=aarch64_ghc-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xhtml-doc}"
SRC_URI[aarch64_ghc-xhtml-doc.sha256sum] = "6773a4a5e95238a0a64ac38a1ae42fe363220e188ef83c00cf7c65d8d464f66b"

URI_aarch64_ghc-xhtml-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xhtml-prof-3000.2.2.1-146.el10_0.aarch64.rpm;name=aarch64_ghc-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xhtml-prof}"
SRC_URI[aarch64_ghc-xhtml-prof.sha256sum] = "97770756b4969a1acced41ca4cf7845b14810b85e2efafbe10c3f358c753adad"

RDEPENDS:ghc = " \
 ghc-compiler \
 ghc-devel \
 ghc-ghc-boot-devel \
 ghc-ghc-compact-devel \
 ghc-ghc-devel \
 ghc-ghc-heap-devel \
 ghc-ghci-devel \
 ghc-hpc-devel \
 ghc-libiserv-devel \
 "
RDEPENDS:ghc-Cabal = " \
 ghc-Cabal-syntax \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-Cabal-devel = " \
 ghc-Cabal \
 ghc-Cabal-syntax-devel \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-mtl-devel \
 ghc-parsec-devel \
 ghc-pretty-devel \
 ghc-process-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-Cabal-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-Cabal-prof = " \
 ghc-Cabal-devel \
 ghc-Cabal-syntax-prof \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-mtl-prof \
 ghc-parsec-prof \
 ghc-pretty-prof \
 ghc-process-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unix-prof \
 "
RDEPENDS:ghc-Cabal-syntax = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-Cabal-syntax-devel = " \
 ghc-Cabal-syntax \
 ghc-array-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-mtl-devel \
 ghc-parsec-devel \
 ghc-pretty-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-Cabal-syntax-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-Cabal-syntax-prof = " \
 ghc-Cabal-syntax-devel \
 ghc-array-prof \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-mtl-prof \
 ghc-parsec-prof \
 ghc-pretty-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unix-prof \
 "
RDEPENDS:ghc-array = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-array-devel = " \
 ghc-array \
 ghc-base-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-array-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-array-prof = " \
 ghc-array-devel \
 ghc-base-prof \
 "
RDEPENDS:ghc-base = " \
 ghc-ghc-bignum \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc-base-devel = " \
 ghc-base \
 ghc-compiler \
 ghc-ghc-bignum-devel \
 gmp-devel \
 libffi-devel \
 "
RDEPENDS:ghc-base-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-base-prof = " \
 ghc-base-devel \
 ghc-ghc-bignum-prof \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc-binary = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-binary-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-binary \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 "
RDEPENDS:ghc-binary-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-binary-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-binary-devel \
 ghc-bytestring-prof \
 ghc-containers-prof \
 "
RDEPENDS:ghc-bytestring = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-bytestring-devel = " \
 ghc-base-devel \
 ghc-bytestring \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-template-haskell-devel \
 "
RDEPENDS:ghc-bytestring-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-bytestring-prof = " \
 ghc-base-prof \
 ghc-bytestring-devel \
 ghc-deepseq-prof \
 ghc-template-haskell-prof \
 "
RDEPENDS:ghc-compiler = " \
 bash \
 binutils \
 gcc \
 ghc-Cabal \
 ghc-Cabal-syntax \
 ghc-array \
 ghc-base \
 ghc-base-devel \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-filesystem \
 ghc-ghc \
 ghc-ghc-bignum \
 ghc-ghc-boot \
 ghc-ghc-boot-th \
 ghc-ghc-heap \
 ghc-ghci \
 ghc-haskeline \
 ghc-hpc \
 ghc-libiserv \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-terminfo \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-xhtml \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 "
RDEPENDS:ghc-containers = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-containers-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers \
 ghc-deepseq-devel \
 ghc-template-haskell-devel \
 "
RDEPENDS:ghc-containers-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-containers-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-containers-devel \
 ghc-deepseq-prof \
 ghc-template-haskell-prof \
 "
RDEPENDS:ghc-deepseq = " \
 ghc-array \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-deepseq-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq \
 "
RDEPENDS:ghc-deepseq-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-deepseq-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-deepseq-devel \
 "
RDEPENDS:ghc-devel = " \
 ghc-Cabal-devel \
 ghc-Cabal-syntax-devel \
 ghc-array-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-ghc-boot-th-devel \
 ghc-haskeline-devel \
 ghc-mtl-devel \
 ghc-parsec-devel \
 ghc-pretty-devel \
 ghc-process-devel \
 ghc-stm-devel \
 ghc-template-haskell-devel \
 ghc-terminfo-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unix-devel \
 ghc-xhtml-devel \
 "
RDEPENDS:ghc-directory = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-directory-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-directory \
 ghc-filepath-devel \
 ghc-time-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-directory-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-directory-prof = " \
 ghc-base-prof \
 ghc-directory-devel \
 ghc-filepath-prof \
 ghc-time-prof \
 ghc-unix-prof \
 "
RDEPENDS:ghc-doc = " \
 "
RDEPENDS:ghc-doc-index = " \
 ghc-compiler \
 "
RDEPENDS:ghc-exceptions = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-exceptions-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-exceptions \
 ghc-mtl-devel \
 ghc-stm-devel \
 ghc-template-haskell-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-exceptions-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-exceptions-prof = " \
 ghc-base-prof \
 ghc-exceptions-devel \
 ghc-mtl-prof \
 ghc-stm-prof \
 ghc-template-haskell-prof \
 ghc-transformers-prof \
 "
RDEPENDS:ghc-filepath = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-exceptions \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-filepath-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-exceptions-devel \
 ghc-filepath \
 ghc-template-haskell-devel \
 "
RDEPENDS:ghc-filepath-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-filepath-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 ghc-exceptions-prof \
 ghc-filepath-devel \
 ghc-template-haskell-prof \
 "
RDEPENDS:ghc-filesystem = " \
 "
RDEPENDS:ghc-ghc = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot \
 ghc-ghc-boot-th \
 ghc-ghc-heap \
 ghc-ghci \
 ghc-hpc \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ghc-bignum = " \
 ghc-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ghc-bignum-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-ghc-bignum \
 "
RDEPENDS:ghc-ghc-bignum-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ghc-bignum-prof = " \
 ghc-base-prof \
 ghc-ghc-bignum-devel \
 "
RDEPENDS:ghc-ghc-boot = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ghc-boot-devel = " \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-ghc-boot \
 ghc-ghc-boot-th-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-ghc-boot-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ghc-boot-prof = " \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-ghc-boot-devel \
 ghc-ghc-boot-th-prof \
 ghc-unix-prof \
 "
RDEPENDS:ghc-ghc-boot-th = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ghc-boot-th-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-ghc-boot-th \
 "
RDEPENDS:ghc-ghc-boot-th-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ghc-boot-th-prof = " \
 ghc-base-prof \
 ghc-ghc-boot-th-devel \
 "
RDEPENDS:ghc-ghc-compact = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ghc-compact-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-ghc-compact \
 "
RDEPENDS:ghc-ghc-compact-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ghc-compact-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-ghc-compact-devel \
 "
RDEPENDS:ghc-ghc-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-ghc \
 ghc-ghc-boot-devel \
 ghc-ghc-heap-devel \
 ghc-ghci-devel \
 ghc-hpc-devel \
 ghc-process-devel \
 ghc-stm-devel \
 ghc-template-haskell-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-ghc-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ghc-heap = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ghc-heap-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-ghc-heap \
 "
RDEPENDS:ghc-ghc-heap-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ghc-heap-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-ghc-heap-devel \
 "
RDEPENDS:ghc-ghc-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-ghc-boot-prof \
 ghc-ghc-devel \
 ghc-ghc-heap-prof \
 ghc-ghci-prof \
 ghc-hpc-prof \
 ghc-process-prof \
 ghc-stm-prof \
 ghc-template-haskell-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unix-prof \
 "
RDEPENDS:ghc-ghci = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot \
 ghc-ghc-boot-th \
 ghc-ghc-heap \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ghci-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-filepath-devel \
 ghc-ghc-boot-devel \
 ghc-ghc-heap-devel \
 ghc-ghci \
 ghc-template-haskell-devel \
 ghc-transformers-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-ghci-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ghci-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-filepath-prof \
 ghc-ghc-boot-prof \
 ghc-ghc-heap-prof \
 ghc-ghci-devel \
 ghc-template-haskell-prof \
 ghc-transformers-prof \
 ghc-unix-prof \
 "
RDEPENDS:ghc-hadrian = " \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc-haskeline = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-terminfo \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc-haskeline-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-haskeline \
 ghc-process-devel \
 ghc-stm-devel \
 ghc-terminfo-devel \
 ghc-transformers-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-haskeline-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-haskeline-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-haskeline-devel \
 ghc-process-prof \
 ghc-stm-prof \
 ghc-terminfo-prof \
 ghc-transformers-prof \
 ghc-unix-prof \
 "
RDEPENDS:ghc-hpc = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hpc-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-hpc \
 ghc-time-devel \
 "
RDEPENDS:ghc-hpc-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hpc-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-hpc-devel \
 ghc-time-prof \
 "
RDEPENDS:ghc-libiserv = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot \
 ghc-ghc-boot-th \
 ghc-ghc-heap \
 ghc-ghci \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-libiserv-devel = " \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-ghci-devel \
 ghc-libiserv \
 ghc-unix-devel \
 "
RDEPENDS:ghc-libiserv-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-libiserv-prof = " \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-ghci-prof \
 ghc-libiserv-devel \
 ghc-unix-prof \
 "
RDEPENDS:ghc-manual = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-mtl = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-mtl-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-mtl \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-mtl-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-mtl-prof = " \
 ghc-base-prof \
 ghc-mtl-devel \
 ghc-transformers-prof \
 "
RDEPENDS:ghc-parsec = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-parsec-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-mtl-devel \
 ghc-parsec \
 ghc-text-devel \
 "
RDEPENDS:ghc-parsec-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-parsec-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-mtl-prof \
 ghc-parsec-devel \
 ghc-text-prof \
 "
RDEPENDS:ghc-pretty = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-pretty-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-pretty \
 "
RDEPENDS:ghc-pretty-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pretty-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-pretty-devel \
 "
RDEPENDS:ghc-process = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-process-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-process \
 ghc-unix-devel \
 "
RDEPENDS:ghc-process-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-process-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-process-devel \
 ghc-unix-prof \
 "
RDEPENDS:ghc-prof = " \
 ghc-compiler \
 "
RDEPENDS:ghc-stm = " \
 ghc-array \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-stm-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-stm \
 "
RDEPENDS:ghc-stm-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-stm-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-stm-devel \
 "
RDEPENDS:ghc-template-haskell = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc-template-haskell-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-ghc-boot-th-devel \
 ghc-pretty-devel \
 ghc-template-haskell \
 "
RDEPENDS:ghc-template-haskell-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-template-haskell-prof = " \
 ghc-base-prof \
 ghc-ghc-boot-th-prof \
 ghc-pretty-prof \
 ghc-template-haskell-devel \
 "
RDEPENDS:ghc-terminfo = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc-terminfo-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-terminfo \
 ncurses-devel \
 "
RDEPENDS:ghc-terminfo-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-terminfo-prof = " \
 ghc-base-prof \
 ghc-terminfo-devel \
 "
RDEPENDS:ghc-text = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-text-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-template-haskell-devel \
 ghc-text \
 "
RDEPENDS:ghc-text-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-text-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 ghc-template-haskell-prof \
 ghc-text-devel \
 "
RDEPENDS:ghc-time = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-time-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-time \
 "
RDEPENDS:ghc-time-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-time-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-time-devel \
 "
RDEPENDS:ghc-transformers = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-transformers-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-transformers \
 "
RDEPENDS:ghc-transformers-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-transformers-prof = " \
 ghc-base-prof \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-unix = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-unix-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-filepath-devel \
 ghc-time-devel \
 ghc-unix \
 "
RDEPENDS:ghc-unix-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-unix-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-filepath-prof \
 ghc-time-prof \
 ghc-unix-devel \
 "
RDEPENDS:ghc-xhtml = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-xhtml-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-xhtml \
 "
RDEPENDS:ghc-xhtml-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-xhtml-prof = " \
 ghc-base-prof \
 ghc-xhtml-devel \
 "
