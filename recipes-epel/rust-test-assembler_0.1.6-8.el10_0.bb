# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-test-assembler"
PV = "0.1.6"
PR = "8.el10_0"
PACKAGES = " \
 rust-test-assembler+default-devel \
 rust-test-assembler-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-test-assembler-0.1.6-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f28159efa4dcbe0c852e98a522dc872d3dc83220542b313512d4c59daa97977e"

URI_x86_64_v2_rust-test-assembler+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-assembler+default-devel-0.1.6-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-assembler+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-assembler+default-devel}"
SRC_URI[x86_64_v2_rust-test-assembler+default-devel.sha256sum] = "502979da3265eec5931d105b1c894154541c3d041069b537de3f99d6d526ac0c"

URI_x86_64_v2_rust-test-assembler-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-assembler-devel-0.1.6-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-assembler-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-assembler-devel}"
SRC_URI[x86_64_v2_rust-test-assembler-devel.sha256sum] = "74105e2b80f7b0f2c10e263d20e7307b8cebfdc953077007888ed31da28ea0fe"

URI_aarch64_rust-test-assembler+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-assembler+default-devel-0.1.6-8.el10_0.noarch.rpm;name=aarch64_rust-test-assembler+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-assembler+default-devel}"
SRC_URI[aarch64_rust-test-assembler+default-devel.sha256sum] = "35270c54218b24c30e0d23a652f54c3606df4565dfe4ff38cd089d9913b563c9"

URI_aarch64_rust-test-assembler-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-assembler-devel-0.1.6-8.el10_0.noarch.rpm;name=aarch64_rust-test-assembler-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-assembler-devel}"
SRC_URI[aarch64_rust-test-assembler-devel.sha256sum] = "b11a5e799e721f5132430d2876fee749fe8d81271ec1fda85cfc67c9b0cd944e"

RDEPENDS:rust-test-assembler+default-devel = " \
 cargo \
 rust-test-assembler-devel \
 "
RDEPENDS:rust-test-assembler-devel = " \
 cargo \
 rust-byteorder+default-devel \
 "
