# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cron-converter"
PV = "1.3.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-cron-converter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cron-converter-1.3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ed8d1ca585104fbc67a00269d7a44fff8d74d1df50fbc1e1627d56be80ede72"

URI_x86_64_v2_python3-cron-converter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cron-converter-1.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cron-converter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cron-converter}"
SRC_URI[x86_64_v2_python3-cron-converter.sha256sum] = "0101dc666299c7a6711f50bd88cac993c21c16bd3f827f02199d31be63a91f7f"

URI_aarch64_python3-cron-converter = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cron-converter-1.3.1-1.el10_1.noarch.rpm;name=aarch64_python3-cron-converter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cron-converter}"
SRC_URI[aarch64_python3-cron-converter.sha256sum] = "60a61987787410a058c3e36ec60c210a90041bc7b05622bf31424f8dce94b207"

RDEPENDS:python3-cron-converter = " \
 python3 \
 python3-dateutil \
 "
