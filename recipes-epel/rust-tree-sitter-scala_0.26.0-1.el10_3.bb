# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-scala"
PV = "0.26.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-scala+default-devel \
 rust-tree-sitter-scala-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-scala-0.26.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d715bf6d44ba391f264a9369f5975e51b250556ba361f54ea21b74683fa67c52"

URI_x86_64_v2_rust-tree-sitter-scala+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-scala+default-devel-0.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-scala+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-scala+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-scala+default-devel.sha256sum] = "8f32699967713ae7a92da7d8225c5a9737740813072fc5f8be8f0e6f35942ea2"

URI_x86_64_v2_rust-tree-sitter-scala-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-scala-devel-0.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-scala-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-scala-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-scala-devel.sha256sum] = "c5a0c8b910e751ef77a3182d192bcfc4e207a601ffc3aba47e6323c3d9f2ab7b"

URI_aarch64_rust-tree-sitter-scala+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-scala+default-devel-0.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-scala+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-scala+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-scala+default-devel.sha256sum] = "6ebc9689a691d90846d3b431d8841e9b3ce4b7022c922eb91aaea15ce5eebfd7"

URI_aarch64_rust-tree-sitter-scala-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-scala-devel-0.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-scala-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-scala-devel}"
SRC_URI[aarch64_rust-tree-sitter-scala-devel.sha256sum] = "a1e8667364fc59343cbc3b29ba27603d82fb355dd7dce0ef9321e70d82bc4939"

RDEPENDS:rust-tree-sitter-scala+default-devel = " \
 cargo \
 rust-tree-sitter-scala-devel \
 "
RDEPENDS:rust-tree-sitter-scala-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
