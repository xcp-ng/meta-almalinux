# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-cpuguy83-md2man"
PV = "2.0.3"
PR = "9.el10"
PACKAGES = " \
 golang-github-cpuguy83-md2man \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/golang-github-cpuguy83-md2man-2.0.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a5a6784c2b990e75b85bcd7e32595af3b6bdd981f437bdc6aac6d51bfc81816"

URI_x86_64_v2_golang-github-cpuguy83-md2man = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/golang-github-cpuguy83-md2man-2.0.3-9.el10.x86_64_v2.rpm;name=x86_64_v2_golang-github-cpuguy83-md2man;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-cpuguy83-md2man}"
SRC_URI[x86_64_v2_golang-github-cpuguy83-md2man.sha256sum] = "5f1ac8a81f852fb85eb58778b49a5aa890ca67e90284bebbdee515e7768ab33b"

URI_aarch64_golang-github-cpuguy83-md2man = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/golang-github-cpuguy83-md2man-2.0.3-9.el10.aarch64.rpm;name=aarch64_golang-github-cpuguy83-md2man;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-cpuguy83-md2man}"
SRC_URI[aarch64_golang-github-cpuguy83-md2man.sha256sum] = "b26b779df623ccee1e85c475259e316a3dff13ee08ecad7dfbd1e65c989133eb"

RDEPENDS:golang-github-cpuguy83-md2man = " \
 glibc \
 "
