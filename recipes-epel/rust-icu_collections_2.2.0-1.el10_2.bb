# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_collections"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_collections+alloc-devel \
 rust-icu_collections+databake-devel \
 rust-icu_collections+default-devel \
 rust-icu_collections+serde-devel \
 rust-icu_collections-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_collections-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86908095e5c5fa8682acc4a6c3ba10aba6ba49072f050a5663f2d5a87f9164fe"

URI_x86_64_v2_rust-icu_collections+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+alloc-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+alloc-devel.sha256sum] = "bc8b9cbe00785a82a6fa3103fe5c19220472858b8087deb629603101470edc20"

URI_x86_64_v2_rust-icu_collections+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+databake-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+databake-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+databake-devel.sha256sum] = "8df9447fb74334de0cac3be1a5d459be9b6fbea52dcf52a5b1fd9601283c60a5"

URI_x86_64_v2_rust-icu_collections+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+default-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+default-devel.sha256sum] = "f17937dc0a3237be87cb48eadbe71ef2f15c198a63b6de2833f7e870831ff91c"

URI_x86_64_v2_rust-icu_collections+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+serde-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+serde-devel.sha256sum] = "2182950921b5b612055fd5c960d3747d52d138013ea45932377acdf7f3c1cfd2"

URI_x86_64_v2_rust-icu_collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections-devel}"
SRC_URI[x86_64_v2_rust-icu_collections-devel.sha256sum] = "bd5d874e57e31acd213fbd2e8f75fe02a78f885a8d0e4bced1240dd93a0dc2d0"

URI_aarch64_rust-icu_collections+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+alloc-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_collections+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+alloc-devel}"
SRC_URI[aarch64_rust-icu_collections+alloc-devel.sha256sum] = "44cacf2693f1206e793d47a838fba584d9c96c8bfebbe2ed0bc2a5abeb6b77ce"

URI_aarch64_rust-icu_collections+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+databake-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_collections+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+databake-devel}"
SRC_URI[aarch64_rust-icu_collections+databake-devel.sha256sum] = "a944336a2371852ca1dbec295237eebffc157048d487e37011d76fda0f150eb0"

URI_aarch64_rust-icu_collections+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_collections+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+default-devel}"
SRC_URI[aarch64_rust-icu_collections+default-devel.sha256sum] = "ada9a94eba3d8179ea33176de68ea68a6069779062f50b8e03781e5d982d6033"

URI_aarch64_rust-icu_collections+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+serde-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_collections+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+serde-devel}"
SRC_URI[aarch64_rust-icu_collections+serde-devel.sha256sum] = "dd2a18b21904a5641220d4c62e02bc86187438d84711a83eb253b4f461937209"

URI_aarch64_rust-icu_collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections-devel}"
SRC_URI[aarch64_rust-icu_collections-devel.sha256sum] = "69c6fc4036d569fda67540181f2f50f755ffc570480d214720445541a25d1bee"

RDEPENDS:rust-icu_collections+alloc-devel = " \
 cargo \
 rust-icu_collections-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+alloc-devel \
 "
RDEPENDS:rust-icu_collections+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collections-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_collections+default-devel = " \
 cargo \
 rust-icu_collections-devel \
 "
RDEPENDS:rust-icu_collections+serde-devel = " \
 cargo \
 rust-icu_collections+alloc-devel \
 rust-icu_collections-devel \
 rust-potential_utf+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_collections-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-potential_utf+zerovec-devel \
 rust-potential_utf-devel \
 rust-utf8_iter-devel \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 rust-zerovec+derive-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
