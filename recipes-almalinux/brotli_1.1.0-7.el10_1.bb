# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "brotli"
PV = "1.1.0"
PR = "7.el10_1"
PACKAGES = " \
 brotli \
 brotli-devel \
 libbrotli \
 python3-brotli \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/brotli-1.1.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c76e7d2712fa2caf2058dc3bf346565bbec74c42ed3078e2336a8565fc32f6ae"

URI_x86_64_v2_brotli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brotli-1.1.0-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_brotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brotli}"
SRC_URI[x86_64_v2_brotli.sha256sum] = "e572f0f8163baa79d0a9ea225a16b36a1fe32518edbcc8b9ca66220b3d76af1f"

URI_x86_64_v2_brotli-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brotli-devel-1.1.0-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brotli-devel}"
SRC_URI[x86_64_v2_brotli-devel.sha256sum] = "e1c8bcaca44125e262148f0bda8b8ce7322f2184d3aa8729a9983315e613c240"

URI_x86_64_v2_libbrotli = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libbrotli-1.1.0-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_libbrotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbrotli}"
SRC_URI[x86_64_v2_libbrotli.sha256sum] = "ffc3756919c2963f54ce2abac63635fb5088e83114cf8459120e07ee4ab9f4b6"

URI_x86_64_v2_python3-brotli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-brotli-1.1.0-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-brotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-brotli}"
SRC_URI[x86_64_v2_python3-brotli.sha256sum] = "37f6d30871ffaf41d72e42d6ba162f605f1fa27a101dfd5b9e1fdceed0dc42f8"

URI_aarch64_brotli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brotli-1.1.0-7.el10_1.aarch64.rpm;name=aarch64_brotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_brotli}"
SRC_URI[aarch64_brotli.sha256sum] = "7873158f2e14074617551d1256e43f3e448f201b4d1aca5a26eb6ed45f45188e"

URI_aarch64_brotli-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brotli-devel-1.1.0-7.el10_1.aarch64.rpm;name=aarch64_brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_brotli-devel}"
SRC_URI[aarch64_brotli-devel.sha256sum] = "6d792c3c9244f7f7a9d1cfdd303d11f67521e95a33a9d5b65ac93697341e1022"

URI_aarch64_libbrotli = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libbrotli-1.1.0-7.el10_1.aarch64.rpm;name=aarch64_libbrotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbrotli}"
SRC_URI[aarch64_libbrotli.sha256sum] = "91fbee74cca6d603e68e8b11a2d9bd25daff81e7d018e3fa7d300e09287040f5"

URI_aarch64_python3-brotli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-brotli-1.1.0-7.el10_1.aarch64.rpm;name=aarch64_python3-brotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-brotli}"
SRC_URI[aarch64_python3-brotli.sha256sum] = "765573fd463dc05b467bcfb0a9001897b01b90e2e4445144b3fb1ca79745b45e"

RDEPENDS:brotli = " \
 glibc \
 libbrotli \
 "
RDEPENDS:brotli-devel = " \
 brotli \
 brotli-devel \
 libbrotli \
 pkgconf-pkg-config \
 "
RDEPENDS:libbrotli = " \
 glibc \
 "
RDEPENDS:python3-brotli = " \
 glibc \
 python3 \
 "
