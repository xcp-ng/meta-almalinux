# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ucd-trie"
PV = "0.1.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-ucd-trie+default-devel \
 rust-ucd-trie+std-devel \
 rust-ucd-trie-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ucd-trie-0.1.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31291f619a69ce4d058361f587d282bc798bd4d69e4f975e561eaafd60b6cb79"

URI_x86_64_v2_rust-ucd-trie+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ucd-trie+default-devel-0.1.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ucd-trie+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ucd-trie+default-devel}"
SRC_URI[x86_64_v2_rust-ucd-trie+default-devel.sha256sum] = "ff0537b89d348e2df307aeefbbf538623a7ba5349faafe1663c2a97ac705265d"

URI_x86_64_v2_rust-ucd-trie+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ucd-trie+std-devel-0.1.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ucd-trie+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ucd-trie+std-devel}"
SRC_URI[x86_64_v2_rust-ucd-trie+std-devel.sha256sum] = "c35a57058f6bcf3c743faec254ead73d6ba258c3e9ccdf74fe477a5bfcfc45fc"

URI_x86_64_v2_rust-ucd-trie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ucd-trie-devel-0.1.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ucd-trie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ucd-trie-devel}"
SRC_URI[x86_64_v2_rust-ucd-trie-devel.sha256sum] = "2d6e0f90063c5c97b32d3f434b15d9f9866b8f61c60c5126685447a72dce3f2a"

URI_aarch64_rust-ucd-trie+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ucd-trie+default-devel-0.1.7-1.el10_0.noarch.rpm;name=aarch64_rust-ucd-trie+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ucd-trie+default-devel}"
SRC_URI[aarch64_rust-ucd-trie+default-devel.sha256sum] = "67f7c752ca1bf8270d7b288921278fcfd5fa53cb9d11cc42ae220b211675b565"

URI_aarch64_rust-ucd-trie+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ucd-trie+std-devel-0.1.7-1.el10_0.noarch.rpm;name=aarch64_rust-ucd-trie+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ucd-trie+std-devel}"
SRC_URI[aarch64_rust-ucd-trie+std-devel.sha256sum] = "be762153b4e17f51d49bbc1fb72160de5c8c7d186beaf0ba1fde0819fa2dfd00"

URI_aarch64_rust-ucd-trie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ucd-trie-devel-0.1.7-1.el10_0.noarch.rpm;name=aarch64_rust-ucd-trie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ucd-trie-devel}"
SRC_URI[aarch64_rust-ucd-trie-devel.sha256sum] = "20728186e9f1e29e860575827f3846bd596043ed39111389c068753d39b89ca3"

RDEPENDS:rust-ucd-trie+default-devel = " \
 cargo \
 rust-ucd-trie+std-devel \
 rust-ucd-trie-devel \
 "
RDEPENDS:rust-ucd-trie+std-devel = " \
 cargo \
 rust-ucd-trie-devel \
 "
RDEPENDS:rust-ucd-trie-devel = " \
 cargo \
 "
