# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-openpgp"
PV = "2.4.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel \
 rust-sequoia-openpgp+compression-bzip2-devel \
 rust-sequoia-openpgp+compression-deflate-devel \
 rust-sequoia-openpgp+compression-devel \
 rust-sequoia-openpgp+crypto-nettle-devel \
 rust-sequoia-openpgp+crypto-openssl-devel \
 rust-sequoia-openpgp+default-devel \
 rust-sequoia-openpgp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sequoia-openpgp-2.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b2bfc11bec8fb0b7b2d2a6af13591dd2dd63c1d76b1ddabf4d2a6c3caaf0346"

URI_x86_64_v2_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel.sha256sum] = "06b3cb67683a0f6b68dd7f7eea602312dead7ef705067ea716b0d65a7757cdc1"

URI_x86_64_v2_rust-sequoia-openpgp+compression-bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+compression-bzip2-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+compression-bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp+compression-bzip2-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+compression-bzip2-devel.sha256sum] = "80a61eed406b61ec481706b2ec24465259dee734c9d17ca4de05d02e72226833"

URI_x86_64_v2_rust-sequoia-openpgp+compression-deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+compression-deflate-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+compression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp+compression-deflate-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+compression-deflate-devel.sha256sum] = "4f129f89c3560e3b0a06b6ba7ff1259fe104d6b28a32ceb45172f471c9081fa3"

URI_x86_64_v2_rust-sequoia-openpgp+compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+compression-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp+compression-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+compression-devel.sha256sum] = "d4ad2a56268e400e17245ec299b7735e6a89ef39658a04b0d26ce85e1009cafb"

URI_x86_64_v2_rust-sequoia-openpgp+crypto-nettle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+crypto-nettle-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+crypto-nettle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp+crypto-nettle-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+crypto-nettle-devel.sha256sum] = "452571da414802604124115fb37bea96fedc63a3f28e72e92458281b9acfbbe0"

URI_x86_64_v2_rust-sequoia-openpgp+crypto-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+crypto-openssl-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp+crypto-openssl-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+crypto-openssl-devel.sha256sum] = "c6202b74e84753880d80237368db1d04e6812ee89afe00f8d50d633fc6c35e96"

URI_x86_64_v2_rust-sequoia-openpgp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+default-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp+default-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+default-devel.sha256sum] = "00edd8409fb35e9e31502989701f3c4f49ef11edeca4fb5506d32df950742095"

URI_x86_64_v2_rust-sequoia-openpgp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp-devel.sha256sum] = "f9cc9a8ccc7f7aad96accb1c3627843c3f4f425759e14687b91e0b18397f82f4"

URI_aarch64_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel.sha256sum] = "d383205319800c4c6eb2cca9897edcda6d7a9cdf5980200ef3f872b13ef647cf"

URI_aarch64_rust-sequoia-openpgp+compression-bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+compression-bzip2-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+compression-bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp+compression-bzip2-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp+compression-bzip2-devel.sha256sum] = "70d705d431ce84d6a463207f361c396d97f3b83d243073da9d70f321d6c07f2a"

URI_aarch64_rust-sequoia-openpgp+compression-deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+compression-deflate-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+compression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp+compression-deflate-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp+compression-deflate-devel.sha256sum] = "50fa10385f6cb680b5cb2ca1fb7a6ac4123504b61c45b70367806df3b998b6b9"

URI_aarch64_rust-sequoia-openpgp+compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+compression-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp+compression-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp+compression-devel.sha256sum] = "f07dd0b4e87a514361ffacd2b06eda64e8263a38d53f56f908bf8ec8df869f8f"

URI_aarch64_rust-sequoia-openpgp+crypto-nettle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+crypto-nettle-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+crypto-nettle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp+crypto-nettle-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp+crypto-nettle-devel.sha256sum] = "b9852c97ee5ba948cde58b09ba108cfb7cf73e40fa01b52aa3b6a69ca13b0663"

URI_aarch64_rust-sequoia-openpgp+crypto-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+crypto-openssl-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp+crypto-openssl-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp+crypto-openssl-devel.sha256sum] = "4636c2a919a44ff634f47ab693421319afa12ca937233240e1b002094d7e4ec8"

URI_aarch64_rust-sequoia-openpgp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+default-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp+default-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp+default-devel.sha256sum] = "d6c6ec1f85fa9a4882fa07eb231f647c7e4813a5c4c16ff4bb5618c3556bf84e"

URI_aarch64_rust-sequoia-openpgp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp-devel.sha256sum] = "6eacc28108426afdd807c1641766d85c36ec624f604540a44b539592c31e4ceb"

RDEPENDS:rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel = " \
 cargo \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+compression-bzip2-devel = " \
 cargo \
 rust-buffered-reader+compression-bzip2-devel \
 rust-bzip2+default-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+compression-deflate-devel = " \
 cargo \
 rust-buffered-reader+compression-deflate-devel \
 rust-flate2+default-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+compression-devel = " \
 cargo \
 rust-sequoia-openpgp+compression-bzip2-devel \
 rust-sequoia-openpgp+compression-deflate-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+crypto-nettle-devel = " \
 cargo \
 rust-nettle+default-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+crypto-openssl-devel = " \
 cargo \
 rust-ossl+openssl-sys-devel \
 rust-ossl+rfc9580-devel \
 rust-ossl-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+default-devel = " \
 cargo \
 rust-sequoia-openpgp+compression-devel \
 rust-sequoia-openpgp+crypto-nettle-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp-devel = " \
 bash \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-argon2+default-devel \
 rust-base64_0.22+default-devel \
 rust-buffered-reader-devel \
 rust-dyn-clone+default-devel \
 rust-idna+default-devel \
 rust-lalrpop-devel \
 rust-lalrpop-util+default-devel \
 rust-libc+default-devel \
 rust-memsec-devel \
 rust-regex+default-devel \
 rust-regex-syntax+default-devel \
 rust-sha1collisiondetection+std-devel \
 rust-sha1collisiondetection-devel \
 rust-xxhash-rust+default-devel \
 rust-xxhash-rust+xxh3-devel \
 virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~ \
 "
