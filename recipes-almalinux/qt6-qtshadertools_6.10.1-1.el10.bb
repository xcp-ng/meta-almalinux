# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtshadertools"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtshadertools \
 qt6-qtshadertools-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtshadertools-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38624a23fbb44e6b2cd3ffd1b0b168d40676aba80a8f041b7f66eaf4a4544797"

URI_x86_64_v2_qt6-qtshadertools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtshadertools-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtshadertools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtshadertools}"
SRC_URI[x86_64_v2_qt6-qtshadertools.sha256sum] = "05fad2cf6171c3f948263fea39de142791544979e2ab6c86618d8fed910f6f30"

URI_x86_64_v2_qt6-qtshadertools-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtshadertools-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtshadertools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtshadertools-devel}"
SRC_URI[x86_64_v2_qt6-qtshadertools-devel.sha256sum] = "5a90ab2a58f2939b7f85ad30528f62be3e75bf833375ba2016c07556cc03cd49"

URI_aarch64_qt6-qtshadertools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtshadertools-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtshadertools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtshadertools}"
SRC_URI[aarch64_qt6-qtshadertools.sha256sum] = "517d42322d048b85662a0330a59a674319eb0d830db29b7139e4ebb2425b4d68"

URI_aarch64_qt6-qtshadertools-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtshadertools-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtshadertools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtshadertools-devel}"
SRC_URI[aarch64_qt6-qtshadertools-devel.sha256sum] = "f24b7472eb4e1a3a30d90b099a4c4e26ef3fdbd582b9ed2bb92e37737caf72c2"

RDEPENDS:qt6-qtshadertools = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 spirv-tools-libs \
 "
RDEPENDS:qt6-qtshadertools-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtshadertools \
 spirv-tools \
 "
