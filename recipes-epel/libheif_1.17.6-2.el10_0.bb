# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libheif"
PV = "1.17.6"
PR = "2.el10_0"
PACKAGES = " \
 heif-pixbuf-loader \
 libheif \
 libheif-devel \
 libheif-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libheif-1.17.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4eb121c3fb8d95d4b4cdbfea725e3d7f3ff6581cb17c812d34797c628bd52ac7"

URI_x86_64_v2_heif-pixbuf-loader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/heif-pixbuf-loader-1.17.6-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_heif-pixbuf-loader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_heif-pixbuf-loader}"
SRC_URI[x86_64_v2_heif-pixbuf-loader.sha256sum] = "32a65c262607820c0ca72f50e4d21d2fe1a52925f16f69d1df9d7a8573d71d99"

URI_x86_64_v2_libheif = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libheif-1.17.6-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libheif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libheif}"
SRC_URI[x86_64_v2_libheif.sha256sum] = "2e77412ecb33bd8ada7b7a93121cddac51407e21d95aeca97b159fa3637d00ed"

URI_x86_64_v2_libheif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libheif-devel-1.17.6-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libheif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libheif-devel}"
SRC_URI[x86_64_v2_libheif-devel.sha256sum] = "24461ed6ccae6058c91aca4a40f10f0c61d5d2fa283bbbdcafe8d1f31d61fb6f"

URI_x86_64_v2_libheif-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libheif-tools-1.17.6-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libheif-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libheif-tools}"
SRC_URI[x86_64_v2_libheif-tools.sha256sum] = "fce3e0957a0ac7d1fe3484945dcfc186b6a3f72970b27d5de009a8025be7c193"

URI_aarch64_heif-pixbuf-loader = "${EPEL_MIRROR}/aarch64/Packages/h/heif-pixbuf-loader-1.17.6-2.el10_0.aarch64.rpm;name=aarch64_heif-pixbuf-loader;unpack=0"
SRC_URI:append = " ${URI_aarch64_heif-pixbuf-loader}"
SRC_URI[aarch64_heif-pixbuf-loader.sha256sum] = "fc164f3a467c41850c8606566a73e1dae403c0c4c88780a06e25d461fedde17f"

URI_aarch64_libheif = "${EPEL_MIRROR}/aarch64/Packages/l/libheif-1.17.6-2.el10_0.aarch64.rpm;name=aarch64_libheif;unpack=0"
SRC_URI:append = " ${URI_aarch64_libheif}"
SRC_URI[aarch64_libheif.sha256sum] = "9a2ad66191493ed65204a352849aac73ba8c11a3716064629de75f2e9a086e92"

URI_aarch64_libheif-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libheif-devel-1.17.6-2.el10_0.aarch64.rpm;name=aarch64_libheif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libheif-devel}"
SRC_URI[aarch64_libheif-devel.sha256sum] = "c4d4b2d7cd7aa86f1d64205656b8ef0b3f685d90182fb7fbb7f59541b9615e8c"

URI_aarch64_libheif-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libheif-tools-1.17.6-2.el10_0.aarch64.rpm;name=aarch64_libheif-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libheif-tools}"
SRC_URI[aarch64_libheif-tools.sha256sum] = "df9ad7bc9e76946ef5a4abd7e8ba2a76cf7b3d28457ddca13a165e00a29bcee4"

RDEPENDS:heif-pixbuf-loader = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libheif \
 "
RDEPENDS:libheif = " \
 glibc \
 libaom \
 libdav1d \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 libwebp \
 openjpeg2 \
 rav1e-libs \
 svt-av1-libs \
 "
RDEPENDS:libheif-devel = " \
 cmake-filesystem \
 libaom-devel \
 libdav1d-devel \
 libheif \
 libjpeg-turbo-devel \
 libwebp-devel \
 openjpeg2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libheif-tools = " \
 glibc \
 libgcc \
 libheif \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 shared-mime-info \
 "
