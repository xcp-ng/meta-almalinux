# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-cloud-google-pubsub"
PV = "1.39.0"
PR = "3.el10_0~bootstrap"
PACKAGES = " \
 golang-cloud-google-pubsub-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-cloud-google-pubsub-1.39.0-3.el10_0~bootstrap.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "736874ea9721f29517389fbf3b61525c16b287796a5e0ddb911e2b2562df6af5"

URI_x86_64_v2_golang-cloud-google-pubsub-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-cloud-google-pubsub-devel-1.39.0-3.el10_0~bootstrap.alma_altarch.noarch.rpm;name=x86_64_v2_golang-cloud-google-pubsub-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-cloud-google-pubsub-devel}"
SRC_URI[x86_64_v2_golang-cloud-google-pubsub-devel.sha256sum] = "1ff69422d100bd15cc514d6c4a5bfaefc8dc8a38f7a15fc8bb53e9f94a710863"

URI_aarch64_golang-cloud-google-pubsub-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-cloud-google-pubsub-devel-1.39.0-3.el10_0~bootstrap.noarch.rpm;name=aarch64_golang-cloud-google-pubsub-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-cloud-google-pubsub-devel}"
SRC_URI[aarch64_golang-cloud-google-pubsub-devel.sha256sum] = "4e36173e15f39da3fc4987b5c9f661912ab29b8a6fcfe07be66e70323d689bda"

RDEPENDS:golang-cloud-google-pubsub-devel = " \
 go-filesystem \
 "
