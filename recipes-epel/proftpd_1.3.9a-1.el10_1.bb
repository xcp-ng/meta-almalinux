# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "proftpd"
PV = "1.3.9a"
PR = "1.el10_1"
PACKAGES = " \
 proftpd \
 proftpd-devel \
 proftpd-ldap \
 proftpd-mysql \
 proftpd-postgresql \
 proftpd-proxy \
 proftpd-sqlite \
 proftpd-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/proftpd-1.3.9a-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d48d553d4286c1c1f56d588b2798ea3696ea169c933a4db1c66b94254b122301"

URI_x86_64_v2_proftpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-1.3.9a-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd}"
SRC_URI[x86_64_v2_proftpd.sha256sum] = "5f4634cb7553142167e39d3733f6f8f28e035fa536cac368f27cb627d911122e"

URI_x86_64_v2_proftpd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-devel-1.3.9a-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-devel}"
SRC_URI[x86_64_v2_proftpd-devel.sha256sum] = "51136e0ab477f1e88d5a157eb0bebc0982fb1424159893319461d7ec30bfd4a0"

URI_x86_64_v2_proftpd-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-ldap-1.3.9a-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-ldap}"
SRC_URI[x86_64_v2_proftpd-ldap.sha256sum] = "977f69f3d3b66da0c2af467510cd811d4d62dd909cda9e7209b28f2074ef6449"

URI_x86_64_v2_proftpd-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-mysql-1.3.9a-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-mysql}"
SRC_URI[x86_64_v2_proftpd-mysql.sha256sum] = "29dcbc979a051f77b891c22ae994e260a0fa999dc055601c756a1f4b9de29a9d"

URI_x86_64_v2_proftpd-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-postgresql-1.3.9a-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-postgresql}"
SRC_URI[x86_64_v2_proftpd-postgresql.sha256sum] = "9e6b5b4fbaa1226d87745ef82969711aad0553efc703b6a669185b64e1acf567"

URI_x86_64_v2_proftpd-proxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-proxy-1.3.9a-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-proxy}"
SRC_URI[x86_64_v2_proftpd-proxy.sha256sum] = "0ebc9a45791f0cb6b9791444fd0feb06ae6507398d77ca3dc8020ed1af548ba8"

URI_x86_64_v2_proftpd-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-sqlite-1.3.9a-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-sqlite}"
SRC_URI[x86_64_v2_proftpd-sqlite.sha256sum] = "ae107b465b614a998928bb7dbbe4c01033b602406a7b8cf337b23e7eb5378c4f"

URI_x86_64_v2_proftpd-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-utils-1.3.9a-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-utils}"
SRC_URI[x86_64_v2_proftpd-utils.sha256sum] = "29fc8e5dacba8fccf1f0cb4d8ee0ee420e7be76866fd982590ecfbe1c8e75c98"

URI_aarch64_proftpd = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-1.3.9a-1.el10_1.aarch64.rpm;name=aarch64_proftpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd}"
SRC_URI[aarch64_proftpd.sha256sum] = "33250c5c0f0759c166171b778cde6443b1f11749f379a70d05fad00d471b6dda"

URI_aarch64_proftpd-devel = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-devel-1.3.9a-1.el10_1.aarch64.rpm;name=aarch64_proftpd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-devel}"
SRC_URI[aarch64_proftpd-devel.sha256sum] = "c06318059a1220a75082cd4bec8691862716518b5c4dce4834920308bcb8f9ca"

URI_aarch64_proftpd-ldap = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-ldap-1.3.9a-1.el10_1.aarch64.rpm;name=aarch64_proftpd-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-ldap}"
SRC_URI[aarch64_proftpd-ldap.sha256sum] = "bcd6a61b851d1149a94cf94ff4975e4778e5fc13ae0ddf396e286f312001cfc7"

URI_aarch64_proftpd-mysql = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-mysql-1.3.9a-1.el10_1.aarch64.rpm;name=aarch64_proftpd-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-mysql}"
SRC_URI[aarch64_proftpd-mysql.sha256sum] = "a3aa5147218350eb86a26a1661802741dad15ecd59d1c977d29f2588bf3d8727"

URI_aarch64_proftpd-postgresql = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-postgresql-1.3.9a-1.el10_1.aarch64.rpm;name=aarch64_proftpd-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-postgresql}"
SRC_URI[aarch64_proftpd-postgresql.sha256sum] = "f61f27e2be4eacf9e35c775cff2891e653ad1333e5beda71acf792e4de24959f"

URI_aarch64_proftpd-proxy = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-proxy-1.3.9a-1.el10_1.aarch64.rpm;name=aarch64_proftpd-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-proxy}"
SRC_URI[aarch64_proftpd-proxy.sha256sum] = "1d3e12c07df63aec31a9f1c6f84ebaae2ba3380c6c20fa07ca98bcdcfef1a6cb"

URI_aarch64_proftpd-sqlite = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-sqlite-1.3.9a-1.el10_1.aarch64.rpm;name=aarch64_proftpd-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-sqlite}"
SRC_URI[aarch64_proftpd-sqlite.sha256sum] = "0472a0575206362b81232d7284903f001f1bc1ee7544711925b01b312ebf0621"

URI_aarch64_proftpd-utils = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-utils-1.3.9a-1.el10_1.aarch64.rpm;name=aarch64_proftpd-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-utils}"
SRC_URI[aarch64_proftpd-utils.sha256sum] = "f0ef33387c799a4b7821e9c8c033812b0747ba6c96e70fd6fa3f29b5a3e172c5"

RDEPENDS:proftpd = " \
 bash \
 findutils \
 glibc \
 libacl \
 libcap \
 libidn2 \
 libmemcached-awesome \
 libsodium \
 libxcrypt \
 logrotate \
 openssl-libs \
 pam-libs \
 pcre2 \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-devel = " \
 gcc \
 libacl-devel \
 libcap-devel \
 libmemcached-awesome-devel \
 libpq-devel \
 libsodium-devel \
 libtool \
 mariadb-connector-c-devel \
 ncurses-devel \
 openldap-devel \
 openssl-devel \
 pam-devel \
 pcre2-devel \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 proftpd \
 sqlite-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:proftpd-ldap = " \
 glibc \
 libidn2 \
 libsodium \
 openldap \
 proftpd \
 "
RDEPENDS:proftpd-mysql = " \
 glibc \
 libidn2 \
 libsodium \
 mariadb-connector-c \
 proftpd \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-postgresql = " \
 glibc \
 libidn2 \
 libpq \
 libsodium \
 proftpd \
 "
RDEPENDS:proftpd-proxy = " \
 glibc \
 libidn2 \
 libsodium \
 openssl-libs \
 proftpd \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-sqlite = " \
 glibc \
 libidn2 \
 libsodium \
 proftpd \
 sqlite-libs \
 "
RDEPENDS:proftpd-utils = " \
 glibc \
 ncurses-libs \
 perl-Crypt-Cracklib \
 perl-Fcntl \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-IO \
 perl-MIME-Base64 \
 perl-Mail-Sendmail \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 proftpd \
 "
