# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "debmirror"
PV = "2.48"
PR = "3.el10_3"
PACKAGES = " \
 debmirror \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/debmirror-2.48-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43eb802d411234f605d518e8cf2d6a515ae9ecc3d7f964a65e909d31502b9536"

URI_x86_64_v2_debmirror = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debmirror-2.48-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_debmirror;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debmirror}"
SRC_URI[x86_64_v2_debmirror.sha256sum] = "592ca03e1c1d8025d80c43d8fea3bb7f21b2a00ecb725593fb5da97224af610a"

URI_aarch64_debmirror = "${EPEL_MIRROR}/aarch64/Packages/d/debmirror-2.48-3.el10_3.noarch.rpm;name=aarch64_debmirror;unpack=0"
SRC_URI:append = " ${URI_aarch64_debmirror}"
SRC_URI[aarch64_debmirror.sha256sum] = "12436452180af2394bf444717badac0749b6dd9bd7bb3b9a8ceb96fba604997d"

RDEPENDS:debmirror = " \
 bzip2 \
 ed \
 findutils \
 gnupg2 \
 gzip \
 patch \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Fcntl \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IO-Compress \
 perl-LockFile-Simple \
 perl-MIME-Base64 \
 perl-PathTools \
 perl-Storable \
 perl-URI \
 perl-if \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 perl-libwww-perl \
 rsync \
 virtual/coreutils \
 "
