# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-x509-parser"
PV = "0.16.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-x509-parser+default-devel \
 rust-x509-parser+ring-devel \
 rust-x509-parser+validate-devel \
 rust-x509-parser+verify-devel \
 rust-x509-parser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-x509-parser-0.16.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da9c9d4d949fdef8a218549bcc878c08b26104d51038b10702a5c9ced40c58d9"

URI_x86_64_v2_rust-x509-parser+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser+default-devel-0.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser+default-devel}"
SRC_URI[x86_64_v2_rust-x509-parser+default-devel.sha256sum] = "af8aff9ba598e8e5511f1e854053c758aff0788f9beb31f488fc848c73e98425"

URI_x86_64_v2_rust-x509-parser+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser+ring-devel-0.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser+ring-devel}"
SRC_URI[x86_64_v2_rust-x509-parser+ring-devel.sha256sum] = "fbcf7808e8d65e04a289a0e83a679639d1a2ed6237e71be50b52271b42b719e8"

URI_x86_64_v2_rust-x509-parser+validate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser+validate-devel-0.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser+validate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser+validate-devel}"
SRC_URI[x86_64_v2_rust-x509-parser+validate-devel.sha256sum] = "e0bb998933ce2519e405e504fddecd167c0118e2bea79ec8d3047a5f801add57"

URI_x86_64_v2_rust-x509-parser+verify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser+verify-devel-0.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser+verify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser+verify-devel}"
SRC_URI[x86_64_v2_rust-x509-parser+verify-devel.sha256sum] = "a5e6a7aa42c5df21dae3dad5b937fc79c2df2948fea1f3c76895c752634e6b36"

URI_x86_64_v2_rust-x509-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser-devel-0.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser-devel}"
SRC_URI[x86_64_v2_rust-x509-parser-devel.sha256sum] = "9b05949df2da1e0fc8c3e50f50215d8cac74373f12a8db03cf5c0a0c9cef5edd"

URI_aarch64_rust-x509-parser+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser+default-devel-0.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-x509-parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser+default-devel}"
SRC_URI[aarch64_rust-x509-parser+default-devel.sha256sum] = "58a70c1e7d47806644c288836cfa8da85b4f8dad253f2fc726143ce92e8d2acc"

URI_aarch64_rust-x509-parser+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser+ring-devel-0.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-x509-parser+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser+ring-devel}"
SRC_URI[aarch64_rust-x509-parser+ring-devel.sha256sum] = "e9630e5d54bf5383e70e779bf18819f32dadec29c155c4ca6a57542ab03c9a38"

URI_aarch64_rust-x509-parser+validate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser+validate-devel-0.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-x509-parser+validate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser+validate-devel}"
SRC_URI[aarch64_rust-x509-parser+validate-devel.sha256sum] = "77e97b3d2b0df67f0570ac0e48784ff87c3fc6bbfebaf80254dc9ba83bca531c"

URI_aarch64_rust-x509-parser+verify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser+verify-devel-0.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-x509-parser+verify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser+verify-devel}"
SRC_URI[aarch64_rust-x509-parser+verify-devel.sha256sum] = "1453af39a0dbf786babbfe8096ec764b00f24a5957a5c28546050294c35bee54"

URI_aarch64_rust-x509-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser-devel-0.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-x509-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser-devel}"
SRC_URI[aarch64_rust-x509-parser-devel.sha256sum] = "c5642b60d84570c5640161d6763e4ceb2a935e4a1db9a2d15c1cbb871957eb3c"

RDEPENDS:rust-x509-parser+default-devel = " \
 cargo \
 rust-x509-parser-devel \
 "
RDEPENDS:rust-x509-parser+ring-devel = " \
 cargo \
 rust-ring+default-devel \
 rust-x509-parser-devel \
 "
RDEPENDS:rust-x509-parser+validate-devel = " \
 cargo \
 rust-x509-parser-devel \
 "
RDEPENDS:rust-x509-parser+verify-devel = " \
 cargo \
 rust-x509-parser+ring-devel \
 rust-x509-parser-devel \
 "
RDEPENDS:rust-x509-parser-devel = " \
 cargo \
 rust \
 rust-asn1-rs+datetime-devel \
 rust-asn1-rs+default-devel \
 rust-data-encoding+default-devel \
 rust-der-parser+bigint-devel \
 rust-der-parser+default-devel \
 rust-lazy_static+default-devel \
 rust-nom7+default-devel \
 rust-oid-registry+crypto-devel \
 rust-oid-registry+default-devel \
 rust-oid-registry+x509-devel \
 rust-oid-registry+x962-devel \
 rust-rusticata-macros+default-devel \
 rust-thiserror1+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 "
