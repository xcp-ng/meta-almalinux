# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-spin"
PV = "0.12.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-spin+barrier-devel \
 rust-spin+default-devel \
 rust-spin+fair_mutex-devel \
 rust-spin+lazy-devel \
 rust-spin+lazylock-devel \
 rust-spin+lock_api-devel \
 rust-spin+mutex-devel \
 rust-spin+once-devel \
 rust-spin+portable-atomic-devel \
 rust-spin+portable_atomic-devel \
 rust-spin+rwlock-devel \
 rust-spin+spin_mutex-devel \
 rust-spin+std-devel \
 rust-spin+ticket_mutex-devel \
 rust-spin+use_ticket_mutex-devel \
 rust-spin-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-spin-0.12.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcb57935a3b697d94139e080a9706f1563775c9f0247cdb1309c41bb79b045ab"

URI_x86_64_v2_rust-spin+barrier-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+barrier-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+barrier-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+barrier-devel}"
SRC_URI[x86_64_v2_rust-spin+barrier-devel.sha256sum] = "a44ef6673028c87366ef9d8f35568490cec2ca9f992538e5909894f647fdaa76"

URI_x86_64_v2_rust-spin+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+default-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+default-devel}"
SRC_URI[x86_64_v2_rust-spin+default-devel.sha256sum] = "3d6dcd4dae637b83aa440deec3f0c06420894af39f318a682726fe75c411d391"

URI_x86_64_v2_rust-spin+fair_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+fair_mutex-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+fair_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+fair_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+fair_mutex-devel.sha256sum] = "9ec35b298487c4bfe208371ee74ee7dc3d9cd7762be1c08cc9d4a5298f473911"

URI_x86_64_v2_rust-spin+lazy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+lazy-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+lazy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+lazy-devel}"
SRC_URI[x86_64_v2_rust-spin+lazy-devel.sha256sum] = "3e4611b65b0140698edf7226218d89c6cd3f8d1385dc0ccd5f4f3c5deaef8dda"

URI_x86_64_v2_rust-spin+lazylock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+lazylock-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+lazylock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+lazylock-devel}"
SRC_URI[x86_64_v2_rust-spin+lazylock-devel.sha256sum] = "b900f611fa668f282cb51b76c2175fc1c56d28423ff5b1f5a48e7575b86f243f"

URI_x86_64_v2_rust-spin+lock_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+lock_api-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+lock_api-devel}"
SRC_URI[x86_64_v2_rust-spin+lock_api-devel.sha256sum] = "2245efe195f16d253a6e4207978ba8757b299e79762a9373990c452a8371f36a"

URI_x86_64_v2_rust-spin+mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+mutex-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+mutex-devel.sha256sum] = "e94382bf91ca275997bc018106d3f2e30abd96029e11ca86e0b012916f1d13c4"

URI_x86_64_v2_rust-spin+once-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+once-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+once-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+once-devel}"
SRC_URI[x86_64_v2_rust-spin+once-devel.sha256sum] = "46b84bb875aed61d588c286e8d9678e4f47f9f753ec8870c3421ca70500dbb33"

URI_x86_64_v2_rust-spin+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+portable-atomic-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-spin+portable-atomic-devel.sha256sum] = "f8675bf4424c55f9872bcf418ff7903a7ddaac383778b6d6257220c0f44c9da0"

URI_x86_64_v2_rust-spin+portable_atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+portable_atomic-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+portable_atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+portable_atomic-devel}"
SRC_URI[x86_64_v2_rust-spin+portable_atomic-devel.sha256sum] = "e3190e4fd5c8771a5b7f328d1542e33ea23438b68b48e4221b09668e23b749f0"

URI_x86_64_v2_rust-spin+rwlock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+rwlock-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+rwlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+rwlock-devel}"
SRC_URI[x86_64_v2_rust-spin+rwlock-devel.sha256sum] = "937d325c07d0bac221f1f03828ccbf2f11241d178f1ef20bf6fe83e60297bdf1"

URI_x86_64_v2_rust-spin+spin_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+spin_mutex-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+spin_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+spin_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+spin_mutex-devel.sha256sum] = "d5106a55e39759649d1f29a555b868a40bf2e9856eb4a88bed62de327db044b2"

URI_x86_64_v2_rust-spin+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+std-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+std-devel}"
SRC_URI[x86_64_v2_rust-spin+std-devel.sha256sum] = "851fc10e3e6fa9316c8d456403836b59088736fb3ab37c399a86140fef72ced8"

URI_x86_64_v2_rust-spin+ticket_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+ticket_mutex-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+ticket_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+ticket_mutex-devel.sha256sum] = "eec3a2c9343b66afd72b15807e4d223449df3a1efd7732e12f7e9e7f4f93a3df"

URI_x86_64_v2_rust-spin+use_ticket_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+use_ticket_mutex-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+use_ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+use_ticket_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+use_ticket_mutex-devel.sha256sum] = "c9ae2bc33871065124623e88291c47d6dfa190b37c8582e873b3357f9b557ca3"

URI_x86_64_v2_rust-spin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin-devel}"
SRC_URI[x86_64_v2_rust-spin-devel.sha256sum] = "0a5fe58b435b3e11486d81ae81960b786af70bad619e3ec67ac714989ee340b0"

URI_aarch64_rust-spin+barrier-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+barrier-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+barrier-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+barrier-devel}"
SRC_URI[aarch64_rust-spin+barrier-devel.sha256sum] = "2b0c7b36533640e35e4eb3b1835c96b04603d7916a7ea9a91bf87bd70dfec096"

URI_aarch64_rust-spin+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+default-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+default-devel}"
SRC_URI[aarch64_rust-spin+default-devel.sha256sum] = "0783ca1a6401f32f4cb7e28705d00e2a89255c062caa63e3a1f1ab4c9fb34db5"

URI_aarch64_rust-spin+fair_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+fair_mutex-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+fair_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+fair_mutex-devel}"
SRC_URI[aarch64_rust-spin+fair_mutex-devel.sha256sum] = "8721acc88d5d5271851b925139825f712b82dd38363361ee625dacdd34894199"

URI_aarch64_rust-spin+lazy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+lazy-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+lazy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+lazy-devel}"
SRC_URI[aarch64_rust-spin+lazy-devel.sha256sum] = "0b8bcaf5546af8fb8ae58df85d93aa010b84ccfe8d5d574a1531af776abd5357"

URI_aarch64_rust-spin+lazylock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+lazylock-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+lazylock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+lazylock-devel}"
SRC_URI[aarch64_rust-spin+lazylock-devel.sha256sum] = "bbbc9db087692f068a33fcc257577f60311bb1e5c97313b6d7ffac441fbae2f7"

URI_aarch64_rust-spin+lock_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+lock_api-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+lock_api-devel}"
SRC_URI[aarch64_rust-spin+lock_api-devel.sha256sum] = "9aa655aab86ecacb3ae1c0da8384fd88be4deca453d51e47ddeee3901d328069"

URI_aarch64_rust-spin+mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+mutex-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+mutex-devel}"
SRC_URI[aarch64_rust-spin+mutex-devel.sha256sum] = "3d5923756a37c5de350e7a36f3572f54bb6eb0521f2e2b3602a0e3c22f63fd5d"

URI_aarch64_rust-spin+once-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+once-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+once-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+once-devel}"
SRC_URI[aarch64_rust-spin+once-devel.sha256sum] = "038564ce5a8c62df874d361a9850919034de5b38b1e55daff9d3572e90b88a04"

URI_aarch64_rust-spin+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+portable-atomic-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+portable-atomic-devel}"
SRC_URI[aarch64_rust-spin+portable-atomic-devel.sha256sum] = "b8e7a1ab0827bd4bf055b72f2fb44eee0e0c27d8e1afdf49902a0bc9e44e8439"

URI_aarch64_rust-spin+portable_atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+portable_atomic-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+portable_atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+portable_atomic-devel}"
SRC_URI[aarch64_rust-spin+portable_atomic-devel.sha256sum] = "456ea39fef204931c936c554c638a7ded5950a72ba74a3c4eebb84b7f461b6c6"

URI_aarch64_rust-spin+rwlock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+rwlock-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+rwlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+rwlock-devel}"
SRC_URI[aarch64_rust-spin+rwlock-devel.sha256sum] = "4263d573e3d52136c979609e03dbed00d8d8a69fd2cd8d1c0ba79434155c395d"

URI_aarch64_rust-spin+spin_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+spin_mutex-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+spin_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+spin_mutex-devel}"
SRC_URI[aarch64_rust-spin+spin_mutex-devel.sha256sum] = "2636027dd66439d8e130f796f90fc0320ce5a30ffba0694ea84f60444320bece"

URI_aarch64_rust-spin+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+std-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+std-devel}"
SRC_URI[aarch64_rust-spin+std-devel.sha256sum] = "942d8aa4007ca874ab1f9318d08e5548813e9c3e86bb52bdb35a4be2516e5825"

URI_aarch64_rust-spin+ticket_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+ticket_mutex-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+ticket_mutex-devel}"
SRC_URI[aarch64_rust-spin+ticket_mutex-devel.sha256sum] = "4924f16baeef312d797aef67844f5847ad14167ba365bccb55906e96aa3f7900"

URI_aarch64_rust-spin+use_ticket_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+use_ticket_mutex-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin+use_ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+use_ticket_mutex-devel}"
SRC_URI[aarch64_rust-spin+use_ticket_mutex-devel.sha256sum] = "1526db498e560235e8907b3f852addef5373d54636caca9520f464e4a70b88eb"

URI_aarch64_rust-spin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-spin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin-devel}"
SRC_URI[aarch64_rust-spin-devel.sha256sum] = "1202d21a4b463ec2e103ad8c232314954669a8ffe34ab9ec25843b0c064c854c"

RDEPENDS:rust-spin+barrier-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+default-devel = " \
 cargo \
 rust-spin+barrier-devel \
 rust-spin+lazylock-devel \
 rust-spin+lock_api-devel \
 rust-spin+mutex-devel \
 rust-spin+once-devel \
 rust-spin+rwlock-devel \
 rust-spin+spin_mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+fair_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+lazy-devel = " \
 cargo \
 rust-spin+lazylock-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+lazylock-devel = " \
 cargo \
 rust-spin+once-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+lock_api-devel = " \
 cargo \
 rust-lock_api+default-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+mutex-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+once-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+portable-atomic-devel = " \
 cargo \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+portable_atomic-devel = " \
 cargo \
 rust-spin+portable-atomic-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+rwlock-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+spin_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+std-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+ticket_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+use_ticket_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin+ticket_mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin-devel = " \
 cargo \
 rust \
 "
