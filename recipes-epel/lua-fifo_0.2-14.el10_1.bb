# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-fifo"
PV = "0.2"
PR = "14.el10_1"
PACKAGES = " \
 lua-fifo \
 lua5.1-fifo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-fifo-0.2-14.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36e7292fd5d51169469ce829e3dd8973dff8923b58c48faa8d8415c31fc50653"

URI_x86_64_v2_lua-fifo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-fifo-0.2-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua-fifo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-fifo}"
SRC_URI[x86_64_v2_lua-fifo.sha256sum] = "38bc236eb7a90b79239d7768e645dca4a695cae88b9bfa84f1121c2e61163898"

URI_x86_64_v2_lua5.1-fifo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-fifo-0.2-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua5.1-fifo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-fifo}"
SRC_URI[x86_64_v2_lua5.1-fifo.sha256sum] = "f9fdda90ec0f1878daf696b9ef18a9dbbfd940059e23651194cc0e7b5f57bc73"

URI_aarch64_lua-fifo = "${EPEL_MIRROR}/aarch64/Packages/l/lua-fifo-0.2-14.el10_1.noarch.rpm;name=aarch64_lua-fifo;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-fifo}"
SRC_URI[aarch64_lua-fifo.sha256sum] = "d04fe4eb5f6aa79cc720d64693b7452e7bb07717eb1e2ffea2232531c48a6db0"

URI_aarch64_lua5.1-fifo = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-fifo-0.2-14.el10_1.noarch.rpm;name=aarch64_lua5.1-fifo;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-fifo}"
SRC_URI[aarch64_lua5.1-fifo.sha256sum] = "aaa67ad1be4152814c056ca87d0ae02a68534ba494f240c11da1bb9c19f8fc82"

RDEPENDS:lua-fifo = " \
 "
RDEPENDS:lua5.1-fifo = " \
 "
