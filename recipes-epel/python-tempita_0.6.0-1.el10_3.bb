# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tempita"
PV = "0.6.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-tempita \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tempita-0.6.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6bb03f144bca2b4aa06f3042bd19a464d3615933b1b7f531474794bc0eab07f"

URI_x86_64_v2_python3-tempita = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tempita-0.6.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tempita;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tempita}"
SRC_URI[x86_64_v2_python3-tempita.sha256sum] = "18d6727a1f39f6cf31d0b38b09edd8896acf8738a392763c39d52084aa78283f"

URI_aarch64_python3-tempita = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tempita-0.6.0-1.el10_3.noarch.rpm;name=aarch64_python3-tempita;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tempita}"
SRC_URI[aarch64_python3-tempita.sha256sum] = "30f32450fded6f7812123a669e54178ea85e2b5d930f14dd7808837a775238aa"

RDEPENDS:python3-tempita = " \
 python3 \
 "
