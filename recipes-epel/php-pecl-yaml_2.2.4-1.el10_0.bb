# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-yaml"
PV = "2.2.4"
PR = "1.el10_0"
PACKAGES = " \
 php-pecl-yaml \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-pecl-yaml-2.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "876eee8165489c31d682fda5f9f40a9047548ea6d3800037ae934a886e5b9120"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-yaml-2.2.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-yaml;unpack=0"
SRC_URI[x86_64_v2_php-pecl-yaml.sha256sum] = "b239f5173b6d6b2ad4ba0437c6a0872043482f54f4a772b17d77fc91608918e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-yaml-2.2.4-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-yaml;unpack=0"
SRC_URI[aarch64_php-pecl-yaml.sha256sum] = "15ab890d506904254810ff095f0c77014d1528a0d6e087f87152bd0d308a649c"

RDEPENDS:php-pecl-yaml = " \
 glibc \
 libyaml \
 php-common \
 "
