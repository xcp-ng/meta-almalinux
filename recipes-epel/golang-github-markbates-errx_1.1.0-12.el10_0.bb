# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-markbates-errx"
PV = "1.1.0"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-markbates-errx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-markbates-errx-1.1.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0f0cadf9466e6cea0b7987929600b5280ed571b5d9876bf11390df976deb20e"

URI_x86_64_v2_golang-github-markbates-errx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-markbates-errx-devel-1.1.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-markbates-errx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-markbates-errx-devel}"
SRC_URI[x86_64_v2_golang-github-markbates-errx-devel.sha256sum] = "654e7529f069494f32b5391477c52de977424b170270ab5b5c102f254450ac8b"

URI_aarch64_golang-github-markbates-errx-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-markbates-errx-devel-1.1.0-12.el10_0.noarch.rpm;name=aarch64_golang-github-markbates-errx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-markbates-errx-devel}"
SRC_URI[aarch64_golang-github-markbates-errx-devel.sha256sum] = "93242e85e5a293a125906bcd1605837b142091176c7d7329800582469ffb88ad"

RDEPENDS:golang-github-markbates-errx-devel = " \
 go-filesystem \
 "
