# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bovo"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 bovo \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bovo-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "00ec699b7f31662dd90da7eb9526199f86c5250cc95cbb45d3f9181954630553"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bovo-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bovo;unpack=0"
SRC_URI[x86_64_v2_bovo.sha256sum] = "f2be3d50d70a26dbefdc1e8afec3bc2a380e3158979d9de11e0567b0d138d980"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bovo-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_bovo;unpack=0"
SRC_URI[aarch64_bovo.sha256sum] = "849ebe2e83d2f48887b06624233bdbae31e1937db4da8d3657bec03212a188bb"

RDEPENDS:bovo = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
