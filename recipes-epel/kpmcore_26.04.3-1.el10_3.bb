# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpmcore"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kpmcore \
 kpmcore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpmcore-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92a496587074177a817ca60893d159c051ae40083a49b065fc1e1eff96102ef7"

URI_x86_64_v2_kpmcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpmcore-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpmcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpmcore}"
SRC_URI[x86_64_v2_kpmcore.sha256sum] = "07211b27fcedb46a1eec6d08e3fba3b3528025bdc057cd259a1093546e619675"

URI_x86_64_v2_kpmcore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpmcore-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpmcore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpmcore-devel}"
SRC_URI[x86_64_v2_kpmcore-devel.sha256sum] = "0baf10819002f16e926d687e1ee2440e7e5f89b8edaf4f3310a430a0e2c0a188"

URI_aarch64_kpmcore = "${EPEL_MIRROR}/aarch64/Packages/k/kpmcore-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kpmcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpmcore}"
SRC_URI[aarch64_kpmcore.sha256sum] = "22c43d9649cef744cc20b7b5f65aded617c72f8000b2a0a4368432743c73a431"

URI_aarch64_kpmcore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpmcore-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kpmcore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpmcore-devel}"
SRC_URI[aarch64_kpmcore-devel.sha256sum] = "09d5513328f16d64f08c22675b637a072301abb116a217e32f0cf6d92ff0b62b"

RDEPENDS:kpmcore = " \
 e2fsprogs \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libblkid \
 libgcc \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kpmcore-devel = " \
 cmake-filesystem \
 kpmcore \
 qt6-qtbase-devel \
 "
