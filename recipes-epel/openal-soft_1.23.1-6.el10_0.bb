# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openal-soft"
PV = "1.23.1"
PR = "6.el10_0"
PACKAGES = " \
 openal-soft \
 openal-soft-devel \
 openal-soft-examples \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/openal-soft-1.23.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "752f9a0e15985243472c334ec69fce90aa16e7cc20bea0cb01bb4552577db39b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openal-soft-1.23.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openal-soft;unpack=0"
SRC_URI[x86_64_v2_openal-soft.sha256sum] = "d1f9d173e30363ba4cc521cf66654c67959ac4cabff3c149ada37156398f6c16"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openal-soft-devel-1.23.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openal-soft-devel;unpack=0"
SRC_URI[x86_64_v2_openal-soft-devel.sha256sum] = "04ec00cea71fd376e9e62f6d593ffa52e39f0b0e0e2cdd086ec47c8c60cc3c33"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openal-soft-examples-1.23.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openal-soft-examples;unpack=0"
SRC_URI[x86_64_v2_openal-soft-examples.sha256sum] = "287e4c7c78c20ba8284a62850973962ed96b36724561c11e61d85881bd1e5888"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openal-soft-1.23.1-6.el10_0.aarch64.rpm;name=aarch64_openal-soft;unpack=0"
SRC_URI[aarch64_openal-soft.sha256sum] = "0af7191ec8c4f08d787101ac8e5a37be86d5b126ed0f5f936874537c3236f980"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openal-soft-devel-1.23.1-6.el10_0.aarch64.rpm;name=aarch64_openal-soft-devel;unpack=0"
SRC_URI[aarch64_openal-soft-devel.sha256sum] = "7dc1aad8f197a58e3bedc4b1d0a44dbcc7ac5418e1effacd70a2208fe1db65ce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openal-soft-examples-1.23.1-6.el10_0.aarch64.rpm;name=aarch64_openal-soft-examples;unpack=0"
SRC_URI[aarch64_openal-soft-examples.sha256sum] = "6e2433ae9d1780a8dab303359d0eca58330f674f4c60d1f3f01552a1bec82732"

RDEPENDS:openal-soft = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:openal-soft-devel = " \
 cmake-filesystem \
 openal-soft \
 pkgconf-pkg-config \
 "
RDEPENDS:openal-soft-examples = " \
 glibc \
 libsndfile \
 openal-soft \
 sdl2-compat \
 "
