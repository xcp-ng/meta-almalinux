# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cpp-httplib"
PV = "0.30.1"
PR = "5.el10_2"
PACKAGES = " \
 cpp-httplib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cpp-httplib-0.30.1-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e402ebae03a78fd2b4d34c733b7df480f2d209b42f8184df1eb9a6b85f6ebedd"

URI_x86_64_v2_cpp-httplib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cpp-httplib-devel-0.30.1-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cpp-httplib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpp-httplib-devel}"
SRC_URI[x86_64_v2_cpp-httplib-devel.sha256sum] = "bd27a4970595095eba35e119c54473ff01d4b55b378b53a4a3a43ab1bc0a5479"

URI_aarch64_cpp-httplib-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cpp-httplib-devel-0.30.1-5.el10_2.aarch64.rpm;name=aarch64_cpp-httplib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpp-httplib-devel}"
SRC_URI[aarch64_cpp-httplib-devel.sha256sum] = "404610a500f787825319645798746ccbfa95c97dab486c3333df5786ea9af49d"

RDEPENDS:cpp-httplib-devel = " \
 brotli-devel \
 cmake-filesystem \
 openssl-devel \
 zlib-ng-compat-devel \
 "
