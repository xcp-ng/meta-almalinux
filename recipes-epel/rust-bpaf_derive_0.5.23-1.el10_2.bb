# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bpaf_derive"
PV = "0.5.23"
PR = "1.el10_2"
PACKAGES = " \
 rust-bpaf_derive+default-devel \
 rust-bpaf_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bpaf_derive-0.5.23-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc6acdc2bebc631ff98275f3a2dcfcba2556644c11fb34774c85fc7f62e8192f"

URI_x86_64_v2_rust-bpaf_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf_derive+default-devel-0.5.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf_derive+default-devel}"
SRC_URI[x86_64_v2_rust-bpaf_derive+default-devel.sha256sum] = "ae67bcbe31231ac6178820c729b808749a9f6a15993f4b5a16c80563adabdbe4"

URI_x86_64_v2_rust-bpaf_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf_derive-devel-0.5.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf_derive-devel}"
SRC_URI[x86_64_v2_rust-bpaf_derive-devel.sha256sum] = "5f3eb2617a6716e947bbd074097801f2cb204fdc0fd11515b0f7506e437abf88"

URI_aarch64_rust-bpaf_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf_derive+default-devel-0.5.23-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf_derive+default-devel}"
SRC_URI[aarch64_rust-bpaf_derive+default-devel.sha256sum] = "630ea26ef42ea7c278ea33ea1de55cd998c3a8537558464731e72edd7a1dcd8f"

URI_aarch64_rust-bpaf_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf_derive-devel-0.5.23-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf_derive-devel}"
SRC_URI[aarch64_rust-bpaf_derive-devel.sha256sum] = "f2e36128b21efd714dae91407020e034494c55f33acabfe0bad4faaf05d95ecc"

RDEPENDS:rust-bpaf_derive+default-devel = " \
 cargo \
 rust-bpaf_derive-devel \
 "
RDEPENDS:rust-bpaf_derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+visit-mut-devel \
 "
