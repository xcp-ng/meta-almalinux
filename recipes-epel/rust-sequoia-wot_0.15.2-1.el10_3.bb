# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-wot"
PV = "0.15.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-sequoia-wot+default-devel \
 rust-sequoia-wot-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sequoia-wot-0.15.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88e5b83325e822e7ef786194e0ed1c1af2ec862d8b7a00fb6ca6a7f554925221"

URI_x86_64_v2_rust-sequoia-wot+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-wot+default-devel-0.15.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-wot+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-wot+default-devel}"
SRC_URI[x86_64_v2_rust-sequoia-wot+default-devel.sha256sum] = "36c8d2d39322b7dd3b6ba4a9fcaa68443b85282f1eb9efb2a64c5de8fdfff38d"

URI_x86_64_v2_rust-sequoia-wot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-wot-devel-0.15.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-wot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-wot-devel}"
SRC_URI[x86_64_v2_rust-sequoia-wot-devel.sha256sum] = "f4a9d6f819e18b6b58f3915a18b97967eb914ee5e3603f5f0eaa500b736a5d3f"

URI_aarch64_rust-sequoia-wot+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-wot+default-devel-0.15.2-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-wot+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-wot+default-devel}"
SRC_URI[aarch64_rust-sequoia-wot+default-devel.sha256sum] = "122ef0cd254e7b2b443a1cf0b4b6daffc96cb45a7fb3bc20e1253d2db55c080d"

URI_aarch64_rust-sequoia-wot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-wot-devel-0.15.2-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-wot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-wot-devel}"
SRC_URI[aarch64_rust-sequoia-wot-devel.sha256sum] = "e9b95241fa5e1957153ed2257b72767fd7e93cebdd98dfc085275188f61055e1"

RDEPENDS:rust-sequoia-wot+default-devel = " \
 cargo \
 rust-sequoia-wot-devel \
 "
RDEPENDS:rust-sequoia-wot-devel = " \
 bash \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-chrono+default-devel \
 rust-crossbeam+default-devel \
 rust-num_cpus+default-devel \
 rust-sequoia-cert-store-devel \
 rust-sequoia-openpgp-devel \
 virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~ \
 "
