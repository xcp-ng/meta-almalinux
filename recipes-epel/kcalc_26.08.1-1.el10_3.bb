# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcalc"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kcalc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kcalc-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ab85aa2a678f677cd10261de8117bbd91b8a55ea1b9bb8827f3c11e249283594"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalc-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcalc;unpack=0"
SRC_URI[x86_64_v2_kcalc.sha256sum] = "81c0249f8c351e5a5eb345dff0c8fd02a40974741d8fe6f9151453c64b6d9091"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcalc-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kcalc;unpack=0"
SRC_URI[aarch64_kcalc.sha256sum] = "e38b5824e0291556677c0c23a5fcd28033ddd333680ef7ed1accee45102711f4"

RDEPENDS:kcalc = " \
 glibc \
 gmp \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libmpc \
 libstdc++ \
 mpfr \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
