# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rosdistro"
PV = "1.1.0"
PR = "1.el10_3"
PACKAGES = " \
 python-rosdistro-doc \
 python3-rosdistro \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-rosdistro-1.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5cdbedb9f6ceb69ea3a85429b4c5d6f2467946f892313daba594d52ddddf40f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-rosdistro-doc-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-rosdistro-doc;unpack=0"
SRC_URI[x86_64_v2_python-rosdistro-doc.sha256sum] = "7aa16c8f9e76391f5482d1136c32a18bac399fa11a0892dffd5eb4ebdc27fb0f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rosdistro-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rosdistro;unpack=0"
SRC_URI[x86_64_v2_python3-rosdistro.sha256sum] = "e3d8e9bc42e79ad0c5f0eb8ae267cea0c7a1958f32e5fdd7bbcc3587154c67d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-rosdistro-doc-1.1.0-1.el10_3.noarch.rpm;name=aarch64_python-rosdistro-doc;unpack=0"
SRC_URI[aarch64_python-rosdistro-doc.sha256sum] = "c28345ca9e56644df58c1b2926a75a0f184465d0dfde876d5b302186790c5c3f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-rosdistro-1.1.0-1.el10_3.noarch.rpm;name=aarch64_python3-rosdistro;unpack=0"
SRC_URI[aarch64_python3-rosdistro.sha256sum] = "6b31254a0361bf35a6e06621cb5ece61eccf11f5339a4f2d1ca910597a3f2d43"

RDEPENDS:python-rosdistro-doc = " \
 "
RDEPENDS:python3-rosdistro = " \
 python3 \
 python3-catkin_pkg \
 python3-packaging \
 python3-pyyaml \
 python3-rospkg \
 python3-setuptools \
 "
