# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyasn1"
PV = "0.6.2"
PR = "1.el10_1"
PACKAGES = " \
 python3-pyasn1 \
 python3-pyasn1-modules \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-pyasn1-0.6.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfd42956bc55a65ac039244bd0be361a315fa8c0744dbf4858682725f2810a80"

URI_x86_64_v2_python3-pyasn1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyasn1-0.6.2-1.el10_1.noarch.rpm;name=x86_64_v2_python3-pyasn1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyasn1}"
SRC_URI[x86_64_v2_python3-pyasn1.sha256sum] = "65a18182ba8a1ff744c54480fef02fc56be2e29cf6f27c21add641993ec5c97b"

URI_x86_64_v2_python3-pyasn1-modules = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyasn1-modules-0.6.2-1.el10_1.noarch.rpm;name=x86_64_v2_python3-pyasn1-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyasn1-modules}"
SRC_URI[x86_64_v2_python3-pyasn1-modules.sha256sum] = "c3870a41221b18ffe9d77fe32757dfda14c1d4cea7549d6e00f8ebc75c031f42"

URI_aarch64_python3-pyasn1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyasn1-0.6.2-1.el10_1.noarch.rpm;name=aarch64_python3-pyasn1;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyasn1}"
SRC_URI[aarch64_python3-pyasn1.sha256sum] = "65a18182ba8a1ff744c54480fef02fc56be2e29cf6f27c21add641993ec5c97b"

URI_aarch64_python3-pyasn1-modules = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyasn1-modules-0.6.2-1.el10_1.noarch.rpm;name=aarch64_python3-pyasn1-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyasn1-modules}"
SRC_URI[aarch64_python3-pyasn1-modules.sha256sum] = "c3870a41221b18ffe9d77fe32757dfda14c1d4cea7549d6e00f8ebc75c031f42"

RDEPENDS:python3-pyasn1 = " \
 python3 \
 "
RDEPENDS:python3-pyasn1-modules = " \
 python3 \
 python3-pyasn1 \
 "
