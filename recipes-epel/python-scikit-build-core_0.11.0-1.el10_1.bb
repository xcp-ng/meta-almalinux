# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-scikit-build-core"
PV = "0.11.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-scikit-build-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-scikit-build-core-0.11.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64f48718ad55741c31ae9498e7b541833b816fca9e62fb5a374aa20985ecd8f1"

URI_x86_64_v2_python3-scikit-build-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-scikit-build-core-0.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-scikit-build-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-scikit-build-core}"
SRC_URI[x86_64_v2_python3-scikit-build-core.sha256sum] = "7375d35531a8ee24e012013214512393fcb4057b19620022494cd9929c7bf1de"

URI_aarch64_python3-scikit-build-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-scikit-build-core-0.11.0-1.el10_1.noarch.rpm;name=aarch64_python3-scikit-build-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-scikit-build-core}"
SRC_URI[aarch64_python3-scikit-build-core.sha256sum] = "7317c580c36da9f5746bc388d4f17e7f1be30f76c82c498ef607147064502a3f"

RDEPENDS:python3-scikit-build-core = " \
 cmake \
 ninja-build \
 python3 \
 python3-packaging \
 python3-pathspec \
 "
