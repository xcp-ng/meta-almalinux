# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-import-wizard"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 akonadi-import-wizard \
 akonadi-import-wizard-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/akonadi-import-wizard-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7017f045aa6f229868335fc2db60ce1d05e656966e714143b5fa7801ef173c15"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-import-wizard-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-import-wizard;unpack=0"
SRC_URI[x86_64_v2_akonadi-import-wizard.sha256sum] = "895336f9e55809d904389edecf912962e6c3077cf5061abca2f8cd8aad8ff430"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-import-wizard-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-import-wizard-devel;unpack=0"
SRC_URI[x86_64_v2_akonadi-import-wizard-devel.sha256sum] = "4d0007165a5cdd49df241152518f68f9944105b9889634c85f33b5c8be33cee2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-import-wizard-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_akonadi-import-wizard;unpack=0"
SRC_URI[aarch64_akonadi-import-wizard.sha256sum] = "fd1c8093d09981c58c514214574f626f2b6e4ff961db94bba90f955c058b3ed6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-import-wizard-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_akonadi-import-wizard-devel;unpack=0"
SRC_URI[aarch64_akonadi-import-wizard-devel.sha256sum] = "f0256fa0e1ce0daae0a227fb7684168bde5bffdc2db61c09c11db16229d5c329"

RDEPENDS:akonadi-import-wizard = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 libgcc \
 libstdc++ \
 mailcommon \
 mailimporter \
 mailimporter-akonadi \
 messagelib \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:akonadi-import-wizard-devel = " \
 akonadi-import-wizard \
 cmake-filesystem \
 kmailtransport-devel \
 "
