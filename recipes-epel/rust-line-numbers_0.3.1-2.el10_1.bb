# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-line-numbers"
PV = "0.3.1"
PR = "2.el10_1"
PACKAGES = " \
 rust-line-numbers+default-devel \
 rust-line-numbers-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-line-numbers-0.3.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8795169f2bf04751e3644f1ba53a69fcfb19254784afe17f959573d69f4fa277"

URI_x86_64_v2_rust-line-numbers+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-line-numbers+default-devel-0.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-line-numbers+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-line-numbers+default-devel}"
SRC_URI[x86_64_v2_rust-line-numbers+default-devel.sha256sum] = "afc8c79518b81838d853c1f741990921b7a175c310624de89642429f638e1df8"

URI_x86_64_v2_rust-line-numbers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-line-numbers-devel-0.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-line-numbers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-line-numbers-devel}"
SRC_URI[x86_64_v2_rust-line-numbers-devel.sha256sum] = "169f2bcdc6a49f74d7df2a7563a1abf0cd85dee81263cb70d837e6f4b7d83a4d"

URI_aarch64_rust-line-numbers+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-line-numbers+default-devel-0.3.1-2.el10_1.noarch.rpm;name=aarch64_rust-line-numbers+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-line-numbers+default-devel}"
SRC_URI[aarch64_rust-line-numbers+default-devel.sha256sum] = "a94ca82f5da6436970019f87d693aedbf01f53d0716ac26083806aefe1a5c855"

URI_aarch64_rust-line-numbers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-line-numbers-devel-0.3.1-2.el10_1.noarch.rpm;name=aarch64_rust-line-numbers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-line-numbers-devel}"
SRC_URI[aarch64_rust-line-numbers-devel.sha256sum] = "39a8966a2cd6e7dbf1e21ce6a4a697e199ee795c14efc8029ea3faf0c8d6b53e"

RDEPENDS:rust-line-numbers+default-devel = " \
 cargo \
 rust-line-numbers-devel \
 "
RDEPENDS:rust-line-numbers-devel = " \
 cargo \
 rust \
 "
