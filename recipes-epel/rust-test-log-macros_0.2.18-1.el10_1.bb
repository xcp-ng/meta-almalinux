# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-test-log-macros"
PV = "0.2.18"
PR = "1.el10_1"
PACKAGES = " \
 rust-test-log-macros+default-devel \
 rust-test-log-macros+log-devel \
 rust-test-log-macros+trace-devel \
 rust-test-log-macros+unstable-devel \
 rust-test-log-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-test-log-macros-0.2.18-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "602e728e5acbcb5c7764fa29df34198fc823562d6cb239fbe3474facd4965f6d"

URI_x86_64_v2_rust-test-log-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros+default-devel-0.2.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros+default-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros+default-devel.sha256sum] = "3fd7cedd5c876dce1997dc4e750598bf8d1dbeeb618044c50f692bb235f42158"

URI_x86_64_v2_rust-test-log-macros+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros+log-devel-0.2.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros+log-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros+log-devel.sha256sum] = "3fc02311eb0dd678ce93bedf3f755bf8cb9aa20f47b9653dfa9717e3f0bf245c"

URI_x86_64_v2_rust-test-log-macros+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros+trace-devel-0.2.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros+trace-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros+trace-devel.sha256sum] = "8f5cfefbf083bf10ace25aa13fbf83a0d97a48b03e9cc23c812d64b514cebfae"

URI_x86_64_v2_rust-test-log-macros+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros+unstable-devel-0.2.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros+unstable-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros+unstable-devel.sha256sum] = "0f749780ff4706f330dd2284ba5a4ffe8a262567d68214f6c53b99933e2e5534"

URI_x86_64_v2_rust-test-log-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros-devel-0.2.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros-devel.sha256sum] = "0f2abdfd5dbeb7d0680e5867f7fc3557476178aa6b187ab9027319fae24aefd7"

URI_aarch64_rust-test-log-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros+default-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-test-log-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros+default-devel}"
SRC_URI[aarch64_rust-test-log-macros+default-devel.sha256sum] = "3b29710ec26853471f0059fc8d8fd5c4f91889b4652e305d9b76770e88766b68"

URI_aarch64_rust-test-log-macros+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros+log-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-test-log-macros+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros+log-devel}"
SRC_URI[aarch64_rust-test-log-macros+log-devel.sha256sum] = "3ffc3a5e1cede05b185b110e033ac4f44c6542990e804671794c466ec8c74a71"

URI_aarch64_rust-test-log-macros+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros+trace-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-test-log-macros+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros+trace-devel}"
SRC_URI[aarch64_rust-test-log-macros+trace-devel.sha256sum] = "e31482d834a44f7da65b484d2e9963849edc71368ddc1d1844c2a9525d5714cb"

URI_aarch64_rust-test-log-macros+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros+unstable-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-test-log-macros+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros+unstable-devel}"
SRC_URI[aarch64_rust-test-log-macros+unstable-devel.sha256sum] = "25b6776fa7901c0c2b3551b4cf5f456cd8b31a1361ed812ff86a4a00ecb3554e"

URI_aarch64_rust-test-log-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-test-log-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros-devel}"
SRC_URI[aarch64_rust-test-log-macros-devel.sha256sum] = "5921460afe80af289c27797bb700c02486ec18ec39a2d5563bbca463809d94c1"

RDEPENDS:rust-test-log-macros+default-devel = " \
 cargo \
 rust-test-log-macros-devel \
 "
RDEPENDS:rust-test-log-macros+log-devel = " \
 cargo \
 rust-test-log-macros-devel \
 "
RDEPENDS:rust-test-log-macros+trace-devel = " \
 cargo \
 rust-test-log-macros-devel \
 "
RDEPENDS:rust-test-log-macros+unstable-devel = " \
 cargo \
 rust-test-log-macros-devel \
 "
RDEPENDS:rust-test-log-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
