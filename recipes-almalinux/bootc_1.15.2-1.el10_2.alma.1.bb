# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bootc"
PV = "1.15.2"
PR = "1.el10_2.alma.1"
PACKAGES = " \
 bootc \
 system-reinstall-bootc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bootc-1.15.2-1.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca4c03ace48a6af5995a34554d1c6b004a50e95399acae088473fa5a1c7f3ba0"

URI_x86_64_v2_bootc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bootc-1.15.2-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_bootc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bootc}"
SRC_URI[x86_64_v2_bootc.sha256sum] = "6fa68932c18afe1feb77098782edc94a90b203b7ff7f4526d8ad6353ec91f962"

URI_x86_64_v2_system-reinstall-bootc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/system-reinstall-bootc-1.15.2-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_system-reinstall-bootc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_system-reinstall-bootc}"
SRC_URI[x86_64_v2_system-reinstall-bootc.sha256sum] = "53f8126a4ec1736b6d8efd0d5b3e6fd9891efd67b42700b96847fa0ee46a05aa"

URI_aarch64_bootc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bootc-1.15.2-1.el10_2.alma.1.aarch64.rpm;name=aarch64_bootc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bootc}"
SRC_URI[aarch64_bootc.sha256sum] = "ee96eaadf2d055c3ae06bf7466d8f35dd0bd3db39645a0d3d9b8ab104c003409"

URI_aarch64_system-reinstall-bootc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/system-reinstall-bootc-1.15.2-1.el10_2.alma.1.aarch64.rpm;name=aarch64_system-reinstall-bootc;unpack=0"
SRC_URI:append = " ${URI_aarch64_system-reinstall-bootc}"
SRC_URI[aarch64_system-reinstall-bootc.sha256sum] = "11ac113434214cfde0b29ffd087271b0f70d322c9f117ae62b6f625f5d5371a6"

RDEPENDS:bootc = " \
 bash \
 composefs \
 glib2 \
 glibc \
 libgcc \
 libzstd \
 openssl-libs \
 ostree \
 ostree-libs \
 podman \
 skopeo \
 util-linux-core \
 virtual//usr/bin/chcon \
 zlib-ng-compat \
 "
RDEPENDS:system-reinstall-bootc = " \
 bash \
 glibc \
 libgcc \
 "
