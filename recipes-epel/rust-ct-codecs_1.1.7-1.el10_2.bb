# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ct-codecs"
PV = "1.1.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-ct-codecs+default-devel \
 rust-ct-codecs+std-devel \
 rust-ct-codecs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ct-codecs-1.1.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "188a664f75b83ae35293672ce2f93eebb4e582c93212fd7ecffd4736f744403c"

URI_x86_64_v2_rust-ct-codecs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs+default-devel-1.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ct-codecs+default-devel}"
SRC_URI[x86_64_v2_rust-ct-codecs+default-devel.sha256sum] = "faf04e7b60f58a96261f52bdcee5ea5c304f94745a6d92629c391ca3b0a4869c"

URI_x86_64_v2_rust-ct-codecs+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs+std-devel-1.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ct-codecs+std-devel}"
SRC_URI[x86_64_v2_rust-ct-codecs+std-devel.sha256sum] = "dbed5b8047a1d0e4f1b749098b3eee56ab25bec16a7a37f51e14cf8cad158afd"

URI_x86_64_v2_rust-ct-codecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs-devel-1.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ct-codecs-devel}"
SRC_URI[x86_64_v2_rust-ct-codecs-devel.sha256sum] = "2852407485e99e23da17965ef4074035d4684bd3aa70759a2eddef83030f6e09"

URI_aarch64_rust-ct-codecs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs+default-devel-1.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-ct-codecs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ct-codecs+default-devel}"
SRC_URI[aarch64_rust-ct-codecs+default-devel.sha256sum] = "85d5a318580355cdd8c41114d6cb42637c0683390f53b80ec1c8cfbf635630e7"

URI_aarch64_rust-ct-codecs+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs+std-devel-1.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-ct-codecs+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ct-codecs+std-devel}"
SRC_URI[aarch64_rust-ct-codecs+std-devel.sha256sum] = "d303968a81981267e9ebabccb04a47b1e112ae38fa484dcd7ca77d3d6f1eae06"

URI_aarch64_rust-ct-codecs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs-devel-1.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ct-codecs-devel}"
SRC_URI[aarch64_rust-ct-codecs-devel.sha256sum] = "0f65af6f2d96dfe53d555d4c6d3ee8aa7a15723411c1733c7f1c6038324a9659"

RDEPENDS:rust-ct-codecs+default-devel = " \
 cargo \
 rust-ct-codecs+std-devel \
 rust-ct-codecs-devel \
 "
RDEPENDS:rust-ct-codecs+std-devel = " \
 cargo \
 rust-ct-codecs-devel \
 "
RDEPENDS:rust-ct-codecs-devel = " \
 cargo \
 "
