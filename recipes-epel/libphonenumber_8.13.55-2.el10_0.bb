# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libphonenumber"
PV = "8.13.55"
PR = "2.el10_0"
PACKAGES = " \
 libphonenumber \
 libphonenumber-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libphonenumber-8.13.55-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63e1f5bbbcb542b719236d545863d040737d480364696be39d908fb748525456"

URI_x86_64_v2_libphonenumber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libphonenumber-8.13.55-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libphonenumber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libphonenumber}"
SRC_URI[x86_64_v2_libphonenumber.sha256sum] = "7bf50aaa4d87a2044f9dee4c0a0f9730db177c8fedaa0448fcc2f63ad9b61c8b"

URI_x86_64_v2_libphonenumber-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libphonenumber-devel-8.13.55-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libphonenumber-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libphonenumber-devel}"
SRC_URI[x86_64_v2_libphonenumber-devel.sha256sum] = "d4592432b70719298021a242f797616554845de40383f5fd03c22b8c4a5d08d4"

URI_aarch64_libphonenumber = "${EPEL_MIRROR}/aarch64/Packages/l/libphonenumber-8.13.55-2.el10_0.aarch64.rpm;name=aarch64_libphonenumber;unpack=0"
SRC_URI:append = " ${URI_aarch64_libphonenumber}"
SRC_URI[aarch64_libphonenumber.sha256sum] = "75b14b5e6d503571e3c33f0c7750a25a88308f485e644334768e98afdf16446e"

URI_aarch64_libphonenumber-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libphonenumber-devel-8.13.55-2.el10_0.aarch64.rpm;name=aarch64_libphonenumber-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libphonenumber-devel}"
SRC_URI[aarch64_libphonenumber-devel.sha256sum] = "068c66e755a6e4e6a842fd260303c8824a1cd89aceaf3f2eddbc94324e29674f"

RDEPENDS:libphonenumber = " \
 abseil-cpp \
 boost-thread \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 protobuf \
 "
RDEPENDS:libphonenumber-devel = " \
 abseil-cpp-devel \
 cmake-filesystem \
 libphonenumber \
 "
