# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak-kcm"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 flatpak-kcm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/flatpak-kcm-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8985fd0bed38b32bb88307a204b3faf5e615554ca3693cfb66bebec7d45c5901"

URI_x86_64_v2_flatpak-kcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flatpak-kcm-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flatpak-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-kcm}"
SRC_URI[x86_64_v2_flatpak-kcm.sha256sum] = "4450f4c56cb66fed4ef38559779b40e783e6ca671d14f198a7092770226d08c2"

URI_aarch64_flatpak-kcm = "${EPEL_MIRROR}/aarch64/Packages/f/flatpak-kcm-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_flatpak-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-kcm}"
SRC_URI[aarch64_flatpak-kcm.sha256sum] = "88e0a57ed88d0809c61163d4077e3bfa7922688c2a7b4b722d9a32a385012911"

RDEPENDS:flatpak-kcm = " \
 flatpak-libs \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
