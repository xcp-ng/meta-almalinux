# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "helix"
PV = "25.07.1"
PR = "3.el10_1"
PACKAGES = " \
 helix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/helix-25.07.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b334f83d38168b97b1d5ca35718a646ea5f26e035419b0a3dc86967f70617903"

URI_x86_64_v2_helix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/helix-25.07.1-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_helix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_helix}"
SRC_URI[x86_64_v2_helix.sha256sum] = "4d7f86f4bb9b91ddc0b3765d66bf3c2fff640d74e4e8c6394b9c13083e3ec874"

URI_aarch64_helix = "${EPEL_MIRROR}/aarch64/Packages/h/helix-25.07.1-3.el10_1.aarch64.rpm;name=aarch64_helix;unpack=0"
SRC_URI:append = " ${URI_aarch64_helix}"
SRC_URI[aarch64_helix.sha256sum] = "bf643eef5219fcc17449a58b0507a50a6270634db6aa4fd047d0df808a80531b"

RDEPENDS:helix = " \
 gcc-c++ \
 git-core \
 glibc \
 libgcc \
 libstdc++ \
 "
