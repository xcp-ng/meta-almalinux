# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit"
PV = "364"
PR = "1.el10"
PACKAGES = " \
 cockpit \
 cockpit-bridge \
 cockpit-doc \
 cockpit-packagekit \
 cockpit-storaged \
 cockpit-system \
 cockpit-ws \
 cockpit-ws-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cockpit-364-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "021f0aab9f7fbd8cdbd28ba3f4094bd91300c92d37fb4de273de384bdc4054a2"

URI_x86_64_v2_cockpit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-364-1.el10.x86_64_v2.rpm;name=x86_64_v2_cockpit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit}"
SRC_URI[x86_64_v2_cockpit.sha256sum] = "ad263ebc86a35d6833744258e1cd79c7281c1e2bd3a8fa430e16a10eeda08c61"

URI_x86_64_v2_cockpit-bridge = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-bridge-364-1.el10.noarch.rpm;name=x86_64_v2_cockpit-bridge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-bridge}"
SRC_URI[x86_64_v2_cockpit-bridge.sha256sum] = "d1b86dc1548c1c9d320c859519bd39759411986636e6444a7fda0dda6adcfbb4"

URI_x86_64_v2_cockpit-doc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-doc-364-1.el10.noarch.rpm;name=x86_64_v2_cockpit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-doc}"
SRC_URI[x86_64_v2_cockpit-doc.sha256sum] = "5130b7d2c0371af450688ed1570cb3c152fe9fb178a47250f84f023a1945b3a9"

URI_x86_64_v2_cockpit-packagekit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-packagekit-364-1.el10.noarch.rpm;name=x86_64_v2_cockpit-packagekit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-packagekit}"
SRC_URI[x86_64_v2_cockpit-packagekit.sha256sum] = "4e86c750016c45f4250cdefdefa96d8e70bee3e9a5c5ec51f2b9cafe21cb94ca"

URI_x86_64_v2_cockpit-storaged = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-storaged-364-1.el10.noarch.rpm;name=x86_64_v2_cockpit-storaged;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-storaged}"
SRC_URI[x86_64_v2_cockpit-storaged.sha256sum] = "ebd5d7db8aecf03da563c34e583ca32e4515a9124994c1f4483b39bd41058a83"

URI_x86_64_v2_cockpit-system = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-system-364-1.el10.noarch.rpm;name=x86_64_v2_cockpit-system;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-system}"
SRC_URI[x86_64_v2_cockpit-system.sha256sum] = "bda0f735a09de79e1de576b0026e9b43664f0e9240c9e33b697f9718b59cb02e"

URI_x86_64_v2_cockpit-ws = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-ws-364-1.el10.x86_64_v2.rpm;name=x86_64_v2_cockpit-ws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-ws}"
SRC_URI[x86_64_v2_cockpit-ws.sha256sum] = "f8064db24d0ea166ff0021b6c40ff2f0b7b5b650c2291cb842e547323bbc259e"

URI_x86_64_v2_cockpit-ws-selinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-ws-selinux-364-1.el10.x86_64_v2.rpm;name=x86_64_v2_cockpit-ws-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-ws-selinux}"
SRC_URI[x86_64_v2_cockpit-ws-selinux.sha256sum] = "4836aa33d60527879fcf240a55cf44f198cdd9ec99be17356492cc3bdce7ecc8"

URI_aarch64_cockpit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-364-1.el10.aarch64.rpm;name=aarch64_cockpit;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit}"
SRC_URI[aarch64_cockpit.sha256sum] = "b4c1a993725d07d99cc24af3ed3d8330962a1cdb6328d771159b76b7072ebfe8"

URI_aarch64_cockpit-bridge = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-bridge-364-1.el10.noarch.rpm;name=aarch64_cockpit-bridge;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-bridge}"
SRC_URI[aarch64_cockpit-bridge.sha256sum] = "d1b86dc1548c1c9d320c859519bd39759411986636e6444a7fda0dda6adcfbb4"

URI_aarch64_cockpit-doc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-doc-364-1.el10.noarch.rpm;name=aarch64_cockpit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-doc}"
SRC_URI[aarch64_cockpit-doc.sha256sum] = "5130b7d2c0371af450688ed1570cb3c152fe9fb178a47250f84f023a1945b3a9"

URI_aarch64_cockpit-packagekit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-packagekit-364-1.el10.noarch.rpm;name=aarch64_cockpit-packagekit;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-packagekit}"
SRC_URI[aarch64_cockpit-packagekit.sha256sum] = "4e86c750016c45f4250cdefdefa96d8e70bee3e9a5c5ec51f2b9cafe21cb94ca"

URI_aarch64_cockpit-storaged = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-storaged-364-1.el10.noarch.rpm;name=aarch64_cockpit-storaged;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-storaged}"
SRC_URI[aarch64_cockpit-storaged.sha256sum] = "ebd5d7db8aecf03da563c34e583ca32e4515a9124994c1f4483b39bd41058a83"

URI_aarch64_cockpit-system = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-system-364-1.el10.noarch.rpm;name=aarch64_cockpit-system;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-system}"
SRC_URI[aarch64_cockpit-system.sha256sum] = "bda0f735a09de79e1de576b0026e9b43664f0e9240c9e33b697f9718b59cb02e"

URI_aarch64_cockpit-ws = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-ws-364-1.el10.aarch64.rpm;name=aarch64_cockpit-ws;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-ws}"
SRC_URI[aarch64_cockpit-ws.sha256sum] = "23adf1a4dddb7135544bc0ea13bf87e3d7f8b174bead3c006b8b20e0bbb91dc1"

URI_aarch64_cockpit-ws-selinux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-ws-selinux-364-1.el10.aarch64.rpm;name=aarch64_cockpit-ws-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-ws-selinux}"
SRC_URI[aarch64_cockpit-ws-selinux.sha256sum] = "f7a4bebe40d1f4c40112b0b822d4179835f63039b5187a8f02b7ae96d2ff15a2"

RDEPENDS:cockpit = " \
 cockpit-bridge \
 cockpit-system \
 cockpit-ws \
 "
RDEPENDS:cockpit-bridge = " \
 python3 \
 "
RDEPENDS:cockpit-doc = " \
 "
RDEPENDS:cockpit-packagekit = " \
 PackageKit \
 cockpit-bridge \
 polkit \
 "
RDEPENDS:cockpit-storaged = " \
 bash \
 cockpit-system \
 python3 \
 python3-dbus \
 udisks2 \
 "
RDEPENDS:cockpit-system = " \
 NetworkManager \
 cockpit-bridge \
 grep \
 libpwquality \
 shadow-utils \
 sos \
 sudo \
 virtual//usr/bin/date \
 "
RDEPENDS:cockpit-ws = " \
 bash \
 cockpit-ws-selinux \
 glib2 \
 glibc \
 gnutls \
 json-glib \
 krb5-libs \
 libgcc \
 openssl \
 pam-libs \
 systemd-libs \
 "
RDEPENDS:cockpit-ws-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 selinux-policy-targeted \
 "
