# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libavc1394"
PV = "0.5.4"
PR = "24.el10_0"
PACKAGES = " \
 libavc1394 \
 libavc1394-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libavc1394-0.5.4-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d07315fb16c8daf212736c27bf69d775a451e2a5d7c664cd37b811bd3ea6ab27"

URI_x86_64_v2_libavc1394 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavc1394-0.5.4-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavc1394;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavc1394}"
SRC_URI[x86_64_v2_libavc1394.sha256sum] = "64d9f668bb695bdcd96fc8d8e4cb4b21e8cebb5d0459ac0173a2c87d352aa071"

URI_x86_64_v2_libavc1394-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavc1394-devel-0.5.4-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavc1394-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavc1394-devel}"
SRC_URI[x86_64_v2_libavc1394-devel.sha256sum] = "24ce922f38350386313cb6de3291bdf5876a148ae01f9e726dae51c7238d1b95"

URI_aarch64_libavc1394 = "${EPEL_MIRROR}/aarch64/Packages/l/libavc1394-0.5.4-24.el10_0.aarch64.rpm;name=aarch64_libavc1394;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavc1394}"
SRC_URI[aarch64_libavc1394.sha256sum] = "60c3f1205724e06e29a04c60396a2f42f0e90c74d8424d4d378751cd69784fe0"

URI_aarch64_libavc1394-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libavc1394-devel-0.5.4-24.el10_0.aarch64.rpm;name=aarch64_libavc1394-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavc1394-devel}"
SRC_URI[aarch64_libavc1394-devel.sha256sum] = "4378dbe4966875e0b0d1c415d9ebc7ab2515423b57cacc05251a537227cdbfe1"

RDEPENDS:libavc1394 = " \
 glibc \
 libraw1394 \
 "
RDEPENDS:libavc1394-devel = " \
 libavc1394 \
 libraw1394-devel \
 pkgconf-pkg-config \
 "
