# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rgb"
PV = "0.8.53"
PR = "1.el10_3"
PACKAGES = " \
 rust-rgb+argb-devel \
 rust-rgb+as-bytes-devel \
 rust-rgb+bytemuck-devel \
 rust-rgb+checked_fns-devel \
 rust-rgb+default-devel \
 rust-rgb+grb-devel \
 rust-rgb+serde-devel \
 rust-rgb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rgb-0.8.53-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f11f6206f9b39ef2a1df42c7b46e3c41d9a33de0bafb9e2621420e9afdfab045"

URI_x86_64_v2_rust-rgb+argb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+argb-devel-0.8.53-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+argb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+argb-devel}"
SRC_URI[x86_64_v2_rust-rgb+argb-devel.sha256sum] = "6fe23bddbbd33db8aac0b82d574f44bb1676a69919342373966f07cfda739bfe"

URI_x86_64_v2_rust-rgb+as-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+as-bytes-devel-0.8.53-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+as-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+as-bytes-devel}"
SRC_URI[x86_64_v2_rust-rgb+as-bytes-devel.sha256sum] = "69f0eb4ea4ac32737dfd81e3a79b1e2738b0cbcb777d59bc44b76c053082afb7"

URI_x86_64_v2_rust-rgb+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+bytemuck-devel-0.8.53-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-rgb+bytemuck-devel.sha256sum] = "8d47221820c27a887110f6aa7e5b625a6f48b21f0baeda9ce801001bd80d6055"

URI_x86_64_v2_rust-rgb+checked_fns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+checked_fns-devel-0.8.53-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+checked_fns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+checked_fns-devel}"
SRC_URI[x86_64_v2_rust-rgb+checked_fns-devel.sha256sum] = "7e52d84c4a290cdd87496dfc3a9453727a490ef4202f7d6e132153ad642c32e5"

URI_x86_64_v2_rust-rgb+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+default-devel-0.8.53-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+default-devel}"
SRC_URI[x86_64_v2_rust-rgb+default-devel.sha256sum] = "41e87a3fe603552dc5a082ad832e75e3a39d810c568997c167d4a80083d67d71"

URI_x86_64_v2_rust-rgb+grb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+grb-devel-0.8.53-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+grb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+grb-devel}"
SRC_URI[x86_64_v2_rust-rgb+grb-devel.sha256sum] = "3041676c5e0832d45fa72185d2a129e6be57345eeb5310b8521a6f5b1701f473"

URI_x86_64_v2_rust-rgb+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+serde-devel-0.8.53-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+serde-devel}"
SRC_URI[x86_64_v2_rust-rgb+serde-devel.sha256sum] = "31d197e0d5bf06ea98d73c1beb23d06ff54d2e4ec34e461c024cdd88cb77341c"

URI_x86_64_v2_rust-rgb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb-devel-0.8.53-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb-devel}"
SRC_URI[x86_64_v2_rust-rgb-devel.sha256sum] = "785f9bd254aaef5fc34078587cbe2b5b0d742688349703dccd79b355f4ed4a0b"

URI_aarch64_rust-rgb+argb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+argb-devel-0.8.53-1.el10_3.noarch.rpm;name=aarch64_rust-rgb+argb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+argb-devel}"
SRC_URI[aarch64_rust-rgb+argb-devel.sha256sum] = "11b26fd0638c4a23f5caa4c067f86b34fdff534cd8eb46f9a7ffcce4fea05ff1"

URI_aarch64_rust-rgb+as-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+as-bytes-devel-0.8.53-1.el10_3.noarch.rpm;name=aarch64_rust-rgb+as-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+as-bytes-devel}"
SRC_URI[aarch64_rust-rgb+as-bytes-devel.sha256sum] = "4499623df146004a816558cacab2ee92543d934e4c33abe1fd0000094ebdc24c"

URI_aarch64_rust-rgb+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+bytemuck-devel-0.8.53-1.el10_3.noarch.rpm;name=aarch64_rust-rgb+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+bytemuck-devel}"
SRC_URI[aarch64_rust-rgb+bytemuck-devel.sha256sum] = "139618ff6527c02e331d4f1073efe99639fbdb901bc01c0795900568da91039f"

URI_aarch64_rust-rgb+checked_fns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+checked_fns-devel-0.8.53-1.el10_3.noarch.rpm;name=aarch64_rust-rgb+checked_fns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+checked_fns-devel}"
SRC_URI[aarch64_rust-rgb+checked_fns-devel.sha256sum] = "6d4a0ba36d5688b4fdad568375de4f0ad71ab7cda9e063c97a994fd9590a65c0"

URI_aarch64_rust-rgb+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+default-devel-0.8.53-1.el10_3.noarch.rpm;name=aarch64_rust-rgb+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+default-devel}"
SRC_URI[aarch64_rust-rgb+default-devel.sha256sum] = "0bf8a4016f2343cc1c85f6f5ba8ff8bad33718f718a84ecf4dbe4e3616b11dab"

URI_aarch64_rust-rgb+grb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+grb-devel-0.8.53-1.el10_3.noarch.rpm;name=aarch64_rust-rgb+grb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+grb-devel}"
SRC_URI[aarch64_rust-rgb+grb-devel.sha256sum] = "32f78a7e21f7642c65c8ff64651a5c9e0b7d8ce9d0bc600edcef37a2cb0d2ef7"

URI_aarch64_rust-rgb+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+serde-devel-0.8.53-1.el10_3.noarch.rpm;name=aarch64_rust-rgb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+serde-devel}"
SRC_URI[aarch64_rust-rgb+serde-devel.sha256sum] = "208e750cc860298faa1f318646209d955d784f216ca4c48c2544b77701a43c5c"

URI_aarch64_rust-rgb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb-devel-0.8.53-1.el10_3.noarch.rpm;name=aarch64_rust-rgb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb-devel}"
SRC_URI[aarch64_rust-rgb-devel.sha256sum] = "2b2d0fd37a2e047ebf2610d2ac164d632880268480484fc573b0bca1e40ef8d1"

RDEPENDS:rust-rgb+argb-devel = " \
 cargo \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+as-bytes-devel = " \
 cargo \
 rust-rgb+bytemuck-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+checked_fns-devel = " \
 cargo \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+default-devel = " \
 cargo \
 rust-rgb+argb-devel \
 rust-rgb+as-bytes-devel \
 rust-rgb+grb-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+grb-devel = " \
 cargo \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+serde-devel = " \
 cargo \
 rust-rgb-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rgb-devel = " \
 cargo \
 rust \
 "
