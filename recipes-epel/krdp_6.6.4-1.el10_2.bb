# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krdp"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 krdp \
 krdp-devel \
 krdp-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krdp-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02edb41005b2e2814b25b39b601c3c2e09b90be35d5a99800068835b3ccbb544"

URI_x86_64_v2_krdp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdp}"
SRC_URI[x86_64_v2_krdp.sha256sum] = "7a3d9da3c84613ac0cea6f83a00e662df2d6d59395795986a4b3fd975e85e6f2"

URI_x86_64_v2_krdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdp-devel}"
SRC_URI[x86_64_v2_krdp-devel.sha256sum] = "1ee768539f6e4e1ddb8ce3bdda51f7e6352b6b387bd01222baa610f1a6f87f8e"

URI_x86_64_v2_krdp-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-libs-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdp-libs}"
SRC_URI[x86_64_v2_krdp-libs.sha256sum] = "edc41c020a1b20cca6739a491cf8bc05c2b13b557f8aaf1a0921d990801e2c61"

URI_aarch64_krdp = "${EPEL_MIRROR}/aarch64/Packages/k/krdp-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_krdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdp}"
SRC_URI[aarch64_krdp.sha256sum] = "e1dad6f8a9c760ed4dcf69f7af835622229325eb93b8459fde9b1a9e69da3941"

URI_aarch64_krdp-devel = "${EPEL_MIRROR}/aarch64/Packages/k/krdp-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_krdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdp-devel}"
SRC_URI[aarch64_krdp-devel.sha256sum] = "2332cea2b1be670697fd2b09c67cacd63864582a6e31c524986eb7abec09341b"

URI_aarch64_krdp-libs = "${EPEL_MIRROR}/aarch64/Packages/k/krdp-libs-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_krdp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdp-libs}"
SRC_URI[aarch64_krdp-libs.sha256sum] = "7f0667148f1e46380c36434da864a74649f002cce6d898d29b4ddf4af2f15c14"

RDEPENDS:krdp = " \
 bash \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kstatusnotifieritem \
 kpipewire \
 krdp-libs \
 libstdc++ \
 openssl \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:krdp-devel = " \
 cmake-filesystem \
 krdp-libs \
 "
RDEPENDS:krdp-libs = " \
 freerdp \
 freerdp-libs \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kpipewire \
 libstdc++ \
 libwayland-client \
 libwinpr \
 libxkbcommon \
 pam-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
