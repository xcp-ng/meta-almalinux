# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dwarves"
PV = "1.30"
PR = "2.el10"
PACKAGES = " \
 dwarves \
 libdwarves1 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dwarves-1.30-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d7bceea132ed5af14dd77abf3d34a2398b828a4fc87e4eabfab1d48d129ad121"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dwarves-1.30-2.el10.x86_64_v2.rpm;name=x86_64_v2_dwarves;unpack=0"
SRC_URI[x86_64_v2_dwarves.sha256sum] = "a7e457805d5df6b2fd6041f298a5e82ff4cabbf2f75110cd13ebbff970f60eda"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libdwarves1-1.30-2.el10.x86_64_v2.rpm;name=x86_64_v2_libdwarves1;unpack=0"
SRC_URI[x86_64_v2_libdwarves1.sha256sum] = "38000b08038b25a3de6f7b0ad798a4da99a974ec3f2b50753d61c352f81888ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dwarves-1.30-2.el10.aarch64.rpm;name=aarch64_dwarves;unpack=0"
SRC_URI[aarch64_dwarves.sha256sum] = "edafa31c36235a4dc424de93e0a061227a9073c883ee3c51748283b3db9ec9c8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libdwarves1-1.30-2.el10.aarch64.rpm;name=aarch64_libdwarves1;unpack=0"
SRC_URI[aarch64_libdwarves1.sha256sum] = "17cae555ae93d749b2aa82144ee25f2d5c712a69fac9fe3d9bf00feea669012e"

RDEPENDS:dwarves = " \
 bash \
 elfutils-libelf \
 glibc \
 libdwarves1 \
 python3 \
 "
RDEPENDS:libdwarves1 = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 zlib-ng-compat \
 "
