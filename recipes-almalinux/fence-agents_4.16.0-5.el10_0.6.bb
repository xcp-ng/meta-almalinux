# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fence-agents"
PV = "4.16.0"
PR = "5.el10_0.6"
PACKAGES:x86_64_v2 = " \
 fence-agents-aliyun \
 fence-agents-all \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-aws \
 fence-agents-azure-arm \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-common \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-gce \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibm-powervs \
 fence-agents-ibm-vpc \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-kubevirt \
 fence-agents-lpar \
 fence-agents-mpath \
 fence-agents-openstack \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-virsh \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
 fence-virt \
 fence-virtd \
 fence-virtd-cpg \
 fence-virtd-libvirt \
 fence-virtd-multicast \
 fence-virtd-serial \
 fence-virtd-tcp \
 ha-cloud-support \
"
PACKAGES:aarch64 = " \
 fence-agents-all \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-common \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibm-powervs \
 fence-agents-ibm-vpc \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-kubevirt \
 fence-agents-lpar \
 fence-agents-mpath \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-virsh \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fence-agents-4.16.0-5.el10_0.6.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d892c5e05241c357c285e2ebf07a1d92c9028ef0df28c020e96e707f58e6682c"

URI_x86_64_v2_fence-agents-aliyun = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-aliyun-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-aliyun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-aliyun}"
SRC_URI[x86_64_v2_fence-agents-aliyun.sha256sum] = "e57ecbfaa35e37a9edcbd4fd2e1dcfe2f9d592d6a0850255f6a9d4f546450816"

URI_x86_64_v2_fence-agents-all = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-all-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-all}"
SRC_URI[x86_64_v2_fence-agents-all.sha256sum] = "900fc61fe3439f4d20f1e3d17c32523613c060989f122fe7f54da356c9adf4ad"

URI_x86_64_v2_fence-agents-amt-ws = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-amt-ws-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-amt-ws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-amt-ws}"
SRC_URI[x86_64_v2_fence-agents-amt-ws.sha256sum] = "8b17ce3bc2e98117b58ea108077d6370332b9d261e1714fd6d79e8a91e25d341"

URI_x86_64_v2_fence-agents-apc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-apc-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-apc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-apc}"
SRC_URI[x86_64_v2_fence-agents-apc.sha256sum] = "df300f49477148f9b2302fa90768be35046653c5dafc60986daaf914249b53f5"

URI_x86_64_v2_fence-agents-apc-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-apc-snmp-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-apc-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-apc-snmp}"
SRC_URI[x86_64_v2_fence-agents-apc-snmp.sha256sum] = "155b6b66e739fb3e2557f36bb3572f95a2ef13026e11420261e52f9cac319792"

URI_x86_64_v2_fence-agents-aws = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-aws-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-aws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-aws}"
SRC_URI[x86_64_v2_fence-agents-aws.sha256sum] = "560708969c369049a9dbada75fa3f1f9258a331592ebefa893d60affd7996044"

URI_x86_64_v2_fence-agents-azure-arm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-azure-arm-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-azure-arm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-azure-arm}"
SRC_URI[x86_64_v2_fence-agents-azure-arm.sha256sum] = "a13a287f661f296429e56841b3219542cb3c447c9e342547cee7e232d8fe1f00"

URI_x86_64_v2_fence-agents-bladecenter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-bladecenter-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-bladecenter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-bladecenter}"
SRC_URI[x86_64_v2_fence-agents-bladecenter.sha256sum] = "adb50dea8b012b1bc66c2033d3b2c839c6b744d8ced06bb34f55d67b6cd83d56"

URI_x86_64_v2_fence-agents-brocade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-brocade-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-brocade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-brocade}"
SRC_URI[x86_64_v2_fence-agents-brocade.sha256sum] = "0789c44001af0eccf7af324d021bf880274c3b3b1e72e3a80a841a5815bbf213"

URI_x86_64_v2_fence-agents-cisco-mds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-cisco-mds-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-cisco-mds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-cisco-mds}"
SRC_URI[x86_64_v2_fence-agents-cisco-mds.sha256sum] = "89a6de2b750f03ef5cfb31d007fb77956d6cd5e97ddd72834340059224592cd7"

URI_x86_64_v2_fence-agents-cisco-ucs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-cisco-ucs-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-cisco-ucs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-cisco-ucs}"
SRC_URI[x86_64_v2_fence-agents-cisco-ucs.sha256sum] = "2e496d063e25be5468a2fcc2ede4ecc91b20b7bf6941b733875229995af0b8d0"

URI_x86_64_v2_fence-agents-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-common-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-common}"
SRC_URI[x86_64_v2_fence-agents-common.sha256sum] = "e3a4c50875856ad4844107e07a6910d87830adf45881ef00bc8fb4ae9a905e38"

URI_x86_64_v2_fence-agents-drac5 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-drac5-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-drac5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-drac5}"
SRC_URI[x86_64_v2_fence-agents-drac5.sha256sum] = "fe90ff28f4cabc0fcace43213ebb2707f0cf551cba435237fe9c13b4b2086b4b"

URI_x86_64_v2_fence-agents-eaton-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-eaton-snmp-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-eaton-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-eaton-snmp}"
SRC_URI[x86_64_v2_fence-agents-eaton-snmp.sha256sum] = "989b4b9885130894a854b30b8b290b70fee26223a0bed9207c5b694852f4fc8a"

URI_x86_64_v2_fence-agents-emerson = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-emerson-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-emerson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-emerson}"
SRC_URI[x86_64_v2_fence-agents-emerson.sha256sum] = "3862049f3fdbeaf0278d403272f973d19e3d87ca99413f11abe2e7ef2441635f"

URI_x86_64_v2_fence-agents-eps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-eps-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-eps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-eps}"
SRC_URI[x86_64_v2_fence-agents-eps.sha256sum] = "34962b703bf72e660ea961f067d7d7fda9ddb643edea1e302aa9862bba27c11f"

URI_x86_64_v2_fence-agents-gce = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-gce-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-gce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-gce}"
SRC_URI[x86_64_v2_fence-agents-gce.sha256sum] = "889b27c6f88f3be42a01a1f7d514f8053683fdd6adcd556f06baa262f8dc743a"

URI_x86_64_v2_fence-agents-heuristics-ping = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-heuristics-ping-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-heuristics-ping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-heuristics-ping}"
SRC_URI[x86_64_v2_fence-agents-heuristics-ping.sha256sum] = "7b15425d65569382aa74f7b9b4dcd95b6e2c5e33aebcf6349e05989fcd5b74fe"

URI_x86_64_v2_fence-agents-hpblade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-hpblade-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-hpblade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-hpblade}"
SRC_URI[x86_64_v2_fence-agents-hpblade.sha256sum] = "1ff5f413be6537a202360cb9689f10fb8bfb877bcb795f79517877a6d78bd34b"

URI_x86_64_v2_fence-agents-ibm-powervs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibm-powervs-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-ibm-powervs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ibm-powervs}"
SRC_URI[x86_64_v2_fence-agents-ibm-powervs.sha256sum] = "cb0b065f64a4afb03ca04f3a314138ee1f1807f97d980fa2340d18fe3dfde79b"

URI_x86_64_v2_fence-agents-ibm-vpc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibm-vpc-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-ibm-vpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ibm-vpc}"
SRC_URI[x86_64_v2_fence-agents-ibm-vpc.sha256sum] = "e36e636b12612fabbe8f3e34566ab4f9829e4e4059c28a6afb82659b03e59f24"

URI_x86_64_v2_fence-agents-ibmblade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibmblade-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-ibmblade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ibmblade}"
SRC_URI[x86_64_v2_fence-agents-ibmblade.sha256sum] = "1e3fce020311a0d91a64444ade2afcb5078a0100cad31345f65475073b13ea8d"

URI_x86_64_v2_fence-agents-ifmib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ifmib-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-ifmib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ifmib}"
SRC_URI[x86_64_v2_fence-agents-ifmib.sha256sum] = "2b83a14d631b52a2c1e91ddd28067c189c05128e373126f6bf3a3fd60b407352"

URI_x86_64_v2_fence-agents-ilo-moonshot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-moonshot-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-ilo-moonshot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo-moonshot}"
SRC_URI[x86_64_v2_fence-agents-ilo-moonshot.sha256sum] = "45c97947a3d73c600f6f8bde05ea132b89d6e9ee879962f4f17a34c28834b986"

URI_x86_64_v2_fence-agents-ilo-mp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-mp-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-ilo-mp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo-mp}"
SRC_URI[x86_64_v2_fence-agents-ilo-mp.sha256sum] = "ce44a7cd7b22f4732197df333e1be8f77319d976d887ac3a9ffdf76c695b3130"

URI_x86_64_v2_fence-agents-ilo-ssh = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-ssh-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-ilo-ssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo-ssh}"
SRC_URI[x86_64_v2_fence-agents-ilo-ssh.sha256sum] = "69a87c30ba85187ef835d24910d71f0ebf688f1b214ca8a6ae577a7332b444f4"

URI_x86_64_v2_fence-agents-ilo2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo2-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-ilo2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo2}"
SRC_URI[x86_64_v2_fence-agents-ilo2.sha256sum] = "dff1e4bc99837b1356ef2d2b2f48009df3f6f0f78de91fa024d14bb3e7f9c5bb"

URI_x86_64_v2_fence-agents-intelmodular = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-intelmodular-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-intelmodular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-intelmodular}"
SRC_URI[x86_64_v2_fence-agents-intelmodular.sha256sum] = "5d61a866da82f72661403c874adc89f543a11ea8fff798b114e013928adc17aa"

URI_x86_64_v2_fence-agents-ipdu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ipdu-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-ipdu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ipdu}"
SRC_URI[x86_64_v2_fence-agents-ipdu.sha256sum] = "996896a1edf9fcbc3e0db8879d89693ea069451d551de0b795579f113159c375"

URI_x86_64_v2_fence-agents-ipmilan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ipmilan-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-ipmilan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ipmilan}"
SRC_URI[x86_64_v2_fence-agents-ipmilan.sha256sum] = "1cc4dbd47f000eddb6383a4088b99f04209685f6b595b02c638d547c84dcda97"

URI_x86_64_v2_fence-agents-kdump = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-kdump-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-kdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-kdump}"
SRC_URI[x86_64_v2_fence-agents-kdump.sha256sum] = "1f9f2da735e9ebed74b581b219f329958e81188f13d8df7df98ce05bb2ee1184"

URI_x86_64_v2_fence-agents-kubevirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-kubevirt-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-kubevirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-kubevirt}"
SRC_URI[x86_64_v2_fence-agents-kubevirt.sha256sum] = "f19b156c1b216b9cced60ca6e39243d03a32b0643e710c8b3e5347531b2ea045"

URI_x86_64_v2_fence-agents-lpar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-lpar-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-lpar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-lpar}"
SRC_URI[x86_64_v2_fence-agents-lpar.sha256sum] = "e884310de55143ef9ed743cd8b9c7de468b7405d7c9c5f0db1722c477cf88c88"

URI_x86_64_v2_fence-agents-mpath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-mpath-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-mpath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-mpath}"
SRC_URI[x86_64_v2_fence-agents-mpath.sha256sum] = "c01cf6b7080acaa34b4a17ecb1d3b25460abc34ed0255c589da2619693697fcc"

URI_x86_64_v2_fence-agents-openstack = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-openstack-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-openstack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-openstack}"
SRC_URI[x86_64_v2_fence-agents-openstack.sha256sum] = "87e9d49957be3460be5d0c00381f5d95195458060744a1f096df55e95d6a76e8"

URI_x86_64_v2_fence-agents-redfish = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-redfish-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-redfish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-redfish}"
SRC_URI[x86_64_v2_fence-agents-redfish.sha256sum] = "0d94c0287e83845a55b816e29d2a2648b34e16b3afe157ffd9ae46b0fda45942"

URI_x86_64_v2_fence-agents-rhevm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rhevm-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-rhevm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-rhevm}"
SRC_URI[x86_64_v2_fence-agents-rhevm.sha256sum] = "2cdd631b5eb14cf11f5ea9810479e533c4492816a3269c7034efa682eb315a1e"

URI_x86_64_v2_fence-agents-rsa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rsa-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-rsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-rsa}"
SRC_URI[x86_64_v2_fence-agents-rsa.sha256sum] = "6c1f42931a8ba96c8b20d57e52396cafd73f4614fdd0d761c1f59069e730b4f5"

URI_x86_64_v2_fence-agents-rsb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rsb-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-rsb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-rsb}"
SRC_URI[x86_64_v2_fence-agents-rsb.sha256sum] = "ef42c97d34ce9fde65f36e8a3c1cafbe0e50f7c197359a15250111b0ed4c1d7f"

URI_x86_64_v2_fence-agents-sbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-sbd-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-sbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-sbd}"
SRC_URI[x86_64_v2_fence-agents-sbd.sha256sum] = "bc39ffb43156ecacb21d43bed078c70977d017a6a82d7dca83f8676c9f4eab83"

URI_x86_64_v2_fence-agents-scsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-scsi-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-scsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-scsi}"
SRC_URI[x86_64_v2_fence-agents-scsi.sha256sum] = "a68f0d6937ad561ca2d9d50b1e9c2e9b66f9d167e3af0b7854d457f60a4ffe17"

URI_x86_64_v2_fence-agents-virsh = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-virsh-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-virsh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-virsh}"
SRC_URI[x86_64_v2_fence-agents-virsh.sha256sum] = "ee61af979be0e9f0311976833092e826a9c41b6a0add612b9577e84814a27260"

URI_x86_64_v2_fence-agents-vmware-rest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-vmware-rest-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-vmware-rest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-vmware-rest}"
SRC_URI[x86_64_v2_fence-agents-vmware-rest.sha256sum] = "760600dc37120ff1500b11ba89736da8cb1661c22b12ad144e8ed0eb82a9b30a"

URI_x86_64_v2_fence-agents-vmware-soap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-vmware-soap-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-vmware-soap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-vmware-soap}"
SRC_URI[x86_64_v2_fence-agents-vmware-soap.sha256sum] = "5951cd9bb1d2ed97349d888ae6bb50650f7f2291e5dfab51c636c6f1d019d684"

URI_x86_64_v2_fence-agents-wti = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-wti-4.16.0-5.el10_0.6.noarch.rpm;name=x86_64_v2_fence-agents-wti;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-wti}"
SRC_URI[x86_64_v2_fence-agents-wti.sha256sum] = "18098e9611516930493de3146ee9d72d2b45110681d50f8b0e2715b8b1a4053c"

URI_x86_64_v2_fence-virt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virt-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virt}"
SRC_URI[x86_64_v2_fence-virt.sha256sum] = "02e8c2df6cce28da5e423b0672ecaebb01ce63c0d61ce8971741a2913b718cdb"

URI_x86_64_v2_fence-virtd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-virtd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd}"
SRC_URI[x86_64_v2_fence-virtd.sha256sum] = "a42a4f4017dd81a50163aab17f48e50dd48ad2b64a2337079b1fa273bc94679d"

URI_x86_64_v2_fence-virtd-cpg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-cpg-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-cpg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-cpg}"
SRC_URI[x86_64_v2_fence-virtd-cpg.sha256sum] = "ded87457756544ce1cf8d518e4aa905041608961a3ded8bba3cc2da44eba491b"

URI_x86_64_v2_fence-virtd-libvirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-libvirt-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-libvirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-libvirt}"
SRC_URI[x86_64_v2_fence-virtd-libvirt.sha256sum] = "a26ceaeee64fbae9b291c9e64b9a976047a6997717844fede383ac1c8e743767"

URI_x86_64_v2_fence-virtd-multicast = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-multicast-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-multicast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-multicast}"
SRC_URI[x86_64_v2_fence-virtd-multicast.sha256sum] = "93e17e3257c6b6c8948ce299248de200f674af18bba98c6ef8e1f9bb40eabddd"

URI_x86_64_v2_fence-virtd-serial = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-serial-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-serial;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-serial}"
SRC_URI[x86_64_v2_fence-virtd-serial.sha256sum] = "93bb3a4e76dadc21a59b78c626eb65c3156f9aa739c6ab86edde6d48a15c57aa"

URI_x86_64_v2_fence-virtd-tcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-tcp-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-tcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-tcp}"
SRC_URI[x86_64_v2_fence-virtd-tcp.sha256sum] = "9a0dce34b58948265db3bf280b100db09f7566dcf4b9571c0a73b6742c5af3d8"

URI_x86_64_v2_ha-cloud-support = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ha-cloud-support-4.16.0-5.el10_0.6.x86_64_v2.rpm;name=x86_64_v2_ha-cloud-support;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ha-cloud-support}"
SRC_URI[x86_64_v2_ha-cloud-support.sha256sum] = "493b63524b0c9b79fad3d92b98897bc6892068e1a14bc28a776dfcfeceaba062"

URI_aarch64_fence-agents-all = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-all-4.16.0-5.el10_0.6.aarch64.rpm;name=aarch64_fence-agents-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-all}"
SRC_URI[aarch64_fence-agents-all.sha256sum] = "df0682a28fe8d8e10bdd6c56de32181dc6b0e084a765a954a4d51e41417d4567"

URI_aarch64_fence-agents-amt-ws = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-amt-ws-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-amt-ws;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-amt-ws}"
SRC_URI[aarch64_fence-agents-amt-ws.sha256sum] = "8b17ce3bc2e98117b58ea108077d6370332b9d261e1714fd6d79e8a91e25d341"

URI_aarch64_fence-agents-apc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-apc-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-apc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-apc}"
SRC_URI[aarch64_fence-agents-apc.sha256sum] = "df300f49477148f9b2302fa90768be35046653c5dafc60986daaf914249b53f5"

URI_aarch64_fence-agents-apc-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-apc-snmp-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-apc-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-apc-snmp}"
SRC_URI[aarch64_fence-agents-apc-snmp.sha256sum] = "155b6b66e739fb3e2557f36bb3572f95a2ef13026e11420261e52f9cac319792"

URI_aarch64_fence-agents-bladecenter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-bladecenter-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-bladecenter;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-bladecenter}"
SRC_URI[aarch64_fence-agents-bladecenter.sha256sum] = "adb50dea8b012b1bc66c2033d3b2c839c6b744d8ced06bb34f55d67b6cd83d56"

URI_aarch64_fence-agents-brocade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-brocade-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-brocade;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-brocade}"
SRC_URI[aarch64_fence-agents-brocade.sha256sum] = "0789c44001af0eccf7af324d021bf880274c3b3b1e72e3a80a841a5815bbf213"

URI_aarch64_fence-agents-cisco-mds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-cisco-mds-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-cisco-mds;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-cisco-mds}"
SRC_URI[aarch64_fence-agents-cisco-mds.sha256sum] = "89a6de2b750f03ef5cfb31d007fb77956d6cd5e97ddd72834340059224592cd7"

URI_aarch64_fence-agents-cisco-ucs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-cisco-ucs-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-cisco-ucs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-cisco-ucs}"
SRC_URI[aarch64_fence-agents-cisco-ucs.sha256sum] = "2e496d063e25be5468a2fcc2ede4ecc91b20b7bf6941b733875229995af0b8d0"

URI_aarch64_fence-agents-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-common-4.16.0-5.el10_0.6.aarch64.rpm;name=aarch64_fence-agents-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-common}"
SRC_URI[aarch64_fence-agents-common.sha256sum] = "25ecafa9321cffcbec2e59656cd367d94d1be2ba1fe155a317dbabc96f4a703e"

URI_aarch64_fence-agents-drac5 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-drac5-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-drac5;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-drac5}"
SRC_URI[aarch64_fence-agents-drac5.sha256sum] = "fe90ff28f4cabc0fcace43213ebb2707f0cf551cba435237fe9c13b4b2086b4b"

URI_aarch64_fence-agents-eaton-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-eaton-snmp-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-eaton-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-eaton-snmp}"
SRC_URI[aarch64_fence-agents-eaton-snmp.sha256sum] = "989b4b9885130894a854b30b8b290b70fee26223a0bed9207c5b694852f4fc8a"

URI_aarch64_fence-agents-emerson = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-emerson-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-emerson;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-emerson}"
SRC_URI[aarch64_fence-agents-emerson.sha256sum] = "3862049f3fdbeaf0278d403272f973d19e3d87ca99413f11abe2e7ef2441635f"

URI_aarch64_fence-agents-eps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-eps-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-eps;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-eps}"
SRC_URI[aarch64_fence-agents-eps.sha256sum] = "34962b703bf72e660ea961f067d7d7fda9ddb643edea1e302aa9862bba27c11f"

URI_aarch64_fence-agents-heuristics-ping = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-heuristics-ping-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-heuristics-ping;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-heuristics-ping}"
SRC_URI[aarch64_fence-agents-heuristics-ping.sha256sum] = "7b15425d65569382aa74f7b9b4dcd95b6e2c5e33aebcf6349e05989fcd5b74fe"

URI_aarch64_fence-agents-hpblade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-hpblade-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-hpblade;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-hpblade}"
SRC_URI[aarch64_fence-agents-hpblade.sha256sum] = "1ff5f413be6537a202360cb9689f10fb8bfb877bcb795f79517877a6d78bd34b"

URI_aarch64_fence-agents-ibm-powervs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibm-powervs-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-ibm-powervs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ibm-powervs}"
SRC_URI[aarch64_fence-agents-ibm-powervs.sha256sum] = "cb0b065f64a4afb03ca04f3a314138ee1f1807f97d980fa2340d18fe3dfde79b"

URI_aarch64_fence-agents-ibm-vpc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibm-vpc-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-ibm-vpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ibm-vpc}"
SRC_URI[aarch64_fence-agents-ibm-vpc.sha256sum] = "e36e636b12612fabbe8f3e34566ab4f9829e4e4059c28a6afb82659b03e59f24"

URI_aarch64_fence-agents-ibmblade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibmblade-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-ibmblade;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ibmblade}"
SRC_URI[aarch64_fence-agents-ibmblade.sha256sum] = "1e3fce020311a0d91a64444ade2afcb5078a0100cad31345f65475073b13ea8d"

URI_aarch64_fence-agents-ifmib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ifmib-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-ifmib;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ifmib}"
SRC_URI[aarch64_fence-agents-ifmib.sha256sum] = "2b83a14d631b52a2c1e91ddd28067c189c05128e373126f6bf3a3fd60b407352"

URI_aarch64_fence-agents-ilo-moonshot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-moonshot-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-ilo-moonshot;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo-moonshot}"
SRC_URI[aarch64_fence-agents-ilo-moonshot.sha256sum] = "45c97947a3d73c600f6f8bde05ea132b89d6e9ee879962f4f17a34c28834b986"

URI_aarch64_fence-agents-ilo-mp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-mp-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-ilo-mp;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo-mp}"
SRC_URI[aarch64_fence-agents-ilo-mp.sha256sum] = "ce44a7cd7b22f4732197df333e1be8f77319d976d887ac3a9ffdf76c695b3130"

URI_aarch64_fence-agents-ilo-ssh = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-ssh-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-ilo-ssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo-ssh}"
SRC_URI[aarch64_fence-agents-ilo-ssh.sha256sum] = "69a87c30ba85187ef835d24910d71f0ebf688f1b214ca8a6ae577a7332b444f4"

URI_aarch64_fence-agents-ilo2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo2-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-ilo2;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo2}"
SRC_URI[aarch64_fence-agents-ilo2.sha256sum] = "dff1e4bc99837b1356ef2d2b2f48009df3f6f0f78de91fa024d14bb3e7f9c5bb"

URI_aarch64_fence-agents-intelmodular = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-intelmodular-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-intelmodular;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-intelmodular}"
SRC_URI[aarch64_fence-agents-intelmodular.sha256sum] = "5d61a866da82f72661403c874adc89f543a11ea8fff798b114e013928adc17aa"

URI_aarch64_fence-agents-ipdu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ipdu-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-ipdu;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ipdu}"
SRC_URI[aarch64_fence-agents-ipdu.sha256sum] = "996896a1edf9fcbc3e0db8879d89693ea069451d551de0b795579f113159c375"

URI_aarch64_fence-agents-ipmilan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ipmilan-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-ipmilan;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ipmilan}"
SRC_URI[aarch64_fence-agents-ipmilan.sha256sum] = "1cc4dbd47f000eddb6383a4088b99f04209685f6b595b02c638d547c84dcda97"

URI_aarch64_fence-agents-kdump = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-kdump-4.16.0-5.el10_0.6.aarch64.rpm;name=aarch64_fence-agents-kdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-kdump}"
SRC_URI[aarch64_fence-agents-kdump.sha256sum] = "11cd4d9b6c738cd2324034de810fb8995043081c22b55ca3026fce0e46a2116f"

URI_aarch64_fence-agents-kubevirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-kubevirt-4.16.0-5.el10_0.6.aarch64.rpm;name=aarch64_fence-agents-kubevirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-kubevirt}"
SRC_URI[aarch64_fence-agents-kubevirt.sha256sum] = "5af51a540d43c7805cb16a29c3a95ae1e5aa1151c7ae2e12256aee2f88fce7a8"

URI_aarch64_fence-agents-lpar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-lpar-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-lpar;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-lpar}"
SRC_URI[aarch64_fence-agents-lpar.sha256sum] = "e884310de55143ef9ed743cd8b9c7de468b7405d7c9c5f0db1722c477cf88c88"

URI_aarch64_fence-agents-mpath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-mpath-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-mpath;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-mpath}"
SRC_URI[aarch64_fence-agents-mpath.sha256sum] = "c01cf6b7080acaa34b4a17ecb1d3b25460abc34ed0255c589da2619693697fcc"

URI_aarch64_fence-agents-redfish = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-redfish-4.16.0-5.el10_0.6.aarch64.rpm;name=aarch64_fence-agents-redfish;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-redfish}"
SRC_URI[aarch64_fence-agents-redfish.sha256sum] = "879f6f133e6db9f982797f6a4afbcd21e8adda571bc9ce919e59b31cdd130c68"

URI_aarch64_fence-agents-rhevm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rhevm-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-rhevm;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-rhevm}"
SRC_URI[aarch64_fence-agents-rhevm.sha256sum] = "2cdd631b5eb14cf11f5ea9810479e533c4492816a3269c7034efa682eb315a1e"

URI_aarch64_fence-agents-rsa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rsa-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-rsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-rsa}"
SRC_URI[aarch64_fence-agents-rsa.sha256sum] = "6c1f42931a8ba96c8b20d57e52396cafd73f4614fdd0d761c1f59069e730b4f5"

URI_aarch64_fence-agents-rsb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rsb-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-rsb;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-rsb}"
SRC_URI[aarch64_fence-agents-rsb.sha256sum] = "ef42c97d34ce9fde65f36e8a3c1cafbe0e50f7c197359a15250111b0ed4c1d7f"

URI_aarch64_fence-agents-sbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-sbd-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-sbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-sbd}"
SRC_URI[aarch64_fence-agents-sbd.sha256sum] = "bc39ffb43156ecacb21d43bed078c70977d017a6a82d7dca83f8676c9f4eab83"

URI_aarch64_fence-agents-scsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-scsi-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-scsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-scsi}"
SRC_URI[aarch64_fence-agents-scsi.sha256sum] = "a68f0d6937ad561ca2d9d50b1e9c2e9b66f9d167e3af0b7854d457f60a4ffe17"

URI_aarch64_fence-agents-virsh = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-virsh-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-virsh;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-virsh}"
SRC_URI[aarch64_fence-agents-virsh.sha256sum] = "ee61af979be0e9f0311976833092e826a9c41b6a0add612b9577e84814a27260"

URI_aarch64_fence-agents-vmware-rest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-vmware-rest-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-vmware-rest;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-vmware-rest}"
SRC_URI[aarch64_fence-agents-vmware-rest.sha256sum] = "760600dc37120ff1500b11ba89736da8cb1661c22b12ad144e8ed0eb82a9b30a"

URI_aarch64_fence-agents-vmware-soap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-vmware-soap-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-vmware-soap;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-vmware-soap}"
SRC_URI[aarch64_fence-agents-vmware-soap.sha256sum] = "5951cd9bb1d2ed97349d888ae6bb50650f7f2291e5dfab51c636c6f1d019d684"

URI_aarch64_fence-agents-wti = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-wti-4.16.0-5.el10_0.6.noarch.rpm;name=aarch64_fence-agents-wti;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-wti}"
SRC_URI[aarch64_fence-agents-wti.sha256sum] = "18098e9611516930493de3146ee9d72d2b45110681d50f8b0e2715b8b1a4053c"

RDEPENDS:fence-agents-aliyun = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 python3-jmespath \
 "
RDEPENDS:fence-agents-all:x86_64_v2 = " \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-mpath \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
 fence-virt \
"
RDEPENDS:fence-agents-all:aarch64 = " \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-mpath \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
"
RDEPENDS:fence-agents-amt-ws = " \
 fence-agents-common \
 openwsman-python3 \
 python3 \
 "
RDEPENDS:fence-agents-apc = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-apc-snmp = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-aws = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-azure-arm = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-bladecenter = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-brocade = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-cisco-mds = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-cisco-ucs = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-common = " \
 glibc \
 openssl-libs \
 pkgconf-pkg-config \
 python3 \
 python3-pexpect \
 python3-ptyprocess \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:fence-agents-drac5 = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-eaton-snmp = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-emerson = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-eps = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-gce = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-heuristics-ping = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-hpblade = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ibm-powervs = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-ibm-vpc = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-ibmblade = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ifmib = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ilo-moonshot = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo-mp = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo-ssh = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo2 = " \
 fence-agents-common \
 gnutls-utils \
 python3 \
 "
RDEPENDS:fence-agents-intelmodular = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ipdu = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ipmilan = " \
 fence-agents-common \
 ipmitool \
 python3 \
 "
RDEPENDS:fence-agents-kdump = " \
 fence-agents-common \
 glibc \
 "
RDEPENDS:fence-agents-kubevirt = " \
 fence-agents-common \
 python3 \
 python3-charset-normalizer \
 python3-dateutil \
 python3-oauthlib \
 python3-pyasn1 \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-urllib3 \
 "
RDEPENDS:fence-agents-lpar = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-mpath = " \
 device-mapper-multipath \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-openstack = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-redfish = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-rhevm = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-rsa = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-rsb = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-sbd = " \
 fence-agents-common \
 python3 \
 sbd \
 "
RDEPENDS:fence-agents-scsi = " \
 fence-agents-common \
 python3 \
 sg3_utils \
 "
RDEPENDS:fence-agents-virsh = " \
 fence-agents-common \
 libvirt-client \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-vmware-rest = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-vmware-soap = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-wti = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-virt = " \
 glibc \
 nss \
 systemd \
 "
RDEPENDS:fence-virtd = " \
 glibc \
 libuuid \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-cpg = " \
 corosynclib \
 fence-virtd \
 glibc \
 libqb \
 libvirt-libs \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-libvirt = " \
 fence-virtd \
 glibc \
 libvirt \
 libvirt-libs \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-multicast = " \
 fence-virtd \
 glibc \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-serial = " \
 fence-virtd \
 glibc \
 libvirt \
 libvirt-libs \
 libxml2 \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-tcp = " \
 fence-virtd \
 glibc \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:ha-cloud-support = " \
 awscli2 \
 glibc \
 python3-cffi \
 python3-charset-normalizer \
 python3-colorama \
 python3-cryptography \
 python3-dateutil \
 python3-docutils \
 python3-idna \
 python3-jmespath \
 python3-oauthlib \
 python3-packaging \
 python3-protobuf \
 python3-pyasn1 \
 python3-pycparser \
 python3-pyparsing \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-typing-extensions \
 python3-urllib3 \
 "
