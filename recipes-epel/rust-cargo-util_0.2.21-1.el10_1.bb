# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-util"
PV = "0.2.21"
PR = "1.el10_1"
PACKAGES = " \
 rust-cargo-util+default-devel \
 rust-cargo-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-util-0.2.21-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b95809c1d51b09f26c7d07185d96fc00ebb127c7a9a523688a55420ea9542340"

URI_x86_64_v2_rust-cargo-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util+default-devel-0.2.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-util+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-util+default-devel.sha256sum] = "31476d534c09e9ab75c8a6882192fe369ddf4e2d629dc9073d21528d2f6d4476"

URI_x86_64_v2_rust-cargo-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-devel-0.2.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-util-devel}"
SRC_URI[x86_64_v2_rust-cargo-util-devel.sha256sum] = "dd83f0dc733c6151d83e847a36fee52ae2439cf372d1bf90f99a442c044c95dd"

URI_aarch64_rust-cargo-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util+default-devel-0.2.21-1.el10_1.noarch.rpm;name=aarch64_rust-cargo-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-util+default-devel}"
SRC_URI[aarch64_rust-cargo-util+default-devel.sha256sum] = "eb004e93ba3cfd39f8216d7fdfd4f79a3a2817245fadfd0146f291ac4efdcc3c"

URI_aarch64_rust-cargo-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-devel-0.2.21-1.el10_1.noarch.rpm;name=aarch64_rust-cargo-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-util-devel}"
SRC_URI[aarch64_rust-cargo-util-devel.sha256sum] = "29131ebb4ecec323e60dcc795e2a95608ba0eb1c19f7cfd03a344f770365c602"

RDEPENDS:rust-cargo-util+default-devel = " \
 cargo \
 rust-cargo-util-devel \
 "
RDEPENDS:rust-cargo-util-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-filetime+default-devel \
 rust-hex+default-devel \
 rust-ignore+default-devel \
 rust-jobserver+default-devel \
 rust-libc+default-devel \
 rust-same-file+default-devel \
 rust-sha2+default-devel \
 rust-shell-escape+default-devel \
 rust-tempfile+default-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 rust-walkdir+default-devel \
 "
