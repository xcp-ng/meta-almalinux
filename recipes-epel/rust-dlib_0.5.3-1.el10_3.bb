# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dlib"
PV = "0.5.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-dlib+default-devel \
 rust-dlib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dlib-0.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f64de1f3e727e65850ad918def92d1b277e2f8c9ba0b6930af3af8d6953a517b"

URI_x86_64_v2_rust-dlib+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dlib+default-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dlib+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dlib+default-devel}"
SRC_URI[x86_64_v2_rust-dlib+default-devel.sha256sum] = "73d92152e3af72c58dd046d7d53d02e1641fa0703f86fe4fb4ab3f200aa71e17"

URI_x86_64_v2_rust-dlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dlib-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dlib-devel}"
SRC_URI[x86_64_v2_rust-dlib-devel.sha256sum] = "29d4a5336077cf2b301f6a3ab58c86803ff9b04f591ae898921bad362e741b77"

URI_aarch64_rust-dlib+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dlib+default-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-dlib+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dlib+default-devel}"
SRC_URI[aarch64_rust-dlib+default-devel.sha256sum] = "559a30d58e764b14828a68bd71967492f42d686e0ca4679a5b09b793538c2e47"

URI_aarch64_rust-dlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dlib-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-dlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dlib-devel}"
SRC_URI[aarch64_rust-dlib-devel.sha256sum] = "f73b744f42f77efba1f82f0654f94c0bda8001c9bb1787ba8d07d77f5c53bff0"

RDEPENDS:rust-dlib+default-devel = " \
 cargo \
 rust-dlib-devel \
 "
RDEPENDS:rust-dlib-devel = " \
 cargo \
 rust \
 virtual/crate_libloading/default__ge_0.7.0_with_crate_libloading/default__lt_0.9.0~ \
 "
