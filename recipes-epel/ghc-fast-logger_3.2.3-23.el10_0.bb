# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-fast-logger"
PV = "3.2.3"
PR = "23.el10_0"
PACKAGES = " \
 ghc-easy-file \
 ghc-easy-file-devel \
 ghc-easy-file-doc \
 ghc-easy-file-prof \
 ghc-fast-logger \
 ghc-fast-logger-devel \
 ghc-fast-logger-doc \
 ghc-fast-logger-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-fast-logger-3.2.3-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c85889aeecbd3f35df20e1b8e44dcccbcb8fb2dd20bc43df6ed9644034c037f"

URI_x86_64_v2_ghc-easy-file = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-easy-file-0.2.5-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-easy-file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-easy-file}"
SRC_URI[x86_64_v2_ghc-easy-file.sha256sum] = "31aac694c6db72e8637de6931f09e44e45e2854bc6fd381a0373262eb59f46a3"

URI_x86_64_v2_ghc-easy-file-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-easy-file-devel-0.2.5-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-easy-file-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-easy-file-devel}"
SRC_URI[x86_64_v2_ghc-easy-file-devel.sha256sum] = "fc28c70ee6ad2a8eb777f67b2dab5d3b8ae7126de4fa16cceb1a9f8592a8cebd"

URI_x86_64_v2_ghc-easy-file-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-easy-file-doc-0.2.5-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-easy-file-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-easy-file-doc}"
SRC_URI[x86_64_v2_ghc-easy-file-doc.sha256sum] = "85e4cac7a78b00aa2a81c063660cd3722e0af92b1d84574e7219f0abf9bb9e77"

URI_x86_64_v2_ghc-easy-file-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-easy-file-prof-0.2.5-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-easy-file-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-easy-file-prof}"
SRC_URI[x86_64_v2_ghc-easy-file-prof.sha256sum] = "4bcb9dd298c7ec898528a9154c2f2ce3cd5c72eea2fd2fd45a6e851dc48cb962"

URI_x86_64_v2_ghc-fast-logger = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fast-logger-3.2.3-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fast-logger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fast-logger}"
SRC_URI[x86_64_v2_ghc-fast-logger.sha256sum] = "5163343fc18f552d418e68c3b84f6c610f2b2a310886226fa381d4edcd6f51bb"

URI_x86_64_v2_ghc-fast-logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fast-logger-devel-3.2.3-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fast-logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fast-logger-devel}"
SRC_URI[x86_64_v2_ghc-fast-logger-devel.sha256sum] = "ae8319346f5d5c7c77da1c9bb99229c1fb15452c4809031cfba26045398666e7"

URI_x86_64_v2_ghc-fast-logger-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fast-logger-doc-3.2.3-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-fast-logger-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fast-logger-doc}"
SRC_URI[x86_64_v2_ghc-fast-logger-doc.sha256sum] = "7807b0b01c86c3db18393d59dead78872f1c24f19ff390f378836bb70120a2fc"

URI_x86_64_v2_ghc-fast-logger-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fast-logger-prof-3.2.3-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fast-logger-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fast-logger-prof}"
SRC_URI[x86_64_v2_ghc-fast-logger-prof.sha256sum] = "4cc25aef33e275d416a667d8965755acdf980cdce4e5f8c193e14d375276550c"

URI_aarch64_ghc-easy-file = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-easy-file-0.2.5-23.el10_0.aarch64.rpm;name=aarch64_ghc-easy-file;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-easy-file}"
SRC_URI[aarch64_ghc-easy-file.sha256sum] = "346a8d1d2a1f9a2d2b1918d787f24c59b69e1532bcfb98a9442f127568091530"

URI_aarch64_ghc-easy-file-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-easy-file-devel-0.2.5-23.el10_0.aarch64.rpm;name=aarch64_ghc-easy-file-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-easy-file-devel}"
SRC_URI[aarch64_ghc-easy-file-devel.sha256sum] = "83561151a02cfb698bf6e14012ef9d8fbaed7a4f9d11757fd43a06f6477a38d4"

URI_aarch64_ghc-easy-file-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-easy-file-doc-0.2.5-23.el10_0.noarch.rpm;name=aarch64_ghc-easy-file-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-easy-file-doc}"
SRC_URI[aarch64_ghc-easy-file-doc.sha256sum] = "8913f3cee13a76b9f01fd992225ab35a828e37d42b11ad8cac6a9983f42953a9"

URI_aarch64_ghc-easy-file-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-easy-file-prof-0.2.5-23.el10_0.aarch64.rpm;name=aarch64_ghc-easy-file-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-easy-file-prof}"
SRC_URI[aarch64_ghc-easy-file-prof.sha256sum] = "ab1c395d110e1dccb0826f4038062b0ce7201f47cee18c7299211da574681419"

URI_aarch64_ghc-fast-logger = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fast-logger-3.2.3-23.el10_0.aarch64.rpm;name=aarch64_ghc-fast-logger;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fast-logger}"
SRC_URI[aarch64_ghc-fast-logger.sha256sum] = "2959975e00c983ae4ae244f9203c424968b7cef88aa1120635ab18ce3ddc9e3e"

URI_aarch64_ghc-fast-logger-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fast-logger-devel-3.2.3-23.el10_0.aarch64.rpm;name=aarch64_ghc-fast-logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fast-logger-devel}"
SRC_URI[aarch64_ghc-fast-logger-devel.sha256sum] = "e595f1ff0593e6c31e096dbba745694cc03f7bff7de78f6a52e11021061599eb"

URI_aarch64_ghc-fast-logger-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fast-logger-doc-3.2.3-23.el10_0.noarch.rpm;name=aarch64_ghc-fast-logger-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fast-logger-doc}"
SRC_URI[aarch64_ghc-fast-logger-doc.sha256sum] = "0e4403978a716daad31dcfd8866a1a57db55bab73b6eb59bef514e11fea9d6d2"

URI_aarch64_ghc-fast-logger-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fast-logger-prof-3.2.3-23.el10_0.aarch64.rpm;name=aarch64_ghc-fast-logger-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fast-logger-prof}"
SRC_URI[aarch64_ghc-fast-logger-prof.sha256sum] = "d9230cc7b46f41daf39c31cea26d3e20cf2ecf269ae18d5b118f99065599d04d"

RDEPENDS:ghc-easy-file = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-easy-file-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-easy-file \
 ghc-filepath-devel \
 ghc-time-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-easy-file-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-easy-file-prof = " \
 ghc-base-prof \
 ghc-directory-prof \
 ghc-easy-file-devel \
 ghc-filepath-prof \
 ghc-time-prof \
 ghc-unix-prof \
 "
RDEPENDS:ghc-fast-logger = " \
 ghc-array \
 ghc-auto-update \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-easy-file \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-old-locale \
 ghc-old-time \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 glibc \
 gmp \
 "
RDEPENDS:ghc-fast-logger-devel = " \
 ghc-array-devel \
 ghc-auto-update-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-easy-file-devel \
 ghc-fast-logger \
 ghc-filepath-devel \
 ghc-stm-devel \
 ghc-text-devel \
 ghc-unix-compat-devel \
 ghc-unix-time-devel \
 "
RDEPENDS:ghc-fast-logger-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-fast-logger-prof = " \
 ghc-array-prof \
 ghc-auto-update-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-directory-prof \
 ghc-easy-file-prof \
 ghc-fast-logger-devel \
 ghc-filepath-prof \
 ghc-stm-prof \
 ghc-text-prof \
 ghc-unix-compat-prof \
 ghc-unix-time-prof \
 "
