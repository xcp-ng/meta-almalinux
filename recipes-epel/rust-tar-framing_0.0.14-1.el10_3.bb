# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tar-framing"
PV = "0.0.14"
PR = "1.el10_3"
PACKAGES = " \
 rust-tar-framing+default-devel \
 rust-tar-framing-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tar-framing-0.0.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e3eb71b29b7d11349dc3dedf53b8972140c75b662060651f1031b69eda3dfb64"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar-framing+default-devel-0.0.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar-framing+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tar-framing+default-devel.sha256sum] = "cefb186279c279a50bc89c84f16a7163fad6b600b5db069be9b6e19c87b50b5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar-framing-devel-0.0.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar-framing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tar-framing-devel.sha256sum] = "499720214413fce882af440a4c18caeb0715ad35c6911a9dbfbda4df67d154a1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tar-framing+default-devel-0.0.14-1.el10_3.noarch.rpm;name=aarch64_rust-tar-framing+default-devel;unpack=0"
SRC_URI[aarch64_rust-tar-framing+default-devel.sha256sum] = "104428c803aaa0a84c7f0cbb815f3362838d317349f00417cb313e1c2952c3f2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tar-framing-devel-0.0.14-1.el10_3.noarch.rpm;name=aarch64_rust-tar-framing-devel;unpack=0"
SRC_URI[aarch64_rust-tar-framing-devel.sha256sum] = "74a50bf391967180b59f5379fee9a6216d98fd7207c63e2dff734e79209f3228"

RDEPENDS:rust-tar-framing+default-devel = " \
 cargo \
 rust-tar-framing-devel \
 "
RDEPENDS:rust-tar-framing-devel = " \
 cargo \
 rust-thiserror+default-devel \
 rust-tokio+default-devel \
 "
