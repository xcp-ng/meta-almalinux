# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-kdcproxy"
PV = "1.1.0"
PR = "1.el10"
PACKAGES = " \
 python3-kdcproxy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-kdcproxy-1.1.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5e96b41df6e0e0fc928d27e9e8ab26560f8960695ff132f32dac59a4dacc3e2"

URI_x86_64_v2_python3-kdcproxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-kdcproxy-1.1.0-1.el10.noarch.rpm;name=x86_64_v2_python3-kdcproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kdcproxy}"
SRC_URI[x86_64_v2_python3-kdcproxy.sha256sum] = "2b43ddd5c1a61a5d992f2f84a6b24056d0182934ed5c549f4ec7cfba58c21af9"

URI_aarch64_python3-kdcproxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-kdcproxy-1.1.0-1.el10.noarch.rpm;name=aarch64_python3-kdcproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kdcproxy}"
SRC_URI[aarch64_python3-kdcproxy.sha256sum] = "2b43ddd5c1a61a5d992f2f84a6b24056d0182934ed5c549f4ec7cfba58c21af9"

RDEPENDS:python3-kdcproxy = " \
 python3 \
 python3-dns \
 python3-pyasn1 \
 "
