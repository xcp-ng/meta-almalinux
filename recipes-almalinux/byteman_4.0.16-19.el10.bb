# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "byteman"
PV = "4.0.16"
PR = "19.el10"
PACKAGES = " \
 byteman \
 byteman-bmunit \
 byteman-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/byteman-4.0.16-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eda9af23ea99d0558154995ff56b8d74a269736f731607a48ac535d6184d8304"

URI_x86_64_v2_byteman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/byteman-4.0.16-19.el10.noarch.rpm;name=x86_64_v2_byteman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_byteman}"
SRC_URI[x86_64_v2_byteman.sha256sum] = "cab6181151a1952bb1f79939884bf6d08e6e55d68558901f36918efaf53fe08c"

URI_x86_64_v2_byteman-bmunit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/byteman-bmunit-4.0.16-19.el10.noarch.rpm;name=x86_64_v2_byteman-bmunit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_byteman-bmunit}"
SRC_URI[x86_64_v2_byteman-bmunit.sha256sum] = "311c13d388dfca8556e972b9428c6904937d1b89e2d3f656a0d8dd60397821a7"

URI_x86_64_v2_byteman-javadoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/byteman-javadoc-4.0.16-19.el10.noarch.rpm;name=x86_64_v2_byteman-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_byteman-javadoc}"
SRC_URI[x86_64_v2_byteman-javadoc.sha256sum] = "d167c41c2592c484393a1c00709b21e0da6d422ad93a4d2ebb4009787491bab4"

URI_aarch64_byteman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/byteman-4.0.16-19.el10.noarch.rpm;name=aarch64_byteman;unpack=0"
SRC_URI:append = " ${URI_aarch64_byteman}"
SRC_URI[aarch64_byteman.sha256sum] = "cab6181151a1952bb1f79939884bf6d08e6e55d68558901f36918efaf53fe08c"

URI_aarch64_byteman-bmunit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/byteman-bmunit-4.0.16-19.el10.noarch.rpm;name=aarch64_byteman-bmunit;unpack=0"
SRC_URI:append = " ${URI_aarch64_byteman-bmunit}"
SRC_URI[aarch64_byteman-bmunit.sha256sum] = "311c13d388dfca8556e972b9428c6904937d1b89e2d3f656a0d8dd60397821a7"

URI_aarch64_byteman-javadoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/byteman-javadoc-4.0.16-19.el10.noarch.rpm;name=aarch64_byteman-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_byteman-javadoc}"
SRC_URI[aarch64_byteman-javadoc.sha256sum] = "d167c41c2592c484393a1c00709b21e0da6d422ad93a4d2ebb4009787491bab4"

RDEPENDS:byteman = " \
 apache-commons-lang3 \
 bash \
 byteman-bmunit \
 java-21-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:byteman-bmunit = " \
 byteman \
 javapackages-filesystem \
 "
RDEPENDS:byteman-javadoc = " \
 javapackages-filesystem \
 "
