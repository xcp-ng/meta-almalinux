# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sqlx-postgres"
PV = "0.8.6"
PR = "4.el10_3"
PACKAGES = " \
 rust-sqlx-postgres+any-devel \
 rust-sqlx-postgres+bigdecimal-devel \
 rust-sqlx-postgres+bit-vec-devel \
 rust-sqlx-postgres+chrono-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+ipnet-devel \
 rust-sqlx-postgres+ipnetwork-devel \
 rust-sqlx-postgres+json-devel \
 rust-sqlx-postgres+mac_address-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-postgres+offline-devel \
 rust-sqlx-postgres+rust_decimal-devel \
 rust-sqlx-postgres+time-devel \
 rust-sqlx-postgres+uuid-devel \
 rust-sqlx-postgres-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sqlx-postgres-0.8.6-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb0e8376e7187910211fe69ed34e7d94c71a801931ab81afd10ad3b8eb1167cb"

URI_x86_64_v2_rust-sqlx-postgres+any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+any-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+any-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+any-devel.sha256sum] = "e7b366bf8ac81c754e821d7e0d31bf676511a10bef9e5743de346da439285668"

URI_x86_64_v2_rust-sqlx-postgres+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+bigdecimal-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+bigdecimal-devel.sha256sum] = "c4383ea4bf4276a0d918f37edb815d144afa47fb82733e825e4810a9b01bf424"

URI_x86_64_v2_rust-sqlx-postgres+bit-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+bit-vec-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+bit-vec-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+bit-vec-devel.sha256sum] = "cef314459a4b10a2ae60ec9a6fd563488e86194d8423cfab39cae80e6b228ef0"

URI_x86_64_v2_rust-sqlx-postgres+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+chrono-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+chrono-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+chrono-devel.sha256sum] = "09a318e80c0cfbd8aae2d9b088015e038e515ae1321a39db42247e8da53be4bd"

URI_x86_64_v2_rust-sqlx-postgres+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+default-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+default-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+default-devel.sha256sum] = "6353b232b1a3a1329c662cf5eeaece81fc6f26e29b9c56dc42ee194694887f99"

URI_x86_64_v2_rust-sqlx-postgres+ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+ipnet-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+ipnet-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+ipnet-devel.sha256sum] = "021a5e1e0f05b02c71d283e8519b8491b349cf8de65ff8d39b5fa124382a2ebc"

URI_x86_64_v2_rust-sqlx-postgres+ipnetwork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+ipnetwork-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+ipnetwork-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+ipnetwork-devel.sha256sum] = "6746f245faa1694a01ec8d65f2293f0ae12fa44f79635a638d48f0410df62eb2"

URI_x86_64_v2_rust-sqlx-postgres+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+json-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+json-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+json-devel.sha256sum] = "2f73637b68aab2d848b4c2517932dd67c544a8e35cd0b129c08535805771a1bc"

URI_x86_64_v2_rust-sqlx-postgres+mac_address-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+mac_address-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+mac_address-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+mac_address-devel.sha256sum] = "64a31a4b41b6cde41b78ecb18fb2d6f17de49777a2b7bf65d673fdaf010ec574"

URI_x86_64_v2_rust-sqlx-postgres+migrate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+migrate-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+migrate-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+migrate-devel.sha256sum] = "f0ccea78f204d0f84a55336934fb1d0f4044ac06eef5b5058f7a4c15c35b88c3"

URI_x86_64_v2_rust-sqlx-postgres+offline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+offline-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+offline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+offline-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+offline-devel.sha256sum] = "56e4f762cba0697d562a3ab7c19942fd200724894eddaf56aead3bf6a8dc730b"

URI_x86_64_v2_rust-sqlx-postgres+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+rust_decimal-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+rust_decimal-devel.sha256sum] = "aface1f3ae77541c903fb4ded40e48539873103e1233c75a0eefa7cfba0de47d"

URI_x86_64_v2_rust-sqlx-postgres+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+time-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+time-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+time-devel.sha256sum] = "bb78b8f379ad365c2410e15879a857ecaa2e040d7794961517ecd5f2eb500db2"

URI_x86_64_v2_rust-sqlx-postgres+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+uuid-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+uuid-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+uuid-devel.sha256sum] = "cb89fd25eb29976a2d43e6866231b1580bb7deba71830e4a2b75681b1f236b8e"

URI_x86_64_v2_rust-sqlx-postgres-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres-devel.sha256sum] = "3e5a1abceaf118393d3b717da97c8cb7f878d2459120d1ad957b07e589035425"

URI_aarch64_rust-sqlx-postgres+any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+any-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres+any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+any-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+any-devel.sha256sum] = "be2415fa8be5ce76b08394eb6d36d952e5adedb819bb04a498cb230190f32b0a"

URI_aarch64_rust-sqlx-postgres+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+bigdecimal-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+bigdecimal-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+bigdecimal-devel.sha256sum] = "55b10b5c9af69cd60cbdabae68ff8b8b5966aea858597a4588f4d3356c2c7a44"

URI_aarch64_rust-sqlx-postgres+bit-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+bit-vec-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+bit-vec-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+bit-vec-devel.sha256sum] = "92ec2c4730b291eb0f633a12abd700060a22dae6299e7482e6b4dde64806c79c"

URI_aarch64_rust-sqlx-postgres+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+chrono-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+chrono-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+chrono-devel.sha256sum] = "eb40b7cc38d70dd1c118036108364b361b7a3ca929ce3a590d4b30ea7143090b"

URI_aarch64_rust-sqlx-postgres+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+default-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+default-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+default-devel.sha256sum] = "678de9450a3a448ecb12f2e6fceea87e51dc2cf14435f25fdd536c0070a38832"

URI_aarch64_rust-sqlx-postgres+ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+ipnet-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+ipnet-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+ipnet-devel.sha256sum] = "024fccb7aae01bd6ba303c5bff503c6b96f385229c50d59435a66d3c94164453"

URI_aarch64_rust-sqlx-postgres+ipnetwork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+ipnetwork-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+ipnetwork-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+ipnetwork-devel.sha256sum] = "5a1f23713c0da2af0b2412e359bf5e9531ee4964bc3ff0c8dcbc5d58db2c8545"

URI_aarch64_rust-sqlx-postgres+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+json-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+json-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+json-devel.sha256sum] = "92c152138df63d8cb5ab128cd90bebf3c7207d402b84c123fe9f524834c27f98"

URI_aarch64_rust-sqlx-postgres+mac_address-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+mac_address-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+mac_address-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+mac_address-devel.sha256sum] = "4e4a65f5506e60b561d52e7c041aa45a1d25d74cf289880fc188c82381551eb0"

URI_aarch64_rust-sqlx-postgres+migrate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+migrate-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+migrate-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+migrate-devel.sha256sum] = "60ab0ed136964d88138c47a09026eb495cd010053207f0fb34a1488930c3ece8"

URI_aarch64_rust-sqlx-postgres+offline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+offline-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres+offline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+offline-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+offline-devel.sha256sum] = "b7f3adef31ca8ed213b08b570a3c3b0f5e68fe8098cddffc1e1c2f8cbc61e9b9"

URI_aarch64_rust-sqlx-postgres+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+rust_decimal-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+rust_decimal-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+rust_decimal-devel.sha256sum] = "d726a2caddef8517155aef8cb722cf1b87912f499f0a072e716bb5183e34d84d"

URI_aarch64_rust-sqlx-postgres+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+time-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+time-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+time-devel.sha256sum] = "89585b41305f2abed7e0477a95ef3d38701f387083fb769e8ec1c36cc4995d57"

URI_aarch64_rust-sqlx-postgres+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+uuid-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+uuid-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+uuid-devel.sha256sum] = "e8e2be2e7cf126fc06a89def01090cfc38933368147ea732ad9182e13e5b4313"

URI_aarch64_rust-sqlx-postgres-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-postgres-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres-devel}"
SRC_URI[aarch64_rust-sqlx-postgres-devel.sha256sum] = "74a6b7985257107ca35d14892162b885bcf0e0e69dc04489b9492b66b5963817"

RDEPENDS:rust-sqlx-postgres+any-devel = " \
 cargo \
 rust-sqlx-core+any-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+bigdecimal-devel = " \
 cargo \
 rust-bigdecimal+default-devel \
 rust-num-bigint+default-devel \
 rust-sqlx-core+bigdecimal-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+bit-vec-devel = " \
 cargo \
 rust-bit-vec0.6+default-devel \
 rust-sqlx-core+bit-vec-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-sqlx-core+chrono-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+default-devel = " \
 cargo \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+ipnet-devel = " \
 cargo \
 rust-ipnet+default-devel \
 rust-sqlx-core+ipnet-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+ipnetwork-devel = " \
 cargo \
 rust-ipnetwork+default-devel \
 rust-sqlx-core+ipnetwork-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+json-devel = " \
 cargo \
 rust-sqlx-core+json-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+mac_address-devel = " \
 cargo \
 rust-mac_address+default-devel \
 rust-sqlx-core+mac_address-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+migrate-devel = " \
 cargo \
 rust-sqlx-core+migrate-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+offline-devel = " \
 cargo \
 rust-sqlx-core+offline-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+rust_decimal-devel = " \
 cargo \
 rust-rust_decimal+maths-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 rust-sqlx-core+rust_decimal-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+time-devel = " \
 cargo \
 rust-sqlx-core+time-devel \
 rust-sqlx-postgres-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-sqlx-postgres+uuid-devel = " \
 cargo \
 rust-sqlx-core+uuid-devel \
 rust-sqlx-postgres-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-sqlx-postgres-devel = " \
 cargo \
 rust-atoi+default-devel \
 rust-base64_0.22+std-devel \
 rust-base64_0.22-devel \
 rust-bitflags-devel \
 rust-byteorder+std-devel \
 rust-byteorder-devel \
 rust-crc+default-devel \
 rust-dotenvy-devel \
 rust-futures-channel+alloc-devel \
 rust-futures-channel+sink-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-core-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util+io-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 rust-hex+default-devel \
 rust-hkdf0.12+default-devel \
 rust-hmac0.12+reset-devel \
 rust-hmac0.12-devel \
 rust-home+default-devel \
 rust-itoa+default-devel \
 rust-log+default-devel \
 rust-md-5_0.10-devel \
 rust-memchr-devel \
 rust-once_cell+default-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-sha2_0.10-devel \
 rust-smallvec+default-devel \
 rust-smallvec+serde-devel \
 rust-sqlx-core+default-devel \
 rust-sqlx-core+json-devel \
 rust-stringprep+default-devel \
 rust-thiserror+default-devel \
 rust-tracing+default-devel \
 rust-tracing+log-devel \
 rust-whoami-devel \
 "
