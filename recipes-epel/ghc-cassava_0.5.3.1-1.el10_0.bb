# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-cassava"
PV = "0.5.3.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-cassava \
 ghc-cassava-devel \
 ghc-cassava-doc \
 ghc-cassava-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-cassava-0.5.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2013fbca05b93540c2adc2ec709d862726c8655bd7a2242d1c0695dd3dd09c89"

URI_x86_64_v2_ghc-cassava = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cassava-0.5.3.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cassava;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cassava}"
SRC_URI[x86_64_v2_ghc-cassava.sha256sum] = "a165262bd45fbe380b1b70329d8eac3b1db44f8f4d56671e9b7cd1e99f9d4b39"

URI_x86_64_v2_ghc-cassava-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cassava-devel-0.5.3.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cassava-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cassava-devel}"
SRC_URI[x86_64_v2_ghc-cassava-devel.sha256sum] = "ef1a05bf4925144aad8061414a3ac06c59151fd91509538b8bb1196215e62036"

URI_x86_64_v2_ghc-cassava-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cassava-doc-0.5.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-cassava-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cassava-doc}"
SRC_URI[x86_64_v2_ghc-cassava-doc.sha256sum] = "a0dfe90ac3004645e5dcc8f74e30a9728f6a548e62a809e7edc0a8e41c00acce"

URI_x86_64_v2_ghc-cassava-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cassava-prof-0.5.3.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cassava-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cassava-prof}"
SRC_URI[x86_64_v2_ghc-cassava-prof.sha256sum] = "a21bba19fe4c96131c586da736b5819cd9b71bc0523a1dd1350ead8f87dec568"

URI_aarch64_ghc-cassava = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cassava-0.5.3.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-cassava;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cassava}"
SRC_URI[aarch64_ghc-cassava.sha256sum] = "66d5325d9c11383cab57effff90c4be68f74143510a40def2b95791220e4533a"

URI_aarch64_ghc-cassava-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cassava-devel-0.5.3.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-cassava-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cassava-devel}"
SRC_URI[aarch64_ghc-cassava-devel.sha256sum] = "191ba67a06f6e3b15460976ed3d79098df3a28669c3f4fd1e6cc9b91f8e23d61"

URI_aarch64_ghc-cassava-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cassava-doc-0.5.3.1-1.el10_0.noarch.rpm;name=aarch64_ghc-cassava-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cassava-doc}"
SRC_URI[aarch64_ghc-cassava-doc.sha256sum] = "a45d97d42b738ed05b8caa4fc0850c9a0044a5530f3ee7b0d4663150dd640257"

URI_aarch64_ghc-cassava-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cassava-prof-0.5.3.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-cassava-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cassava-prof}"
SRC_URI[aarch64_ghc-cassava-prof.sha256sum] = "1db02c7fd6ef1082842c51edf18a65326469b7911ba5a78b53a440492c283b30"

RDEPENDS:ghc-cassava = " \
 ghc-Only \
 ghc-array \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-scientific \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-transformers \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-cassava-devel = " \
 ghc-Only-devel \
 ghc-array-devel \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-cassava \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-hashable-devel \
 ghc-scientific-devel \
 ghc-text-devel \
 ghc-text-short-devel \
 ghc-transformers-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-cassava-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cassava-prof = " \
 ghc-Only-prof \
 ghc-array-prof \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cassava-devel \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-hashable-prof \
 ghc-scientific-prof \
 ghc-text-prof \
 ghc-text-short-prof \
 ghc-transformers-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
