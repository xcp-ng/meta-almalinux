# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oidc-agent"
PV = "5.3.8"
PR = "1.el10_2"
PACKAGES = " \
 oidc-agent-cli \
 oidc-agent-desktop \
 oidc-agent-devel \
 oidc-agent-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/oidc-agent-5.3.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0de80e3bf8100372c55284fb72768e76e8f50fc17e049745d8191b249d76b884"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-cli-5.3.8-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-cli;unpack=0"
SRC_URI[x86_64_v2_oidc-agent-cli.sha256sum] = "a19e40dbf6bfdaac9188db408a4beae43b5e6ab1253d3334ee4351f37a7d243d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-desktop-5.3.8-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-desktop;unpack=0"
SRC_URI[x86_64_v2_oidc-agent-desktop.sha256sum] = "cde6319492afe2bd2dc6fac3cf62e607168891f52790edfeb38631ef52b03a92"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-devel-5.3.8-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-devel;unpack=0"
SRC_URI[x86_64_v2_oidc-agent-devel.sha256sum] = "27b50d56baa69469a746398a2ed94406fd5adda8948f2f590cd86bcfe7ab93a6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-libs-5.3.8-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-libs;unpack=0"
SRC_URI[x86_64_v2_oidc-agent-libs.sha256sum] = "84126d66383a9ab59849417621b93523655cde38a03057af2da4498e7b4ba6ea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-cli-5.3.8-1.el10_2.aarch64.rpm;name=aarch64_oidc-agent-cli;unpack=0"
SRC_URI[aarch64_oidc-agent-cli.sha256sum] = "49fbd530a0de5e6bc1a4ad8bc08d8b6dde24e780675ae36024956b4a44b706ac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-desktop-5.3.8-1.el10_2.aarch64.rpm;name=aarch64_oidc-agent-desktop;unpack=0"
SRC_URI[aarch64_oidc-agent-desktop.sha256sum] = "62fcacd5fa30ff405016f59e170dbdcb1e504799c72dd6f8d624d6c1721ec889"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-devel-5.3.8-1.el10_2.aarch64.rpm;name=aarch64_oidc-agent-devel;unpack=0"
SRC_URI[aarch64_oidc-agent-devel.sha256sum] = "f02416c9cdd77ac41b3c7537acdeb35ef98f291d52efb8c988bdd44d1a7f78a6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-libs-5.3.8-1.el10_2.aarch64.rpm;name=aarch64_oidc-agent-libs;unpack=0"
SRC_URI[aarch64_oidc-agent-libs.sha256sum] = "bde00c9025375cc781ad1ccb0008df7b669a8a840c234525ba0472063539c43b"

RDEPENDS:oidc-agent-cli = " \
 bash \
 cjson \
 clibs-list \
 glibc \
 libmicrohttpd \
 libsodium \
 oidc-agent-libs \
 qrencode-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:oidc-agent-desktop = " \
 cjson \
 clibs-list \
 glib2 \
 glibc \
 gtk3 \
 javascriptcoregtk4.1 \
 libgcc \
 libsodium \
 libstdc++ \
 oidc-agent-cli \
 oidc-agent-libs \
 webkit2gtk4.1 \
 "
RDEPENDS:oidc-agent-devel = " \
 oidc-agent-libs \
 "
RDEPENDS:oidc-agent-libs = " \
 cjson \
 clibs-list \
 glibc \
 libsodium \
 "
