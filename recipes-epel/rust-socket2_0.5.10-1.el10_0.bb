# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-socket2"
PV = "0.5.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 rust-socket2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-socket2-0.5.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49114f1dd41209bc787b240c32417cae26de43ec781ffc203d97b1898442f39e"

URI_x86_64_v2_rust-socket2+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2+all-devel-0.5.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2+all-devel}"
SRC_URI[x86_64_v2_rust-socket2+all-devel.sha256sum] = "d471cfcc723b478f8a567c54c4c673902430385950ce151fff01f1be8198a561"

URI_x86_64_v2_rust-socket2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2+default-devel-0.5.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2+default-devel}"
SRC_URI[x86_64_v2_rust-socket2+default-devel.sha256sum] = "88e5735718dc87a92670c6ff9343578f394c659536d5ddc760551742ce0a9c4e"

URI_x86_64_v2_rust-socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2-devel-0.5.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2-devel}"
SRC_URI[x86_64_v2_rust-socket2-devel.sha256sum] = "3602908ae135e21cfc61cf760d854a5ab5791dce68da8e77b4c5750034b587ed"

URI_aarch64_rust-socket2+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2+all-devel-0.5.10-1.el10_0.noarch.rpm;name=aarch64_rust-socket2+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2+all-devel}"
SRC_URI[aarch64_rust-socket2+all-devel.sha256sum] = "0ba87b3d8b25145d3c55a9a2fe783bb0c8810cb67e6b4d1a39a0c0b6b15b8247"

URI_aarch64_rust-socket2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2+default-devel-0.5.10-1.el10_0.noarch.rpm;name=aarch64_rust-socket2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2+default-devel}"
SRC_URI[aarch64_rust-socket2+default-devel.sha256sum] = "d7e90e5daab99e254a517aa7945692fc80152f239e85364b807ee901fe8eec63"

URI_aarch64_rust-socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2-devel-0.5.10-1.el10_0.noarch.rpm;name=aarch64_rust-socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2-devel}"
SRC_URI[aarch64_rust-socket2-devel.sha256sum] = "1778685f58633fd14760ed7fbe48f958b1cdf647bf8f9d3e7243c23dec5b3cdf"

RDEPENDS:rust-socket2+all-devel = " \
 cargo \
 rust-socket2-devel \
 "
RDEPENDS:rust-socket2+default-devel = " \
 cargo \
 rust-socket2-devel \
 "
RDEPENDS:rust-socket2-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
