# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bitcoin-core"
PV = "29.2"
PR = "1.el10_0"
PACKAGES = " \
 bitcoin-core-desktop \
 bitcoin-core-devel \
 bitcoin-core-server \
 bitcoin-core-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bitcoin-core-29.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0daae37ccabbb9e0a2484c1329d819f4552843851f2d5fb3f370645c3ba87256"

URI_x86_64_v2_bitcoin-core-desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-desktop-29.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-desktop}"
SRC_URI[x86_64_v2_bitcoin-core-desktop.sha256sum] = "361db8e00f627bee609565487e5e53d86de94ae1903d51c518267678e0c4385c"

URI_x86_64_v2_bitcoin-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-devel-29.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-devel}"
SRC_URI[x86_64_v2_bitcoin-core-devel.sha256sum] = "9fdd05ad201aa8c19709e5a43f009fe566e8dceeb65dbd0259118e430f12efa9"

URI_x86_64_v2_bitcoin-core-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-server-29.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-server}"
SRC_URI[x86_64_v2_bitcoin-core-server.sha256sum] = "b742f83997b110e0b6f485a19e5e7aabf015b53765dcebbda7a15434c169e3c3"

URI_x86_64_v2_bitcoin-core-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-utils-29.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-utils}"
SRC_URI[x86_64_v2_bitcoin-core-utils.sha256sum] = "9d7804a65792a4e3e8ef130cf9315247771a2c88e882765ab7ded8189492e7a6"

URI_aarch64_bitcoin-core-desktop = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-desktop-29.2-1.el10_0.aarch64.rpm;name=aarch64_bitcoin-core-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-desktop}"
SRC_URI[aarch64_bitcoin-core-desktop.sha256sum] = "6c5ba8d2c48965f1ae95d0091b509f3a6a35a45bce7298c6bb0628ab96d4d78b"

URI_aarch64_bitcoin-core-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-devel-29.2-1.el10_0.aarch64.rpm;name=aarch64_bitcoin-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-devel}"
SRC_URI[aarch64_bitcoin-core-devel.sha256sum] = "3c5e6859717a349f61320c8c1db5d0723f2cb1b3bbfefa7897c8e5fc8039a9ed"

URI_aarch64_bitcoin-core-server = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-server-29.2-1.el10_0.aarch64.rpm;name=aarch64_bitcoin-core-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-server}"
SRC_URI[aarch64_bitcoin-core-server.sha256sum] = "8b269ebf7cd1f9b87aec9976ef1b5cb28cc8501f885cf6eff6cf1ea9e752b516"

URI_aarch64_bitcoin-core-utils = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-utils-29.2-1.el10_0.aarch64.rpm;name=aarch64_bitcoin-core-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-utils}"
SRC_URI[aarch64_bitcoin-core-utils.sha256sum] = "c7e133270e37e33171b779a9984ceeed6b130b353f9445efe1a6ad681f8863ff"

RDEPENDS:bitcoin-core-desktop = " \
 glibc \
 libevent \
 libgcc \
 libstdc++ \
 qrencode-libs \
 qt5-qtbase \
 qt5-qtbase-gui \
 sqlite-libs \
 zeromq \
 "
RDEPENDS:bitcoin-core-devel = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:bitcoin-core-server = " \
 bash \
 bitcoin-core-selinux \
 glibc \
 libevent \
 libgcc \
 libstdc++ \
 shadow-utils \
 sqlite-libs \
 zeromq \
 "
RDEPENDS:bitcoin-core-utils = " \
 glibc \
 libevent \
 libgcc \
 libstdc++ \
 sqlite-libs \
 "
