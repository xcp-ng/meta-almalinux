# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamermm"
PV = "1.10.0"
PR = "27.el10_1"
PACKAGES = " \
 gstreamermm \
 gstreamermm-devel \
 gstreamermm-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gstreamermm-1.10.0-27.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b12352b312f6ad3a6eae672a7f525cb88d98832e408eae3b9947e8858009e646"

URI_x86_64_v2_gstreamermm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gstreamermm-1.10.0-27.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gstreamermm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamermm}"
SRC_URI[x86_64_v2_gstreamermm.sha256sum] = "c7b453934a04769d46ac16649ef5053dafa466f7e2bd23a87372c5b29fd17fd0"

URI_x86_64_v2_gstreamermm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gstreamermm-devel-1.10.0-27.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gstreamermm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamermm-devel}"
SRC_URI[x86_64_v2_gstreamermm-devel.sha256sum] = "d34caa1b56c3c8e6e1330248446945b766339e1b69cc5e51541e79ad9bddf353"

URI_x86_64_v2_gstreamermm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gstreamermm-doc-1.10.0-27.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gstreamermm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamermm-doc}"
SRC_URI[x86_64_v2_gstreamermm-doc.sha256sum] = "8c214fb80858ab667d5ad4c1539906e173992e4981523ea57c4b51c94b094e4f"

URI_aarch64_gstreamermm = "${EPEL_MIRROR}/aarch64/Packages/g/gstreamermm-1.10.0-27.el10_1.aarch64.rpm;name=aarch64_gstreamermm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamermm}"
SRC_URI[aarch64_gstreamermm.sha256sum] = "cc1e79312863433737aea35d0fb1f1161a3674cb9f389d95a9cf4f59cfca6ab4"

URI_aarch64_gstreamermm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gstreamermm-devel-1.10.0-27.el10_1.aarch64.rpm;name=aarch64_gstreamermm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamermm-devel}"
SRC_URI[aarch64_gstreamermm-devel.sha256sum] = "f798b24d6444706583419b041f605162d0718fb67208d300f955c284e9c0814e"

URI_aarch64_gstreamermm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gstreamermm-doc-1.10.0-27.el10_1.noarch.rpm;name=aarch64_gstreamermm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamermm-doc}"
SRC_URI[aarch64_gstreamermm-doc.sha256sum] = "4b6cd85988c3413b2c04eefdf6b2ace43ade5e510f180e748ad5b7bbe242b8fa"

RDEPENDS:gstreamermm = " \
 glib2 \
 glibc \
 glibmm2.4 \
 gstreamer1 \
 gstreamer1-plugins-base \
 libdrm \
 libgcc \
 libsigc++20 \
 libstdc++ \
 "
RDEPENDS:gstreamermm-devel = " \
 glib2 \
 glibc \
 glibmm2.4 \
 glibmm2.4-devel \
 gstreamer1 \
 gstreamer1-devel \
 gstreamer1-plugins-base-devel \
 gstreamermm \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 "
RDEPENDS:gstreamermm-doc = " \
 glibmm2.4-doc \
 "
