# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klickety"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 klickety \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/klickety-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2060fd3cb75ee39e549cb53803f7008ed07320d3e0558101f53382c2cc7a7cb7"

URI_x86_64_v2_klickety = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klickety-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klickety;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_klickety}"
SRC_URI[x86_64_v2_klickety.sha256sum] = "357073e133afe0698bf1049ef5e6c128224b297ce3ee33205cc3252a264d14ba"

URI_aarch64_klickety = "${EPEL_MIRROR}/aarch64/Packages/k/klickety-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_klickety;unpack=0"
SRC_URI:append = " ${URI_aarch64_klickety}"
SRC_URI[aarch64_klickety.sha256sum] = "d5daf583f04824102e42d049572d62e5f7821dfbf6db274d9302559d4a226f02"

RDEPENDS:klickety = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 perl-interpreter \
 perl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
