# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uutests"
PV = "0.7.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-uutests+default-devel \
 rust-uutests-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uutests-0.7.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56a72526da2b742924ec3ad6572425ffb7b4cb127349b1e74b2b9b0054c03baf"

URI_x86_64_v2_rust-uutests+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uutests+default-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uutests+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uutests+default-devel}"
SRC_URI[x86_64_v2_rust-uutests+default-devel.sha256sum] = "9338bf3b75258d866a657df4d5255f1bdffdd8faae3c95c95de1bd836b00494c"

URI_x86_64_v2_rust-uutests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uutests-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uutests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uutests-devel}"
SRC_URI[x86_64_v2_rust-uutests-devel.sha256sum] = "cedac2edafb010029d25da9eeeaee0a46b51798b483d2372db8124686a9bd978"

URI_aarch64_rust-uutests+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uutests+default-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uutests+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uutests+default-devel}"
SRC_URI[aarch64_rust-uutests+default-devel.sha256sum] = "34805a177b08137e99076cbac224b787103bddb3c825003119285a4dcc434aa5"

URI_aarch64_rust-uutests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uutests-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uutests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uutests-devel}"
SRC_URI[aarch64_rust-uutests-devel.sha256sum] = "6bd860a79037da154cf68dfbed927aff444cfb9c7da7a07b676adc8f31401142"

RDEPENDS:rust-uutests+default-devel = " \
 cargo \
 rust-uutests-devel \
 "
RDEPENDS:rust-uutests-devel = " \
 cargo \
 rust \
 rust-ctor+default-devel \
 rust-libc+default-devel \
 rust-nix0.30+process-devel \
 rust-nix0.30+signal-devel \
 rust-nix0.30+term-devel \
 rust-nix0.30+user-devel \
 rust-nix0.30-devel \
 rust-pretty_assertions+default-devel \
 rust-rand0.9+default-devel \
 rust-rand0.9+small_rng-devel \
 rust-regex+default-devel \
 rust-rlimit+default-devel \
 rust-tempfile+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+mode-devel \
 rust-uucore+process-devel \
 rust-uucore+signals-devel \
 rust-uucore+utmpx-devel \
 rust-xattr+default-devel \
 "
