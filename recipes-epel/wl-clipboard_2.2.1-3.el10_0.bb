# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wl-clipboard"
PV = "2.2.1"
PR = "3.el10_0"
PACKAGES = " \
 wl-clipboard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wl-clipboard-2.2.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb6d49aa402d888073223d355585a863ccee8c997cc7fb230626d9ce314c1b19"

URI_x86_64_v2_wl-clipboard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wl-clipboard-2.2.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wl-clipboard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wl-clipboard}"
SRC_URI[x86_64_v2_wl-clipboard.sha256sum] = "0f9aec8a851bd8a36b1a0db534af49eecef87d4f3f671bc07ef0e2926cf03dfa"

URI_aarch64_wl-clipboard = "${EPEL_MIRROR}/aarch64/Packages/w/wl-clipboard-2.2.1-3.el10_0.aarch64.rpm;name=aarch64_wl-clipboard;unpack=0"
SRC_URI:append = " ${URI_aarch64_wl-clipboard}"
SRC_URI[aarch64_wl-clipboard.sha256sum] = "7ee08ceeea8f8c8827fae142d63962524a64293dd787dd8222f65193528e50c3"

RDEPENDS:wl-clipboard = " \
 glibc \
 libwayland-client \
 "
