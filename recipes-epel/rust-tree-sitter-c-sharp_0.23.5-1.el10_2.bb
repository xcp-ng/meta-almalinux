# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-c-sharp"
PV = "0.23.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-c-sharp+default-devel \
 rust-tree-sitter-c-sharp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-c-sharp-0.23.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a8572a357dfdf4359419e2247ff65db64da69f0843f22e20b13919486fb6400"

URI_x86_64_v2_rust-tree-sitter-c-sharp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-c-sharp+default-devel-0.23.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-c-sharp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-c-sharp+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-c-sharp+default-devel.sha256sum] = "35e9df4f5c0e0bfdab0b243d7afb73f4e10dc9089bce0c4064649065457a582f"

URI_x86_64_v2_rust-tree-sitter-c-sharp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-c-sharp-devel-0.23.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-c-sharp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-c-sharp-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-c-sharp-devel.sha256sum] = "442e32b16dafa38ec5532a3fa0d5bf33c529dff9a90dfdc8991037f3751a1866"

URI_aarch64_rust-tree-sitter-c-sharp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-c-sharp+default-devel-0.23.5-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-c-sharp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-c-sharp+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-c-sharp+default-devel.sha256sum] = "d7f9576ae7015752910d9888d300435692a881e9c1ccc3cb3001332e9a5bcdb4"

URI_aarch64_rust-tree-sitter-c-sharp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-c-sharp-devel-0.23.5-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-c-sharp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-c-sharp-devel}"
SRC_URI[aarch64_rust-tree-sitter-c-sharp-devel.sha256sum] = "b02c70e28b440d185657bb5c056e21cf4d6d1f4777a8d9a2b0680b1afbb00081"

RDEPENDS:rust-tree-sitter-c-sharp+default-devel = " \
 cargo \
 rust-tree-sitter-c-sharp-devel \
 "
RDEPENDS:rust-tree-sitter-c-sharp-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
