# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xfontsel"
PV = "1.1.2"
PR = "2.el10_3"
PACKAGES = " \
 xfontsel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xfontsel-1.1.2-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2eda928924e9a02bed68497a7a4c8aad1f2bfa6d37dbb326c7afc7eb3fbdf75d"

URI_x86_64_v2_xfontsel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xfontsel-1.1.2-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xfontsel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfontsel}"
SRC_URI[x86_64_v2_xfontsel.sha256sum] = "2b5239cc7c59ff4f0121e2514b5d0bb763297997e4a663555000f05be75b36ef"

URI_aarch64_xfontsel = "${EPEL_MIRROR}/aarch64/Packages/x/xfontsel-1.1.2-2.el10_3.aarch64.rpm;name=aarch64_xfontsel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfontsel}"
SRC_URI[aarch64_xfontsel.sha256sum] = "8ee3e4ecb365c79862d587bebca3add23725c38480469df64b525ba8a1e2fc1c"

RDEPENDS:xfontsel = " \
 glibc \
 libX11 \
 libXaw \
 libXmu \
 libXt \
 "
