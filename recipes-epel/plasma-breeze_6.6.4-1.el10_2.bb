# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-breeze"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 breeze-cursor-theme \
 plasma-breeze \
 plasma-breeze-common \
 plasma-breeze-qt6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-breeze-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55575245bb9642da6f1d65e3e5c3ceee3ed337bdbbaa1fa004f6d360ceb4e367"

URI_x86_64_v2_breeze-cursor-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-cursor-theme-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-cursor-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-cursor-theme}"
SRC_URI[x86_64_v2_breeze-cursor-theme.sha256sum] = "bd20742b106547c34c018b6f4b47441593818aed079e824e656e40f7903836a0"

URI_x86_64_v2_plasma-breeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-breeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-breeze}"
SRC_URI[x86_64_v2_plasma-breeze.sha256sum] = "4549d710741529e70c77e4d763069fda9481fd542a743deff7922c8bfd9b7369"

URI_x86_64_v2_plasma-breeze-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-common-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-breeze-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-breeze-common}"
SRC_URI[x86_64_v2_plasma-breeze-common.sha256sum] = "ab352347ef4e47bbc5c66fa4c98711b2357d662f2a064a23ca93c74f3bf28630"

URI_x86_64_v2_plasma-breeze-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-qt6-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-breeze-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-breeze-qt6}"
SRC_URI[x86_64_v2_plasma-breeze-qt6.sha256sum] = "760d155aacd8823b536f1184a1a91175f693e7c725c68def6b6b18f5e5fd254d"

URI_aarch64_breeze-cursor-theme = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-cursor-theme-6.6.4-1.el10_2.noarch.rpm;name=aarch64_breeze-cursor-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-cursor-theme}"
SRC_URI[aarch64_breeze-cursor-theme.sha256sum] = "96a3bee9a1ece55699440aad54eafd2ba73f9df95a8116f1aac6b72c520e8991"

URI_aarch64_plasma-breeze = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-breeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-breeze}"
SRC_URI[aarch64_plasma-breeze.sha256sum] = "14c25374909598e9489a3144aae42266849e1831bbf216cc1bbdd7fce24b335d"

URI_aarch64_plasma-breeze-common = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-common-6.6.4-1.el10_2.noarch.rpm;name=aarch64_plasma-breeze-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-breeze-common}"
SRC_URI[aarch64_plasma-breeze-common.sha256sum] = "97e66675d66028c0f7b28f32419a0911993d5e9a39b1ffa2a121e40960ffb92b"

URI_aarch64_plasma-breeze-qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-qt6-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-breeze-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-breeze-qt6}"
SRC_URI[aarch64_plasma-breeze-qt6.sha256sum] = "46b491fcf35d21dd22cb7086592368a271a21f77ddecbd8973665d92f015753b"

RDEPENDS:breeze-cursor-theme = " \
 "
RDEPENDS:plasma-breeze = " \
 cmake-filesystem \
 glibc \
 kdecoration \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 libstdc++ \
 plasma-breeze-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:plasma-breeze-common = " \
 "
RDEPENDS:plasma-breeze-qt6 = " \
 glibc \
 kf6-frameworkintegration-libs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-kwindowsystem \
 libstdc++ \
 plasma-breeze-common \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
