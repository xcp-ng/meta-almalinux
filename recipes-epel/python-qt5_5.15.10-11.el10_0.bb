# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-qt5"
PV = "5.15.10"
PR = "11.el10_0"
PACKAGES = " \
 python-qt5-doc \
 python-qt5-rpm-macros \
 python3-qt5 \
 python3-qt5-base \
 python3-qt5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-qt5-5.15.10-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f293249ca336d55cba6ed1a248085fb705d1481e74edc889cf23294ab85209a4"

URI_x86_64_v2_python-qt5-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-qt5-doc-5.15.10-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-qt5-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-qt5-doc}"
SRC_URI[x86_64_v2_python-qt5-doc.sha256sum] = "1337b306acef951655025b85cf8550fe822bfe399424485d3ce16aaf6fdfdcb1"

URI_x86_64_v2_python-qt5-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-qt5-rpm-macros-5.15.10-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-qt5-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-qt5-rpm-macros}"
SRC_URI[x86_64_v2_python-qt5-rpm-macros.sha256sum] = "b861150ee6d1fa3301561f81febf9218dd28697f959fb4211aa887332cf2c32a"

URI_x86_64_v2_python3-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-qt5-5.15.10-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-qt5}"
SRC_URI[x86_64_v2_python3-qt5.sha256sum] = "563a140fe6d5ad11d49573746efa7b8d10e4e4fba3f46296ad30de45a1684ced"

URI_x86_64_v2_python3-qt5-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-qt5-base-5.15.10-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-qt5-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-qt5-base}"
SRC_URI[x86_64_v2_python3-qt5-base.sha256sum] = "fadfd68d421b4df636bf8ce8c808e40b2484163ddb7877559fad98abf0055455"

URI_x86_64_v2_python3-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-qt5-devel-5.15.10-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-qt5-devel}"
SRC_URI[x86_64_v2_python3-qt5-devel.sha256sum] = "4f78e715bf601b6f604b898d5a02ddd2a89c155218ec3473adfd81903c0f7b51"

URI_aarch64_python-qt5-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-qt5-doc-5.15.10-11.el10_0.noarch.rpm;name=aarch64_python-qt5-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-qt5-doc}"
SRC_URI[aarch64_python-qt5-doc.sha256sum] = "72006b09a5f2caf8141c4db68db364c39b57586336c60d9ab0d1f58d4604ef5c"

URI_aarch64_python-qt5-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/p/python-qt5-rpm-macros-5.15.10-11.el10_0.noarch.rpm;name=aarch64_python-qt5-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-qt5-rpm-macros}"
SRC_URI[aarch64_python-qt5-rpm-macros.sha256sum] = "a63aae84348f8635b93c651002eef5475c855b225898ecf214e8e82471b7611f"

URI_aarch64_python3-qt5 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-qt5-5.15.10-11.el10_0.aarch64.rpm;name=aarch64_python3-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-qt5}"
SRC_URI[aarch64_python3-qt5.sha256sum] = "d0ad08bb9c5941195d94ca4d97d4df66672347b470f952de2962dbb6116bf66d"

URI_aarch64_python3-qt5-base = "${EPEL_MIRROR}/aarch64/Packages/p/python3-qt5-base-5.15.10-11.el10_0.aarch64.rpm;name=aarch64_python3-qt5-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-qt5-base}"
SRC_URI[aarch64_python3-qt5-base.sha256sum] = "e083f33a6d6792f384613ad6845f8dffeaeade8bcf8ac954aae82d07f62f25bd"

URI_aarch64_python3-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-qt5-devel-5.15.10-11.el10_0.aarch64.rpm;name=aarch64_python3-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-qt5-devel}"
SRC_URI[aarch64_python3-qt5-devel.sha256sum] = "c221a8c2b050e4708117279d9a6479f17f863a9aa45737644a4d700b378c4ad1"

RDEPENDS:python-qt5-doc = " \
 "
RDEPENDS:python-qt5-rpm-macros = " \
 "
RDEPENDS:python3-qt5 = " \
 glibc \
 libstdc++ \
 python3 \
 python3-qt5-base \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtconnectivity \
 qt5-qtdeclarative \
 qt5-qtlocation \
 qt5-qtmultimedia \
 qt5-qtsensors \
 qt5-qtserialport \
 qt5-qtsvg \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-help \
 qt5-qtwebchannel \
 qt5-qtwebsockets \
 qt5-qtx11extras \
 qt5-qtxmlpatterns \
 "
RDEPENDS:python3-qt5-base = " \
 bash \
 dbus-libs \
 glibc \
 libgcc \
 libstdc++ \
 python-qt5-rpm-macros \
 python3 \
 python3-dbus \
 python3-libs \
 python3-pyqt5-sip \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:python3-qt5-devel = " \
 python3-qt5 \
 qt5-qtbase-devel \
 "
