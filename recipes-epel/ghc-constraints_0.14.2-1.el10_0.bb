# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-constraints"
PV = "0.14.2"
PR = "1.el10_0"
PACKAGES = " \
 ghc-constraints \
 ghc-constraints-devel \
 ghc-constraints-doc \
 ghc-constraints-prof \
 ghc-type-equality \
 ghc-type-equality-devel \
 ghc-type-equality-doc \
 ghc-type-equality-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-constraints-0.14.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b628351b07ba2a1ec12fb5a822def3586d430d6648cc0b85dc0e9773fa9c0a82"

URI_x86_64_v2_ghc-constraints = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-constraints-0.14.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-constraints;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-constraints}"
SRC_URI[x86_64_v2_ghc-constraints.sha256sum] = "1064e2e87b9894ec747d61d5d08d86022f83fe3f405805e0476583f03e629460"

URI_x86_64_v2_ghc-constraints-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-constraints-devel-0.14.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-constraints-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-constraints-devel}"
SRC_URI[x86_64_v2_ghc-constraints-devel.sha256sum] = "77771530eb7b4998b70e0fa31ac104dd734edc373936132866429a156aec9ff0"

URI_x86_64_v2_ghc-constraints-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-constraints-doc-0.14.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-constraints-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-constraints-doc}"
SRC_URI[x86_64_v2_ghc-constraints-doc.sha256sum] = "6f76d86917a5e169687c92969759fa83a5852bcb5c72e6572c8c640651417cbd"

URI_x86_64_v2_ghc-constraints-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-constraints-prof-0.14.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-constraints-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-constraints-prof}"
SRC_URI[x86_64_v2_ghc-constraints-prof.sha256sum] = "9850fc642fb5b7390db4236c1061253e67b47764fcfacfd7392c5fd1ae6e70f2"

URI_x86_64_v2_ghc-type-equality = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-type-equality-1.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-type-equality;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-type-equality}"
SRC_URI[x86_64_v2_ghc-type-equality.sha256sum] = "a059f9901c5adad4811f926f2837c36e2028b9bf11410a4e6d3bc84f9a59d028"

URI_x86_64_v2_ghc-type-equality-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-type-equality-devel-1.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-type-equality-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-type-equality-devel}"
SRC_URI[x86_64_v2_ghc-type-equality-devel.sha256sum] = "01d397348323d5e15af95e60d265b0f0335cdc97cb0679053d81d4189aff90a9"

URI_x86_64_v2_ghc-type-equality-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-type-equality-doc-1.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-type-equality-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-type-equality-doc}"
SRC_URI[x86_64_v2_ghc-type-equality-doc.sha256sum] = "5afd964357c22d54b207b2c87a0be7d4c55c3292e1685c1a8b664ec178851882"

URI_x86_64_v2_ghc-type-equality-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-type-equality-prof-1.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-type-equality-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-type-equality-prof}"
SRC_URI[x86_64_v2_ghc-type-equality-prof.sha256sum] = "08168cf27249ef9c3d5d697923a5697c020cfc40c8ba5e37d8ba422f20c6009e"

URI_aarch64_ghc-constraints = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-constraints-0.14.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-constraints;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-constraints}"
SRC_URI[aarch64_ghc-constraints.sha256sum] = "79972168712b176c277bfa24a8f3f2ca42ffbdf4d05d1ced901a9a502724992f"

URI_aarch64_ghc-constraints-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-constraints-devel-0.14.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-constraints-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-constraints-devel}"
SRC_URI[aarch64_ghc-constraints-devel.sha256sum] = "766099aa42cd9aeec7750ed79b60e607eb29ae2ec72ce58f34782d12c5019f69"

URI_aarch64_ghc-constraints-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-constraints-doc-0.14.2-1.el10_0.noarch.rpm;name=aarch64_ghc-constraints-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-constraints-doc}"
SRC_URI[aarch64_ghc-constraints-doc.sha256sum] = "bbd359863a1d2fad3e6b7117fc0a92d3f4b3be04b2daedfdc699d57b78d50dbb"

URI_aarch64_ghc-constraints-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-constraints-prof-0.14.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-constraints-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-constraints-prof}"
SRC_URI[aarch64_ghc-constraints-prof.sha256sum] = "7ea77bd4d5d2bf1ce3f7065a1844cf0f95a426d664286cd39a6702a2316bb457"

URI_aarch64_ghc-type-equality = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-type-equality-1.0.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-type-equality;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-type-equality}"
SRC_URI[aarch64_ghc-type-equality.sha256sum] = "3fe159030259e8f358c6d9f95b10eec0df76ac24a5aebe7ce38b296f8e65d6c8"

URI_aarch64_ghc-type-equality-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-type-equality-devel-1.0.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-type-equality-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-type-equality-devel}"
SRC_URI[aarch64_ghc-type-equality-devel.sha256sum] = "b759ac93845970d08c7ab5c2177bc646b2a1d043fa31c9f51b9d69d441360966"

URI_aarch64_ghc-type-equality-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-type-equality-doc-1.0.1-1.el10_0.noarch.rpm;name=aarch64_ghc-type-equality-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-type-equality-doc}"
SRC_URI[aarch64_ghc-type-equality-doc.sha256sum] = "ea56bd656d2bac01377c7a3f6468ee71083f96926940b0528e2e46550b3a3581"

URI_aarch64_ghc-type-equality-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-type-equality-prof-1.0.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-type-equality-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-type-equality-prof}"
SRC_URI[aarch64_ghc-type-equality-prof.sha256sum] = "b0c2968e75acda7c4935090f9a33b9c144152b9b2eab3b5a11d1d2c70927dca3"

RDEPENDS:ghc-constraints = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-boring \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-constraints-devel = " \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-boring-devel \
 ghc-compiler \
 ghc-constraints \
 ghc-deepseq-devel \
 ghc-hashable-devel \
 ghc-mtl-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-constraints-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-constraints-prof = " \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-boring-prof \
 ghc-constraints-devel \
 ghc-deepseq-prof \
 ghc-hashable-prof \
 ghc-mtl-prof \
 ghc-transformers-prof \
 "
RDEPENDS:ghc-type-equality = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-type-equality-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-type-equality \
 "
RDEPENDS:ghc-type-equality-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-type-equality-prof = " \
 ghc-base-prof \
 ghc-type-equality-devel \
 "
