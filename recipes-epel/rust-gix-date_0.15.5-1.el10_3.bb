# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-date"
PV = "0.15.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-date+default-devel \
 rust-gix-date+document-features-devel \
 rust-gix-date+serde-devel \
 rust-gix-date-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-date-0.15.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91307ea980839e93817223ab36b071762f9010c24363e4f432b770bbb70088cb"

URI_x86_64_v2_rust-gix-date+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date+default-devel-0.15.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date+default-devel}"
SRC_URI[x86_64_v2_rust-gix-date+default-devel.sha256sum] = "8bd20afafca8a9c14808f04ba89f5f5589a136caf9852017048fe6d752819d1d"

URI_x86_64_v2_rust-gix-date+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date+document-features-devel-0.15.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-date+document-features-devel.sha256sum] = "5b947d932e7b1c5c7552e293a718761013cc8623b20c572d1e58c1d7d71171d1"

URI_x86_64_v2_rust-gix-date+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date+serde-devel-0.15.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-date+serde-devel.sha256sum] = "24cbd34cc8e83902b21c94c1dd11492d5054155ab044cf41ce0be15bf1fb502f"

URI_x86_64_v2_rust-gix-date-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date-devel-0.15.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date-devel}"
SRC_URI[x86_64_v2_rust-gix-date-devel.sha256sum] = "24804cf334e5654480eef9678599696bfe3888b48156249e9dde47e66c885b07"

URI_aarch64_rust-gix-date+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date+default-devel-0.15.5-1.el10_3.noarch.rpm;name=aarch64_rust-gix-date+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date+default-devel}"
SRC_URI[aarch64_rust-gix-date+default-devel.sha256sum] = "d5a1a8e903c877e4ce01efeb797bf20c2efe037bf781d0d5bf4cb6bd57c82325"

URI_aarch64_rust-gix-date+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date+document-features-devel-0.15.5-1.el10_3.noarch.rpm;name=aarch64_rust-gix-date+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date+document-features-devel}"
SRC_URI[aarch64_rust-gix-date+document-features-devel.sha256sum] = "c6f436e863081bf291ae7dbef0fd41093b77f38b32f8c987ad340a60a97db941"

URI_aarch64_rust-gix-date+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date+serde-devel-0.15.5-1.el10_3.noarch.rpm;name=aarch64_rust-gix-date+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date+serde-devel}"
SRC_URI[aarch64_rust-gix-date+serde-devel.sha256sum] = "ccf6384b48d8cf479399eec8a1f9639077ae6e31490c12d91da26af2f82e604d"

URI_aarch64_rust-gix-date-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date-devel-0.15.5-1.el10_3.noarch.rpm;name=aarch64_rust-gix-date-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date-devel}"
SRC_URI[aarch64_rust-gix-date-devel.sha256sum] = "c1f1b3663a214e1cc31fde434562c20051a525c8e2217994e6f0d614b9e6f9bb"

RDEPENDS:rust-gix-date+default-devel = " \
 cargo \
 rust-gix-date-devel \
 "
RDEPENDS:rust-gix-date+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-date-devel \
 "
RDEPENDS:rust-gix-date+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-date-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-date-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-error+default-devel \
 rust-itoa+default-devel \
 rust-jiff+default-devel \
 "
