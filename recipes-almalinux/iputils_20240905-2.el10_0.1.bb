# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iputils"
PV = "20240905"
PR = "2.el10_0.1"
PACKAGES = " \
 iputils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iputils-20240905-2.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d48fd892abcf4e4aeeca311de3774700a3162c2225234f379ceb53fd419946d5"

URI_x86_64_v2_iputils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iputils-20240905-2.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_iputils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iputils}"
SRC_URI[x86_64_v2_iputils.sha256sum] = "772c5149a230e1b4e1e5b916035d1bf418208bcbace9755a40e1f1354e0d11ac"

URI_aarch64_iputils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iputils-20240905-2.el10_0.1.aarch64.rpm;name=aarch64_iputils;unpack=0"
SRC_URI:append = " ${URI_aarch64_iputils}"
SRC_URI[aarch64_iputils.sha256sum] = "67e49e506a0c3897cea3470ce3b91926f34ffe4d3bfae65d1985e205f1edcd47"

RDEPENDS:iputils = " \
 glibc \
 libcap \
 libidn2 \
 "
