# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freerdp2"
PV = "2.11.7"
PR = "7.el10_3"
PACKAGES = " \
 freerdp2-devel \
 freerdp2-libs \
 libwinpr2 \
 libwinpr2-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/freerdp2-2.11.7-7.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2fb66bf11e47444e5afd297fe83490913d9b42597e71bcc5fb61e0c58e5616d2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freerdp2-devel-2.11.7-7.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freerdp2-devel;unpack=0"
SRC_URI[x86_64_v2_freerdp2-devel.sha256sum] = "a272c04b900b9dbc78ae6ee6e2a8dbec657be6893f715dbb9e0c297fdf976640"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freerdp2-libs-2.11.7-7.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freerdp2-libs;unpack=0"
SRC_URI[x86_64_v2_freerdp2-libs.sha256sum] = "eaa8b8f0255ea51fa91b35ca4789aeb56580d69e588c013a1a0755b163247e65"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwinpr2-2.11.7-7.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwinpr2;unpack=0"
SRC_URI[x86_64_v2_libwinpr2.sha256sum] = "e0f4c470e651402a0b28279625e509eb53e39c8c50537003d7113e2fdf0221eb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwinpr2-devel-2.11.7-7.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwinpr2-devel;unpack=0"
SRC_URI[x86_64_v2_libwinpr2-devel.sha256sum] = "9b9548ae45fc5a4b03c505ba61aa0599c6fc9de1414e36fa6c4e49cab8c4adfb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/freerdp2-devel-2.11.7-7.el10_3.aarch64.rpm;name=aarch64_freerdp2-devel;unpack=0"
SRC_URI[aarch64_freerdp2-devel.sha256sum] = "a2b8202b66a6219fbec2390a40fa4dc2c52d8dff43ea10f54cea0b7be035a68e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/freerdp2-libs-2.11.7-7.el10_3.aarch64.rpm;name=aarch64_freerdp2-libs;unpack=0"
SRC_URI[aarch64_freerdp2-libs.sha256sum] = "a63c55866d441deb60950f6de40130ccad127f16d11e3dfea95d50f73fccd474"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libwinpr2-2.11.7-7.el10_3.aarch64.rpm;name=aarch64_libwinpr2;unpack=0"
SRC_URI[aarch64_libwinpr2.sha256sum] = "890d452ec8073299db8220504f58cca3ae32096b586eaeed19d5e37abeeae451"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libwinpr2-devel-2.11.7-7.el10_3.aarch64.rpm;name=aarch64_libwinpr2-devel;unpack=0"
SRC_URI[aarch64_libwinpr2-devel.sha256sum] = "b0258685e3a6f9a7b79da8a0f833929dc98c9a3e44a3534288ae7c8ef00f06e8"

RDEPENDS:freerdp2-devel = " \
 cmake \
 cmake-filesystem \
 freerdp2-devel \
 freerdp2-libs \
 libwinpr2-devel \
 libxkbcommon-devel \
 openssl-devel \
 pkgconf-pkg-config \
 wayland-devel \
 "
RDEPENDS:freerdp2-libs = " \
 alsa-lib \
 cairo \
 cups-libs \
 glibc \
 gsm \
 lame-libs \
 libX11 \
 libXdamage \
 libXext \
 libXfixes \
 libXinerama \
 libXtst \
 libjpeg-turbo \
 libusb1 \
 libwayland-client \
 libwayland-cursor \
 libwinpr2 \
 libxkbcommon \
 libxkbfile \
 noopenh264 \
 openssl-libs \
 pam-libs \
 pulseaudio-libs \
 "
RDEPENDS:libwinpr2 = " \
 glibc \
 libicu \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:libwinpr2-devel = " \
 cmake \
 cmake-filesystem \
 libwinpr2 \
 libwinpr2-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
