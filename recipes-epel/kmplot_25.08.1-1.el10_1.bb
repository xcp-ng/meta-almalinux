# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmplot"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kmplot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmplot-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7655950c6cce211737379c5256811c33624ad74396779ebd148fb3772ac6f9b2"

URI_x86_64_v2_kmplot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmplot-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmplot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmplot}"
SRC_URI[x86_64_v2_kmplot.sha256sum] = "7bb4259f7dd70ca0d2ca5226318b91b49ae91efff83888c46fd37fe27dde4ec7"

URI_aarch64_kmplot = "${EPEL_MIRROR}/aarch64/Packages/k/kmplot-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kmplot;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmplot}"
SRC_URI[aarch64_kmplot.sha256sum] = "ca0b2e012bd36bade72be28c0fc6ba2289313f38ea38d08f49bdc46da8679bfc"

RDEPENDS:kmplot = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
