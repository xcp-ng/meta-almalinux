# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kpackage"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kpackage \
 kf6-kpackage-devel \
 kf6-kpackage-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kpackage-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21330f0dd1449fcfe344775fd58bf6b310c993f4d730f54217335946da28d42f"

URI_x86_64_v2_kf6-kpackage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpackage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage}"
SRC_URI[x86_64_v2_kf6-kpackage.sha256sum] = "50611e2b97e38da058f2b9a206a98ef7485628d63d836299f900185782f38353"

URI_x86_64_v2_kf6-kpackage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpackage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage-devel}"
SRC_URI[x86_64_v2_kf6-kpackage-devel.sha256sum] = "2806a6fbad60eed1f740a5d4ee2057736b1064a66fd4ce08f0ef8196c50433be"

URI_x86_64_v2_kf6-kpackage-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpackage-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage-doc}"
SRC_URI[x86_64_v2_kf6-kpackage-doc.sha256sum] = "9cf85b0734da80bd63512c495285a71e52c8d273a0c8d323db43fe44ad76ac12"

URI_aarch64_kf6-kpackage = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kpackage;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage}"
SRC_URI[aarch64_kf6-kpackage.sha256sum] = "030ea257169531df7a2f03e68bed62d57456187afd5bc08237c56d08f27db45b"

URI_aarch64_kf6-kpackage-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kpackage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage-devel}"
SRC_URI[aarch64_kf6-kpackage-devel.sha256sum] = "053ec1fa6b62c0efee9353abb648e7fbcc37de46b71367120afd4c5c566ae2bf"

URI_aarch64_kf6-kpackage-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kpackage-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage-doc}"
SRC_URI[aarch64_kf6-kpackage-doc.sha256sum] = "227b14fbf40ac5b88df7204e2ef8522b221f70a0d7d7244be79da20892b85440"

RDEPENDS:kf6-kpackage = " \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kpackage-devel = " \
 cmake-filesystem \
 kf6-kpackage \
 "
RDEPENDS:kf6-kpackage-doc = " \
 "
