# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalk"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kalk \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kalk-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7cf4f4c50f6cdde79d0b56389572c30c14f6baaf82c1a195efc91f521754ec4f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalk-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalk;unpack=0"
SRC_URI[x86_64_v2_kalk.sha256sum] = "e2586a4956035c8d0a185901a5b02e207d14a91c43552f384f062d0d09e1f068"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kalk-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kalk;unpack=0"
SRC_URI[aarch64_kalk.sha256sum] = "b5864e11245c0d16b4b1995bfca19d26b82490ceca7905ce631d999c6fc4fc5e"

RDEPENDS:kalk = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kunitconversion \
 kf6-qqc2-desktop-style \
 kf6-sonnet \
 libqalculate \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
