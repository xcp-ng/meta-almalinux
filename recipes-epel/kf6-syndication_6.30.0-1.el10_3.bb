# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-syndication"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-syndication \
 kf6-syndication-devel \
 kf6-syndication-doc \
 kf6-syndication-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-syndication-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c1eb4cc2687220b493efd2fb5a0b9cb94279545fe8a9b465ad0ef0e43b6e9243"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syndication;unpack=0"
SRC_URI[x86_64_v2_kf6-syndication.sha256sum] = "4d4f7e57db8ac4d5716dd52391682f783db7eeedb445df64ce8efd16ac87f097"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syndication-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-syndication-devel.sha256sum] = "fa236b85ae50219bfcd83945ae2842ce9d94d42334c12655be3b3b5b005b9ad8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syndication-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-syndication-doc.sha256sum] = "14787ea5d82ed09207be1432a53ceffcd58525ce2d496a7dc9cf8239fb15a969"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syndication-html;unpack=0"
SRC_URI[x86_64_v2_kf6-syndication-html.sha256sum] = "c862d41ce5ca2c064f1fedf5bf70c350cceb64e90d30d1d5cccb4e41e825f7f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-syndication;unpack=0"
SRC_URI[aarch64_kf6-syndication.sha256sum] = "0d0dd8d1f465b638b3f73344a5eeed25704077519648e06ab39e825a60180cbc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-syndication-devel;unpack=0"
SRC_URI[aarch64_kf6-syndication-devel.sha256sum] = "cddf108a0dff97506214f3ecc46332a243be31d1e0d3190446984da7caa45699"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-syndication-doc;unpack=0"
SRC_URI[aarch64_kf6-syndication-doc.sha256sum] = "8faf7598169759d1e5b8333598c6a77757046aef15966492e6a9bc74172ad0e1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-syndication-html;unpack=0"
SRC_URI[aarch64_kf6-syndication-html.sha256sum] = "adb5597641a537937daee5a41cdf5de6b15b88e851cbaff258e4c41f35423566"

RDEPENDS:kf6-syndication = " \
 glibc \
 kf6-filesystem \
 kf6-kcodecs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-syndication-devel = " \
 cmake-filesystem \
 kf6-syndication \
 "
RDEPENDS:kf6-syndication-doc = " \
 "
RDEPENDS:kf6-syndication-html = " \
 "
