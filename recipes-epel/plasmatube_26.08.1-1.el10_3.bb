# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasmatube"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 plasmatube \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasmatube-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "68dbae70e08ab956d0c4a3d6c5f9f055a65c8d1fb2b2bdeab684d8f599a4854e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasmatube-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasmatube;unpack=0"
SRC_URI[x86_64_v2_plasmatube.sha256sum] = "635c27ccb37d4ebf8b211b75cbab5aab1122f3cbc14abd8bafa177b2cb0461d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasmatube-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_plasmatube;unpack=0"
SRC_URI[aarch64_plasmatube.sha256sum] = "78f610b72d5b8a992aa02f3f4c6dc0c4049db74a36a8f75f3da7bccc0214c286"

RDEPENDS:plasmatube = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kwindowsystem \
 kf6-purpose \
 libstdc++ \
 mpvqt \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qtkeychain-qt6 \
 "
