# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cfg-if"
PV = "1.0.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-cfg-if+default-devel \
 rust-cfg-if-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cfg-if-1.0.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7aac790da744a7ca66c9ef9ebf9c143f963eaa8b3bb9b3e9d26457c7219f3c30"

URI_x86_64_v2_rust-cfg-if+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-if+default-devel-1.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-if+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-if+default-devel}"
SRC_URI[x86_64_v2_rust-cfg-if+default-devel.sha256sum] = "c352422dc80d63a340a0bef7290419969c60efa3e31979de3c5556c403908855"

URI_x86_64_v2_rust-cfg-if-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-if-devel-1.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-if-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-if-devel}"
SRC_URI[x86_64_v2_rust-cfg-if-devel.sha256sum] = "f3e3893b4e19a847e2c6eb558d41184086c844a32a74e4bbd1282c654bd729f2"

URI_aarch64_rust-cfg-if+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-if+default-devel-1.0.4-1.el10_1.noarch.rpm;name=aarch64_rust-cfg-if+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-if+default-devel}"
SRC_URI[aarch64_rust-cfg-if+default-devel.sha256sum] = "356c82d930ee78d326762a519480d3ce1a1a65653c4a4ff3c878179c8ebd56cf"

URI_aarch64_rust-cfg-if-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-if-devel-1.0.4-1.el10_1.noarch.rpm;name=aarch64_rust-cfg-if-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-if-devel}"
SRC_URI[aarch64_rust-cfg-if-devel.sha256sum] = "693afe3df97b946cd923b9db2269336f65dc4e824fb64fe0dfffd05dbd31aad8"

RDEPENDS:rust-cfg-if+default-devel = " \
 cargo \
 rust-cfg-if-devel \
 "
RDEPENDS:rust-cfg-if-devel = " \
 cargo \
 rust \
 "
