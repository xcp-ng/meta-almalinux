# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "elfutils"
PV = "0.195"
PR = "1.el10"
PACKAGES = " \
 elfutils \
 elfutils-debuginfod \
 elfutils-debuginfod-client \
 elfutils-debuginfod-client-devel \
 elfutils-default-yama-scope \
 elfutils-devel \
 elfutils-libelf \
 elfutils-libelf-devel \
 elfutils-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/elfutils-0.195-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3baafaa0d589a5b31574180f7c753005949fbbfaff765a4a789e9d6959f2dcc"

URI_x86_64_v2_elfutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-0.195-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils}"
SRC_URI[x86_64_v2_elfutils.sha256sum] = "d5bccd4fd628a011e8368b9bea881f82d835e5202d9a3594ee96da18daffafca"

URI_x86_64_v2_elfutils-debuginfod = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-debuginfod-0.195-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils-debuginfod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-debuginfod}"
SRC_URI[x86_64_v2_elfutils-debuginfod.sha256sum] = "5d1b2df5e5e7624635ceb0d88c50779fde2c2f8a667f7ec6739e2736b22cc574"

URI_x86_64_v2_elfutils-debuginfod-client = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-debuginfod-client-0.195-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils-debuginfod-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-debuginfod-client}"
SRC_URI[x86_64_v2_elfutils-debuginfod-client.sha256sum] = "93d25ea5ea2327b09c3cf7ac22ce54f2dffefccf9094d80009ef585cf8c5f129"

URI_x86_64_v2_elfutils-debuginfod-client-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-debuginfod-client-devel-0.195-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils-debuginfod-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-debuginfod-client-devel}"
SRC_URI[x86_64_v2_elfutils-debuginfod-client-devel.sha256sum] = "0f48347af458dce2d2e43628bd6fad3d451457b952ecb632ccacdea885a023ea"

URI_x86_64_v2_elfutils-default-yama-scope = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-default-yama-scope-0.195-1.el10.noarch.rpm;name=x86_64_v2_elfutils-default-yama-scope;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-default-yama-scope}"
SRC_URI[x86_64_v2_elfutils-default-yama-scope.sha256sum] = "226f77f16718b5064e0f473e298140bccdbe8b7ab227dec4e8f50f4ab45f70ec"

URI_x86_64_v2_elfutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-devel-0.195-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-devel}"
SRC_URI[x86_64_v2_elfutils-devel.sha256sum] = "2e3e95fa41f4880cba14c3582b52867e85f2a08a37d53918b4e5c164d253dbe5"

URI_x86_64_v2_elfutils-libelf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-libelf-0.195-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils-libelf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-libelf}"
SRC_URI[x86_64_v2_elfutils-libelf.sha256sum] = "2232e8e6c1a894c88fb3e834e72efcd87253d7b8334e6d2bd1e2046beac7c023"

URI_x86_64_v2_elfutils-libelf-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-libelf-devel-0.195-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-libelf-devel}"
SRC_URI[x86_64_v2_elfutils-libelf-devel.sha256sum] = "5cac343e253522e75000c6e5224cd41b6423c0bdafc95bc4d18ecf80dacd7e71"

URI_x86_64_v2_elfutils-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-libs-0.195-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-libs}"
SRC_URI[x86_64_v2_elfutils-libs.sha256sum] = "bc7832728323a9f40908c3208f54d1b2b237ec715a109b64477ddfe6670cfaf0"

URI_aarch64_elfutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-0.195-1.el10.aarch64.rpm;name=aarch64_elfutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils}"
SRC_URI[aarch64_elfutils.sha256sum] = "5bb63a4d93cd30db3d80f3f947fe0e9309ec5df7a3d4c5b6481a81d5cf2d07b6"

URI_aarch64_elfutils-debuginfod = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-debuginfod-0.195-1.el10.aarch64.rpm;name=aarch64_elfutils-debuginfod;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-debuginfod}"
SRC_URI[aarch64_elfutils-debuginfod.sha256sum] = "8b2201c8aa3a37391262fa96648e6f96a93c451842b82b16795ffe95bf2ad449"

URI_aarch64_elfutils-debuginfod-client = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-debuginfod-client-0.195-1.el10.aarch64.rpm;name=aarch64_elfutils-debuginfod-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-debuginfod-client}"
SRC_URI[aarch64_elfutils-debuginfod-client.sha256sum] = "7895a0016b9fe3ea9448d2e8a02885fa3d6a8660e33d3061dda098a735c6710d"

URI_aarch64_elfutils-debuginfod-client-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-debuginfod-client-devel-0.195-1.el10.aarch64.rpm;name=aarch64_elfutils-debuginfod-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-debuginfod-client-devel}"
SRC_URI[aarch64_elfutils-debuginfod-client-devel.sha256sum] = "9a9aeeab843d11c0358f50c2fd1aa5bd4cb34c0a2ec9f793671c0d3924cb9b78"

URI_aarch64_elfutils-default-yama-scope = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-default-yama-scope-0.195-1.el10.noarch.rpm;name=aarch64_elfutils-default-yama-scope;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-default-yama-scope}"
SRC_URI[aarch64_elfutils-default-yama-scope.sha256sum] = "226f77f16718b5064e0f473e298140bccdbe8b7ab227dec4e8f50f4ab45f70ec"

URI_aarch64_elfutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-devel-0.195-1.el10.aarch64.rpm;name=aarch64_elfutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-devel}"
SRC_URI[aarch64_elfutils-devel.sha256sum] = "8840af60200b8546b55724b6846979761e04415d8cf17fadfcf6fd949e185145"

URI_aarch64_elfutils-libelf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-libelf-0.195-1.el10.aarch64.rpm;name=aarch64_elfutils-libelf;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-libelf}"
SRC_URI[aarch64_elfutils-libelf.sha256sum] = "f83106d5db54ff95e5780c31d0f67ddce2aaa538be99a2d3d52a7920e7f5e306"

URI_aarch64_elfutils-libelf-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-libelf-devel-0.195-1.el10.aarch64.rpm;name=aarch64_elfutils-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-libelf-devel}"
SRC_URI[aarch64_elfutils-libelf-devel.sha256sum] = "1d01af0de8777dd6522034be4bfe89d5fece9a8760652da9be1a365c644bc009"

URI_aarch64_elfutils-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-libs-0.195-1.el10.aarch64.rpm;name=aarch64_elfutils-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-libs}"
SRC_URI[aarch64_elfutils-libs.sha256sum] = "de728bf983bdccebe1749239695582b858371dc0dbf79bb2e05c279ab0f262d1"

RDEPENDS:elfutils = " \
 bash \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libarchive \
 libgcc \
 libstdc++ \
 "
RDEPENDS:elfutils-debuginfod = " \
 bash \
 bsdtar \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 json-c \
 libarchive \
 libgcc \
 libmicrohttpd \
 libstdc++ \
 rpm-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 xz-libs \
 "
RDEPENDS:elfutils-debuginfod-client = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 json-c \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:elfutils-debuginfod-client-devel = " \
 elfutils-debuginfod-client \
 pkgconf-pkg-config \
 "
RDEPENDS:elfutils-default-yama-scope = " \
 bash \
 "
RDEPENDS:elfutils-devel = " \
 elfutils-libelf-devel \
 elfutils-libs \
 libzstd-devel \
 pkgconf-pkg-config \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:elfutils-libelf = " \
 glibc \
 libzstd \
 zlib-ng-compat \
 "
RDEPENDS:elfutils-libelf-devel = " \
 elfutils-libelf \
 libzstd-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:elfutils-libs = " \
 bzip2-libs \
 elfutils-default-yama-scope \
 elfutils-libelf \
 glibc \
 libzstd \
 xz-libs \
 zlib-ng-compat \
 "
