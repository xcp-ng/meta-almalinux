# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ps_mem"
PV = "3.14"
PR = "9.el10"
PACKAGES = " \
 ps_mem \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ps_mem-3.14-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb067e489d7145c5093c6d31a52af230c49194edb0f59d923878d332a3825ddb"

URI_x86_64_v2_ps_mem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ps_mem-3.14-9.el10.noarch.rpm;name=x86_64_v2_ps_mem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ps_mem}"
SRC_URI[x86_64_v2_ps_mem.sha256sum] = "6a27caedfefe09f58effa5f13aea004a97940aaa7c84f7a44514ba0290abd9af"

URI_aarch64_ps_mem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ps_mem-3.14-9.el10.noarch.rpm;name=aarch64_ps_mem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ps_mem}"
SRC_URI[aarch64_ps_mem.sha256sum] = "6a27caedfefe09f58effa5f13aea004a97940aaa7c84f7a44514ba0290abd9af"

RDEPENDS:ps_mem = " \
 python3 \
 "
