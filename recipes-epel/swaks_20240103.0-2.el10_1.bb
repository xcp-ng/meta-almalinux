# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "swaks"
PV = "20240103.0"
PR = "2.el10_1"
PACKAGES = " \
 swaks \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/swaks-20240103.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0bfcad4e0238d3daeb1b324f6e1b65e65c5c0080051458d0b22a9ed5baa687dd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/swaks-20240103.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_swaks;unpack=0"
SRC_URI[x86_64_v2_swaks.sha256sum] = "d3162c741f9b9ce281bf884957603d29a323540ac59306d0461f12bfec6b75d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/swaks-20240103.0-2.el10_1.noarch.rpm;name=aarch64_swaks;unpack=0"
SRC_URI[aarch64_swaks.sha256sum] = "227065ab63b48bd05f28cac9dbf27238c4687745feff4298ca17fc9549322071"

RDEPENDS:swaks = " \
 perl-Authen-DigestMD5 \
 perl-Authen-SASL \
 perl-Digest-SHA \
 perl-IO-Socket-IP \
 perl-NTLM \
 perl-Net-DNS \
 perl-Net-SSLeay \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Time-HiRes \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
