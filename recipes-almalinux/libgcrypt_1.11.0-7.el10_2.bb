# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgcrypt"
PV = "1.11.0"
PR = "7.el10_2"
PACKAGES = " \
 libgcrypt \
 libgcrypt-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libgcrypt-1.11.0-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "515dc8730351cca1596ec7be5766b8b348d6b350aaed4c61b41b15c4d82027a6"

URI_x86_64_v2_libgcrypt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgcrypt-1.11.0-7.el10_2.x86_64_v2.rpm;name=x86_64_v2_libgcrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgcrypt}"
SRC_URI[x86_64_v2_libgcrypt.sha256sum] = "6fce4c1d4db169d58dc1e10348c2f12dfeb7e45492a3796154c9f8c0e2486994"

URI_x86_64_v2_libgcrypt-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgcrypt-devel-1.11.0-7.el10_2.x86_64_v2.rpm;name=x86_64_v2_libgcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgcrypt-devel}"
SRC_URI[x86_64_v2_libgcrypt-devel.sha256sum] = "e6b885077bd8a779bfdb13740abf81cbe2ca7d129494b989143e853384d5df72"

URI_aarch64_libgcrypt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgcrypt-1.11.0-7.el10_2.aarch64.rpm;name=aarch64_libgcrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgcrypt}"
SRC_URI[aarch64_libgcrypt.sha256sum] = "d9c0035d76f1f0ab9210edef29eb1332f0149c7fc23d790890cfabc29f856354"

URI_aarch64_libgcrypt-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgcrypt-devel-1.11.0-7.el10_2.aarch64.rpm;name=aarch64_libgcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgcrypt-devel}"
SRC_URI[aarch64_libgcrypt-devel.sha256sum] = "0ec71cfef23a624d6e88846e68bd81e00635aa613d72e4ab90f64c005a8f292d"

RDEPENDS:libgcrypt = " \
 glibc \
 libgpg-error \
 "
RDEPENDS:libgcrypt-devel = " \
 bash \
 glibc \
 libgcrypt \
 libgpg-error \
 libgpg-error-devel \
 pkgconf-pkg-config \
 "
