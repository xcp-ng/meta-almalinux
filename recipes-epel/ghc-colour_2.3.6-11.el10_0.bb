# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-colour"
PV = "2.3.6"
PR = "11.el10_0"
PACKAGES = " \
 ghc-colour \
 ghc-colour-devel \
 ghc-colour-doc \
 ghc-colour-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-colour-2.3.6-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39b4d5c39139fe2b81eeb89d17868c2575c1c013d6088487c39f3bad18b6bad7"

URI_x86_64_v2_ghc-colour = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-colour-2.3.6-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-colour;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-colour}"
SRC_URI[x86_64_v2_ghc-colour.sha256sum] = "b4870d86ed82959301f15c4a223fd222a50c66e73c1ef2a49aa68549c9dc3b94"

URI_x86_64_v2_ghc-colour-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-colour-devel-2.3.6-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-colour-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-colour-devel}"
SRC_URI[x86_64_v2_ghc-colour-devel.sha256sum] = "626cbaf9274f64bf4d2da04dec76f4745294f0b7a3b62a19873276c1b07defee"

URI_x86_64_v2_ghc-colour-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-colour-doc-2.3.6-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-colour-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-colour-doc}"
SRC_URI[x86_64_v2_ghc-colour-doc.sha256sum] = "1541a9bc6c3047abb31ed673837f7d19c549333961c0742f3ad1948fa08086f7"

URI_x86_64_v2_ghc-colour-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-colour-prof-2.3.6-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-colour-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-colour-prof}"
SRC_URI[x86_64_v2_ghc-colour-prof.sha256sum] = "0d08d52965ac7ae4d51c0d0aedeebff5419655e312c5bdf24b2f239c12fe75d5"

URI_aarch64_ghc-colour = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-colour-2.3.6-11.el10_0.aarch64.rpm;name=aarch64_ghc-colour;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-colour}"
SRC_URI[aarch64_ghc-colour.sha256sum] = "a6a533e35a2d5f2920b687a83fb3fd547204a69505f5f6eebac0ec40a7789c85"

URI_aarch64_ghc-colour-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-colour-devel-2.3.6-11.el10_0.aarch64.rpm;name=aarch64_ghc-colour-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-colour-devel}"
SRC_URI[aarch64_ghc-colour-devel.sha256sum] = "575caab212c6f90b2279f3321450ae1e53b921a7a633f23c2206e082dda4ca29"

URI_aarch64_ghc-colour-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-colour-doc-2.3.6-11.el10_0.noarch.rpm;name=aarch64_ghc-colour-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-colour-doc}"
SRC_URI[aarch64_ghc-colour-doc.sha256sum] = "00e290c94388c76b1d5ff40c8d1c0fa2888fd48e7e6dcaf0e723bb426c5fb262"

URI_aarch64_ghc-colour-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-colour-prof-2.3.6-11.el10_0.aarch64.rpm;name=aarch64_ghc-colour-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-colour-prof}"
SRC_URI[aarch64_ghc-colour-prof.sha256sum] = "6f69af9d4ca79bd7fd11bb79a49997c54195673c95268eba4d024cfbf5a4aee3"

RDEPENDS:ghc-colour = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-colour-devel = " \
 ghc-base-devel \
 ghc-colour \
 ghc-compiler \
 "
RDEPENDS:ghc-colour-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-colour-prof = " \
 ghc-base-prof \
 ghc-colour-devel \
 "
