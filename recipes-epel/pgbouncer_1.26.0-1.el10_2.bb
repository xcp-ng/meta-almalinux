# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pgbouncer"
PV = "1.26.0"
PR = "1.el10_2"
PACKAGES = " \
 pgbouncer \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pgbouncer-1.26.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "98d8b676847501f5adf3c6d336ac320ead28e789f77e394725f5a408251f8a7d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pgbouncer-1.26.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pgbouncer;unpack=0"
SRC_URI[x86_64_v2_pgbouncer.sha256sum] = "506c8aa2ad9c8ff410fcfe4e7096463bc7251899b657bd9abc19bb8cd6d03190"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pgbouncer-1.26.0-1.el10_2.aarch64.rpm;name=aarch64_pgbouncer;unpack=0"
SRC_URI[aarch64_pgbouncer.sha256sum] = "1607ed12faae4bea55f3dbb758bf5efd3175c1e6a137e20fa3832fbb5a4c8d49"

RDEPENDS:pgbouncer = " \
 bash \
 c-ares \
 glibc \
 libevent \
 logrotate \
 openldap \
 openssl-libs \
 pam-libs \
 python3 \
 python3-psycopg2 \
 shadow-utils \
 systemd \
 systemd-libs \
 "
