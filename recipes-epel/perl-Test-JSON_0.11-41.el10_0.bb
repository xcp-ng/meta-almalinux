# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-JSON"
PV = "0.11"
PR = "41.el10_0"
PACKAGES = " \
 perl-Test-JSON \
 perl-Test-JSON-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-JSON-0.11-41.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c942315a3423c5d5b7261b3fc75f416c09b0137b921cac055487424481e5ddb3"

URI_x86_64_v2_perl-Test-JSON = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-JSON-0.11-41.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-JSON;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-JSON}"
SRC_URI[x86_64_v2_perl-Test-JSON.sha256sum] = "50e7ac67c030b22910015f4ce7947b1329d4ea01e238777f008ef0a626755ec5"

URI_x86_64_v2_perl-Test-JSON-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-JSON-tests-0.11-41.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-JSON-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-JSON-tests}"
SRC_URI[x86_64_v2_perl-Test-JSON-tests.sha256sum] = "9a9eeb45f604d6b6d42c56f9da77ef7c6964c9fc19087ec713c1c5c48a87bc57"

URI_aarch64_perl-Test-JSON = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-JSON-0.11-41.el10_0.noarch.rpm;name=aarch64_perl-Test-JSON;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-JSON}"
SRC_URI[aarch64_perl-Test-JSON.sha256sum] = "1faa092bd6d5ece76dd9f7c8f64f7ebd1410146d1dda71436b44fc839902547d"

URI_aarch64_perl-Test-JSON-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-JSON-tests-0.11-41.el10_0.noarch.rpm;name=aarch64_perl-Test-JSON-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-JSON-tests}"
SRC_URI[aarch64_perl-Test-JSON-tests.sha256sum] = "89a23d8354475ea73519c4fc2285d30664cd10c5aabe0d7a32aa8b8b0e664be4"

RDEPENDS:perl-Test-JSON = " \
 perl-Carp \
 perl-JSON-Any \
 perl-Test-Differences \
 perl-Test-Simple \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-Test-JSON-tests = " \
 perl-Test-Harness \
 perl-Test-JSON \
 "
