# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-av-decoders"
PV = "0.11.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-av-decoders+default-devel \
 rust-av-decoders-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-av-decoders-0.11.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59fb2fd0b218e90cd88b5c038cf4d682ea9a07b0c8dde1d0c786b9bbb21afef8"

URI_x86_64_v2_rust-av-decoders+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-decoders+default-devel-0.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-decoders+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-decoders+default-devel}"
SRC_URI[x86_64_v2_rust-av-decoders+default-devel.sha256sum] = "47b9df48f29f775cc7eb12dd1fc6b0b6cfe7d7185d21a7994068c7f533680d8b"

URI_x86_64_v2_rust-av-decoders-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-decoders-devel-0.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-decoders-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-decoders-devel}"
SRC_URI[x86_64_v2_rust-av-decoders-devel.sha256sum] = "06aa554a8deb069a70fd75e7aa39a9586a78de6f3736ce98aeed6ad3f91e6e0b"

URI_aarch64_rust-av-decoders+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-decoders+default-devel-0.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-decoders+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-decoders+default-devel}"
SRC_URI[aarch64_rust-av-decoders+default-devel.sha256sum] = "4fc8bfce9392eaa2e059d982c4779e9c5a7061a968f858d704b75994e56f9584"

URI_aarch64_rust-av-decoders-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-decoders-devel-0.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-decoders-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-decoders-devel}"
SRC_URI[aarch64_rust-av-decoders-devel.sha256sum] = "0a31fed2202036d71376fd051b1886339e6d1544cad9cfe9dadca3ce87b11d73"

RDEPENDS:rust-av-decoders+default-devel = " \
 cargo \
 rust-av-decoders-devel \
 "
RDEPENDS:rust-av-decoders-devel = " \
 cargo \
 rust \
 rust-num-rational-devel \
 rust-thiserror+default-devel \
 rust-v_frame+default-devel \
 rust-y4m+default-devel \
 "
