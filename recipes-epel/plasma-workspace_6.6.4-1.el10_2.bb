# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-workspace"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 libkworkspace6 \
 plasma-lookandfeel-fedora \
 plasma-workspace \
 plasma-workspace-common \
 plasma-workspace-devel \
 plasma-workspace-doc \
 plasma-workspace-libs \
 sddm-wayland-plasma \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-workspace-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e13ca0190de0e65d7bfae3f255cadba01fbcf741992f89b4d5fcfebf2d51c049"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - plasma-workspace: kde-settings-plasma

URI_x86_64_v2_libkworkspace6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkworkspace6-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkworkspace6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkworkspace6}"
SRC_URI[x86_64_v2_libkworkspace6.sha256sum] = "477b1c61173a2565be62da23f474709c7915add034844376b23273f786409708"

URI_x86_64_v2_plasma-lookandfeel-fedora = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-lookandfeel-fedora-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-lookandfeel-fedora;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-lookandfeel-fedora}"
SRC_URI[x86_64_v2_plasma-lookandfeel-fedora.sha256sum] = "dcc6282655d6c04e3ad13298e2bd35023f415a49c58a9adf715fffa502d6e67b"

URI_x86_64_v2_plasma-workspace = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace}"
SRC_URI[x86_64_v2_plasma-workspace.sha256sum] = "a3c396732043320c0601eab40880ff7ceb891699e5b8f9e89fc4a3e52f24c37b"

URI_x86_64_v2_plasma-workspace-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-common-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-common}"
SRC_URI[x86_64_v2_plasma-workspace-common.sha256sum] = "92e8311e934cc680e0f408c72e26f6b839dd3319e1207311d837fcea5166a7bc"

URI_x86_64_v2_plasma-workspace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-devel}"
SRC_URI[x86_64_v2_plasma-workspace-devel.sha256sum] = "a36be53a4172de31cd213e3a0f3cbb3056977ec2a98a94ab26b1f9779b43dc96"

URI_x86_64_v2_plasma-workspace-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-doc-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-workspace-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-doc}"
SRC_URI[x86_64_v2_plasma-workspace-doc.sha256sum] = "da03557866cd14c34d12bfa5820040b50967d0795a2f9dda35d3a12e93eb779c"

URI_x86_64_v2_plasma-workspace-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-libs-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-libs}"
SRC_URI[x86_64_v2_plasma-workspace-libs.sha256sum] = "66794253de7d5ca65889730d6939154269808507729d2761416c373f2813c340"

URI_x86_64_v2_sddm-wayland-plasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-wayland-plasma-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sddm-wayland-plasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm-wayland-plasma}"
SRC_URI[x86_64_v2_sddm-wayland-plasma.sha256sum] = "2a9bf3050f8c89b79cd53148792f4249c1225bc4d1d1bd3f76faf6d5a2adea1e"
RPROVIDES:sddm-wayland-plasma:x86_64_v2 = "virtual/sddm-greeter-displayserver"

URI_aarch64_libkworkspace6 = "${EPEL_MIRROR}/aarch64/Packages/l/libkworkspace6-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_libkworkspace6;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkworkspace6}"
SRC_URI[aarch64_libkworkspace6.sha256sum] = "ad2160cd12311dded4e2cced584a5aa61a51052cac8bdcad8ebe3cb53ac58db7"

URI_aarch64_plasma-lookandfeel-fedora = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-lookandfeel-fedora-6.6.4-1.el10_2.noarch.rpm;name=aarch64_plasma-lookandfeel-fedora;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-lookandfeel-fedora}"
SRC_URI[aarch64_plasma-lookandfeel-fedora.sha256sum] = "9c3e6c7bcb282e51dc18006ad9f192085f5a9cf53410b8a613b735e933d3b54f"

URI_aarch64_plasma-workspace = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-workspace;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace}"
SRC_URI[aarch64_plasma-workspace.sha256sum] = "12fd0047b730c97dbc18e9ef39d31a3f7a8ccf0fdce90123e87ac1aede23a3ea"

URI_aarch64_plasma-workspace-common = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-common-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-workspace-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-common}"
SRC_URI[aarch64_plasma-workspace-common.sha256sum] = "39acf93999c8feda0806cb3dcb76323e150fa0a34b272cf4d5e2fd502b15e05e"

URI_aarch64_plasma-workspace-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-workspace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-devel}"
SRC_URI[aarch64_plasma-workspace-devel.sha256sum] = "0646097335e00014725eb56810d9f7826f921d6375ee7a07acc3a2812180761b"

URI_aarch64_plasma-workspace-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-doc-6.6.4-1.el10_2.noarch.rpm;name=aarch64_plasma-workspace-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-doc}"
SRC_URI[aarch64_plasma-workspace-doc.sha256sum] = "f2994958bb1c7494a7263514dcdb1f1ed62894ed5ebf931484ca3e5b35045097"

URI_aarch64_plasma-workspace-libs = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-libs-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-workspace-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-libs}"
SRC_URI[aarch64_plasma-workspace-libs.sha256sum] = "45981d0d6816ae7ab46fe58179c3211524fb405eda85b3ce3de8489fe4735fd8"

URI_aarch64_sddm-wayland-plasma = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-wayland-plasma-6.6.4-1.el10_2.noarch.rpm;name=aarch64_sddm-wayland-plasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm-wayland-plasma}"
SRC_URI[aarch64_sddm-wayland-plasma.sha256sum] = "861393489d7f23d2a71b961fc8c6227b2390df7e97390ed1925b9eccad7c9869"
RPROVIDES:sddm-wayland-plasma:aarch64 = "virtual/sddm-greeter-displayserver"

RDEPENDS:libkworkspace6 = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 libXau \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-workspace-common \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-lookandfeel-fedora = " \
 plasma-workspace \
 qt6-qtvirtualkeyboard \
 "
RDEPENDS:plasma-workspace:x86_64_v2 = " \
 PackageKit-Qt6 \
 appstream-qt \
 bash \
 dbus \
 dbus-libs \
 dbus-tools \
 fontconfig \
 glibc \
 gnome-menus \
 iso-codes \
 kactivitymanagerd \
 kf6-baloo \
 kf6-baloo-libs \
 kf6-frameworkintegration \
 kf6-karchive \
 kf6-kauth \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kded \
 kf6-kdoctools \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kparts \
 kf6-kquickcharts \
 kf6-krunner \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-ksvg \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 kio-extras \
 kio-fuse \
 knighttime \
 kscreenlocker \
 ksystemstats \
 kwayland \
 kwin \
 layer-shell-qt \
 libICE \
 libSM \
 libX11 \
 libXcursor \
 libXfixes \
 libXtst \
 libcanberra \
 libicu \
 libkexiv2-qt6 \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 ocean-sound-theme \
 plasma-activities \
 plasma-activities-stats \
 plasma-desktop \
 plasma-keyboard \
 plasma-lookandfeel-fedora \
 plasma-workspace-common \
 plasma-workspace-libs \
 policycoreutils \
 polkit-kde \
 powerdevil \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 qt6-qttools \
 qt6-qtvirtualkeyboard \
 qt6-qtwayland \
 socat \
 systemd \
 unity-gtk3-module \
 uresourced \
 virtual/coreutils \
 xcb-util \
 xcb-util-cursor \
 xcb-util-image \
 xdg-desktop-portal-kde \
 xmessage \
 xorg-x11-server-Xwayland \
 xprop \
 xrdb \
 zlib-ng-compat \
"
RDEPENDS:plasma-workspace:aarch64 = " \
 PackageKit-Qt6 \
 appstream-qt \
 bash \
 dbus \
 dbus-libs \
 dbus-tools \
 fontconfig \
 glibc \
 gnome-menus \
 iso-codes \
 kactivitymanagerd \
 kde-settings-plasma \
 kf6-baloo \
 kf6-baloo-libs \
 kf6-frameworkintegration \
 kf6-karchive \
 kf6-kauth \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kded \
 kf6-kdoctools \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kparts \
 kf6-kquickcharts \
 kf6-krunner \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-ksvg \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 kio-extras \
 kio-fuse \
 knighttime \
 kscreenlocker \
 ksystemstats \
 kwayland \
 kwin \
 layer-shell-qt \
 libICE \
 libSM \
 libX11 \
 libXcursor \
 libXfixes \
 libXtst \
 libcanberra \
 libicu \
 libkexiv2-qt6 \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 ocean-sound-theme \
 plasma-activities \
 plasma-activities-stats \
 plasma-desktop \
 plasma-keyboard \
 plasma-lookandfeel-fedora \
 plasma-workspace-common \
 plasma-workspace-libs \
 policycoreutils \
 polkit-kde \
 powerdevil \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 qt6-qttools \
 qt6-qtvirtualkeyboard \
 qt6-qtwayland \
 socat \
 systemd \
 unity-gtk3-module \
 uresourced \
 virtual/coreutils \
 xcb-util \
 xcb-util-cursor \
 xcb-util-image \
 xdg-desktop-portal-kde \
 xmessage \
 xorg-x11-server-Xwayland \
 xprop \
 xrdb \
 zlib-ng-compat \
"
RDEPENDS:plasma-workspace-common = " \
 "
RDEPENDS:plasma-workspace-devel = " \
 cmake-filesystem \
 libkworkspace6 \
 plasma-workspace-libs \
 "
RDEPENDS:plasma-workspace-doc = " \
 plasma-workspace-common \
 "
RDEPENDS:plasma-workspace-libs = " \
 appstream-qt \
 fontconfig \
 freetype \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kparts \
 kf6-krunner \
 kf6-kservice \
 kf6-ksvg \
 kf6-kuserfeedback \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-networkmanager-qt \
 kf6-solid \
 knighttime \
 kwayland \
 libX11 \
 libXcursor \
 libXfixes \
 libXft \
 libcanberra \
 libgcc \
 libksysguard \
 libkworkspace6 \
 libplasma \
 libqalculate \
 libstdc++ \
 libwayland-client \
 libxcb \
 libxcrypt \
 plasma-activities \
 plasma-activities-stats \
 plasma-workspace-common \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 qt6-qtsvg \
 systemd-libs \
 xcb-util \
 xcb-util-cursor \
 "
RDEPENDS:sddm-wayland-plasma = " \
 kwin \
 layer-shell-qt \
 plasma-keyboard \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/sddm-greeter-displayserver"

PROVIDES:append:aarch64 = " rpm/virtual/sddm-greeter-displayserver"
