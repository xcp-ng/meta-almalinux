# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nftables"
PE = "1"
PV = "1.1.5"
PR = "6.el10"
PACKAGES = " \
 nftables \
 nftables-devel \
 python3-nftables \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nftables-1.1.5-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "64bf000b57224b1b405e74ae63b1029bcbdb124c04a95d0c24b6be15bd581058"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nftables-1.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_nftables;unpack=0"
SRC_URI[x86_64_v2_nftables.sha256sum] = "0e952ae59e12d256726f1cb3a313e991346c9493eb065048c6fadcd34f1d5582"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nftables-devel-1.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_nftables-devel;unpack=0"
SRC_URI[x86_64_v2_nftables-devel.sha256sum] = "cec8f7096954956a89646cb399122582cdaa52a0482d4ebfe993decfad903d52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-nftables-1.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_python3-nftables;unpack=0"
SRC_URI[x86_64_v2_python3-nftables.sha256sum] = "9bf3ff0d86774b8e3575a3c4b166809d0a07ba2c15356b0a51782d2d8b27f440"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nftables-1.1.5-6.el10.aarch64.rpm;name=aarch64_nftables;unpack=0"
SRC_URI[aarch64_nftables.sha256sum] = "951e71e199e099e5f6440cd9d39bbce3dd4905cd50315113695de033a3df4e77"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nftables-devel-1.1.5-6.el10.aarch64.rpm;name=aarch64_nftables-devel;unpack=0"
SRC_URI[aarch64_nftables-devel.sha256sum] = "449464aa2159509bb8fdd3a8c42c5079c2c887c6841dbe085ccd37ee0b148b1a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-nftables-1.1.5-6.el10.aarch64.rpm;name=aarch64_python3-nftables;unpack=0"
SRC_URI[aarch64_python3-nftables.sha256sum] = "a6d4f1318057b97d0d10db73a9e936036721a4fda490ec8e35750556932549b8"

RDEPENDS:nftables = " \
 bash \
 glibc \
 gmp \
 iptables-libs \
 jansson \
 libmnl \
 libnftnl \
 readline \
 "
RDEPENDS:nftables-devel = " \
 nftables \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-nftables = " \
 nftables \
 python3 \
 "
