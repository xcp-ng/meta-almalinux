# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Font-AFM"
PV = "1.20"
PR = "49.el10_0"
PACKAGES = " \
 perl-Font-AFM \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Font-AFM-1.20-49.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "43a5a31c352238fcb2a07d1272eac5eb571f9b0cbba3da11473bf6fe3850a0c1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Font-AFM-1.20-49.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Font-AFM;unpack=0"
SRC_URI[x86_64_v2_perl-Font-AFM.sha256sum] = "c20cb72f0d0a2cd47830bedf254be1ca1a9c48e813fc204280c23bfd623d0f66"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Font-AFM-1.20-49.el10_0.noarch.rpm;name=aarch64_perl-Font-AFM;unpack=0"
SRC_URI[aarch64_perl-Font-AFM.sha256sum] = "4b33a6dcbb447cdf0831e46715fa9bfc823f2551b2b430ce1740edc31c63746f"

RDEPENDS:perl-Font-AFM = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
