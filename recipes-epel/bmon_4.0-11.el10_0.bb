# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bmon"
PV = "4.0"
PR = "11.el10_0"
PACKAGES = " \
 bmon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bmon-4.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14e45e94fb2b483779930f4d5f9346a911bb2262931b3e2c221b584ea92e5bf3"

URI_x86_64_v2_bmon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bmon-4.0-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bmon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bmon}"
SRC_URI[x86_64_v2_bmon.sha256sum] = "58f87ebb6a0bcea5ae659aafcefb58e83e1feca3ae52500aa4e511ff54f11fdc"

URI_aarch64_bmon = "${EPEL_MIRROR}/aarch64/Packages/b/bmon-4.0-11.el10_0.aarch64.rpm;name=aarch64_bmon;unpack=0"
SRC_URI:append = " ${URI_aarch64_bmon}"
SRC_URI[aarch64_bmon.sha256sum] = "1f4084aee345901822f7358f61d9a43578b27df45e151d0c09f9f615c94d723b"

RDEPENDS:bmon = " \
 glibc \
 libconfuse \
 libnl3 \
 ncurses-libs \
 "
