# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-git-revision-date-localized-plugin"
PV = "1.5.4"
PR = "1.el10_3"
PACKAGES = " \
 python3-mkdocs-git-revision-date-localized-plugin \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-git-revision-date-localized-plugin-1.5.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b5124ad600bc3dd30c56216ee01dd1586a52997fa9ef080c3cabe94e8aae093b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-git-revision-date-localized-plugin-1.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-git-revision-date-localized-plugin;unpack=0"
SRC_URI[x86_64_v2_python3-mkdocs-git-revision-date-localized-plugin.sha256sum] = "e67510c7b3a86d56bb27a1483118648ddcfb59bd8faa19bae29ca61c597b6387"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-git-revision-date-localized-plugin-1.5.4-1.el10_3.noarch.rpm;name=aarch64_python3-mkdocs-git-revision-date-localized-plugin;unpack=0"
SRC_URI[aarch64_python3-mkdocs-git-revision-date-localized-plugin.sha256sum] = "329515979e4c355cce0a177175af76fe0718fd5d97ac060ed60d299542784adf"

RDEPENDS:python3-mkdocs-git-revision-date-localized-plugin = " \
 mkdocs \
 python3 \
 python3-GitPython \
 python3-babel \
 "
