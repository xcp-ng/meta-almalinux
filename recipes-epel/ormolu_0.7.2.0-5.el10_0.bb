# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ormolu"
PV = "0.7.2.0"
PR = "5.el10_0"
PACKAGES = " \
 ghc-markdown-unlit \
 ghc-markdown-unlit-devel \
 ghc-markdown-unlit-doc \
 ghc-markdown-unlit-prof \
 ghc-ormolu \
 ghc-ormolu-devel \
 ghc-ormolu-doc \
 ghc-ormolu-prof \
 ghc-th-env \
 ghc-th-env-devel \
 ghc-th-env-doc \
 ghc-th-env-prof \
 ormolu \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/ormolu-0.7.2.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d8f3a18006b9f325e7268fcc9aaa24f6704a9a03eb100ce6ba9bb94672a1c69"

URI_x86_64_v2_ghc-markdown-unlit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-markdown-unlit-0.6.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-markdown-unlit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-markdown-unlit}"
SRC_URI[x86_64_v2_ghc-markdown-unlit.sha256sum] = "3cdf4b59c361de2425326c2e7ed1bd7db9bf5ae247909aa05fc2a25c548dec0d"

URI_x86_64_v2_ghc-markdown-unlit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-markdown-unlit-devel-0.6.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-markdown-unlit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-markdown-unlit-devel}"
SRC_URI[x86_64_v2_ghc-markdown-unlit-devel.sha256sum] = "9160e9dcdd56766ae2bedb4ece14f36c31f5adf9ea29d2fc530e25ab43054ef2"

URI_x86_64_v2_ghc-markdown-unlit-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-markdown-unlit-doc-0.6.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-markdown-unlit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-markdown-unlit-doc}"
SRC_URI[x86_64_v2_ghc-markdown-unlit-doc.sha256sum] = "7b365eda64e0b48cbecb1fbfca379f44b27873fa50650ee3b29cfb8e6923bf2d"

URI_x86_64_v2_ghc-markdown-unlit-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-markdown-unlit-prof-0.6.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-markdown-unlit-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-markdown-unlit-prof}"
SRC_URI[x86_64_v2_ghc-markdown-unlit-prof.sha256sum] = "29ab41eb86c3a9969ef8ea7b791b19e0de50ac24679718da489c2220a3a5a117"

URI_x86_64_v2_ghc-ormolu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ormolu-0.7.2.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ormolu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ormolu}"
SRC_URI[x86_64_v2_ghc-ormolu.sha256sum] = "0d14ccaed7766e585a968ebaf5adc9edb37a1d9151ff4846b6f0e74dc468ff53"

URI_x86_64_v2_ghc-ormolu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ormolu-devel-0.7.2.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ormolu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ormolu-devel}"
SRC_URI[x86_64_v2_ghc-ormolu-devel.sha256sum] = "9a9dfa9374c4cfa75bc77b3b8a0ddbd33a44f6a0dc98ba91e262b391dc4a5553"

URI_x86_64_v2_ghc-ormolu-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ormolu-doc-0.7.2.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ormolu-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ormolu-doc}"
SRC_URI[x86_64_v2_ghc-ormolu-doc.sha256sum] = "526a1a4fad547576ee824473abdfbd5d459da9d1cdb2d72d3e208f2cd5891977"

URI_x86_64_v2_ghc-ormolu-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ormolu-prof-0.7.2.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ormolu-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ormolu-prof}"
SRC_URI[x86_64_v2_ghc-ormolu-prof.sha256sum] = "173bf7b971764079a05d9963d3f1cf74a672769bcaffd5c68b137fe580365282"

URI_x86_64_v2_ghc-th-env = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-env-0.1.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-env;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-env}"
SRC_URI[x86_64_v2_ghc-th-env.sha256sum] = "6ebb8612ddd36b5407fe0714cdd1dd38fe6938a04c616c748271b63b3560b161"

URI_x86_64_v2_ghc-th-env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-env-devel-0.1.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-env-devel}"
SRC_URI[x86_64_v2_ghc-th-env-devel.sha256sum] = "9191b60a777b1d55c24539e7dd78341ed2407d8670a31f0c623c75790bd3abed"

URI_x86_64_v2_ghc-th-env-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-env-doc-0.1.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-th-env-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-env-doc}"
SRC_URI[x86_64_v2_ghc-th-env-doc.sha256sum] = "217e439096e464302ae26b3aed14ca5ab65fdd946c711376163f6ddc88b211d4"

URI_x86_64_v2_ghc-th-env-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-env-prof-0.1.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-env-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-env-prof}"
SRC_URI[x86_64_v2_ghc-th-env-prof.sha256sum] = "1b4fc7e98a6bd2814e1a5606e0d8c099cab66bab33eddd32019f4e542c22d8fc"

URI_x86_64_v2_ormolu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ormolu-0.7.2.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ormolu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ormolu}"
SRC_URI[x86_64_v2_ormolu.sha256sum] = "f93966b59221aaa3d2cdf901d243d64574a429c49be12bf76d18efb64cbc38cd"

URI_aarch64_ghc-markdown-unlit = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-markdown-unlit-0.6.0-5.el10_0.aarch64.rpm;name=aarch64_ghc-markdown-unlit;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-markdown-unlit}"
SRC_URI[aarch64_ghc-markdown-unlit.sha256sum] = "863f461434869103821318fad1c52908e8f137c14e8df7200b4f8cf81776d361"

URI_aarch64_ghc-markdown-unlit-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-markdown-unlit-devel-0.6.0-5.el10_0.aarch64.rpm;name=aarch64_ghc-markdown-unlit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-markdown-unlit-devel}"
SRC_URI[aarch64_ghc-markdown-unlit-devel.sha256sum] = "b5de8c315ef29b6d776efa6b145a314eb95c10a4f4ded5ee4cfc67d3aab1107c"

URI_aarch64_ghc-markdown-unlit-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-markdown-unlit-doc-0.6.0-5.el10_0.noarch.rpm;name=aarch64_ghc-markdown-unlit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-markdown-unlit-doc}"
SRC_URI[aarch64_ghc-markdown-unlit-doc.sha256sum] = "3dcff2e20ec0f02254ea755f234ed255b50328b9175d7977c4288e84850389ef"

URI_aarch64_ghc-markdown-unlit-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-markdown-unlit-prof-0.6.0-5.el10_0.aarch64.rpm;name=aarch64_ghc-markdown-unlit-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-markdown-unlit-prof}"
SRC_URI[aarch64_ghc-markdown-unlit-prof.sha256sum] = "ad38faa3ed7d71204edd6cb89c2858a95e046adc009a18b9e50328f58d5c1be4"

URI_aarch64_ghc-ormolu = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ormolu-0.7.2.0-5.el10_0.aarch64.rpm;name=aarch64_ghc-ormolu;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ormolu}"
SRC_URI[aarch64_ghc-ormolu.sha256sum] = "b3b54489a8471dd03b06a0bf5ea4d39a3f83da3c7ffd2a71db2b1e2917bd5808"

URI_aarch64_ghc-ormolu-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ormolu-devel-0.7.2.0-5.el10_0.aarch64.rpm;name=aarch64_ghc-ormolu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ormolu-devel}"
SRC_URI[aarch64_ghc-ormolu-devel.sha256sum] = "7aa06fd6421d14de243b3637ff6d3531cfe1ba343906116d75d36d09b497c51b"

URI_aarch64_ghc-ormolu-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ormolu-doc-0.7.2.0-5.el10_0.noarch.rpm;name=aarch64_ghc-ormolu-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ormolu-doc}"
SRC_URI[aarch64_ghc-ormolu-doc.sha256sum] = "05ea21a56f43c9279b8f3b190e513e69bc0b6f9dbd081092d862104849a0d1ee"

URI_aarch64_ghc-ormolu-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ormolu-prof-0.7.2.0-5.el10_0.aarch64.rpm;name=aarch64_ghc-ormolu-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ormolu-prof}"
SRC_URI[aarch64_ghc-ormolu-prof.sha256sum] = "62395f9a033ca8754b533e4184569177525885f155406557ce58584837b3f434"

URI_aarch64_ghc-th-env = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-env-0.1.1-5.el10_0.aarch64.rpm;name=aarch64_ghc-th-env;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-env}"
SRC_URI[aarch64_ghc-th-env.sha256sum] = "e1135d32c436b32acd92c7dd9e11b9fd009284b67f29004636aa105a3770da44"

URI_aarch64_ghc-th-env-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-env-devel-0.1.1-5.el10_0.aarch64.rpm;name=aarch64_ghc-th-env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-env-devel}"
SRC_URI[aarch64_ghc-th-env-devel.sha256sum] = "3835265cb2a0b2e2819c94a9d09f9101f66e2de25e469cc859aa0c6b02833e0e"

URI_aarch64_ghc-th-env-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-env-doc-0.1.1-5.el10_0.noarch.rpm;name=aarch64_ghc-th-env-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-env-doc}"
SRC_URI[aarch64_ghc-th-env-doc.sha256sum] = "c7692c19f6c7617a573dfb2921892ccd8c1203267b133739ad017c0610a3f1fc"

URI_aarch64_ghc-th-env-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-env-prof-0.1.1-5.el10_0.aarch64.rpm;name=aarch64_ghc-th-env-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-env-prof}"
SRC_URI[aarch64_ghc-th-env-prof.sha256sum] = "5f7d346d9cfc7b207586c81fa8974daa4fe1609243dac55d5aab8559707e409d"

URI_aarch64_ormolu = "${EPEL_MIRROR}/aarch64/Packages/o/ormolu-0.7.2.0-5.el10_0.aarch64.rpm;name=aarch64_ormolu;unpack=0"
SRC_URI:append = " ${URI_aarch64_ormolu}"
SRC_URI[aarch64_ormolu.sha256sum] = "be526db0ab5e53a09b6c7ed40b0abca0657a210147dddb8255f12ce570e3e215"

RDEPENDS:ghc-markdown-unlit = " \
 ghc-array \
 ghc-base \
 ghc-base-compat \
 ghc-bytestring \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc-markdown-unlit-devel = " \
 ghc-base-compat-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-markdown-unlit \
 "
RDEPENDS:ghc-markdown-unlit-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-markdown-unlit-prof = " \
 ghc-base-compat-prof \
 ghc-base-prof \
 ghc-markdown-unlit-devel \
 "
RDEPENDS:ghc-ormolu = " \
 ghc-Cabal-syntax \
 ghc-Diff \
 ghc-MemoTrie \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-file-embed \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-ghc-lib-parser \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-megaparsec \
 ghc-mtl \
 ghc-newtype-generics \
 ghc-os-string \
 ghc-parsec \
 ghc-parser-combinators \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-scientific \
 ghc-stm \
 ghc-syb \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ormolu-devel = " \
 ghc-Cabal-syntax-devel \
 ghc-Diff-devel \
 ghc-MemoTrie-devel \
 ghc-ansi-terminal-devel \
 ghc-array-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-file-embed-devel \
 ghc-filepath-devel \
 ghc-ghc-lib-parser-devel \
 ghc-megaparsec-devel \
 ghc-mtl-devel \
 ghc-ormolu \
 ghc-syb-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-ormolu-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ormolu-prof = " \
 ghc-Cabal-syntax-prof \
 ghc-Diff-prof \
 ghc-MemoTrie-prof \
 ghc-ansi-terminal-prof \
 ghc-array-prof \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-file-embed-prof \
 ghc-filepath-prof \
 ghc-ghc-lib-parser-prof \
 ghc-megaparsec-prof \
 ghc-mtl-prof \
 ghc-ormolu-devel \
 ghc-syb-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-th-env = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-th-compat \
 glibc \
 gmp \
 "
RDEPENDS:ghc-th-env-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-template-haskell-devel \
 ghc-th-compat-devel \
 ghc-th-env \
 "
RDEPENDS:ghc-th-env-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-th-env-prof = " \
 ghc-base-prof \
 ghc-template-haskell-prof \
 ghc-th-compat-prof \
 ghc-th-env-devel \
 "
RDEPENDS:ormolu = " \
 glibc \
 gmp \
 libffi \
 "
