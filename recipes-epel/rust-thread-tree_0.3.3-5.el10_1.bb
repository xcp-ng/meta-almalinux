# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thread-tree"
PV = "0.3.3"
PR = "5.el10_1"
PACKAGES = " \
 rust-thread-tree+default-devel \
 rust-thread-tree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thread-tree-0.3.3-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4b5385e7a0d7f69e91eeee74c416d65bcfa35e8b6ee04a80fcd5877bd073fc0"

URI_x86_64_v2_rust-thread-tree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread-tree+default-devel-0.3.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread-tree+default-devel}"
SRC_URI[x86_64_v2_rust-thread-tree+default-devel.sha256sum] = "c3f65f0107a85d324c8d2fb0f45db726108f7a83c54c13bdd25756e5f37f04d4"

URI_x86_64_v2_rust-thread-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread-tree-devel-0.3.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread-tree-devel}"
SRC_URI[x86_64_v2_rust-thread-tree-devel.sha256sum] = "3ac90db4f4c179a9addb5a5114c9175616a789e3c563b1ea55d8e2035e812cc9"

URI_aarch64_rust-thread-tree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread-tree+default-devel-0.3.3-5.el10_1.noarch.rpm;name=aarch64_rust-thread-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread-tree+default-devel}"
SRC_URI[aarch64_rust-thread-tree+default-devel.sha256sum] = "6466e265e83ec29bb1319259406fa21dab2d73975e48048cc5f3fdfb792ed643"

URI_aarch64_rust-thread-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread-tree-devel-0.3.3-5.el10_1.noarch.rpm;name=aarch64_rust-thread-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread-tree-devel}"
SRC_URI[aarch64_rust-thread-tree-devel.sha256sum] = "9c6dd8a4d67d21e6a33ef904b64c35a4aa13e65dcf20bc92cf61c4c59c2d9a3c"

RDEPENDS:rust-thread-tree+default-devel = " \
 cargo \
 rust-thread-tree-devel \
 "
RDEPENDS:rust-thread-tree-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 "
