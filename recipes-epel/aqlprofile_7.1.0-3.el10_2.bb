# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aqlprofile"
PV = "7.1.0"
PR = "3.el10_2"
PACKAGES:x86_64_v2 = " \
 aqlprofile \
 aqlprofile-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/a/aqlprofile-7.1.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f59aa2c69a598caf48b73b120b7c7e45643bf06e3cdedb064f2de6ffde845d24"

URI_x86_64_v2_aqlprofile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aqlprofile-7.1.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aqlprofile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aqlprofile}"
SRC_URI[x86_64_v2_aqlprofile.sha256sum] = "0eff0e68d184628ca0122960fd4df0264c168c3ff505b974680f941ef4e39e99"

URI_x86_64_v2_aqlprofile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aqlprofile-devel-7.1.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aqlprofile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aqlprofile-devel}"
SRC_URI[x86_64_v2_aqlprofile-devel.sha256sum] = "67eb1649ceb78aff8aa5e1a42a0f483bfc02e8af0db4e755fc6bd6df7a8baa1a"

RDEPENDS:aqlprofile = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-runtime \
 "
RDEPENDS:aqlprofile-devel = " \
 aqlprofile \
 "
