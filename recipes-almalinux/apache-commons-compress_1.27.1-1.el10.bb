# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apache-commons-compress"
PV = "1.27.1"
PR = "1.el10"
PACKAGES = " \
 apache-commons-compress \
 apache-commons-compress-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/apache-commons-compress-1.27.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d84add1f99633598d83ae7942b2b00679df7efd69f8fa7574403c8aa71fc334"

URI_x86_64_v2_apache-commons-compress = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apache-commons-compress-1.27.1-1.el10.noarch.rpm;name=x86_64_v2_apache-commons-compress;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-compress}"
SRC_URI[x86_64_v2_apache-commons-compress.sha256sum] = "f579d5db87d7ae548b1ee77701f0ff38b17a5bf062543ed9b5e0abf8f4d8e5fb"

URI_x86_64_v2_apache-commons-compress-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-compress-javadoc-1.27.1-1.el10.noarch.rpm;name=x86_64_v2_apache-commons-compress-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-compress-javadoc}"
SRC_URI[x86_64_v2_apache-commons-compress-javadoc.sha256sum] = "bdabe3405810eb9eecae31d2ed2dafb6324bec8b12c5f238a6b0c62fe9c34d8d"

URI_aarch64_apache-commons-compress = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apache-commons-compress-1.27.1-1.el10.noarch.rpm;name=aarch64_apache-commons-compress;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-compress}"
SRC_URI[aarch64_apache-commons-compress.sha256sum] = "f579d5db87d7ae548b1ee77701f0ff38b17a5bf062543ed9b5e0abf8f4d8e5fb"

URI_aarch64_apache-commons-compress-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-compress-javadoc-1.27.1-1.el10.noarch.rpm;name=aarch64_apache-commons-compress-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-compress-javadoc}"
SRC_URI[aarch64_apache-commons-compress-javadoc.sha256sum] = "bdabe3405810eb9eecae31d2ed2dafb6324bec8b12c5f238a6b0c62fe9c34d8d"

RDEPENDS:apache-commons-compress = " \
 apache-commons-codec \
 apache-commons-io \
 apache-commons-lang3 \
 javapackages-filesystem \
 "
RDEPENDS:apache-commons-compress-javadoc = " \
 javapackages-filesystem \
 "
