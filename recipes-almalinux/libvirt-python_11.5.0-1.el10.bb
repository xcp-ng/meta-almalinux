# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvirt-python"
PV = "11.5.0"
PR = "1.el10"
PACKAGES = " \
 python3-libvirt \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvirt-python-11.5.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47854397b40dd6740894519376f5cf6281654e0665239a84f72142b00b4ad76a"

URI_x86_64_v2_python3-libvirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libvirt-11.5.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libvirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libvirt}"
SRC_URI[x86_64_v2_python3-libvirt.sha256sum] = "be326a8ac56413df69d6faa59cd1daef3e42ecf9ab9026592a38addeea31ab4e"

URI_aarch64_python3-libvirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libvirt-11.5.0-1.el10.aarch64.rpm;name=aarch64_python3-libvirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libvirt}"
SRC_URI[aarch64_python3-libvirt.sha256sum] = "703c3be8588d1162d4d43c166206d7b22dfe126a50f5e3c37f307086ac2467b9"

RDEPENDS:python3-libvirt = " \
 glibc \
 libvirt-libs \
 python3 \
 "
