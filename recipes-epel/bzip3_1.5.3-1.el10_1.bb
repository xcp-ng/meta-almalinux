# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bzip3"
PV = "1.5.3"
PR = "1.el10_1"
PACKAGES = " \
 bzip3 \
 bzip3-devel \
 bzip3-grep \
 bzip3-less \
 bzip3-libs \
 bzip3-more \
 bzip3-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bzip3-1.5.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5838ebfbb64eeec648ca2b1b87000c59c242a01c63cbd5fa002bc6b2b5b0c2d"

URI_x86_64_v2_bzip3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-1.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip3}"
SRC_URI[x86_64_v2_bzip3.sha256sum] = "7c5232c72a773aeb68a7c9f70f653ebcaa11cfa50a350de7a6005f5aa1a2e059"

URI_x86_64_v2_bzip3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-devel-1.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip3-devel}"
SRC_URI[x86_64_v2_bzip3-devel.sha256sum] = "acc7634b93443e3b6f24c343a0e8862ed6677dac2dbe4c5476e1c646212ffbd9"

URI_x86_64_v2_bzip3-grep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-grep-1.5.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_bzip3-grep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip3-grep}"
SRC_URI[x86_64_v2_bzip3-grep.sha256sum] = "df7583993b0c79e6f2ae5a2050e22ca683b337659afdfafbc3e8260815498188"

URI_x86_64_v2_bzip3-less = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-less-1.5.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_bzip3-less;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip3-less}"
SRC_URI[x86_64_v2_bzip3-less.sha256sum] = "562dc256d9f9146b197533644ed79febd28e95a2968dfa8fcdfb4681174c3416"

URI_x86_64_v2_bzip3-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-libs-1.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip3-libs}"
SRC_URI[x86_64_v2_bzip3-libs.sha256sum] = "79005928f2aac512ada04b89a4bc082042844f46f3ecf795fc9f5f7b24907a32"

URI_x86_64_v2_bzip3-more = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-more-1.5.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_bzip3-more;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip3-more}"
SRC_URI[x86_64_v2_bzip3-more.sha256sum] = "b03eea72b43ebe98ad81ee4c8ef8d515f6756975722d2d09b28afffd3530d9d1"

URI_x86_64_v2_bzip3-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-tools-1.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip3-tools}"
SRC_URI[x86_64_v2_bzip3-tools.sha256sum] = "5b6ee3848550eebd5c2077855f14df714a2e2e2044cdd80485fac2bdd319c236"

URI_aarch64_bzip3 = "${EPEL_MIRROR}/aarch64/Packages/b/bzip3-1.5.3-1.el10_1.aarch64.rpm;name=aarch64_bzip3;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip3}"
SRC_URI[aarch64_bzip3.sha256sum] = "c7da196882223c155d839c69e101af154661a52c2e065b002b945576922d52a3"

URI_aarch64_bzip3-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bzip3-devel-1.5.3-1.el10_1.aarch64.rpm;name=aarch64_bzip3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip3-devel}"
SRC_URI[aarch64_bzip3-devel.sha256sum] = "fc6a6d0dcce3d6f2ab2c61ad099e092f827ab8f0e696aa44a71ada33d91c0c5b"

URI_aarch64_bzip3-grep = "${EPEL_MIRROR}/aarch64/Packages/b/bzip3-grep-1.5.3-1.el10_1.noarch.rpm;name=aarch64_bzip3-grep;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip3-grep}"
SRC_URI[aarch64_bzip3-grep.sha256sum] = "baf2558baf012fe10448c1cd7db4cbed9b1ee68f7f0704803bc8fc166c3cfd41"

URI_aarch64_bzip3-less = "${EPEL_MIRROR}/aarch64/Packages/b/bzip3-less-1.5.3-1.el10_1.noarch.rpm;name=aarch64_bzip3-less;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip3-less}"
SRC_URI[aarch64_bzip3-less.sha256sum] = "b07f90ef1af336473b836b863977642d49abe6805ef658c977535034364abf29"

URI_aarch64_bzip3-libs = "${EPEL_MIRROR}/aarch64/Packages/b/bzip3-libs-1.5.3-1.el10_1.aarch64.rpm;name=aarch64_bzip3-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip3-libs}"
SRC_URI[aarch64_bzip3-libs.sha256sum] = "09a701c3fb95b5e40695178c46c5abc28f9bc4f593d95c40b8d97ebc3188e974"

URI_aarch64_bzip3-more = "${EPEL_MIRROR}/aarch64/Packages/b/bzip3-more-1.5.3-1.el10_1.noarch.rpm;name=aarch64_bzip3-more;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip3-more}"
SRC_URI[aarch64_bzip3-more.sha256sum] = "d88ebf8ce4df392dee9c672150e73fe7ff950395703e2dd2835bb8fadae8b0b7"

URI_aarch64_bzip3-tools = "${EPEL_MIRROR}/aarch64/Packages/b/bzip3-tools-1.5.3-1.el10_1.aarch64.rpm;name=aarch64_bzip3-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip3-tools}"
SRC_URI[aarch64_bzip3-tools.sha256sum] = "cd0f5dbaabb00b2ee88010eab85ab320c20daa3106bd8ffd3f0c3f3bae60014a"

RDEPENDS:bzip3 = " \
 bzip3-grep \
 bzip3-less \
 bzip3-more \
 bzip3-tools \
 "
RDEPENDS:bzip3-devel = " \
 bzip3-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:bzip3-grep = " \
 bash \
 bzip3-tools \
 grep \
 "
RDEPENDS:bzip3-less = " \
 bash \
 bzip3-tools \
 less \
 "
RDEPENDS:bzip3-libs = " \
 glibc \
 "
RDEPENDS:bzip3-more = " \
 bash \
 bzip3-tools \
 util-linux-core \
 "
RDEPENDS:bzip3-tools = " \
 bash \
 bzip3-libs \
 glibc \
 "
