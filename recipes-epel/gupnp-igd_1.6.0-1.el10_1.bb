# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gupnp-igd"
PV = "1.6.0"
PR = "1.el10_1"
PACKAGES = " \
 gupnp-igd \
 gupnp-igd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gupnp-igd-1.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfb1f95bd35e927a54c2432b1b61e92529ce11b3420992ed7354d39782ce3828"

URI_x86_64_v2_gupnp-igd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gupnp-igd-1.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gupnp-igd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gupnp-igd}"
SRC_URI[x86_64_v2_gupnp-igd.sha256sum] = "01cdfad2a84e3e3abbd1b7969b654a414308a6493d322f47dcfcab92747fb8dd"

URI_x86_64_v2_gupnp-igd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gupnp-igd-devel-1.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gupnp-igd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gupnp-igd-devel}"
SRC_URI[x86_64_v2_gupnp-igd-devel.sha256sum] = "e246cf32959a158d1848edef6de6b567dfca1578c5c8a1e2bdc882c988ba0bed"

URI_aarch64_gupnp-igd = "${EPEL_MIRROR}/aarch64/Packages/g/gupnp-igd-1.6.0-1.el10_1.aarch64.rpm;name=aarch64_gupnp-igd;unpack=0"
SRC_URI:append = " ${URI_aarch64_gupnp-igd}"
SRC_URI[aarch64_gupnp-igd.sha256sum] = "6601e048999dc046a207aa3e30e58b97996db26067d0515048f7134ae9e14c50"

URI_aarch64_gupnp-igd-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gupnp-igd-devel-1.6.0-1.el10_1.aarch64.rpm;name=aarch64_gupnp-igd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gupnp-igd-devel}"
SRC_URI[aarch64_gupnp-igd-devel.sha256sum] = "ac54f8d748a52e7b1131db43a3e8c0e784023c4dab9429e2e015bfa803afd45f"

RDEPENDS:gupnp-igd = " \
 glib2 \
 glibc \
 gssdp \
 gupnp \
 "
RDEPENDS:gupnp-igd-devel = " \
 glib2-devel \
 gssdp-devel \
 gupnp-devel \
 gupnp-igd \
 pkgconf-pkg-config \
 "
