# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hscolour"
PV = "1.25"
PR = "1.el10_0"
PACKAGES = " \
 ghc-hscolour \
 ghc-hscolour-devel \
 ghc-hscolour-doc \
 ghc-hscolour-prof \
 hscolour \
 hscolour-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hscolour-1.25-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6fbb647db529a6fe14a77974ea84f2fba375fd9328b2ede5a02bfc5857b0b9a"

URI_x86_64_v2_ghc-hscolour = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hscolour-1.25-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hscolour;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hscolour}"
SRC_URI[x86_64_v2_ghc-hscolour.sha256sum] = "8ed0bc1e8cb3c1e99516293fed2a9c8cdf45b0c53f1ce8598613aebccf4d6d5e"

URI_x86_64_v2_ghc-hscolour-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hscolour-devel-1.25-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hscolour-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hscolour-devel}"
SRC_URI[x86_64_v2_ghc-hscolour-devel.sha256sum] = "9b9afc5637bdbc1bdffcfefe0be9307e285b5aa644dbfd4bcd9c67b561d01758"

URI_x86_64_v2_ghc-hscolour-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hscolour-doc-1.25-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hscolour-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hscolour-doc}"
SRC_URI[x86_64_v2_ghc-hscolour-doc.sha256sum] = "b850db313e7ae16be14c88d3a105d70e1b00ac17d1d7d93973619e2edffcea05"

URI_x86_64_v2_ghc-hscolour-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hscolour-prof-1.25-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hscolour-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hscolour-prof}"
SRC_URI[x86_64_v2_ghc-hscolour-prof.sha256sum] = "28c336a3b0ca4a5b0926b113176dbec44e5c9a38eecb41f057e6b86828137b9b"

URI_x86_64_v2_hscolour = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hscolour-1.25-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hscolour;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hscolour}"
SRC_URI[x86_64_v2_hscolour.sha256sum] = "6a7d27838f976030245a20e17e16e3275ef433af596890188db9a00b3fd423fa"

URI_x86_64_v2_hscolour-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hscolour-common-1.25-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_hscolour-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hscolour-common}"
SRC_URI[x86_64_v2_hscolour-common.sha256sum] = "dd94e29152b779c457e6dc1f284dc7d9c85c9aa353257b9b73d007bb259d9ef5"

URI_aarch64_ghc-hscolour = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hscolour-1.25-1.el10_0.aarch64.rpm;name=aarch64_ghc-hscolour;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hscolour}"
SRC_URI[aarch64_ghc-hscolour.sha256sum] = "cf08cb8124460e4f93b66e7601dbc061d5162ce98d4ef7b9511688680b63181c"

URI_aarch64_ghc-hscolour-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hscolour-devel-1.25-1.el10_0.aarch64.rpm;name=aarch64_ghc-hscolour-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hscolour-devel}"
SRC_URI[aarch64_ghc-hscolour-devel.sha256sum] = "c2e871ca59d07217d61f56c1aa73f6ae2b42c101f1d19660ce967b3adb927fab"

URI_aarch64_ghc-hscolour-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hscolour-doc-1.25-1.el10_0.noarch.rpm;name=aarch64_ghc-hscolour-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hscolour-doc}"
SRC_URI[aarch64_ghc-hscolour-doc.sha256sum] = "b84ed68af72d9df4ed787b9c2323a3f4e2f566efbc039cc2c45a7fac546a4eef"

URI_aarch64_ghc-hscolour-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hscolour-prof-1.25-1.el10_0.aarch64.rpm;name=aarch64_ghc-hscolour-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hscolour-prof}"
SRC_URI[aarch64_ghc-hscolour-prof.sha256sum] = "bf9e5e3c9fd4a26953ab63ce879cf26cba2a097e5467778475616812affdb8e1"

URI_aarch64_hscolour = "${EPEL_MIRROR}/aarch64/Packages/h/hscolour-1.25-1.el10_0.aarch64.rpm;name=aarch64_hscolour;unpack=0"
SRC_URI:append = " ${URI_aarch64_hscolour}"
SRC_URI[aarch64_hscolour.sha256sum] = "ac5f2c33392f437b370570729fd0f76fe0cbcf6ae3d2388a12be4385a94b96c4"

URI_aarch64_hscolour-common = "${EPEL_MIRROR}/aarch64/Packages/h/hscolour-common-1.25-1.el10_0.noarch.rpm;name=aarch64_hscolour-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_hscolour-common}"
SRC_URI[aarch64_hscolour-common.sha256sum] = "16e0f33443fe39b04817cc0ec97fcc8054fb5b30cc39e46839b8d7ca331540d6"

RDEPENDS:ghc-hscolour = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 hscolour-common \
 "
RDEPENDS:ghc-hscolour-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-hscolour \
 "
RDEPENDS:ghc-hscolour-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hscolour-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-hscolour-devel \
 "
RDEPENDS:hscolour = " \
 glibc \
 gmp \
 hscolour-common \
 libffi \
 "
RDEPENDS:hscolour-common = " \
 "
