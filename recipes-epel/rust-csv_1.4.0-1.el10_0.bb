# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-csv"
PV = "1.4.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-csv+default-devel \
 rust-csv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-csv-1.4.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85b053fdae8be1028260f046053320ac620c2c98a6360fec05103d7c8d159eda"

URI_x86_64_v2_rust-csv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv+default-devel-1.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv+default-devel}"
SRC_URI[x86_64_v2_rust-csv+default-devel.sha256sum] = "a4e22b9c9f3eec051e4a129794324a31ce1c3e128c72451529334cc3eeb0764b"

URI_x86_64_v2_rust-csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv-devel-1.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv-devel}"
SRC_URI[x86_64_v2_rust-csv-devel.sha256sum] = "c441f7c28b30dc22489ef2f4e14347fbbd7d3dbbd79806d625c3296508bf817e"

URI_aarch64_rust-csv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv+default-devel-1.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-csv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv+default-devel}"
SRC_URI[aarch64_rust-csv+default-devel.sha256sum] = "e3b1d44cb3a8b09480ecff47ecb74d55c524c4d077aa0f99ac97bc54030d3425"

URI_aarch64_rust-csv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv-devel-1.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv-devel}"
SRC_URI[aarch64_rust-csv-devel.sha256sum] = "e48edee315f5d431b2c100f7c305021bb97444ee7bf18e41e2c805a4c63defb9"

RDEPENDS:rust-csv+default-devel = " \
 cargo \
 rust-csv-devel \
 "
RDEPENDS:rust-csv-devel = " \
 cargo \
 rust \
 rust-csv-core+default-devel \
 rust-itoa+default-devel \
 rust-ryu+default-devel \
 rust-serde_core+default-devel \
 "
