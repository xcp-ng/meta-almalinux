# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qttools"
PV = "5.15.18"
PR = "2.el10_2"
PACKAGES = " \
 qt5-assistant \
 qt5-designer \
 qt5-doctools \
 qt5-linguist \
 qt5-qdbusviewer \
 qt5-qttools \
 qt5-qttools-common \
 qt5-qttools-devel \
 qt5-qttools-examples \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-designercomponents \
 qt5-qttools-libs-help \
 qt5-qttools-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qttools-5.15.18-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a06bf4af3a3e30fd9703da4413dd332613f032fa37291067b31d65cbdb7b969a"

URI_x86_64_v2_qt5-assistant = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-assistant-5.15.18-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-assistant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-assistant}"
SRC_URI[x86_64_v2_qt5-assistant.sha256sum] = "ed7f936029d2cdcc9da71bd1541fda3a04dbf31dba111c28a1e3d22c5c7f7a26"

URI_x86_64_v2_qt5-designer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-designer-5.15.18-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-designer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-designer}"
SRC_URI[x86_64_v2_qt5-designer.sha256sum] = "d86a8a1f5e3b75e08bf99caf1546d40fb22aabb6ca896d624eb877cc4b2e6720"

URI_x86_64_v2_qt5-doctools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-doctools-5.15.18-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-doctools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-doctools}"
SRC_URI[x86_64_v2_qt5-doctools.sha256sum] = "59a092457f565b50c6869ee6e5002c09c9eb418b0e02c2e4910ca4b61e7f6b88"

URI_x86_64_v2_qt5-linguist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-linguist-5.15.18-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-linguist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-linguist}"
SRC_URI[x86_64_v2_qt5-linguist.sha256sum] = "cd5414d2d48f8397201d7ec8be7a95d641a9c67153d151fa64427f72784fd92a"

URI_x86_64_v2_qt5-qdbusviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qdbusviewer-5.15.18-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qdbusviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qdbusviewer}"
SRC_URI[x86_64_v2_qt5-qdbusviewer.sha256sum] = "97da462e9351a5f4111075fcc9c5cf3f065dbefab87c37ada0bb7cf7085e9f47"

URI_x86_64_v2_qt5-qttools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-5.15.18-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools}"
SRC_URI[x86_64_v2_qt5-qttools.sha256sum] = "0b82cbbcb091a91e156efb27df6b3550241ee7568eca62bc4edb300a0602c3cd"

URI_x86_64_v2_qt5-qttools-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-common-5.15.18-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qttools-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-common}"
SRC_URI[x86_64_v2_qt5-qttools-common.sha256sum] = "5b8d16ee023644b29885fb1992dba65a737bd2fe366f1f30ba2621d9fbd1dd58"

URI_x86_64_v2_qt5-qttools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-devel-5.15.18-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-devel}"
SRC_URI[x86_64_v2_qt5-qttools-devel.sha256sum] = "ec9deedb311aed1865fedbdc9e4bf8fb52e71af363f728f4d57f1f2abd6a22b3"

URI_x86_64_v2_qt5-qttools-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-examples-5.15.18-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-examples}"
SRC_URI[x86_64_v2_qt5-qttools-examples.sha256sum] = "d9fb8848c4a4480c525f978310eee764d4ba35db76bc237b21b9e721ac4abda5"

URI_x86_64_v2_qt5-qttools-libs-designer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-libs-designer-5.15.18-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-libs-designer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-libs-designer}"
SRC_URI[x86_64_v2_qt5-qttools-libs-designer.sha256sum] = "720608ed264b1fb8ac17e82fa5a3081214a8033277d65bcc30a7f115d4d912ee"

URI_x86_64_v2_qt5-qttools-libs-designercomponents = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-libs-designercomponents-5.15.18-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-libs-designercomponents;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-libs-designercomponents}"
SRC_URI[x86_64_v2_qt5-qttools-libs-designercomponents.sha256sum] = "d874ec44bc3bd28b430ed6506d1b7e8685c9cc1272bf88abe2d294d70437fe90"

URI_x86_64_v2_qt5-qttools-libs-help = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-libs-help-5.15.18-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-libs-help;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-libs-help}"
SRC_URI[x86_64_v2_qt5-qttools-libs-help.sha256sum] = "c54f882c4624edcb5651507e3638735c3fc8d38913214e1bb87ed33c65ce4b50"

URI_x86_64_v2_qt5-qttools-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-static-5.15.18-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-static}"
SRC_URI[x86_64_v2_qt5-qttools-static.sha256sum] = "a86a12c6c0f72b1e43c8bffa307eedfeb83f6c5abbf0ba3ba95bd7bde1f2afa9"

URI_aarch64_qt5-assistant = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-assistant-5.15.18-2.el10_2.aarch64.rpm;name=aarch64_qt5-assistant;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-assistant}"
SRC_URI[aarch64_qt5-assistant.sha256sum] = "49f77b77a82e31fe7dcc5c072a543070b8e1b03b10492caab35f86b393311536"

URI_aarch64_qt5-designer = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-designer-5.15.18-2.el10_2.aarch64.rpm;name=aarch64_qt5-designer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-designer}"
SRC_URI[aarch64_qt5-designer.sha256sum] = "0f377628722ef7b972da00d1521569b3940033a3f3b4bce56326a338b0de35c4"

URI_aarch64_qt5-doctools = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-doctools-5.15.18-2.el10_2.aarch64.rpm;name=aarch64_qt5-doctools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-doctools}"
SRC_URI[aarch64_qt5-doctools.sha256sum] = "3e2960ecf40e3b24078d2b01825cd3d1568429de5cef1a874e3e6ce4006131c0"

URI_aarch64_qt5-linguist = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-linguist-5.15.18-2.el10_2.aarch64.rpm;name=aarch64_qt5-linguist;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-linguist}"
SRC_URI[aarch64_qt5-linguist.sha256sum] = "37e527b489e2e7b225f493d9f545ac07fb3e4aa39f8908122aa4cf36de5b128a"

URI_aarch64_qt5-qdbusviewer = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qdbusviewer-5.15.18-2.el10_2.aarch64.rpm;name=aarch64_qt5-qdbusviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qdbusviewer}"
SRC_URI[aarch64_qt5-qdbusviewer.sha256sum] = "56ac0c4f11e8a919425fe281b4b35c0827d548af59b68e08a993a93e1a4e551f"

URI_aarch64_qt5-qttools = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-5.15.18-2.el10_2.aarch64.rpm;name=aarch64_qt5-qttools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools}"
SRC_URI[aarch64_qt5-qttools.sha256sum] = "563ef87f91819797585580bbf2e8291aef383cd26e945a100a5a5d5b0539eedb"

URI_aarch64_qt5-qttools-common = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-common-5.15.18-2.el10_2.noarch.rpm;name=aarch64_qt5-qttools-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-common}"
SRC_URI[aarch64_qt5-qttools-common.sha256sum] = "bd11f0d4cca71f82d9c41a594b1983e689d685f807d2767e7b1031fe6391ff8b"

URI_aarch64_qt5-qttools-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-devel-5.15.18-2.el10_2.aarch64.rpm;name=aarch64_qt5-qttools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-devel}"
SRC_URI[aarch64_qt5-qttools-devel.sha256sum] = "e04b14bfe182513e432e2aa9b2f53b7da50bddb807523ec43fa41831454fc01d"

URI_aarch64_qt5-qttools-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-examples-5.15.18-2.el10_2.aarch64.rpm;name=aarch64_qt5-qttools-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-examples}"
SRC_URI[aarch64_qt5-qttools-examples.sha256sum] = "e4918c7461405271d4e368daffd9fe591872f88ed0610b4043441e49fafa982b"

URI_aarch64_qt5-qttools-libs-designer = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-libs-designer-5.15.18-2.el10_2.aarch64.rpm;name=aarch64_qt5-qttools-libs-designer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-libs-designer}"
SRC_URI[aarch64_qt5-qttools-libs-designer.sha256sum] = "b43f780b039eb42c5134f3dea43be04c26d6f394e22a0e4a8916fef138bb8b4f"

URI_aarch64_qt5-qttools-libs-designercomponents = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-libs-designercomponents-5.15.18-2.el10_2.aarch64.rpm;name=aarch64_qt5-qttools-libs-designercomponents;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-libs-designercomponents}"
SRC_URI[aarch64_qt5-qttools-libs-designercomponents.sha256sum] = "2a90849f7f2e74d1af58df36ecf362c67d11d22809ad4150be7bb3118e4a16cc"

URI_aarch64_qt5-qttools-libs-help = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-libs-help-5.15.18-2.el10_2.aarch64.rpm;name=aarch64_qt5-qttools-libs-help;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-libs-help}"
SRC_URI[aarch64_qt5-qttools-libs-help.sha256sum] = "942885ec82ffb59ed84423abefc128cafdf915096149d4873f8319fd0f47afb4"

URI_aarch64_qt5-qttools-static = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-static-5.15.18-2.el10_2.aarch64.rpm;name=aarch64_qt5-qttools-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-static}"
SRC_URI[aarch64_qt5-qttools-static.sha256sum] = "525824d96153487ee509f3c85562a97df6856d6ac2c05c24c56081146ef2d928"

RDEPENDS:qt5-assistant = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-designer = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-designercomponents \
 "
RDEPENDS:qt5-doctools = " \
 clang-libs \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-linguist = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qdbusviewer = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools-common = " \
 "
RDEPENDS:qt5-qttools-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-designer \
 qt5-doctools \
 qt5-linguist \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtbase-gui \
 qt5-qttools \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-designercomponents \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-qttools-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qttools-common \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-qttools-libs-designer = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools-libs-designercomponents = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 qt5-qttools-libs-designer \
 "
RDEPENDS:qt5-qttools-libs-help = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools-static = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qttools-devel \
 "
