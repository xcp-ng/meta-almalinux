# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libquotient"
PV = "0.9.5"
PR = "1.el10_2"
PACKAGES = " \
 libquotient-qt6 \
 libquotient-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libquotient-0.9.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c71db9b6d2d1364e8965abdbbebbf01e3a7b73e6608c7780d17d3aaa8cdf9877"

URI_x86_64_v2_libquotient-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libquotient-qt6-0.9.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libquotient-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquotient-qt6}"
SRC_URI[x86_64_v2_libquotient-qt6.sha256sum] = "d5f8482c395114c5860a93275e3dd446326749e5ed65545bb555d6d56bef7902"

URI_x86_64_v2_libquotient-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libquotient-qt6-devel-0.9.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libquotient-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquotient-qt6-devel}"
SRC_URI[x86_64_v2_libquotient-qt6-devel.sha256sum] = "7a0520caaf7b73239ae3ae2f241644cfb229b3ade75e8eeb4de04353a2035277"

URI_aarch64_libquotient-qt6 = "${EPEL_MIRROR}/aarch64/Packages/l/libquotient-qt6-0.9.5-1.el10_2.aarch64.rpm;name=aarch64_libquotient-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_libquotient-qt6}"
SRC_URI[aarch64_libquotient-qt6.sha256sum] = "2592bdbf30f55541fbbb772f2b089c3136e0aa689dab3fae5eb1af06d227179d"

URI_aarch64_libquotient-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libquotient-qt6-devel-0.9.5-1.el10_2.aarch64.rpm;name=aarch64_libquotient-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libquotient-qt6-devel}"
SRC_URI[aarch64_libquotient-qt6-devel.sha256sum] = "33241703bfd056905903419b4a50b38153320b39ff6210965342f6d33ac06df5"

RDEPENDS:libquotient-qt6 = " \
 glibc \
 libolm \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:libquotient-qt6-devel = " \
 cmake-filesystem \
 libolm-devel \
 libquotient-qt6 \
 openssl-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qtkeychain-qt6-devel \
 "
