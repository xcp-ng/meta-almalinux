# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksystemlog"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ksystemlog \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksystemlog-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25a9dc991aa34d4c1794d714ff0462c1c2d101755ee6259766606dca32362685"

URI_x86_64_v2_ksystemlog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksystemlog-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksystemlog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksystemlog}"
SRC_URI[x86_64_v2_ksystemlog.sha256sum] = "867bb0a4aae06c10ae7f31e8a54ce77befd4efb4bddb8bc6dd38e20e9d7b503e"

URI_aarch64_ksystemlog = "${EPEL_MIRROR}/aarch64/Packages/k/ksystemlog-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ksystemlog;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksystemlog}"
SRC_URI[aarch64_ksystemlog.sha256sum] = "cb95afdcae62b1624e25d50f19e65a2b48cb8c99f133e744a8daae4f76223542"

RDEPENDS:ksystemlog = " \
 audit-libs \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 systemd-libs \
 "
