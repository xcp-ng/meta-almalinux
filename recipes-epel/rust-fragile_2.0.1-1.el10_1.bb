# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fragile"
PV = "2.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-fragile+default-devel \
 rust-fragile+slab-devel \
 rust-fragile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fragile-2.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e957f08a202056929675d5c2299b841aaf42b56882419245e7884590171440f"

URI_x86_64_v2_rust-fragile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile+default-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fragile+default-devel}"
SRC_URI[x86_64_v2_rust-fragile+default-devel.sha256sum] = "2b50c48b5adaf794b1004ac69b6f787909e76d9bda29b56c528fe5b7545a0e39"

URI_x86_64_v2_rust-fragile+slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile+slab-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile+slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fragile+slab-devel}"
SRC_URI[x86_64_v2_rust-fragile+slab-devel.sha256sum] = "ebc64e0a3d6a2765c6788f62bd3317ce4c26c3322fe229ee0e43853ee7ca01ef"

URI_x86_64_v2_rust-fragile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fragile-devel}"
SRC_URI[x86_64_v2_rust-fragile-devel.sha256sum] = "c350991a68ef9aa05eae7b5c0432889c88febf1d2a19a63accf4ac78eaefc4c7"

URI_aarch64_rust-fragile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile+default-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-fragile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fragile+default-devel}"
SRC_URI[aarch64_rust-fragile+default-devel.sha256sum] = "e18f9577daf969626adb9ac9c05b891aa41de7d82149d7cea42acd4c4a778d58"

URI_aarch64_rust-fragile+slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile+slab-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-fragile+slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fragile+slab-devel}"
SRC_URI[aarch64_rust-fragile+slab-devel.sha256sum] = "7d1e8f3d7edc841b85ffa785c25b5dac86d2832f04999a57164e094b848f9fc6"

URI_aarch64_rust-fragile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-fragile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fragile-devel}"
SRC_URI[aarch64_rust-fragile-devel.sha256sum] = "224ec002f6da258bcd169cc7c22584dcf3b4c438663cf2faf25b440f30dee01a"

RDEPENDS:rust-fragile+default-devel = " \
 cargo \
 rust-fragile-devel \
 "
RDEPENDS:rust-fragile+slab-devel = " \
 cargo \
 rust-fragile-devel \
 rust-slab+default-devel \
 "
RDEPENDS:rust-fragile-devel = " \
 cargo \
 "
