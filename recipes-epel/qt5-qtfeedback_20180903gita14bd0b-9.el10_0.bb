# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtfeedback"
PV = "20180903gita14bd0b"
PR = "9.el10_0"
PACKAGES = " \
 qt5-qtfeedback \
 qt5-qtfeedback-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtfeedback-20180903gita14bd0b-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da7585eb59ee5fd3f5abc5fa434e1d1ac5c4393110d0757a69ff507282f6b531"

URI_x86_64_v2_qt5-qtfeedback = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtfeedback-20180903gita14bd0b-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtfeedback;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtfeedback}"
SRC_URI[x86_64_v2_qt5-qtfeedback.sha256sum] = "fc7aa411b7df06de624be8a79e52850c542ee57226ba9000335a2d992f2ba930"

URI_x86_64_v2_qt5-qtfeedback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtfeedback-devel-20180903gita14bd0b-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtfeedback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtfeedback-devel}"
SRC_URI[x86_64_v2_qt5-qtfeedback-devel.sha256sum] = "f3d92fc1830f9002955d3c05ae03fdb334a47f15a362546150167e3605965af7"

URI_aarch64_qt5-qtfeedback = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtfeedback-20180903gita14bd0b-9.el10_0.aarch64.rpm;name=aarch64_qt5-qtfeedback;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtfeedback}"
SRC_URI[aarch64_qt5-qtfeedback.sha256sum] = "6676200828e6c590d97eabbc2f4a74145729dd78ff3c8a59ab2112db9a95431e"

URI_aarch64_qt5-qtfeedback-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtfeedback-devel-20180903gita14bd0b-9.el10_0.aarch64.rpm;name=aarch64_qt5-qtfeedback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtfeedback-devel}"
SRC_URI[aarch64_qt5-qtfeedback-devel.sha256sum] = "11f922fa01b3655e4965d2de7911739fce27094837c8d50dfd3167a14944c6d6"

RDEPENDS:qt5-qtfeedback = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtfeedback-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtfeedback \
 "
