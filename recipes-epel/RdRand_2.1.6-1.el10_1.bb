# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "RdRand"
PV = "2.1.6"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 RdRand \
 RdRand-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/RdRand-2.1.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b3f9f2bb5bef3b1d9f848ae23f7178c336747e4548155b8424220690dd63003"

URI_x86_64_v2_RdRand = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/RdRand-2.1.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_RdRand;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_RdRand}"
SRC_URI[x86_64_v2_RdRand.sha256sum] = "9697269d2e90b0915b08745f4b1a36cda07c3bf4dffad0f5da9f322638b9bdac"

URI_x86_64_v2_RdRand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/RdRand-devel-2.1.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_RdRand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_RdRand-devel}"
SRC_URI[x86_64_v2_RdRand-devel.sha256sum] = "b6507a35a0597828bd38259865859c3cf3a500fe6b530408ce984db606da6e0c"

RDEPENDS:RdRand = " \
 glibc \
 libgcc \
 libgomp \
 openssl \
 openssl-libs \
 "
RDEPENDS:RdRand-devel = " \
 RdRand \
 openssl-devel \
 pkgconf-pkg-config \
 "
