# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust"
PV = "1.96.0"
PR = "1.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 cargo \
 clippy \
 rust \
 rust-analyzer \
 rust-debugger-common \
 rust-doc \
 rust-gdb \
 rust-lldb \
 rust-src \
 rust-std-static \
 rust-std-static-wasm32-unknown-unknown \
 rust-std-static-wasm32-wasip1 \
 rust-std-static-x86_64-unknown-none \
 rust-toolset \
 rust-toolset-srpm-macros \
 rustfmt \
"
PACKAGES:aarch64 = " \
 cargo \
 clippy \
 rust \
 rust-analyzer \
 rust-debugger-common \
 rust-doc \
 rust-gdb \
 rust-lldb \
 rust-src \
 rust-std-static \
 rust-std-static-aarch64-unknown-none-softfloat \
 rust-std-static-wasm32-unknown-unknown \
 rust-std-static-wasm32-wasip1 \
 rust-toolset \
 rust-toolset-srpm-macros \
 rustfmt \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-1.96.0-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cfeb52cee8b3fe248ebd83c2588d04edac00c31986fa0b34d0d98d1e5e7b819"

URI_x86_64_v2_cargo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cargo-1.96.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_cargo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo}"
SRC_URI[x86_64_v2_cargo.sha256sum] = "45cc491f6cea36a50b9a8aa1d57153a2963fbf2fea94a4fc8e3b7da7fd341cb8"

URI_x86_64_v2_clippy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clippy-1.96.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clippy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clippy}"
SRC_URI[x86_64_v2_clippy.sha256sum] = "4bac0b9bf8288f7d9243b3ff17e4481588791e694314af7d2e0a71e44f5af5d1"

URI_x86_64_v2_rust = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-1.96.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust}"
SRC_URI[x86_64_v2_rust.sha256sum] = "bcef0c7c120ad98c2daa8d4d564a3312eac86bf5498b998154546bd029895cba"

URI_x86_64_v2_rust-analyzer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-analyzer-1.96.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-analyzer}"
SRC_URI[x86_64_v2_rust-analyzer.sha256sum] = "f84210ba6cbdccbfb03acfe1f146826a5c9228e072316f29c5443744569a4a20"

URI_x86_64_v2_rust-debugger-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-debugger-common-1.96.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-debugger-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-debugger-common}"
SRC_URI[x86_64_v2_rust-debugger-common.sha256sum] = "4f4b68b6345d8017f17e9f5578fff06d6237d027b2708a66e76ddf2cd1fb4a37"

URI_x86_64_v2_rust-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-doc-1.96.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc}"
SRC_URI[x86_64_v2_rust-doc.sha256sum] = "2402f74e7b2807af1e3568496be31b4217f5d22f2a217a489ab13672c31de4fd"

URI_x86_64_v2_rust-gdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-gdb-1.96.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-gdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gdb}"
SRC_URI[x86_64_v2_rust-gdb.sha256sum] = "3e78a07f11945b9f650888af3cf88b68d227939776314fd582d12718f05ae006"

URI_x86_64_v2_rust-lldb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-lldb-1.96.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-lldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lldb}"
SRC_URI[x86_64_v2_rust-lldb.sha256sum] = "76a722b4b74e5e43293ae50e78ecfb39dfa07c9c1567e4fe214c8956c6fdb66d"

URI_x86_64_v2_rust-src = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-src-1.96.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-src}"
SRC_URI[x86_64_v2_rust-src.sha256sum] = "d99be209f816efec5db4278bbdf0713105e92beeb3f19023f0426ebc4cf0c13a"

URI_x86_64_v2_rust-std-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-1.96.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-std-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static}"
SRC_URI[x86_64_v2_rust-std-static.sha256sum] = "97e5fee464540047e77ed537b26f7164a4adaa0254ab4532b9ed6d32288b7f22"

URI_x86_64_v2_rust-std-static-wasm32-unknown-unknown = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-wasm32-unknown-unknown-1.96.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-std-static-wasm32-unknown-unknown;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static-wasm32-unknown-unknown}"
SRC_URI[x86_64_v2_rust-std-static-wasm32-unknown-unknown.sha256sum] = "350f18737af5c4c3ee40c274797355197bb730b509f1098f4534b44666816743"

URI_x86_64_v2_rust-std-static-wasm32-wasip1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-wasm32-wasip1-1.96.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-std-static-wasm32-wasip1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static-wasm32-wasip1}"
SRC_URI[x86_64_v2_rust-std-static-wasm32-wasip1.sha256sum] = "d2b575ab57b7cff9e03eb22afde8cc91c01b6cd79e7bf7041ab4e95879968872"

URI_x86_64_v2_rust-std-static-x86_64-unknown-none = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rust-std-static-x86_64-unknown-none-1.96.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-std-static-x86_64-unknown-none;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static-x86_64-unknown-none}"
SRC_URI[x86_64_v2_rust-std-static-x86_64-unknown-none.sha256sum] = "40922e2b4c17d9e0f49c74c9e9e6a679145ecd3d733f8786b6a4671f2b29a63e"

URI_x86_64_v2_rust-toolset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-toolset-1.96.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-toolset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toolset}"
SRC_URI[x86_64_v2_rust-toolset.sha256sum] = "1d5f63975e0e14ac188e019236a66915e87ae6492d23384b5c2132172b3e4617"

URI_x86_64_v2_rust-toolset-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-toolset-srpm-macros-1.96.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-toolset-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toolset-srpm-macros}"
SRC_URI[x86_64_v2_rust-toolset-srpm-macros.sha256sum] = "ac7ebc78bc2ec4384de80ee6185d5e23de5c83bd65ce5ffb685bd1b2e7bbeaf9"

URI_x86_64_v2_rustfmt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rustfmt-1.96.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rustfmt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rustfmt}"
SRC_URI[x86_64_v2_rustfmt.sha256sum] = "6975c1fd068726e19af5b15308897e3db0b12d365409e21456dfd0d55275d7bb"

URI_aarch64_cargo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cargo-1.96.0-1.el10.alma.1.aarch64.rpm;name=aarch64_cargo;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo}"
SRC_URI[aarch64_cargo.sha256sum] = "e04c50ed765faa2aa5c89be9613b35c35fcf4794c247655354706dad5eeeeae1"

URI_aarch64_clippy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clippy-1.96.0-1.el10.alma.1.aarch64.rpm;name=aarch64_clippy;unpack=0"
SRC_URI:append = " ${URI_aarch64_clippy}"
SRC_URI[aarch64_clippy.sha256sum] = "251deebcfb322c9b8889062ff8256151c01cdd0f2fd7b009fc5d9d37c8b7e8f0"

URI_aarch64_rust = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-1.96.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust}"
SRC_URI[aarch64_rust.sha256sum] = "dd1c48b2f74f97197876503a7f4a0110644e84af47d1cd56766f3ea6664afd1e"

URI_aarch64_rust-analyzer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-analyzer-1.96.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-analyzer}"
SRC_URI[aarch64_rust-analyzer.sha256sum] = "5a4c51ab3005ff7e5c9c40e83e335e535a8f38be277c4c59af789e3777fd0eda"

URI_aarch64_rust-debugger-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-debugger-common-1.96.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-debugger-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-debugger-common}"
SRC_URI[aarch64_rust-debugger-common.sha256sum] = "4f4b68b6345d8017f17e9f5578fff06d6237d027b2708a66e76ddf2cd1fb4a37"

URI_aarch64_rust-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-doc-1.96.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc}"
SRC_URI[aarch64_rust-doc.sha256sum] = "ee7b2d4bda99d67107e3c76b4809a6a2b62a51a302090bf671d7d8659a642d47"

URI_aarch64_rust-gdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-gdb-1.96.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-gdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gdb}"
SRC_URI[aarch64_rust-gdb.sha256sum] = "3e78a07f11945b9f650888af3cf88b68d227939776314fd582d12718f05ae006"

URI_aarch64_rust-lldb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-lldb-1.96.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-lldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lldb}"
SRC_URI[aarch64_rust-lldb.sha256sum] = "76a722b4b74e5e43293ae50e78ecfb39dfa07c9c1567e4fe214c8956c6fdb66d"

URI_aarch64_rust-src = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-src-1.96.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-src}"
SRC_URI[aarch64_rust-src.sha256sum] = "d99be209f816efec5db4278bbdf0713105e92beeb3f19023f0426ebc4cf0c13a"

URI_aarch64_rust-std-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-1.96.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-std-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static}"
SRC_URI[aarch64_rust-std-static.sha256sum] = "ac902c12f54bbf3951d7ae24716b87bdd14e50a107dd216e14f0f4d77ad4f29a"

URI_aarch64_rust-std-static-aarch64-unknown-none-softfloat = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rust-std-static-aarch64-unknown-none-softfloat-1.96.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-std-static-aarch64-unknown-none-softfloat;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static-aarch64-unknown-none-softfloat}"
SRC_URI[aarch64_rust-std-static-aarch64-unknown-none-softfloat.sha256sum] = "35fe28c89fe1619255886368b96292ad30b129d8e3441fee12529ff64f410e1e"

URI_aarch64_rust-std-static-wasm32-unknown-unknown = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-wasm32-unknown-unknown-1.96.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-std-static-wasm32-unknown-unknown;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static-wasm32-unknown-unknown}"
SRC_URI[aarch64_rust-std-static-wasm32-unknown-unknown.sha256sum] = "350f18737af5c4c3ee40c274797355197bb730b509f1098f4534b44666816743"

URI_aarch64_rust-std-static-wasm32-wasip1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-wasm32-wasip1-1.96.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-std-static-wasm32-wasip1;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static-wasm32-wasip1}"
SRC_URI[aarch64_rust-std-static-wasm32-wasip1.sha256sum] = "d2b575ab57b7cff9e03eb22afde8cc91c01b6cd79e7bf7041ab4e95879968872"

URI_aarch64_rust-toolset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-toolset-1.96.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toolset}"
SRC_URI[aarch64_rust-toolset.sha256sum] = "1d5f63975e0e14ac188e019236a66915e87ae6492d23384b5c2132172b3e4617"

URI_aarch64_rust-toolset-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-toolset-srpm-macros-1.96.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-toolset-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toolset-srpm-macros}"
SRC_URI[aarch64_rust-toolset-srpm-macros.sha256sum] = "ac7ebc78bc2ec4384de80ee6185d5e23de5c83bd65ce5ffb685bd1b2e7bbeaf9"

URI_aarch64_rustfmt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rustfmt-1.96.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rustfmt;unpack=0"
SRC_URI:append = " ${URI_aarch64_rustfmt}"
SRC_URI[aarch64_rustfmt.sha256sum] = "3ed943e9883a1c49336e873288645fec4c86d441245b6e64589528e8db25574d"

RDEPENDS:cargo = " \
 glibc \
 libgcc \
 openssl-libs \
 rust \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clippy = " \
 cargo \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust = " \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 rust-std-static \
 "
RDEPENDS:rust-analyzer = " \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust-debugger-common = " \
 "
RDEPENDS:rust-doc = " \
 "
RDEPENDS:rust-gdb = " \
 bash \
 gdb \
 rust \
 rust-debugger-common \
 "
RDEPENDS:rust-lldb = " \
 bash \
 lldb \
 python3-lldb \
 rust \
 rust-debugger-common \
 "
RDEPENDS:rust-src = " \
 "
RDEPENDS:rust-std-static = " \
 glibc \
 glibc-devel \
 libgcc \
 rust \
 "
RDEPENDS:rust-std-static-wasm32-unknown-unknown = " \
 lld \
 rust \
 "
RDEPENDS:rust-std-static-wasm32-wasip1 = " \
 lld \
 rust \
 "
RDEPENDS:rust-std-static-x86_64-unknown-none = " \
 lld \
 rust \
 "
RDEPENDS:rust-toolset = " \
 cargo \
 python3 \
 rust \
 rust-toolset-srpm-macros \
 "
RDEPENDS:rust-toolset-srpm-macros = " \
 "
RDEPENDS:rustfmt = " \
 cargo \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust-std-static-aarch64-unknown-none-softfloat = " \
 lld \
 rust \
 "
