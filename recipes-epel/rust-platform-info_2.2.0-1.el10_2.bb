# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-platform-info"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-platform-info+default-devel \
 rust-platform-info-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-platform-info-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5388b190db7497ec6fc3b56baa4e9e5742169832add4dd1786cfacca8be1ae5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-platform-info+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-platform-info+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-platform-info+default-devel.sha256sum] = "2634571d975173a8ff3e2336abbeb188301eaecde1551184d48b98a2892e27b9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-platform-info-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-platform-info-devel;unpack=0"
SRC_URI[x86_64_v2_rust-platform-info-devel.sha256sum] = "436249d6e3c205c51816f0d919d0fee45b886ba05c7e68197a54588e1d38c2c5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-platform-info+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-platform-info+default-devel;unpack=0"
SRC_URI[aarch64_rust-platform-info+default-devel.sha256sum] = "8ffa875aabfd7622f73c80e9e9938384092c4012c523fbae0dbec34d3437b2ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-platform-info-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-platform-info-devel;unpack=0"
SRC_URI[aarch64_rust-platform-info-devel.sha256sum] = "33fa60f88fcfd5d663abe9275be310fa3b476c2ce5e55c9b42d469b1914b60ff"

RDEPENDS:rust-platform-info+default-devel = " \
 cargo \
 rust-platform-info-devel \
 "
RDEPENDS:rust-platform-info-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
