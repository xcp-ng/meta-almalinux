# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virtiofsd"
PV = "1.13.3"
PR = "2.el10.alma.1"
PACKAGES = " \
 virtiofsd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virtiofsd-1.13.3-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "63af70964a6df264d3da297ccd0265a9b05c6c1adbdaef23aba521e3a1220ab7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virtiofsd-1.13.3-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_virtiofsd;unpack=0"
SRC_URI[x86_64_v2_virtiofsd.sha256sum] = "b5d55ad843e7fec4afe8e2f624f00bffaabc6e35aab2cb35842cff1340672a12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virtiofsd-1.13.3-2.el10.alma.1.aarch64.rpm;name=aarch64_virtiofsd;unpack=0"
SRC_URI[aarch64_virtiofsd.sha256sum] = "853ac3bb3671dfd99b6ff3149b575feca5bf0b7185ec40c6930eed735682ce89"

RDEPENDS:virtiofsd = " \
 glibc \
 libcap-ng \
 libgcc \
 libseccomp \
 qemu-kvm-common \
 shadow-utils \
 "
