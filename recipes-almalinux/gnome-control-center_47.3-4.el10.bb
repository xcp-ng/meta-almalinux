# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-control-center"
PV = "47.3"
PR = "4.el10"
PACKAGES = " \
 gnome-control-center \
 gnome-control-center-filesystem \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-control-center-47.3-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bdb15028d170348bd07dc4dc4880c725db5ef5eeb95aca7fb64d1e3b7a4ea42"

URI_x86_64_v2_gnome-control-center = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-control-center-47.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-control-center;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-control-center}"
SRC_URI[x86_64_v2_gnome-control-center.sha256sum] = "186eba7479fff3dfcb938063a0829e47514b2b1a727d52a526bebf37633d71db"

URI_x86_64_v2_gnome-control-center-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-control-center-filesystem-47.3-4.el10.noarch.rpm;name=x86_64_v2_gnome-control-center-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-control-center-filesystem}"
SRC_URI[x86_64_v2_gnome-control-center-filesystem.sha256sum] = "045900891b4af093bf3183bfc620c5a97e5228076f692ebec5e2c7360969a25f"

URI_aarch64_gnome-control-center = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-control-center-47.3-4.el10.aarch64.rpm;name=aarch64_gnome-control-center;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-control-center}"
SRC_URI[aarch64_gnome-control-center.sha256sum] = "197a162367ddc75b061a71a200449d7e66008ca0e5d548fcd9e74cafdba29e34"

URI_aarch64_gnome-control-center-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-control-center-filesystem-47.3-4.el10.noarch.rpm;name=aarch64_gnome-control-center-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-control-center-filesystem}"
SRC_URI[aarch64_gnome-control-center-filesystem.sha256sum] = "045900891b4af093bf3183bfc620c5a97e5228076f692ebec5e2c7360969a25f"

RDEPENDS:gnome-control-center = " \
 ModemManager-glib \
 NetworkManager-libnm \
 accountsservice \
 accountsservice-libs \
 alsa-lib \
 cairo \
 colord \
 colord-gtk4 \
 colord-libs \
 cups-libs \
 cups-pk-helper \
 dbus \
 fontconfig \
 gcr-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-bluetooth-libs \
 gnome-control-center-filesystem \
 gnome-desktop4 \
 gnome-online-accounts \
 gnome-settings-daemon \
 gnutls \
 graphene \
 gsettings-desktop-schemas \
 gsound \
 gtk4 \
 ibus-libs \
 iso-codes \
 json-glib \
 krb5-libs \
 libX11 \
 libXi \
 libadwaita \
 libepoxy \
 libgcc \
 libgtop2 \
 libgudev \
 libnma-gtk4 \
 libpwquality \
 libsecret \
 libsmbclient \
 libsoup3 \
 libudisks2 \
 libwacom \
 libxml2 \
 pango \
 pkgconf-pkg-config \
 polkit-libs \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 tecla \
 upower \
 upower-libs \
 "
RDEPENDS:gnome-control-center-filesystem = " \
 "
