# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gass-transfer"
PV = "9.4"
PR = "8.el10_0"
PACKAGES = " \
 globus-gass-transfer \
 globus-gass-transfer-devel \
 globus-gass-transfer-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gass-transfer-9.4-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a25c48f7b6c11a75011023f2e4c1d89834f1bb1772c427138fb8e2b6da86b362"

URI_x86_64_v2_globus-gass-transfer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-transfer-9.4-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gass-transfer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-transfer}"
SRC_URI[x86_64_v2_globus-gass-transfer.sha256sum] = "397286432dc3236ab35ae69bf919ded6a2296c866c1a9833ce140524cd221dd3"

URI_x86_64_v2_globus-gass-transfer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-transfer-devel-9.4-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gass-transfer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-transfer-devel}"
SRC_URI[x86_64_v2_globus-gass-transfer-devel.sha256sum] = "ef102768287e79e531ea7db3a3a4c88536afb5ac747ecf6b81d61d1e7e40a3b7"

URI_x86_64_v2_globus-gass-transfer-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-transfer-doc-9.4-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gass-transfer-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-transfer-doc}"
SRC_URI[x86_64_v2_globus-gass-transfer-doc.sha256sum] = "3e9d2be35a56c4fbcdd975b27824b8c09b52b55f1a17ae4e42380a9f3744a076"

URI_aarch64_globus-gass-transfer = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-transfer-9.4-8.el10_0.aarch64.rpm;name=aarch64_globus-gass-transfer;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-transfer}"
SRC_URI[aarch64_globus-gass-transfer.sha256sum] = "953bca6576078c6e53053b908b1415a728e88a5a63c2327b6be031622bb26c2f"

URI_aarch64_globus-gass-transfer-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-transfer-devel-9.4-8.el10_0.aarch64.rpm;name=aarch64_globus-gass-transfer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-transfer-devel}"
SRC_URI[aarch64_globus-gass-transfer-devel.sha256sum] = "197c41efe03f43259023b649befe16e87e4df6f453f9f637c489d23b4d0d7f61"

URI_aarch64_globus-gass-transfer-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-transfer-doc-9.4-8.el10_0.noarch.rpm;name=aarch64_globus-gass-transfer-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-transfer-doc}"
SRC_URI[aarch64_globus-gass-transfer-doc.sha256sum] = "93f4780bdd110ed0984f1c0f374c884cc7a6797d2ae2ef89b3ed9aebaaa612b6"

RDEPENDS:globus-gass-transfer = " \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-io \
 "
RDEPENDS:globus-gass-transfer-devel = " \
 globus-common-devel \
 globus-gass-transfer \
 globus-gss-assist-devel \
 globus-gssapi-gsi-devel \
 globus-io-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gass-transfer-doc = " \
 "
