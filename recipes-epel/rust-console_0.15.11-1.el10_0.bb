# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-console"
PV = "0.15.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-console+ansi-parsing-devel \
 rust-console+default-devel \
 rust-console+unicode-width-devel \
 rust-console-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-console-0.15.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8946637fad91b9f52c206c49de4f0d3c8a116930a74f28411611d2c8cdf4291f"

URI_x86_64_v2_rust-console+ansi-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+ansi-parsing-devel-0.15.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+ansi-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+ansi-parsing-devel}"
SRC_URI[x86_64_v2_rust-console+ansi-parsing-devel.sha256sum] = "0c9a74880efd16909161c5e0c8f22a63a48e61faf4fa335f31f9737e0d9e9eee"

URI_x86_64_v2_rust-console+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+default-devel-0.15.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+default-devel}"
SRC_URI[x86_64_v2_rust-console+default-devel.sha256sum] = "f0983b936d31220b2092f7f619b7adb38035d719725b134c45623d5f57ed822f"

URI_x86_64_v2_rust-console+unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+unicode-width-devel-0.15.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+unicode-width-devel}"
SRC_URI[x86_64_v2_rust-console+unicode-width-devel.sha256sum] = "ffd5c9be4d501f45b97e43c86332f8de94b6566caf735ad287b6dd9418fe0410"

URI_x86_64_v2_rust-console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console-devel-0.15.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console-devel}"
SRC_URI[x86_64_v2_rust-console-devel.sha256sum] = "96fe934156a7092312f02d1217e0739642af7f08af45f825a62639be200f3b6c"

URI_aarch64_rust-console+ansi-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+ansi-parsing-devel-0.15.11-1.el10_0.noarch.rpm;name=aarch64_rust-console+ansi-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+ansi-parsing-devel}"
SRC_URI[aarch64_rust-console+ansi-parsing-devel.sha256sum] = "77d04e0165dc7f1c37a504b14630b71d0db716859380e4f82576efdf560f8e76"

URI_aarch64_rust-console+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+default-devel-0.15.11-1.el10_0.noarch.rpm;name=aarch64_rust-console+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+default-devel}"
SRC_URI[aarch64_rust-console+default-devel.sha256sum] = "89e1f5e9f70afa72de52bbf29b9c9e15e7142d511dbc76c861a0d8de16d2063d"

URI_aarch64_rust-console+unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+unicode-width-devel-0.15.11-1.el10_0.noarch.rpm;name=aarch64_rust-console+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+unicode-width-devel}"
SRC_URI[aarch64_rust-console+unicode-width-devel.sha256sum] = "bea4bd203a526a92a41d763d1021f0117525dd7d2285688852d35851fbda026b"

URI_aarch64_rust-console-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console-devel-0.15.11-1.el10_0.noarch.rpm;name=aarch64_rust-console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console-devel}"
SRC_URI[aarch64_rust-console-devel.sha256sum] = "22f9a3ea17de1e966ffebfa7a899d8ef861f783e8e640dfefe011ff86b902c6c"

RDEPENDS:rust-console+ansi-parsing-devel = " \
 cargo \
 rust-console-devel \
 "
RDEPENDS:rust-console+default-devel = " \
 cargo \
 rust-console+ansi-parsing-devel \
 rust-console+unicode-width-devel \
 rust-console-devel \
 "
RDEPENDS:rust-console+unicode-width-devel = " \
 cargo \
 rust-console-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-console-devel = " \
 bash \
 cargo \
 rust \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 "
