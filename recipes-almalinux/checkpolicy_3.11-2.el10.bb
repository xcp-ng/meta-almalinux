# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "checkpolicy"
PV = "3.11"
PR = "2.el10"
PACKAGES = " \
 checkpolicy \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/checkpolicy-3.11-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3ea040d36dff95b5319c208da50f213a3b1a5566140a52fa08bda8796621ba82"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/checkpolicy-3.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_checkpolicy;unpack=0"
SRC_URI[x86_64_v2_checkpolicy.sha256sum] = "e79f3d805d5c6db2f68a56eb179c14b16b86278958d19d58b2a5bc4b6bc19050"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/checkpolicy-3.11-2.el10.aarch64.rpm;name=aarch64_checkpolicy;unpack=0"
SRC_URI[aarch64_checkpolicy.sha256sum] = "27a5c45d0c3f108ac48de7dd185d11a66dbc36139f79531faa49863b57cc7ab0"

RDEPENDS:checkpolicy = " \
 glibc \
 "
