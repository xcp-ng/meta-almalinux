# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-dash-to-panel"
PV = "64"
PR = "1.el10"
PACKAGES = " \
 gnome-shell-extension-dash-to-panel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-shell-extension-dash-to-panel-64-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0225ef3c38f14b05e31a42b6aa0bb354654f61e57131a7193dc6d8fd6ed1ea3d"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - gnome-shell-extension-dash-to-panel: gnome-shell >= 47~alpha

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - gnome-shell-extension-dash-to-panel: gnome-shell >= 47~alpha

URI_x86_64_v2_gnome-shell-extension-dash-to-panel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-dash-to-panel-64-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-dash-to-panel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-dash-to-panel}"
SRC_URI[x86_64_v2_gnome-shell-extension-dash-to-panel.sha256sum] = "238fb1c88a828ef3556e31cdfe6def4f90963397ee90accf6b94799bcd84a84f"

URI_aarch64_gnome-shell-extension-dash-to-panel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-dash-to-panel-64-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-dash-to-panel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-dash-to-panel}"
SRC_URI[aarch64_gnome-shell-extension-dash-to-panel.sha256sum] = "238fb1c88a828ef3556e31cdfe6def4f90963397ee90accf6b94799bcd84a84f"

RDEPENDS:gnome-shell-extension-dash-to-panel = " \
 "
