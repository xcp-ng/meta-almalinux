# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-md-5_0.10"
PV = "0.10.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-md-5_0.10+asm-devel \
 rust-md-5_0.10+default-devel \
 rust-md-5_0.10+force-soft-devel \
 rust-md-5_0.10+loongarch64_asm-devel \
 rust-md-5_0.10+md5-asm-devel \
 rust-md-5_0.10+oid-devel \
 rust-md-5_0.10+std-devel \
 rust-md-5_0.10-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-md-5_0.10-0.10.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31def5bd3c1bb0d97c9f72874e59414e82b558e417eb19b901de9d930178e043"

URI_x86_64_v2_rust-md-5_0.10+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5_0.10+asm-devel-0.10.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5_0.10+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5_0.10+asm-devel}"
SRC_URI[x86_64_v2_rust-md-5_0.10+asm-devel.sha256sum] = "1de70dfbf74b99efd8481a296d077a821fb36bf1934011d908f0970cc22e028e"

URI_x86_64_v2_rust-md-5_0.10+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5_0.10+default-devel-0.10.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5_0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5_0.10+default-devel}"
SRC_URI[x86_64_v2_rust-md-5_0.10+default-devel.sha256sum] = "03078a393b7f17fa5bf6ad12d368fcbf9ced33317fefd1c76a8c72546c56967c"

URI_x86_64_v2_rust-md-5_0.10+force-soft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5_0.10+force-soft-devel-0.10.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5_0.10+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5_0.10+force-soft-devel}"
SRC_URI[x86_64_v2_rust-md-5_0.10+force-soft-devel.sha256sum] = "220200a7b637f0c0ebcd36a8b7d412e5d8932aa0146c7da7a13dc273c545db2f"

URI_x86_64_v2_rust-md-5_0.10+loongarch64_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5_0.10+loongarch64_asm-devel-0.10.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5_0.10+loongarch64_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5_0.10+loongarch64_asm-devel}"
SRC_URI[x86_64_v2_rust-md-5_0.10+loongarch64_asm-devel.sha256sum] = "3b9b9b15ba1759398b2090d4d7c9b0c986c7ff0750939f8fc4823a270ff624ce"

URI_x86_64_v2_rust-md-5_0.10+md5-asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5_0.10+md5-asm-devel-0.10.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5_0.10+md5-asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5_0.10+md5-asm-devel}"
SRC_URI[x86_64_v2_rust-md-5_0.10+md5-asm-devel.sha256sum] = "034b1fc9a49b1056dee04717473bc622abe70c161c82dd79091d077f527db1f2"

URI_x86_64_v2_rust-md-5_0.10+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5_0.10+oid-devel-0.10.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5_0.10+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5_0.10+oid-devel}"
SRC_URI[x86_64_v2_rust-md-5_0.10+oid-devel.sha256sum] = "8096d99e950e0c700eb4e57fe7022ffef3f589e4c4b4e7c70a7ec3e349dbf6db"

URI_x86_64_v2_rust-md-5_0.10+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5_0.10+std-devel-0.10.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5_0.10+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5_0.10+std-devel}"
SRC_URI[x86_64_v2_rust-md-5_0.10+std-devel.sha256sum] = "c654068455a30c1a617fd1abf3a9d594f8a2629d81174daf027725a373234432"

URI_x86_64_v2_rust-md-5_0.10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5_0.10-devel-0.10.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5_0.10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5_0.10-devel}"
SRC_URI[x86_64_v2_rust-md-5_0.10-devel.sha256sum] = "594ab05e2707c624d6545d67a621b87b358946b27e9e6278a983f88f2db44d3b"

URI_aarch64_rust-md-5_0.10+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5_0.10+asm-devel-0.10.6-1.el10_3.noarch.rpm;name=aarch64_rust-md-5_0.10+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5_0.10+asm-devel}"
SRC_URI[aarch64_rust-md-5_0.10+asm-devel.sha256sum] = "04ec4b04ef45c7cfacd98c1ac18a98912310abf08817136e64bdb5d3eb59e781"

URI_aarch64_rust-md-5_0.10+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5_0.10+default-devel-0.10.6-1.el10_3.noarch.rpm;name=aarch64_rust-md-5_0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5_0.10+default-devel}"
SRC_URI[aarch64_rust-md-5_0.10+default-devel.sha256sum] = "3667d4c77e674653129e3379e4a85b81661ca99b259d49aa1e959e9a3bf0713f"

URI_aarch64_rust-md-5_0.10+force-soft-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5_0.10+force-soft-devel-0.10.6-1.el10_3.noarch.rpm;name=aarch64_rust-md-5_0.10+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5_0.10+force-soft-devel}"
SRC_URI[aarch64_rust-md-5_0.10+force-soft-devel.sha256sum] = "cf6c85c80c3aca1dba2667149838878d5cf08c20c064c46dbe3b911eeb67f142"

URI_aarch64_rust-md-5_0.10+loongarch64_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5_0.10+loongarch64_asm-devel-0.10.6-1.el10_3.noarch.rpm;name=aarch64_rust-md-5_0.10+loongarch64_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5_0.10+loongarch64_asm-devel}"
SRC_URI[aarch64_rust-md-5_0.10+loongarch64_asm-devel.sha256sum] = "4dbb6c8b04908646837a7a3f3e9647c37c6ddae7f2b8ba77383af51a89672585"

URI_aarch64_rust-md-5_0.10+md5-asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5_0.10+md5-asm-devel-0.10.6-1.el10_3.noarch.rpm;name=aarch64_rust-md-5_0.10+md5-asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5_0.10+md5-asm-devel}"
SRC_URI[aarch64_rust-md-5_0.10+md5-asm-devel.sha256sum] = "d299d2705b21b5cc1c4893068afe06277e307bca98f280cc5d4d1062c1019399"

URI_aarch64_rust-md-5_0.10+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5_0.10+oid-devel-0.10.6-1.el10_3.noarch.rpm;name=aarch64_rust-md-5_0.10+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5_0.10+oid-devel}"
SRC_URI[aarch64_rust-md-5_0.10+oid-devel.sha256sum] = "b95aa0c13c22d4cd2335597407d47591c8dc45f11d9c42869edfb9147457b498"

URI_aarch64_rust-md-5_0.10+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5_0.10+std-devel-0.10.6-1.el10_3.noarch.rpm;name=aarch64_rust-md-5_0.10+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5_0.10+std-devel}"
SRC_URI[aarch64_rust-md-5_0.10+std-devel.sha256sum] = "d6506b0c4d69f1a427ffafdc5a8bb47326fc39f33b60816d3ff7c50a8b433ff0"

URI_aarch64_rust-md-5_0.10-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5_0.10-devel-0.10.6-1.el10_3.noarch.rpm;name=aarch64_rust-md-5_0.10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5_0.10-devel}"
SRC_URI[aarch64_rust-md-5_0.10-devel.sha256sum] = "e458c9f38973e865644d160f0c76fe1d28679feeeb95c9c2d1629d433aba66d3"

RDEPENDS:rust-md-5_0.10+asm-devel = " \
 cargo \
 rust-md-5_0.10+md5-asm-devel \
 rust-md-5_0.10-devel \
 "
RDEPENDS:rust-md-5_0.10+default-devel = " \
 cargo \
 rust-md-5_0.10+std-devel \
 rust-md-5_0.10-devel \
 "
RDEPENDS:rust-md-5_0.10+force-soft-devel = " \
 cargo \
 rust-md-5_0.10-devel \
 "
RDEPENDS:rust-md-5_0.10+loongarch64_asm-devel = " \
 cargo \
 rust-md-5_0.10-devel \
 "
RDEPENDS:rust-md-5_0.10+md5-asm-devel = " \
 cargo \
 rust-md-5_0.10-devel \
 rust-md5-asm+default-devel \
 "
RDEPENDS:rust-md-5_0.10+oid-devel = " \
 cargo \
 rust-digest0.10+oid-devel \
 rust-md-5_0.10-devel \
 "
RDEPENDS:rust-md-5_0.10+std-devel = " \
 cargo \
 rust-digest0.10+std-devel \
 rust-md-5_0.10-devel \
 "
RDEPENDS:rust-md-5_0.10-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-digest0.10+default-devel \
 "
