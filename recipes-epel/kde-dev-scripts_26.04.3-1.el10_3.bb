# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-dev-scripts"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kde-dev-scripts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-dev-scripts-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d19f063b3076b22faee4dcce2fc0b0eb6b1492ac0e6c5f1a92a44c7d9ee203d9"

URI_x86_64_v2_kde-dev-scripts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-dev-scripts-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kde-dev-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-dev-scripts}"
SRC_URI[x86_64_v2_kde-dev-scripts.sha256sum] = "d5bff0c5e794ad41fec4ef9b9a65f365f4fbb91317b31e7dea9bebe8714c33ae"

URI_aarch64_kde-dev-scripts = "${EPEL_MIRROR}/aarch64/Packages/k/kde-dev-scripts-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kde-dev-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-dev-scripts}"
SRC_URI[aarch64_kde-dev-scripts.sha256sum] = "4c41daf1c836413aaa972e61da86f884e2b0998b84369c3025c35363bea81cdb"

RDEPENDS:kde-dev-scripts = " \
 advancecomp \
 bash \
 optipng \
 perl-Data-Dumper \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Term-ANSIColor \
 perl-Time-Local \
 perl-XML-DOM \
 perl-constant \
 perl-interpreter \
 perl-libs \
 python3 \
 "
