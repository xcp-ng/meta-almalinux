# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nalgebra"
PV = "0.33.2"
PR = "2.el10_1"
PACKAGES = " \
 rust-nalgebra+alloc-devel \
 rust-nalgebra+arbitrary-devel \
 rust-nalgebra+bytemuck-devel \
 rust-nalgebra+compare-devel \
 rust-nalgebra+convert-bytemuck-devel \
 rust-nalgebra+convert-mint-devel \
 rust-nalgebra+debug-devel \
 rust-nalgebra+default-devel \
 rust-nalgebra+io-devel \
 rust-nalgebra+libm-devel \
 rust-nalgebra+libm-force-devel \
 rust-nalgebra+macros-devel \
 rust-nalgebra+matrixcompare-core-devel \
 rust-nalgebra+matrixmultiply-devel \
 rust-nalgebra+mint-devel \
 rust-nalgebra+nalgebra-macros-devel \
 rust-nalgebra+pest-devel \
 rust-nalgebra+pest_derive-devel \
 rust-nalgebra+proptest-devel \
 rust-nalgebra+proptest-support-devel \
 rust-nalgebra+quickcheck-devel \
 rust-nalgebra+rand-devel \
 rust-nalgebra+rand-no-std-devel \
 rust-nalgebra+rand-package-devel \
 rust-nalgebra+rand_distr-devel \
 rust-nalgebra+rayon-devel \
 rust-nalgebra+serde-devel \
 rust-nalgebra+serde-serialize-devel \
 rust-nalgebra+serde-serialize-no-std-devel \
 rust-nalgebra+slow-tests-devel \
 rust-nalgebra+sparse-devel \
 rust-nalgebra+std-devel \
 rust-nalgebra-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nalgebra-0.33.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed7a6ffa498a5d3883a1f1aa22f566a8239ba75eb47109e85998974f53b89be1"

URI_x86_64_v2_rust-nalgebra+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+alloc-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+alloc-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+alloc-devel.sha256sum] = "07d2b5df28acc5bcfaaaa5b4f11ba8a06a0702c5985c8707d94de7f3dacba40a"

URI_x86_64_v2_rust-nalgebra+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+arbitrary-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+arbitrary-devel.sha256sum] = "df4155cc00fad8126ed2cebe41c052faa0536de1665f06bc0b4f75c58e10cb02"

URI_x86_64_v2_rust-nalgebra+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+bytemuck-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+bytemuck-devel.sha256sum] = "a4a4238b1edd49d1c98eef4994351456007e924b7c5873cdc5b72a2a65d6b97a"

URI_x86_64_v2_rust-nalgebra+compare-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+compare-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+compare-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+compare-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+compare-devel.sha256sum] = "f10c10f84c1125f43d065bdaa83ebdb829950f6bfb5686188f841748b14c71b8"

URI_x86_64_v2_rust-nalgebra+convert-bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+convert-bytemuck-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+convert-bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+convert-bytemuck-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+convert-bytemuck-devel.sha256sum] = "855bc7a674074d5dfa48c8ff17a2d33e37e25f98ac288be95e814837b3e810c3"

URI_x86_64_v2_rust-nalgebra+convert-mint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+convert-mint-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+convert-mint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+convert-mint-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+convert-mint-devel.sha256sum] = "0629a9c83794ea801e6253c461d7acc2aad972d288aab5cf82c800721484525b"

URI_x86_64_v2_rust-nalgebra+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+debug-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+debug-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+debug-devel.sha256sum] = "ad393a817f650c2bafdf61457ce267d0c047794181a9d424e28750d06c48d1ce"

URI_x86_64_v2_rust-nalgebra+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+default-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+default-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+default-devel.sha256sum] = "b7c4c3db3401c3d61d23463dcce9150f169be87e611de56fa260b6f07cc061bc"

URI_x86_64_v2_rust-nalgebra+io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+io-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+io-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+io-devel.sha256sum] = "4106542e9e80b167a8a23acd6cf1647595df482cef7f019a67360f46f33ffe59"

URI_x86_64_v2_rust-nalgebra+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+libm-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+libm-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+libm-devel.sha256sum] = "7142c7ab81d79c007a22379cfd1325dc5ed5ba8e5a584d3e08808f3c48d487d4"

URI_x86_64_v2_rust-nalgebra+libm-force-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+libm-force-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+libm-force-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+libm-force-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+libm-force-devel.sha256sum] = "ffb9260036328c4025a9af7539714218fa25efcacc674cade72bda527f31605e"

URI_x86_64_v2_rust-nalgebra+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+macros-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+macros-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+macros-devel.sha256sum] = "d267b4b8db07c4b03abe5d8aecc24ef2e603e648bd5c953fda0d2ae19768c6dd"

URI_x86_64_v2_rust-nalgebra+matrixcompare-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+matrixcompare-core-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+matrixcompare-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+matrixcompare-core-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+matrixcompare-core-devel.sha256sum] = "953c45d20df41578858fa4bbe5423103d0fc63672cc9e4dc882c65e68b7fd0fc"

URI_x86_64_v2_rust-nalgebra+matrixmultiply-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+matrixmultiply-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+matrixmultiply-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+matrixmultiply-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+matrixmultiply-devel.sha256sum] = "c6a8ef7d8479c6f7199e67902446ab605708f75dbe704c4ca922ad61d634349b"

URI_x86_64_v2_rust-nalgebra+mint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+mint-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+mint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+mint-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+mint-devel.sha256sum] = "976b59c4e143189e225810abc86e069971b4de0175cbc941223574262040d270"

URI_x86_64_v2_rust-nalgebra+nalgebra-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+nalgebra-macros-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+nalgebra-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+nalgebra-macros-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+nalgebra-macros-devel.sha256sum] = "a9bdb4141df5eed76fc023e5bef4f900936d0190bb6c5da80b34a73bb0595614"

URI_x86_64_v2_rust-nalgebra+pest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+pest-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+pest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+pest-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+pest-devel.sha256sum] = "413eb023d7d9d50b55a7246735fc19e48ffa7be7dda83bf4d4495a51051aee97"

URI_x86_64_v2_rust-nalgebra+pest_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+pest_derive-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+pest_derive-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+pest_derive-devel.sha256sum] = "90b07ee012d19b12a412297445064181469bb4d8590f107d564f6c5c8f732fb6"

URI_x86_64_v2_rust-nalgebra+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+proptest-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+proptest-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+proptest-devel.sha256sum] = "20cae5a0b86d985ef7219aeaded6f2be6d52617d7f4dd013c2ba8648dc8768a8"

URI_x86_64_v2_rust-nalgebra+proptest-support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+proptest-support-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+proptest-support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+proptest-support-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+proptest-support-devel.sha256sum] = "2c3b169d60eb0cb35324ba0a2daa3081fea856738bb89400251ac9564e3a631e"

URI_x86_64_v2_rust-nalgebra+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+quickcheck-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+quickcheck-devel.sha256sum] = "ce9fddb5d8352c085601720b9745cd3641f4f3f2725cd6b82c6ef50c657d9136"

URI_x86_64_v2_rust-nalgebra+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+rand-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+rand-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+rand-devel.sha256sum] = "c350eb5712998eec17cb56316a566ddaf993c59beba057605b5742997eeb7b60"

URI_x86_64_v2_rust-nalgebra+rand-no-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+rand-no-std-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+rand-no-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+rand-no-std-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+rand-no-std-devel.sha256sum] = "7f6f5d6a82b58b359fa5a07b5be600c934b63beadf6bc0fc4e2aa6f881100113"

URI_x86_64_v2_rust-nalgebra+rand-package-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+rand-package-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+rand-package-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+rand-package-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+rand-package-devel.sha256sum] = "af1c3e988a3568fd166ac664529da85c61dca6d4149dc8d61716dec4a025eea1"

URI_x86_64_v2_rust-nalgebra+rand_distr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+rand_distr-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+rand_distr-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+rand_distr-devel.sha256sum] = "306442ff81f659a080c478853b0c0ac807e31e92172c27c8487f1d6d9d096847"

URI_x86_64_v2_rust-nalgebra+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+rayon-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+rayon-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+rayon-devel.sha256sum] = "3f8dadb3f4e0d81c8409eb511d5f309e12bf1f796773b76ab8122c06bba5b4e2"

URI_x86_64_v2_rust-nalgebra+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+serde-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+serde-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+serde-devel.sha256sum] = "137be8327f31a67731c3289120fccdb8bd39639974501f97072b931cb4253e27"

URI_x86_64_v2_rust-nalgebra+serde-serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+serde-serialize-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+serde-serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+serde-serialize-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+serde-serialize-devel.sha256sum] = "73f7058ca976726692f22335cec0a6ff8f20f6361bea5cfa9dbe10158d81761e"

URI_x86_64_v2_rust-nalgebra+serde-serialize-no-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+serde-serialize-no-std-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+serde-serialize-no-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+serde-serialize-no-std-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+serde-serialize-no-std-devel.sha256sum] = "8eedba34a6310b3201c9c0b2ad2c310b82e610f8a194c16e488c2004e44882ac"

URI_x86_64_v2_rust-nalgebra+slow-tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+slow-tests-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+slow-tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+slow-tests-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+slow-tests-devel.sha256sum] = "d1a876d3a13db61149b28bda6ba461a673749f04c1ee97a8d85887944e09fcdd"

URI_x86_64_v2_rust-nalgebra+sparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+sparse-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+sparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+sparse-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+sparse-devel.sha256sum] = "82fa198b82b2e0c43d11be9ee3e4cef8fe30b7e91f32bed74f9b948611729335"

URI_x86_64_v2_rust-nalgebra+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+std-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+std-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+std-devel.sha256sum] = "d074e868f705a6a9619e7b2831b5c82d79e4e10fbaf84eb5b10cbe8b1b82412a"

URI_x86_64_v2_rust-nalgebra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra-devel-0.33.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra-devel}"
SRC_URI[x86_64_v2_rust-nalgebra-devel.sha256sum] = "9f54c3140edf046ff443fe684acb0d5016199ff4f735f753e1949d4838a96fb2"

URI_aarch64_rust-nalgebra+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+alloc-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+alloc-devel}"
SRC_URI[aarch64_rust-nalgebra+alloc-devel.sha256sum] = "c6ed889d0773897054220c0d8e6e96df5de7a2f340d197aecada6476b9ef15dc"

URI_aarch64_rust-nalgebra+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+arbitrary-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+arbitrary-devel}"
SRC_URI[aarch64_rust-nalgebra+arbitrary-devel.sha256sum] = "7fc16ce7ce2e6f05d50fac5faf5c16e5349e0a76d568079f5ea314d92b7935da"

URI_aarch64_rust-nalgebra+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+bytemuck-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+bytemuck-devel}"
SRC_URI[aarch64_rust-nalgebra+bytemuck-devel.sha256sum] = "e403b4472501ba7170719448f33de13055eb9658f3eb22b1b8cfd35ecec550e3"

URI_aarch64_rust-nalgebra+compare-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+compare-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+compare-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+compare-devel}"
SRC_URI[aarch64_rust-nalgebra+compare-devel.sha256sum] = "3af4f9de48e3c9b6aeb1cb83043601cf74a6607c55c3315c8a745f2012f0592f"

URI_aarch64_rust-nalgebra+convert-bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+convert-bytemuck-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+convert-bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+convert-bytemuck-devel}"
SRC_URI[aarch64_rust-nalgebra+convert-bytemuck-devel.sha256sum] = "a7e2aac95fcb374258acf7652e5fb8e70dc121328ffc29508e1cc16ddd635a8b"

URI_aarch64_rust-nalgebra+convert-mint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+convert-mint-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+convert-mint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+convert-mint-devel}"
SRC_URI[aarch64_rust-nalgebra+convert-mint-devel.sha256sum] = "3a69c320754971a26491c2b25995e95de87f1430633e97ffd7844d811fdea3af"

URI_aarch64_rust-nalgebra+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+debug-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+debug-devel}"
SRC_URI[aarch64_rust-nalgebra+debug-devel.sha256sum] = "e7d1231300e2b57ef06d3e0756a78432f8b05623b5e271c31d828a1335e1c589"

URI_aarch64_rust-nalgebra+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+default-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+default-devel}"
SRC_URI[aarch64_rust-nalgebra+default-devel.sha256sum] = "a7910fbf08a957d9c79beed1479fd37f921f51f5bde2097e80187232280e67c5"

URI_aarch64_rust-nalgebra+io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+io-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+io-devel}"
SRC_URI[aarch64_rust-nalgebra+io-devel.sha256sum] = "23b64541589349631cc097a205981141b676f0c4884f18ebb74047f4071aa7a3"

URI_aarch64_rust-nalgebra+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+libm-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+libm-devel}"
SRC_URI[aarch64_rust-nalgebra+libm-devel.sha256sum] = "6446cd2adf35dbb1047a902b9c2748cf978502f047f1d1441ca8b70704afa186"

URI_aarch64_rust-nalgebra+libm-force-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+libm-force-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+libm-force-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+libm-force-devel}"
SRC_URI[aarch64_rust-nalgebra+libm-force-devel.sha256sum] = "ebe3158b591e9644a3e9293074525398e802c27be42c525d9fdad0fe1b902c57"

URI_aarch64_rust-nalgebra+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+macros-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+macros-devel}"
SRC_URI[aarch64_rust-nalgebra+macros-devel.sha256sum] = "a6e0dfeff85fa2bc58e4592fb3c418623678db26d6c3e42ab3024c787c102e4a"

URI_aarch64_rust-nalgebra+matrixcompare-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+matrixcompare-core-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+matrixcompare-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+matrixcompare-core-devel}"
SRC_URI[aarch64_rust-nalgebra+matrixcompare-core-devel.sha256sum] = "43a5b2828b4e69aadfc4d8a45b06338a6499352a26eb219fbf0fbe628be86ebd"

URI_aarch64_rust-nalgebra+matrixmultiply-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+matrixmultiply-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+matrixmultiply-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+matrixmultiply-devel}"
SRC_URI[aarch64_rust-nalgebra+matrixmultiply-devel.sha256sum] = "edb41efba4c99330c3ca1ce9d78c3db15cbafc696cfdd87bc2b9df732c349735"

URI_aarch64_rust-nalgebra+mint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+mint-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+mint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+mint-devel}"
SRC_URI[aarch64_rust-nalgebra+mint-devel.sha256sum] = "3a9569515e4d230082d7ccf088c0aeffdc501ef75477774c13fabb0dad26582d"

URI_aarch64_rust-nalgebra+nalgebra-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+nalgebra-macros-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+nalgebra-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+nalgebra-macros-devel}"
SRC_URI[aarch64_rust-nalgebra+nalgebra-macros-devel.sha256sum] = "6e726862ddb9918d2b9a64560fa23ccdc0f5da4bcac408c5c94cf0ee808be0a8"

URI_aarch64_rust-nalgebra+pest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+pest-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+pest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+pest-devel}"
SRC_URI[aarch64_rust-nalgebra+pest-devel.sha256sum] = "7400d0da141063e0bbcdf504a96987918af17009c43c521ec6a97a49fd25c4b7"

URI_aarch64_rust-nalgebra+pest_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+pest_derive-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+pest_derive-devel}"
SRC_URI[aarch64_rust-nalgebra+pest_derive-devel.sha256sum] = "3faa7db077d7f3366b86c8e364c403a48f5a1f8f2ba239adf76ce5efeb62c2ef"

URI_aarch64_rust-nalgebra+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+proptest-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+proptest-devel}"
SRC_URI[aarch64_rust-nalgebra+proptest-devel.sha256sum] = "70733d941906bcf1a5f60cc4fe377dd557ba94d1afbde5f7ffe6a04ac5fc38fb"

URI_aarch64_rust-nalgebra+proptest-support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+proptest-support-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+proptest-support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+proptest-support-devel}"
SRC_URI[aarch64_rust-nalgebra+proptest-support-devel.sha256sum] = "b119527df2974fdc897e9dd3932aa9bb858b1dea51bca2f5fb80314516c974da"

URI_aarch64_rust-nalgebra+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+quickcheck-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+quickcheck-devel}"
SRC_URI[aarch64_rust-nalgebra+quickcheck-devel.sha256sum] = "3c74d115766cfa529e1651d68492cfb4aaeeb9aa8d6c12dd1dec470e20396d7a"

URI_aarch64_rust-nalgebra+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+rand-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+rand-devel}"
SRC_URI[aarch64_rust-nalgebra+rand-devel.sha256sum] = "8ec7dfdd550fcbc11dc936dd049b89a9fa8d78b4aeaaa9b6e1da588356c9bf17"

URI_aarch64_rust-nalgebra+rand-no-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+rand-no-std-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+rand-no-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+rand-no-std-devel}"
SRC_URI[aarch64_rust-nalgebra+rand-no-std-devel.sha256sum] = "cd8002ea3e3ebf7242f7df576d069653fc87a014c7990c94223d0d69c7dbcdc9"

URI_aarch64_rust-nalgebra+rand-package-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+rand-package-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+rand-package-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+rand-package-devel}"
SRC_URI[aarch64_rust-nalgebra+rand-package-devel.sha256sum] = "bc6b5cde783ac2a02ed78b4d0fc469190595971c5a7d234b4b56327c8c42c8de"

URI_aarch64_rust-nalgebra+rand_distr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+rand_distr-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+rand_distr-devel}"
SRC_URI[aarch64_rust-nalgebra+rand_distr-devel.sha256sum] = "fc1642ce3b631b7d3a66c32cc23112910a928146cfecacd7476b548bfda4e0fa"

URI_aarch64_rust-nalgebra+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+rayon-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+rayon-devel}"
SRC_URI[aarch64_rust-nalgebra+rayon-devel.sha256sum] = "a487c6e68e0dbd0f1a4e743880324d7e499c5a4764b08a1432017c57b68b4e3e"

URI_aarch64_rust-nalgebra+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+serde-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+serde-devel}"
SRC_URI[aarch64_rust-nalgebra+serde-devel.sha256sum] = "74a843b5b5bbe0ad1e95ed8c66b040f3f6f7528e968c840efb4689cb19348985"

URI_aarch64_rust-nalgebra+serde-serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+serde-serialize-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+serde-serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+serde-serialize-devel}"
SRC_URI[aarch64_rust-nalgebra+serde-serialize-devel.sha256sum] = "f28eb1e4057ec311449a3b36d48c62e7aaa5d6aac7e7b910a8e60b51edc7d1f2"

URI_aarch64_rust-nalgebra+serde-serialize-no-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+serde-serialize-no-std-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+serde-serialize-no-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+serde-serialize-no-std-devel}"
SRC_URI[aarch64_rust-nalgebra+serde-serialize-no-std-devel.sha256sum] = "9592ddf60c5fb74090e48456677913f4ae36a572b503bb530e5730292b57f75d"

URI_aarch64_rust-nalgebra+slow-tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+slow-tests-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+slow-tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+slow-tests-devel}"
SRC_URI[aarch64_rust-nalgebra+slow-tests-devel.sha256sum] = "69b004d8e070bed2cbc1a3509e13a3e457d833cc1afce69e5c4a47280125b420"

URI_aarch64_rust-nalgebra+sparse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+sparse-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+sparse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+sparse-devel}"
SRC_URI[aarch64_rust-nalgebra+sparse-devel.sha256sum] = "fa16c79b88b76a8c11a5fe8449ea0dfe8aae39d0d18f6e93a10b9a600f6f9fce"

URI_aarch64_rust-nalgebra+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+std-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+std-devel}"
SRC_URI[aarch64_rust-nalgebra+std-devel.sha256sum] = "c6f8a77469178e3fd20958995d090583e8dfb2198c80c46028ccb306d463062e"

URI_aarch64_rust-nalgebra-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra-devel-0.33.2-2.el10_1.noarch.rpm;name=aarch64_rust-nalgebra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra-devel}"
SRC_URI[aarch64_rust-nalgebra-devel.sha256sum] = "cdf14458aaa4b2a87961915f16a39ba063c29512e7d65961a34801e860268cdb"

RDEPENDS:rust-nalgebra+alloc-devel = " \
 cargo \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+arbitrary-devel = " \
 cargo \
 rust-nalgebra+quickcheck-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+compare-devel = " \
 cargo \
 rust-nalgebra+matrixcompare-core-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+convert-bytemuck-devel = " \
 cargo \
 rust-nalgebra+bytemuck-devel \
 rust-nalgebra-devel \
 rust-num-complex+bytemuck-devel \
 "
RDEPENDS:rust-nalgebra+convert-mint-devel = " \
 cargo \
 rust-nalgebra+mint-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+debug-devel = " \
 cargo \
 rust-approx+num-complex-devel \
 rust-nalgebra+rand-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+default-devel = " \
 cargo \
 rust-nalgebra+macros-devel \
 rust-nalgebra+std-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+io-devel = " \
 cargo \
 rust-nalgebra+pest-devel \
 rust-nalgebra+pest_derive-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+libm-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-simba+libm-devel \
 "
RDEPENDS:rust-nalgebra+libm-force-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-simba+libm_force-devel \
 "
RDEPENDS:rust-nalgebra+macros-devel = " \
 cargo \
 rust-nalgebra+nalgebra-macros-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+matrixcompare-core-devel = " \
 cargo \
 rust-matrixcompare-core+default-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+matrixmultiply-devel = " \
 cargo \
 rust-matrixmultiply+default-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+mint-devel = " \
 cargo \
 rust-mint+default-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+nalgebra-macros-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-nalgebra-macros+default-devel \
 "
RDEPENDS:rust-nalgebra+pest-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-pest+default-devel \
 "
RDEPENDS:rust-nalgebra+pest_derive-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-pest_derive+default-devel \
 "
RDEPENDS:rust-nalgebra+proptest-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-nalgebra+proptest-support-devel = " \
 cargo \
 rust-nalgebra+proptest-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+quickcheck-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-quickcheck+default-devel \
 "
RDEPENDS:rust-nalgebra+rand-devel = " \
 cargo \
 rust-nalgebra+rand-no-std-devel \
 rust-nalgebra+rand_distr-devel \
 rust-nalgebra-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-nalgebra+rand-no-std-devel = " \
 cargo \
 rust-nalgebra+rand-package-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+rand-package-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-nalgebra+rand_distr-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-rand_distr0.4-devel \
 "
RDEPENDS:rust-nalgebra+rayon-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-nalgebra+serde-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-nalgebra+serde-serialize-devel = " \
 cargo \
 rust-nalgebra+serde-serialize-no-std-devel \
 rust-nalgebra-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-nalgebra+serde-serialize-no-std-devel = " \
 cargo \
 rust-nalgebra+serde-devel \
 rust-nalgebra-devel \
 rust-num-complex+serde-devel \
 "
RDEPENDS:rust-nalgebra+slow-tests-devel = " \
 cargo \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+sparse-devel = " \
 cargo \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+std-devel = " \
 cargo \
 rust-approx+std-devel \
 rust-nalgebra+matrixmultiply-devel \
 rust-nalgebra-devel \
 rust-num-complex+std-devel \
 rust-num-rational+std-devel \
 rust-num-traits+std-devel \
 rust-simba+std-devel \
 "
RDEPENDS:rust-nalgebra-devel = " \
 cargo \
 rust-approx-devel \
 rust-num-complex-devel \
 rust-num-rational-devel \
 rust-num-traits-devel \
 rust-simba-devel \
 rust-typenum+default-devel \
 "
