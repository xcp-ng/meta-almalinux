# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-mod_wsgi"
PV = "5.0.2"
PR = "5.el10"
PACKAGES = " \
 python3.14-mod_wsgi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-mod_wsgi-5.0.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c38ff0e57c72a1210605642db0d4dbde0db941ec1654a4e9856cea3583f35dc9"

URI_x86_64_v2_python3.14-mod_wsgi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-mod_wsgi-5.0.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-mod_wsgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-mod_wsgi}"
SRC_URI[x86_64_v2_python3.14-mod_wsgi.sha256sum] = "d18ae42034f2717bf4074a7833e7d9c1cde15f3aeb4e8813bd7fa1b9bf02dc5b"

URI_aarch64_python3.14-mod_wsgi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-mod_wsgi-5.0.2-5.el10.aarch64.rpm;name=aarch64_python3.14-mod_wsgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-mod_wsgi}"
SRC_URI[aarch64_python3.14-mod_wsgi.sha256sum] = "ee813a54e85450547266f92a82808af216dc169431ca4276066096b6a7b1f544"

RDEPENDS:python3.14-mod_wsgi = " \
 glibc \
 httpd-core \
 python3.14 \
 python3.14-libs \
 "
