# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libeatmydata"
PV = "131"
PR = "1.el10_1"
PACKAGES = " \
 eatmydata \
 libeatmydata \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libeatmydata-131-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0c5214499e3fad2466aba324eb43052811c66a80ab998c2966b2d23dfc178e67"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eatmydata-131-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eatmydata;unpack=0"
SRC_URI[x86_64_v2_eatmydata.sha256sum] = "80c7b3f88495086c9749f6eb6a00d24ff3e514a5c1202894c922bf8cf99cdd1f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libeatmydata-131-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libeatmydata;unpack=0"
SRC_URI[x86_64_v2_libeatmydata.sha256sum] = "2a33c1170acfcc060e3399090b7e0a9b6b97405763bf317c90505392ad1a1dad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/eatmydata-131-1.el10_1.aarch64.rpm;name=aarch64_eatmydata;unpack=0"
SRC_URI[aarch64_eatmydata.sha256sum] = "262fb9801107179c40421c73a43662faf44dd071982c6c7d0ca2df16ffc6595d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libeatmydata-131-1.el10_1.aarch64.rpm;name=aarch64_libeatmydata;unpack=0"
SRC_URI[aarch64_libeatmydata.sha256sum] = "50dbfcbab15e1ac29434b7f0053ca19413a4bec2a7e13e85763a63a446e3eab8"

RDEPENDS:eatmydata = " \
 bash \
 libeatmydata \
 "
RDEPENDS:libeatmydata = " \
 glibc \
 "
