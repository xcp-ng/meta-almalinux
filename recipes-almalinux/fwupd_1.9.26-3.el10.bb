# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fwupd"
PV = "1.9.26"
PR = "3.el10"
PACKAGES = " \
 fwupd \
 fwupd-devel \
 fwupd-plugin-flashrom \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/fwupd-1.9.26-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e463e52fb73554073f37372df20d4f7699ed5dd4934e28ad07998f42934e0f24"

URI_x86_64_v2_fwupd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/fwupd-1.9.26-3.el10.x86_64_v2.rpm;name=x86_64_v2_fwupd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fwupd}"
SRC_URI[x86_64_v2_fwupd.sha256sum] = "b2fd71415fd76b376646a6c462b995d847b54e3eec452fcd3d2d3e3873e9c58f"

URI_x86_64_v2_fwupd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fwupd-devel-1.9.26-3.el10.x86_64_v2.rpm;name=x86_64_v2_fwupd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fwupd-devel}"
SRC_URI[x86_64_v2_fwupd-devel.sha256sum] = "7758d8d65d13a312353b11f1214926a4c641c48edb13985c58dba3e882a7bd36"

URI_x86_64_v2_fwupd-plugin-flashrom = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fwupd-plugin-flashrom-1.9.26-3.el10.x86_64_v2.rpm;name=x86_64_v2_fwupd-plugin-flashrom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fwupd-plugin-flashrom}"
SRC_URI[x86_64_v2_fwupd-plugin-flashrom.sha256sum] = "18412c19d7401db5bf203c5aed880325e70bce0e9d5e9f5e8452d0b9fd095a06"

URI_aarch64_fwupd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/fwupd-1.9.26-3.el10.aarch64.rpm;name=aarch64_fwupd;unpack=0"
SRC_URI:append = " ${URI_aarch64_fwupd}"
SRC_URI[aarch64_fwupd.sha256sum] = "525d5aeddb004282f46ce50559fb0fab81fa567d05c4f4355dd576e37a74ed20"

URI_aarch64_fwupd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fwupd-devel-1.9.26-3.el10.aarch64.rpm;name=aarch64_fwupd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fwupd-devel}"
SRC_URI[aarch64_fwupd-devel.sha256sum] = "ae9df1c6dcbdcd3c8f4fc18d8655d5e43ef726aef6eb6db739f1817be35a98b5"

URI_aarch64_fwupd-plugin-flashrom = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fwupd-plugin-flashrom-1.9.26-3.el10.aarch64.rpm;name=aarch64_fwupd-plugin-flashrom;unpack=0"
SRC_URI:append = " ${URI_aarch64_fwupd-plugin-flashrom}"
SRC_URI[aarch64_fwupd-plugin-flashrom.sha256sum] = "6c34181fddf86e26ee6feb53c66b31a79e2b960d29cba54fa91e42486e5be5c1"

RDEPENDS:fwupd = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 json-glib \
 libarchive \
 libgcc \
 libgudev \
 libgusb \
 libjcat \
 libxmlb \
 polkit-libs \
 shared-mime-info \
 sqlite-libs \
 systemd \
 systemd-libs \
 tpm2-tss \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:fwupd-devel = " \
 fwupd \
 glib2-devel \
 json-glib-devel \
 libcurl-devel \
 libjcat-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:fwupd-plugin-flashrom = " \
 flashrom \
 fwupd \
 glib2 \
 glibc \
 libgcc \
 "
