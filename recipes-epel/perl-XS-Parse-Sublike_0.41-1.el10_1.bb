# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XS-Parse-Sublike"
PV = "0.41"
PR = "1.el10_1"
PACKAGES = " \
 perl-XS-Parse-Sublike \
 perl-XS-Parse-Sublike-Builder \
 perl-XS-Parse-Sublike-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XS-Parse-Sublike-0.41-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e5443e54ee8117e5cd550fcb57d084631c75d89802c65375b023431fab418ef"

URI_x86_64_v2_perl-XS-Parse-Sublike = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XS-Parse-Sublike-0.41-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Sublike;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Sublike}"
SRC_URI[x86_64_v2_perl-XS-Parse-Sublike.sha256sum] = "8287386bba36ab3361743f5a93d4eb4c769658c2c827bc2931eabe95c4a20377"

URI_x86_64_v2_perl-XS-Parse-Sublike-Builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XS-Parse-Sublike-Builder-0.41-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Sublike-Builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Sublike-Builder}"
SRC_URI[x86_64_v2_perl-XS-Parse-Sublike-Builder.sha256sum] = "ffc39a96407a65ea1e32f1c1b9e2ba7200aaa2bc7cb051324ef269897c65b70c"

URI_x86_64_v2_perl-XS-Parse-Sublike-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XS-Parse-Sublike-tests-0.41-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Sublike-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Sublike-tests}"
SRC_URI[x86_64_v2_perl-XS-Parse-Sublike-tests.sha256sum] = "abb56f91039c1f648227ad326ffe8ba9109146e3a50348e8f3a006c465eb2c2f"

URI_aarch64_perl-XS-Parse-Sublike = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XS-Parse-Sublike-0.41-1.el10_1.aarch64.rpm;name=aarch64_perl-XS-Parse-Sublike;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Sublike}"
SRC_URI[aarch64_perl-XS-Parse-Sublike.sha256sum] = "2dc71b9f5823901580d13076b7cdfdcae6dffe366267c86de1fd8c238c8bcf92"

URI_aarch64_perl-XS-Parse-Sublike-Builder = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XS-Parse-Sublike-Builder-0.41-1.el10_1.aarch64.rpm;name=aarch64_perl-XS-Parse-Sublike-Builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Sublike-Builder}"
SRC_URI[aarch64_perl-XS-Parse-Sublike-Builder.sha256sum] = "d2f4b4caa666d2b532083911efa5d45aba5ad0fc8a1456717ff62948bb145b3e"

URI_aarch64_perl-XS-Parse-Sublike-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XS-Parse-Sublike-tests-0.41-1.el10_1.aarch64.rpm;name=aarch64_perl-XS-Parse-Sublike-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Sublike-tests}"
SRC_URI[aarch64_perl-XS-Parse-Sublike-tests.sha256sum] = "ccfa4fb5cc200eb8ba8be6c996811edb8f7968454d118419922556d8cc92b124"

RDEPENDS:perl-XS-Parse-Sublike = " \
 glibc \
 perl-Carp \
 perl-XS-Parse-Sublike \
 perl-libs \
 "
RDEPENDS:perl-XS-Parse-Sublike-Builder = " \
 perl-File-ShareDir \
 perl-PathTools \
 perl-XS-Parse-Sublike \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-XS-Parse-Sublike-tests = " \
 bash \
 glibc \
 perl-B \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Test2-Suite \
 perl-XS-Parse-Sublike \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
