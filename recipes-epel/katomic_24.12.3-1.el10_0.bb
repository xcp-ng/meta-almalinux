# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "katomic"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 katomic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/katomic-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2963c4d8af0948bfa4fff91f08457545ab6e9111fd24e3c73b2e76d9294d6f2f"

URI_x86_64_v2_katomic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/katomic-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_katomic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_katomic}"
SRC_URI[x86_64_v2_katomic.sha256sum] = "dd59e1943ad4d226b221a3b81e4cc3f1455104c45e3a4571451f982b9c224e43"

URI_aarch64_katomic = "${EPEL_MIRROR}/aarch64/Packages/k/katomic-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_katomic;unpack=0"
SRC_URI:append = " ${URI_aarch64_katomic}"
SRC_URI[aarch64_katomic.sha256sum] = "7cbd3a544d520ae115f63df3d808f739cc2e83249ef8ff9ba1afb4013fa3bf18"

RDEPENDS:katomic = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
