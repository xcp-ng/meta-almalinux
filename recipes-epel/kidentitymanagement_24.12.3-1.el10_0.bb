# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kidentitymanagement"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kidentitymanagement \
 kidentitymanagement-devel \
 kidentitymanagement-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kidentitymanagement-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8d9400984ce11e6b127140159261c46430ac9f921e08231075d11202f6cc37e"

URI_x86_64_v2_kidentitymanagement = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kidentitymanagement-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kidentitymanagement;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kidentitymanagement}"
SRC_URI[x86_64_v2_kidentitymanagement.sha256sum] = "b50403961ded6ffc1595238cb93d6d0f2b5f39a5d657556f22e8d721e9e82620"

URI_x86_64_v2_kidentitymanagement-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kidentitymanagement-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kidentitymanagement-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kidentitymanagement-devel}"
SRC_URI[x86_64_v2_kidentitymanagement-devel.sha256sum] = "560d8fe3534ab9747d802bfe4a6e2b935cd9f89e98829db59e63851c12fde26c"

URI_x86_64_v2_kidentitymanagement-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kidentitymanagement-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kidentitymanagement-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kidentitymanagement-doc}"
SRC_URI[x86_64_v2_kidentitymanagement-doc.sha256sum] = "b1c2a6e673ee4ca9fc60d825462b91719b9c528d1154e5671ae44d740e79de1a"

URI_aarch64_kidentitymanagement = "${EPEL_MIRROR}/aarch64/Packages/k/kidentitymanagement-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kidentitymanagement;unpack=0"
SRC_URI:append = " ${URI_aarch64_kidentitymanagement}"
SRC_URI[aarch64_kidentitymanagement.sha256sum] = "246f3cb603e432740486162d49e308a73a8539295531929f7170abf5de56bac5"

URI_aarch64_kidentitymanagement-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kidentitymanagement-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kidentitymanagement-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kidentitymanagement-devel}"
SRC_URI[aarch64_kidentitymanagement-devel.sha256sum] = "a6d4c48b36877cc2c8ff7c3caca1616eb2d9b30c76667f5b7024cefa886afed2"

URI_aarch64_kidentitymanagement-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kidentitymanagement-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kidentitymanagement-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kidentitymanagement-doc}"
SRC_URI[aarch64_kidentitymanagement-doc.sha256sum] = "a8c21d0b0ebb7db8f56723d8f947adf073ee2aa909f454278ee079c216e11cd3"

RDEPENDS:kidentitymanagement = " \
 glibc \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kpimtextedit \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kidentitymanagement-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kidentitymanagement \
 kpimtextedit-devel \
 "
RDEPENDS:kidentitymanagement-doc = " \
 "
