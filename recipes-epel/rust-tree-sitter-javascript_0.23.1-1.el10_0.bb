# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-javascript"
PV = "0.23.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-javascript+default-devel \
 rust-tree-sitter-javascript-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-javascript-0.23.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d10072cb8c03c3f65cb5e8c0668298ed0ca1669afacbdd0d1f92c5a8c4b305d3"

URI_x86_64_v2_rust-tree-sitter-javascript+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-javascript+default-devel-0.23.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-javascript+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-javascript+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-javascript+default-devel.sha256sum] = "8ac3bc512aaa0bc57db1336b69d6d14cd32167919623749b33948df748bf686f"

URI_x86_64_v2_rust-tree-sitter-javascript-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-javascript-devel-0.23.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-javascript-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-javascript-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-javascript-devel.sha256sum] = "bb338903d111f9c4a116011586b42bde4a014967883847e00a2b4a21fdbbf57a"

URI_aarch64_rust-tree-sitter-javascript+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-javascript+default-devel-0.23.1-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-javascript+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-javascript+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-javascript+default-devel.sha256sum] = "6400eb3efce1fa09ceba84c70a0d2e249eca35262bea3a1254a468a6fe5b34e8"

URI_aarch64_rust-tree-sitter-javascript-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-javascript-devel-0.23.1-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-javascript-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-javascript-devel}"
SRC_URI[aarch64_rust-tree-sitter-javascript-devel.sha256sum] = "a020a781410fe07698d5ffb396fb151fc9c37b422fdb6d86cae0766245b4fe3f"

RDEPENDS:rust-tree-sitter-javascript+default-devel = " \
 cargo \
 rust-tree-sitter-javascript-devel \
 "
RDEPENDS:rust-tree-sitter-javascript-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
