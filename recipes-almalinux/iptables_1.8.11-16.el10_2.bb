# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iptables"
PV = "1.8.11"
PR = "16.el10_2"
PACKAGES = " \
 iptables-devel \
 iptables-libs \
 iptables-nft \
 iptables-nft-services \
 iptables-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iptables-1.8.11-16.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e2b4216b4fa8865bc97d0c1fde3bebec325b569591341dedca857fbc01c934a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-devel-1.8.11-16.el10_2.x86_64_v2.rpm;name=x86_64_v2_iptables-devel;unpack=0"
SRC_URI[x86_64_v2_iptables-devel.sha256sum] = "907ba5c34a67234f5a92d70265ec8c1ecbb96e5a27f84d1c32a442c6f375be5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iptables-libs-1.8.11-16.el10_2.x86_64_v2.rpm;name=x86_64_v2_iptables-libs;unpack=0"
SRC_URI[x86_64_v2_iptables-libs.sha256sum] = "333b0aac978ce354ed3f7fbe63fb6bc68caeee51e08c015339cec6a910109af3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-nft-1.8.11-16.el10_2.x86_64_v2.rpm;name=x86_64_v2_iptables-nft;unpack=0"
SRC_URI[x86_64_v2_iptables-nft.sha256sum] = "15f3cd0fac031c0cc11c615a7898f6f5461bccf59af22b9e4467fef90978aded"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-nft-services-1.8.11-16.el10_2.noarch.rpm;name=x86_64_v2_iptables-nft-services;unpack=0"
SRC_URI[x86_64_v2_iptables-nft-services.sha256sum] = "a4884b26c90a7bddecc994120ad3b75e37ddb75fb8df8a9a9bda97b9aaea488f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-utils-1.8.11-16.el10_2.x86_64_v2.rpm;name=x86_64_v2_iptables-utils;unpack=0"
SRC_URI[x86_64_v2_iptables-utils.sha256sum] = "314eeb204a0dcb3ed80d1404fbf8619fa5169575c45ad07d094052f93c4cc6f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-devel-1.8.11-16.el10_2.aarch64.rpm;name=aarch64_iptables-devel;unpack=0"
SRC_URI[aarch64_iptables-devel.sha256sum] = "e054c591b995ffafd33d46907adc1397bb7972882018a2f63ccd69457523dee4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iptables-libs-1.8.11-16.el10_2.aarch64.rpm;name=aarch64_iptables-libs;unpack=0"
SRC_URI[aarch64_iptables-libs.sha256sum] = "905d22d4c355873207d7bdf5d543700dc74ea6aaf1f4d4c3ffa930bb6a91811d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-nft-1.8.11-16.el10_2.aarch64.rpm;name=aarch64_iptables-nft;unpack=0"
SRC_URI[aarch64_iptables-nft.sha256sum] = "6503b25eaf53b7e447504931a75e2d3237ba6ef0a128bebe85fae93968b6078a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-nft-services-1.8.11-16.el10_2.noarch.rpm;name=aarch64_iptables-nft-services;unpack=0"
SRC_URI[aarch64_iptables-nft-services.sha256sum] = "a4884b26c90a7bddecc994120ad3b75e37ddb75fb8df8a9a9bda97b9aaea488f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-utils-1.8.11-16.el10_2.aarch64.rpm;name=aarch64_iptables-utils;unpack=0"
SRC_URI[aarch64_iptables-utils.sha256sum] = "02a9b5c5d0b5a9bbca879f163de54c60f997f7197a3605074f7b1ed98f0f4f3e"

RDEPENDS:iptables-devel = " \
 iptables-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:iptables-libs = " \
 glibc \
 libnetfilter_conntrack \
 "
RDEPENDS:iptables-nft = " \
 alternatives \
 bash \
 glibc \
 iptables-libs \
 libmnl \
 libnftnl \
 virtual//usr/bin/readlink \
 "
RDEPENDS:iptables-nft-services = " \
 bash \
 iptables-nft \
 "
RDEPENDS:iptables-utils = " \
 bash \
 glibc \
 iptables-nft \
 libnfnetlink \
 libpcap \
 "
