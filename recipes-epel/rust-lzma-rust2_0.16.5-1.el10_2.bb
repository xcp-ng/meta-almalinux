# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lzma-rust2"
PV = "0.16.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-lzma-rust2+default-devel \
 rust-lzma-rust2+encoder-devel \
 rust-lzma-rust2+lzip-devel \
 rust-lzma-rust2+optimization-devel \
 rust-lzma-rust2+sha2-devel \
 rust-lzma-rust2+std-devel \
 rust-lzma-rust2+xz-devel \
 rust-lzma-rust2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lzma-rust2-0.16.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4c1952459045f3e764576e3441d7fc2130b9009b5c9d24ccf0f34a4fc9bf628"

URI_x86_64_v2_rust-lzma-rust2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2+default-devel-0.16.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rust2+default-devel}"
SRC_URI[x86_64_v2_rust-lzma-rust2+default-devel.sha256sum] = "10b7376569e434dcaeb5980d1dda424c14d47934d53ffb78620476aef41eb733"

URI_x86_64_v2_rust-lzma-rust2+encoder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2+encoder-devel-0.16.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2+encoder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rust2+encoder-devel}"
SRC_URI[x86_64_v2_rust-lzma-rust2+encoder-devel.sha256sum] = "e29112979486438705d3a2844057e398b71c9abba58078ba75c54a32a1d8034b"

URI_x86_64_v2_rust-lzma-rust2+lzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2+lzip-devel-0.16.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2+lzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rust2+lzip-devel}"
SRC_URI[x86_64_v2_rust-lzma-rust2+lzip-devel.sha256sum] = "cdd11e3db76ba9f217cc65a0fa557cb907dfcdef9e74a5d09a3359b157518d40"

URI_x86_64_v2_rust-lzma-rust2+optimization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2+optimization-devel-0.16.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2+optimization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rust2+optimization-devel}"
SRC_URI[x86_64_v2_rust-lzma-rust2+optimization-devel.sha256sum] = "851092eec9594d102a4573b2803d154607576a7cb39f2156d0b96c3e012c5b41"

URI_x86_64_v2_rust-lzma-rust2+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2+sha2-devel-0.16.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rust2+sha2-devel}"
SRC_URI[x86_64_v2_rust-lzma-rust2+sha2-devel.sha256sum] = "a5760c2a6053aabb2df286f39d9abb4fe6bbb11e99ba52b7189d0335fc05400d"

URI_x86_64_v2_rust-lzma-rust2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2+std-devel-0.16.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rust2+std-devel}"
SRC_URI[x86_64_v2_rust-lzma-rust2+std-devel.sha256sum] = "e33742082d7cae57621eca7d4bc397e79c2def8b63c7a6bb18c13fd888b84f8e"

URI_x86_64_v2_rust-lzma-rust2+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2+xz-devel-0.16.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rust2+xz-devel}"
SRC_URI[x86_64_v2_rust-lzma-rust2+xz-devel.sha256sum] = "22c0830b1ff73a48e386b8f09485f1c62608752999f11ab76c5b1d3c225bbc21"

URI_x86_64_v2_rust-lzma-rust2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2-devel-0.16.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rust2-devel}"
SRC_URI[x86_64_v2_rust-lzma-rust2-devel.sha256sum] = "b7d1f2885103e5d26c82c6014848982000449f855224b47ebf1ab77110f4afe5"

URI_aarch64_rust-lzma-rust2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2+default-devel-0.16.5-1.el10_2.noarch.rpm;name=aarch64_rust-lzma-rust2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rust2+default-devel}"
SRC_URI[aarch64_rust-lzma-rust2+default-devel.sha256sum] = "eab91107aaf9a6636cbc0a078c0a59287c7f31c847acead9c246dd377d278be1"

URI_aarch64_rust-lzma-rust2+encoder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2+encoder-devel-0.16.5-1.el10_2.noarch.rpm;name=aarch64_rust-lzma-rust2+encoder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rust2+encoder-devel}"
SRC_URI[aarch64_rust-lzma-rust2+encoder-devel.sha256sum] = "012763b6f500870b1a38732673212e1712dddfcb4bb6f8b256ecc96c9b89e070"

URI_aarch64_rust-lzma-rust2+lzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2+lzip-devel-0.16.5-1.el10_2.noarch.rpm;name=aarch64_rust-lzma-rust2+lzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rust2+lzip-devel}"
SRC_URI[aarch64_rust-lzma-rust2+lzip-devel.sha256sum] = "06b8ebe528304fbbf574e8fb8ad6f701a73b88887c8cae9dd1f967c94dd9f368"

URI_aarch64_rust-lzma-rust2+optimization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2+optimization-devel-0.16.5-1.el10_2.noarch.rpm;name=aarch64_rust-lzma-rust2+optimization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rust2+optimization-devel}"
SRC_URI[aarch64_rust-lzma-rust2+optimization-devel.sha256sum] = "694f550ad54c6aa115ce518ba91716cc11935a8fdb06bb0e44b0b9e995b7ba54"

URI_aarch64_rust-lzma-rust2+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2+sha2-devel-0.16.5-1.el10_2.noarch.rpm;name=aarch64_rust-lzma-rust2+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rust2+sha2-devel}"
SRC_URI[aarch64_rust-lzma-rust2+sha2-devel.sha256sum] = "254613c5c2860aee9f269c02739572cd9936643a1f14e3ce17b5075afa4cc167"

URI_aarch64_rust-lzma-rust2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2+std-devel-0.16.5-1.el10_2.noarch.rpm;name=aarch64_rust-lzma-rust2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rust2+std-devel}"
SRC_URI[aarch64_rust-lzma-rust2+std-devel.sha256sum] = "2086f99b243662787ded0281d287ef0cfa2ba24ec541008b94dbe5d801ad8900"

URI_aarch64_rust-lzma-rust2+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2+xz-devel-0.16.5-1.el10_2.noarch.rpm;name=aarch64_rust-lzma-rust2+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rust2+xz-devel}"
SRC_URI[aarch64_rust-lzma-rust2+xz-devel.sha256sum] = "a08132b465fa411ec57dc434b117e86f02ac44a5d0e0c720db588bc43e46b3a9"

URI_aarch64_rust-lzma-rust2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2-devel-0.16.5-1.el10_2.noarch.rpm;name=aarch64_rust-lzma-rust2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rust2-devel}"
SRC_URI[aarch64_rust-lzma-rust2-devel.sha256sum] = "7a29406b3e5deeaa49f1b30751cee699071eefd7e5cef6df26760789a99f04bb"

RDEPENDS:rust-lzma-rust2+default-devel = " \
 cargo \
 rust-lzma-rust2+encoder-devel \
 rust-lzma-rust2+lzip-devel \
 rust-lzma-rust2+optimization-devel \
 rust-lzma-rust2+std-devel \
 rust-lzma-rust2+xz-devel \
 rust-lzma-rust2-devel \
 "
RDEPENDS:rust-lzma-rust2+encoder-devel = " \
 cargo \
 rust-lzma-rust2-devel \
 "
RDEPENDS:rust-lzma-rust2+lzip-devel = " \
 cargo \
 rust-lzma-rust2-devel \
 "
RDEPENDS:rust-lzma-rust2+optimization-devel = " \
 cargo \
 rust-lzma-rust2-devel \
 "
RDEPENDS:rust-lzma-rust2+sha2-devel = " \
 cargo \
 rust-lzma-rust2-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-lzma-rust2+std-devel = " \
 cargo \
 rust-lzma-rust2-devel \
 "
RDEPENDS:rust-lzma-rust2+xz-devel = " \
 cargo \
 rust-lzma-rust2+sha2-devel \
 rust-lzma-rust2-devel \
 "
RDEPENDS:rust-lzma-rust2-devel = " \
 cargo \
 rust \
 "
