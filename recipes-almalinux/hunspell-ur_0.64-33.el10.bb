# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ur"
PV = "0.64"
PR = "33.el10"
PACKAGES = " \
 hunspell-ur \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ur-0.64-33.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f9a710b80d2cdff91d964f20ce6a0a3bf290f61d4f3beb658de5c49080c30165"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ur-0.64-33.el10.noarch.rpm;name=x86_64_v2_hunspell-ur;unpack=0"
SRC_URI[x86_64_v2_hunspell-ur.sha256sum] = "0a7c21dd9e0e257c3181474986b85d8cb9a8ddcd7d208359b295bcf03e4a949a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ur-0.64-33.el10.noarch.rpm;name=aarch64_hunspell-ur;unpack=0"
SRC_URI[aarch64_hunspell-ur.sha256sum] = "0a7c21dd9e0e257c3181474986b85d8cb9a8ddcd7d208359b295bcf03e4a949a"

RDEPENDS:hunspell-ur = " \
 hunspell-filesystem \
 "
