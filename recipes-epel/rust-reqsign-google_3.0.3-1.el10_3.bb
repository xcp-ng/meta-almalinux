# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-google"
PV = "3.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-google+default-devel \
 rust-reqsign-google-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-google-3.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "01a072868a160076a42970bb6ae4ff1a9a9c5775299a1a892c26e06573e9a2e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-google+default-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-google+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-google+default-devel.sha256sum] = "312887bfae29be1552a30a427af325d230c598501c7b30fa8a590aea839ecae3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-google-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-google-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-google-devel.sha256sum] = "31c8cc82387aba302fb684d957381aaa00bc50497c1be3132e7fe2c23e2d3817"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-google+default-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-google+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-google+default-devel.sha256sum] = "fba8484f375b701b0d1ae4d3b8ad5fd7bfb31ac713f1872a184ab66db386190f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-google-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-google-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-google-devel.sha256sum] = "db5a80ed99957c388d83a7fb78f2d224ca51b5df94e979584f0d557cd5d54a79"

RDEPENDS:rust-reqsign-google+default-devel = " \
 cargo \
 rust-reqsign-google-devel \
 "
RDEPENDS:rust-reqsign-google-devel = " \
 cargo \
 rust \
 rust-form_urlencoded+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-aws-v4+default-devel \
 rust-reqsign-core+default-devel \
 rust-reqsign-core+jwt-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
