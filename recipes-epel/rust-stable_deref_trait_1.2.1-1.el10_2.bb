# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-stable_deref_trait"
PV = "1.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-stable_deref_trait+alloc-devel \
 rust-stable_deref_trait+default-devel \
 rust-stable_deref_trait+std-devel \
 rust-stable_deref_trait-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-stable_deref_trait-1.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a37c0680800e5ff833b71b153b939c1903624fc07a549ae973a919f09de310ec"

URI_x86_64_v2_rust-stable_deref_trait+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stable_deref_trait+alloc-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stable_deref_trait+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stable_deref_trait+alloc-devel}"
SRC_URI[x86_64_v2_rust-stable_deref_trait+alloc-devel.sha256sum] = "168f9d8a33a3c4c33b140c31d0792e4dfc948aa421633acab715bbababc8176f"

URI_x86_64_v2_rust-stable_deref_trait+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stable_deref_trait+default-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stable_deref_trait+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stable_deref_trait+default-devel}"
SRC_URI[x86_64_v2_rust-stable_deref_trait+default-devel.sha256sum] = "3d4b7588953f4fce8cc8278b9d8795410e2573fc0feeed77ec75c2ec6cbe55a6"

URI_x86_64_v2_rust-stable_deref_trait+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stable_deref_trait+std-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stable_deref_trait+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stable_deref_trait+std-devel}"
SRC_URI[x86_64_v2_rust-stable_deref_trait+std-devel.sha256sum] = "f326def1c24775ee606035078dea023b53b199db29f706f00efe8dfed26bff97"

URI_x86_64_v2_rust-stable_deref_trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stable_deref_trait-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stable_deref_trait-devel}"
SRC_URI[x86_64_v2_rust-stable_deref_trait-devel.sha256sum] = "82555467e9cc968b96b1bad7cc6114a97543d213bfb49633e25ef04aa40b7aaa"

URI_aarch64_rust-stable_deref_trait+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stable_deref_trait+alloc-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-stable_deref_trait+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stable_deref_trait+alloc-devel}"
SRC_URI[aarch64_rust-stable_deref_trait+alloc-devel.sha256sum] = "b8f188f0ea9e0c9c2cbc5115f75c119d5b01bcaf13e94e358afbd5656cbf0e1f"

URI_aarch64_rust-stable_deref_trait+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stable_deref_trait+default-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-stable_deref_trait+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stable_deref_trait+default-devel}"
SRC_URI[aarch64_rust-stable_deref_trait+default-devel.sha256sum] = "bf587c02a95393eca23e1c1c0dd27f6155c9e5032f21ee1ed25727eb97716ff2"

URI_aarch64_rust-stable_deref_trait+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stable_deref_trait+std-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-stable_deref_trait+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stable_deref_trait+std-devel}"
SRC_URI[aarch64_rust-stable_deref_trait+std-devel.sha256sum] = "f4c90d1b8dad0e40125dc3f39329cd1b144041b99360f56f2292ba28f4a710ce"

URI_aarch64_rust-stable_deref_trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stable_deref_trait-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stable_deref_trait-devel}"
SRC_URI[aarch64_rust-stable_deref_trait-devel.sha256sum] = "39cc346deda1b066b5cd7d0dd2cf09ebdd99e114f50cefb84216b3162d1e6ae5"

RDEPENDS:rust-stable_deref_trait+alloc-devel = " \
 cargo \
 rust-stable_deref_trait-devel \
 "
RDEPENDS:rust-stable_deref_trait+default-devel = " \
 cargo \
 rust-stable_deref_trait+std-devel \
 rust-stable_deref_trait-devel \
 "
RDEPENDS:rust-stable_deref_trait+std-devel = " \
 cargo \
 rust-stable_deref_trait+alloc-devel \
 rust-stable_deref_trait-devel \
 "
RDEPENDS:rust-stable_deref_trait-devel = " \
 cargo \
 "
