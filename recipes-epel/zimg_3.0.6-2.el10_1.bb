# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zimg"
PV = "3.0.6"
PR = "2.el10_1"
PACKAGES = " \
 zimg \
 zimg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zimg-3.0.6-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0a348a53b824be1f13131647d63d61595afec254adbf315bcc68d0d996d2697"

URI_x86_64_v2_zimg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zimg-3.0.6-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zimg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zimg}"
SRC_URI[x86_64_v2_zimg.sha256sum] = "7d2cd3c65fb7861792b00773f3365448136a0a6fd35b32a689f1f7502f60af9d"

URI_x86_64_v2_zimg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zimg-devel-3.0.6-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zimg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zimg-devel}"
SRC_URI[x86_64_v2_zimg-devel.sha256sum] = "5e51adb9bb3d185f537dce700b087541fe005abf7177f141947f99dbbc5fa29d"

URI_aarch64_zimg = "${EPEL_MIRROR}/aarch64/Packages/z/zimg-3.0.6-2.el10_1.aarch64.rpm;name=aarch64_zimg;unpack=0"
SRC_URI:append = " ${URI_aarch64_zimg}"
SRC_URI[aarch64_zimg.sha256sum] = "8218eaca0d4ab7c031a5733a5b4d29b36849cade5a13430ddf1501ff3588c7ea"

URI_aarch64_zimg-devel = "${EPEL_MIRROR}/aarch64/Packages/z/zimg-devel-3.0.6-2.el10_1.aarch64.rpm;name=aarch64_zimg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zimg-devel}"
SRC_URI[aarch64_zimg-devel.sha256sum] = "f32f8fb381a32b08f7d7cdff61aca5c41ba52f974a7b4b4faf0e1577880b9bf2"

RDEPENDS:zimg = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:zimg-devel = " \
 glibc \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 zimg \
 "
