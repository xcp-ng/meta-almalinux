# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-concolor-query"
PV = "0.3.3"
PR = "7.el10_3"
PACKAGES = " \
 rust-concolor-query+default-devel \
 rust-concolor-query-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-concolor-query-0.3.3-7.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26ef922d941b4379d3eadf04fa7d296b52a9dceb6eaeac15681c7c69a216765f"

URI_x86_64_v2_rust-concolor-query+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concolor-query+default-devel-0.3.3-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concolor-query+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concolor-query+default-devel}"
SRC_URI[x86_64_v2_rust-concolor-query+default-devel.sha256sum] = "d709fafcb1c67311093126f39d00c4aad6c87e1bec736089efab5ece46824024"

URI_x86_64_v2_rust-concolor-query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concolor-query-devel-0.3.3-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concolor-query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concolor-query-devel}"
SRC_URI[x86_64_v2_rust-concolor-query-devel.sha256sum] = "7affe9ed89a0c7cfc4421b736cc4fdf2f57bd45d97cb9aec6861a3afe1e6dcc5"

URI_aarch64_rust-concolor-query+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concolor-query+default-devel-0.3.3-7.el10_3.noarch.rpm;name=aarch64_rust-concolor-query+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concolor-query+default-devel}"
SRC_URI[aarch64_rust-concolor-query+default-devel.sha256sum] = "8025c08516f1abe43825f92be0b9d91e5f54354e2cdfad3be1620e54e08fa658"

URI_aarch64_rust-concolor-query-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concolor-query-devel-0.3.3-7.el10_3.noarch.rpm;name=aarch64_rust-concolor-query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concolor-query-devel}"
SRC_URI[aarch64_rust-concolor-query-devel.sha256sum] = "fb85e4ba4b9968ee7ffa5572fb67be15dcfee0ee2a6647ac1ce0d35b3852058c"

RDEPENDS:rust-concolor-query+default-devel = " \
 cargo \
 rust-concolor-query-devel \
 "
RDEPENDS:rust-concolor-query-devel = " \
 cargo \
 rust \
 "
