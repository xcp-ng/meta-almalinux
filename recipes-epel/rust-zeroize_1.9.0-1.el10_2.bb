# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zeroize"
PV = "1.9.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-zeroize+aarch64-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize+default-devel \
 rust-zeroize+derive-devel \
 rust-zeroize+serde-devel \
 rust-zeroize+simd-devel \
 rust-zeroize+std-devel \
 rust-zeroize+zeroize_derive-devel \
 rust-zeroize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zeroize-1.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d305f1c981a1613ea412708652fcb529210c5c67122320ed2b2f2b3de9be52d"

URI_x86_64_v2_rust-zeroize+aarch64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+aarch64-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+aarch64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+aarch64-devel}"
SRC_URI[x86_64_v2_rust-zeroize+aarch64-devel.sha256sum] = "ba2fc390d821f546694b97d609a544762a7393f7ad1ce6f9eab93e5e59623524"

URI_x86_64_v2_rust-zeroize+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+alloc-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+alloc-devel}"
SRC_URI[x86_64_v2_rust-zeroize+alloc-devel.sha256sum] = "592afb8446803436365d49537680bb7ecd112f7c8f9b39f5dae1cb9de10b6159"

URI_x86_64_v2_rust-zeroize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+default-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+default-devel}"
SRC_URI[x86_64_v2_rust-zeroize+default-devel.sha256sum] = "b351b7e5128d76d3e215f2468ea41af2a398b110d7e78963be8e424ca44c49dd"

URI_x86_64_v2_rust-zeroize+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+derive-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+derive-devel}"
SRC_URI[x86_64_v2_rust-zeroize+derive-devel.sha256sum] = "d85320b4b15b0d6a4df4aee18364d2a7421c0c25ccfefe85433183289ef4c8e3"

URI_x86_64_v2_rust-zeroize+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+serde-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+serde-devel}"
SRC_URI[x86_64_v2_rust-zeroize+serde-devel.sha256sum] = "b807688a9f992ea44cba76bb16b2677197819ec1b3a041a5f488b4329ebb571b"

URI_x86_64_v2_rust-zeroize+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+simd-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+simd-devel}"
SRC_URI[x86_64_v2_rust-zeroize+simd-devel.sha256sum] = "e91ff6218c0994c68235b94b1de303512e8a9cabfdfe1d1b49af9f704825cc55"

URI_x86_64_v2_rust-zeroize+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+std-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+std-devel}"
SRC_URI[x86_64_v2_rust-zeroize+std-devel.sha256sum] = "59a62ba1d16e2b976a335d7bee0d0dca7bc1c9f12221a6b197797b9797b172ab"

URI_x86_64_v2_rust-zeroize+zeroize_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+zeroize_derive-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+zeroize_derive-devel}"
SRC_URI[x86_64_v2_rust-zeroize+zeroize_derive-devel.sha256sum] = "647467d7d08ae646e518c347fd1a4677fd5448ed7c8cd94fd64f617dcda1b608"

URI_x86_64_v2_rust-zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize-devel}"
SRC_URI[x86_64_v2_rust-zeroize-devel.sha256sum] = "e60dbe791b862e69446af6e6cc1ec55348058582e81d2bbc9436cea4391f8de6"

URI_aarch64_rust-zeroize+aarch64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+aarch64-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-zeroize+aarch64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+aarch64-devel}"
SRC_URI[aarch64_rust-zeroize+aarch64-devel.sha256sum] = "e5a8419db043ca0f769de10421efa12101b38b7a59d6a494e0ac84541c3318fa"

URI_aarch64_rust-zeroize+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+alloc-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-zeroize+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+alloc-devel}"
SRC_URI[aarch64_rust-zeroize+alloc-devel.sha256sum] = "21a9f4d67c3aef6c2e8a1e01f82e4b714133c5cb31818cdf3374e219d0acee45"

URI_aarch64_rust-zeroize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+default-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-zeroize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+default-devel}"
SRC_URI[aarch64_rust-zeroize+default-devel.sha256sum] = "9290b2703db4ff66a8124edf3ddcfe3285ce3fb3259e0381bcc30006a13041b1"

URI_aarch64_rust-zeroize+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+derive-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-zeroize+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+derive-devel}"
SRC_URI[aarch64_rust-zeroize+derive-devel.sha256sum] = "f5576de8180565404c894a01f2eaa96cd633216ec51f7f89bea77b0e655afb91"

URI_aarch64_rust-zeroize+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+serde-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-zeroize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+serde-devel}"
SRC_URI[aarch64_rust-zeroize+serde-devel.sha256sum] = "19f65d9170343545b42bd42def41c18aeb467970b71010081a5c350c2de8e5cd"

URI_aarch64_rust-zeroize+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+simd-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-zeroize+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+simd-devel}"
SRC_URI[aarch64_rust-zeroize+simd-devel.sha256sum] = "fef5e92418cfe566660b4cf65ad034efc370a83ec2a1f0cbceac8e404a4f5cae"

URI_aarch64_rust-zeroize+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+std-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-zeroize+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+std-devel}"
SRC_URI[aarch64_rust-zeroize+std-devel.sha256sum] = "92aad2acc045507febc54410097c9518537c49415cb831663ec5bebb6619adfd"

URI_aarch64_rust-zeroize+zeroize_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+zeroize_derive-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-zeroize+zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+zeroize_derive-devel}"
SRC_URI[aarch64_rust-zeroize+zeroize_derive-devel.sha256sum] = "7f9942a4379dca66f2e886eef3aa5c77ad2aa7251516688fde0312f7d1a0dba6"

URI_aarch64_rust-zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize-devel}"
SRC_URI[aarch64_rust-zeroize-devel.sha256sum] = "dd19a347f553ae11fc61bfab65c70b20c289a9adea11ce0a8ab5d056626c9537"

RDEPENDS:rust-zeroize+aarch64-devel = " \
 cargo \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+alloc-devel = " \
 cargo \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+default-devel = " \
 cargo \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+derive-devel = " \
 cargo \
 rust-zeroize+zeroize_derive-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+simd-devel = " \
 cargo \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+std-devel = " \
 cargo \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+zeroize_derive-devel = " \
 cargo \
 rust-zeroize-devel \
 rust-zeroize_derive+default-devel \
 "
RDEPENDS:rust-zeroize-devel = " \
 cargo \
 rust \
 "
