# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crypto-common0.1"
PV = "0.1.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-crypto-common0.1+default-devel \
 rust-crypto-common0.1+getrandom-devel \
 rust-crypto-common0.1+rand_core-devel \
 rust-crypto-common0.1+std-devel \
 rust-crypto-common0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crypto-common0.1-0.1.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be63e53f7562d3e21fa452ae5dfab3973c0b0e2d052a39e1d60c9801f6ed41ec"

URI_x86_64_v2_rust-crypto-common0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common0.1+default-devel-0.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common0.1+default-devel}"
SRC_URI[x86_64_v2_rust-crypto-common0.1+default-devel.sha256sum] = "c8f4c57a9c62136f91a1ffb04f7df4121f86b15ea112e8c150ffe00aa8e17a2d"

URI_x86_64_v2_rust-crypto-common0.1+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common0.1+getrandom-devel-0.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common0.1+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common0.1+getrandom-devel}"
SRC_URI[x86_64_v2_rust-crypto-common0.1+getrandom-devel.sha256sum] = "ba7e48cebf8fc5dc9fdb870bef302e05277d639edf3bdea8b8e97de84ef77095"

URI_x86_64_v2_rust-crypto-common0.1+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common0.1+rand_core-devel-0.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common0.1+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common0.1+rand_core-devel}"
SRC_URI[x86_64_v2_rust-crypto-common0.1+rand_core-devel.sha256sum] = "217fafe98866a5e0068fdac803d2d5e13acc260eea40b1ecdfc971e282de7f4f"

URI_x86_64_v2_rust-crypto-common0.1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common0.1+std-devel-0.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common0.1+std-devel}"
SRC_URI[x86_64_v2_rust-crypto-common0.1+std-devel.sha256sum] = "acca7797db2b2e9e6018416e64a52004a7558775e0d26ac2032c5af1bc793ac8"

URI_x86_64_v2_rust-crypto-common0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common0.1-devel-0.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common0.1-devel}"
SRC_URI[x86_64_v2_rust-crypto-common0.1-devel.sha256sum] = "71d89669cccf62b4b60ad84b0eb11c78d699e6a42cb5900b8d54a3a1756bf23f"

URI_aarch64_rust-crypto-common0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common0.1+default-devel-0.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-crypto-common0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common0.1+default-devel}"
SRC_URI[aarch64_rust-crypto-common0.1+default-devel.sha256sum] = "c11f3929c1217846ad7a2a43feb34ef33e91afbfee43bd76e70b82b4ac4120b5"

URI_aarch64_rust-crypto-common0.1+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common0.1+getrandom-devel-0.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-crypto-common0.1+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common0.1+getrandom-devel}"
SRC_URI[aarch64_rust-crypto-common0.1+getrandom-devel.sha256sum] = "fb7a34ab2e15467cd5ac32e774b0a23934ae16fc716301e3e69cd9a41408cb2b"

URI_aarch64_rust-crypto-common0.1+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common0.1+rand_core-devel-0.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-crypto-common0.1+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common0.1+rand_core-devel}"
SRC_URI[aarch64_rust-crypto-common0.1+rand_core-devel.sha256sum] = "5d3bd32479a252767fe6fe5eadcd64080fcdd0153f445452b5af5c848587b5eb"

URI_aarch64_rust-crypto-common0.1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common0.1+std-devel-0.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-crypto-common0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common0.1+std-devel}"
SRC_URI[aarch64_rust-crypto-common0.1+std-devel.sha256sum] = "73b8ab9cd3d9915e94645df05b209bce2e599367ddff748fa177d82bdc823726"

URI_aarch64_rust-crypto-common0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common0.1-devel-0.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-crypto-common0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common0.1-devel}"
SRC_URI[aarch64_rust-crypto-common0.1-devel.sha256sum] = "0442c1ecf5495aad7360b2857bbf44bd064a319df5f9ece57b23c5b30e84c5a3"

RDEPENDS:rust-crypto-common0.1+default-devel = " \
 cargo \
 rust-crypto-common0.1-devel \
 "
RDEPENDS:rust-crypto-common0.1+getrandom-devel = " \
 cargo \
 rust-crypto-common0.1-devel \
 rust-rand_core0.6+default-devel \
 rust-rand_core0.6+getrandom-devel \
 "
RDEPENDS:rust-crypto-common0.1+rand_core-devel = " \
 cargo \
 rust-crypto-common0.1-devel \
 rust-rand_core0.6+default-devel \
 "
RDEPENDS:rust-crypto-common0.1+std-devel = " \
 cargo \
 rust-crypto-common0.1-devel \
 "
RDEPENDS:rust-crypto-common0.1-devel = " \
 cargo \
 rust-generic-array+default-devel \
 rust-generic-array+more_lengths-devel \
 rust-typenum+default-devel \
 "
