# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_normalizer_data"
PV = "1.5.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-icu_normalizer_data+default-devel \
 rust-icu_normalizer_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_normalizer_data-1.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da6dc5441d9ef26007846bc58d210d63e83855bf560a1e3f4db40090c6886883"

URI_x86_64_v2_rust-icu_normalizer_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer_data+default-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer_data+default-devel.sha256sum] = "33d593b74a0571200d65bf71b55c9680512453d3db6dfad7f70dc6f91e0c9faa"

URI_x86_64_v2_rust-icu_normalizer_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer_data-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer_data-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer_data-devel.sha256sum] = "cfa6a95b97339660f57eb8f62865d50d887c9d2b751d452aa3d67eef9f952146"

URI_aarch64_rust-icu_normalizer_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer_data+default-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-icu_normalizer_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer_data+default-devel}"
SRC_URI[aarch64_rust-icu_normalizer_data+default-devel.sha256sum] = "4dbddf498d07e2cde8d0cb796f3b19a4ebe7f77acdc0b4a0b6e9cb34b81b0a81"

URI_aarch64_rust-icu_normalizer_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer_data-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-icu_normalizer_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer_data-devel}"
SRC_URI[aarch64_rust-icu_normalizer_data-devel.sha256sum] = "e14192db4ea15fe7cc4c00fe884ca769686b5452a569564e0850ef7558460fd2"

RDEPENDS:rust-icu_normalizer_data+default-devel = " \
 cargo \
 rust-icu_normalizer_data-devel \
 "
RDEPENDS:rust-icu_normalizer_data-devel = " \
 cargo \
 rust \
 "
