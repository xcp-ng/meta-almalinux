# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "massif-visualizer"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 massif-visualizer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/massif-visualizer-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f3d6eb344a67389aae04aa621d290be459b54b7224e53480fce06f0d09a28fa"

URI_x86_64_v2_massif-visualizer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/massif-visualizer-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_massif-visualizer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_massif-visualizer}"
SRC_URI[x86_64_v2_massif-visualizer.sha256sum] = "bf21b5cacb2bc8f20f1f60f1fe50e8b4d5e4376903953cb31b149f3701136481"

URI_aarch64_massif-visualizer = "${EPEL_MIRROR}/aarch64/Packages/m/massif-visualizer-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_massif-visualizer;unpack=0"
SRC_URI:append = " ${URI_aarch64_massif-visualizer}"
SRC_URI[aarch64_massif-visualizer.sha256sum] = "2bdfc56bc6915a331aeb95a1ecc864d05dfac93d07b1f6e64b0ee1ace04ab8cd"

RDEPENDS:massif-visualizer = " \
 glibc \
 kdiagram \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
