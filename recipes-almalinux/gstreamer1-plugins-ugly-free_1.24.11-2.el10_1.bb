# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-ugly-free"
PV = "1.24.11"
PR = "2.el10_1"
PACKAGES = " \
 gstreamer1-plugins-ugly-free \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-ugly-free-1.24.11-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4adcea2c32fce060259b54db4c6ae8c17058a0c097f991f2ea305b2da8184a14"

URI_x86_64_v2_gstreamer1-plugins-ugly-free = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-ugly-free-1.24.11-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-ugly-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-ugly-free}"
SRC_URI[x86_64_v2_gstreamer1-plugins-ugly-free.sha256sum] = "4de013a5a4778b81c5ed39b250fd5ed0859f14c2f408d06a44c5b581c6c28139"

URI_aarch64_gstreamer1-plugins-ugly-free = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-ugly-free-1.24.11-2.el10_1.aarch64.rpm;name=aarch64_gstreamer1-plugins-ugly-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-ugly-free}"
SRC_URI[aarch64_gstreamer1-plugins-ugly-free.sha256sum] = "d265de246a777647fcbccd502ccd3c6b284486099a51b98a5af19bb1973da3ff"

RDEPENDS:gstreamer1-plugins-ugly-free = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 liba52 \
 libcdio \
 libdvdread \
 libmpeg2 \
 orc \
 "
