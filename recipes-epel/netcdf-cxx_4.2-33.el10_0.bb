# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netcdf-cxx"
PV = "4.2"
PR = "33.el10_0"
PACKAGES = " \
 netcdf-cxx \
 netcdf-cxx-devel \
 netcdf-cxx-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netcdf-cxx-4.2-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1815f8b7f94da45bf184e51cbbf91686f5463f2c962d847205b328f68153ee5"

URI_x86_64_v2_netcdf-cxx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-cxx-4.2-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-cxx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-cxx}"
SRC_URI[x86_64_v2_netcdf-cxx.sha256sum] = "0742daa7176621a5d31ec4e35cd2f34e6e3ba7333132f498bee37dacee94163e"

URI_x86_64_v2_netcdf-cxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-cxx-devel-4.2-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-cxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-cxx-devel}"
SRC_URI[x86_64_v2_netcdf-cxx-devel.sha256sum] = "36f1841c585a114da1c0f865528763fc87dc0aff5c92382c4ca2766124ba9ce6"

URI_x86_64_v2_netcdf-cxx-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-cxx-static-4.2-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-cxx-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-cxx-static}"
SRC_URI[x86_64_v2_netcdf-cxx-static.sha256sum] = "45a866a4b9dc1b529b7ff38a229f088ba4eade26586cf4cc74a5a932fbda3a4c"

URI_aarch64_netcdf-cxx = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-cxx-4.2-33.el10_0.aarch64.rpm;name=aarch64_netcdf-cxx;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-cxx}"
SRC_URI[aarch64_netcdf-cxx.sha256sum] = "6422cc83b85ac8ded2662b3d3b0d4ca75261c51fa07f040494243eafb83a4091"

URI_aarch64_netcdf-cxx-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-cxx-devel-4.2-33.el10_0.aarch64.rpm;name=aarch64_netcdf-cxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-cxx-devel}"
SRC_URI[aarch64_netcdf-cxx-devel.sha256sum] = "edac1bb823bcd60c6c618feabf7219b40e71777e64fb6ddc75c7b5f858878dfc"

URI_aarch64_netcdf-cxx-static = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-cxx-static-4.2-33.el10_0.aarch64.rpm;name=aarch64_netcdf-cxx-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-cxx-static}"
SRC_URI[aarch64_netcdf-cxx-static.sha256sum] = "2ea722703470f54e637cf4176f32048e6d5cbef2ca3429ff2ff950370ce9ebd5"

RDEPENDS:netcdf-cxx = " \
 glibc \
 libgcc \
 libstdc++ \
 netcdf \
 "
RDEPENDS:netcdf-cxx-devel = " \
 netcdf-cxx \
 netcdf-devel \
 "
RDEPENDS:netcdf-cxx-static = " \
 netcdf-cxx-devel \
 "
