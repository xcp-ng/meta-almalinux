# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libuv"
PE = "1"
PV = "1.51.0"
PR = "1.el10_0"
PACKAGES = " \
 libuv \
 libuv-devel \
 libuv-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libuv-1.51.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfd2ec264a20a166d6e33247b556bb7adf06e5887d9837fd73517aa7b8417136"

URI_x86_64_v2_libuv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libuv-1.51.0-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_libuv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuv}"
SRC_URI[x86_64_v2_libuv.sha256sum] = "eae959fecf065091b332ecdd353787b3b783c0e511a7fe1bdecef5a4a7f44862"

URI_x86_64_v2_libuv-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libuv-devel-1.51.0-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_libuv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuv-devel}"
SRC_URI[x86_64_v2_libuv-devel.sha256sum] = "d9ccb63cdc995ef7fc1143df867725b6a996c3158a1a68d7c11185745c1a8635"

URI_x86_64_v2_libuv-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libuv-static-1.51.0-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_libuv-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuv-static}"
SRC_URI[x86_64_v2_libuv-static.sha256sum] = "7b1de95c7572b7bd852b59b1e02ce4ee755f009f10d7edd93b2e9df9fe8aac6f"

URI_aarch64_libuv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libuv-1.51.0-1.el10_0.aarch64.rpm;name=aarch64_libuv;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuv}"
SRC_URI[aarch64_libuv.sha256sum] = "68ed70e106d61b0308dcad17fd398661508b073c0fc303d055c292c33eae56f3"

URI_aarch64_libuv-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libuv-devel-1.51.0-1.el10_0.aarch64.rpm;name=aarch64_libuv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuv-devel}"
SRC_URI[aarch64_libuv-devel.sha256sum] = "87f8b04e6a376aa0d109bd1da9143f7a69aa57e584b087711841856c19c77a26"

URI_aarch64_libuv-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libuv-static-1.51.0-1.el10_0.aarch64.rpm;name=aarch64_libuv-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuv-static}"
SRC_URI[aarch64_libuv-static.sha256sum] = "15b91b0caf5e62c3e0dd6971c64fb17113c206040c8409e4aab287dcaa9c4d9c"

RDEPENDS:libuv = " \
 glibc \
 "
RDEPENDS:libuv-devel = " \
 cmake-filesystem \
 libuv \
 libuv-static \
 pkgconf-pkg-config \
 "
RDEPENDS:libuv-static = " \
 libuv-devel \
 pkgconf-pkg-config \
 "
