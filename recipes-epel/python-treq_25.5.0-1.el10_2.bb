# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-treq"
PV = "25.5.0"
PR = "1.el10_2"
PACKAGES = " \
 python-treq-doc \
 python3-treq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-treq-25.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "983e1ac9151826531bb0e210bd95a0ee518758a8c9be578837297eeb43065302"

URI_x86_64_v2_python-treq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-treq-doc-25.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-treq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-treq-doc}"
SRC_URI[x86_64_v2_python-treq-doc.sha256sum] = "3b8d68abb6debb467479b962895aff4df1a7f8e475b1f8c7da477c67f3947355"

URI_x86_64_v2_python3-treq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-treq-25.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-treq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-treq}"
SRC_URI[x86_64_v2_python3-treq.sha256sum] = "0694daf3440b97c9a5ae476790e0f61b48d3fcc4466438e6f7b3e0dd3c2ca8e9"

URI_aarch64_python-treq-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-treq-doc-25.5.0-1.el10_2.noarch.rpm;name=aarch64_python-treq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-treq-doc}"
SRC_URI[aarch64_python-treq-doc.sha256sum] = "e4bb3087aa220090f578825e0b094a74b78ed885c2f32c03629d68d31104596f"

URI_aarch64_python3-treq = "${EPEL_MIRROR}/aarch64/Packages/p/python3-treq-25.5.0-1.el10_2.noarch.rpm;name=aarch64_python3-treq;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-treq}"
SRC_URI[aarch64_python3-treq.sha256sum] = "8195bdee33e7559cb4369ded9b8f5f1a022ffe7f89c3ba66ed64c3586aed7462"

RDEPENDS:python-treq-doc = " \
 "
RDEPENDS:python3-treq = " \
 python3 \
 python3-attrs \
 python3-hyperlink \
 python3-incremental \
 python3-multipart \
 python3-requests \
 python3-twisted \
 python3-twisted+tls \
 python3-typing-extensions \
 "
