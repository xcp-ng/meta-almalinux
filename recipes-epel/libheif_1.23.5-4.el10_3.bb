# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libheif"
PV = "1.23.5"
PR = "4.el10_3"
PACKAGES = " \
 heif-pixbuf-loader \
 libheif \
 libheif-devel \
 libheif-ffmpeg \
 libheif-tools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libheif-1.23.5-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "deac9bc08ecb0c76f99948acc12cfb30ee6c5473db4a682d13a5dc701d337a34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/heif-pixbuf-loader-1.23.5-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_heif-pixbuf-loader;unpack=0"
SRC_URI[x86_64_v2_heif-pixbuf-loader.sha256sum] = "60f6cfc0c5557ba7be12d1fe2f0090d092c178ae969c357e7f6c01b3584075e3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libheif-1.23.5-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libheif;unpack=0"
SRC_URI[x86_64_v2_libheif.sha256sum] = "34044c884dcc0e8940e865a87572b90315c11603878df76b9f0800e9a952c2a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libheif-devel-1.23.5-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libheif-devel;unpack=0"
SRC_URI[x86_64_v2_libheif-devel.sha256sum] = "621b627e2c8417f3d3288ec66f87d0ac80a676da587bd1d07ba2a33fd075496a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libheif-ffmpeg-1.23.5-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libheif-ffmpeg;unpack=0"
SRC_URI[x86_64_v2_libheif-ffmpeg.sha256sum] = "aab25d4ecd7ec7bfee57f39fa73401881c80123d547d12d8174b8cb540b709a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libheif-tools-1.23.5-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libheif-tools;unpack=0"
SRC_URI[x86_64_v2_libheif-tools.sha256sum] = "9047a18795f5e578b45a98f2fbc28590f1075572d14d21da7cd280d6d187a68a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/heif-pixbuf-loader-1.23.5-4.el10_3.aarch64.rpm;name=aarch64_heif-pixbuf-loader;unpack=0"
SRC_URI[aarch64_heif-pixbuf-loader.sha256sum] = "7137c7d5853b23e2ce48f3094a574723bd46d72e59e7d8954c39d87db862dcbc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libheif-1.23.5-4.el10_3.aarch64.rpm;name=aarch64_libheif;unpack=0"
SRC_URI[aarch64_libheif.sha256sum] = "df0ac270c560837c81cd064f3736e7c96134b5f3ed24db0be878d7efe68712eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libheif-devel-1.23.5-4.el10_3.aarch64.rpm;name=aarch64_libheif-devel;unpack=0"
SRC_URI[aarch64_libheif-devel.sha256sum] = "eede36dd52f5117cfc47c25b6fc9e3c479f4c2e0dc969c8664394542cc43301d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libheif-ffmpeg-1.23.5-4.el10_3.aarch64.rpm;name=aarch64_libheif-ffmpeg;unpack=0"
SRC_URI[aarch64_libheif-ffmpeg.sha256sum] = "5612991db72b439a32f295eb102f0b2a6a3cd3d9a3b7c859fa4c266aa8c89e47"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libheif-tools-1.23.5-4.el10_3.aarch64.rpm;name=aarch64_libheif-tools;unpack=0"
SRC_URI[aarch64_libheif-tools.sha256sum] = "c4803f52d301e0c1eed21f9ba467bee9b7cff7d4277db35aa3466e869d62072b"

RDEPENDS:heif-pixbuf-loader = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libheif \
 "
RDEPENDS:libheif = " \
 glibc \
 libaom \
 libbrotli \
 libdav1d \
 libgcc \
 libjpeg-turbo \
 libopenjph \
 libstdc++ \
 libwebp \
 noopenh264 \
 openjpeg2 \
 rav1e-libs \
 svt-av1-libs \
 zlib-ng-compat \
 "
RDEPENDS:libheif-devel = " \
 brotli-devel \
 cmake-filesystem \
 libheif \
 libwebp-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:libheif-ffmpeg = " \
 glibc \
 libavcodec-free \
 libavutil-free \
 libgcc \
 libheif \
 libstdc++ \
 "
RDEPENDS:libheif-tools = " \
 glibc \
 libgcc \
 libheif \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 libwebp \
 shared-mime-info \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
