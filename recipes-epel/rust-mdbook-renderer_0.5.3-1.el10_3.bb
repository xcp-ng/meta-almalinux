# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mdbook-renderer"
PV = "0.5.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-mdbook-renderer+default-devel \
 rust-mdbook-renderer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mdbook-renderer-0.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50bc9a1b24e69566e45da3ca36686bacd25ac7154ba3fe97a0fcd3b72269fd60"

URI_x86_64_v2_rust-mdbook-renderer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-renderer+default-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-renderer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-renderer+default-devel}"
SRC_URI[x86_64_v2_rust-mdbook-renderer+default-devel.sha256sum] = "68ed70a86a41cd995617854026244d771048403c5ee8e5c3f21e235cf9d778d7"

URI_x86_64_v2_rust-mdbook-renderer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-renderer-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-renderer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-renderer-devel}"
SRC_URI[x86_64_v2_rust-mdbook-renderer-devel.sha256sum] = "9ebb759813acac5cd5f40aa308cb2e6fe8289e68cf7f0d6dd70607d4ae7aa06e"

URI_aarch64_rust-mdbook-renderer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-renderer+default-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-renderer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-renderer+default-devel}"
SRC_URI[aarch64_rust-mdbook-renderer+default-devel.sha256sum] = "45eb67429a9335d720782ae3dfbdcbac7d937651e7fa8e814b6fe3503da7e6a3"

URI_aarch64_rust-mdbook-renderer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-renderer-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-renderer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-renderer-devel}"
SRC_URI[aarch64_rust-mdbook-renderer-devel.sha256sum] = "010825924db9ed8753fec40eef4d18dd97c4d822125cca94a406a4766efc45f0"

RDEPENDS:rust-mdbook-renderer+default-devel = " \
 cargo \
 rust-mdbook-renderer-devel \
 "
RDEPENDS:rust-mdbook-renderer-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-mdbook-core+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
