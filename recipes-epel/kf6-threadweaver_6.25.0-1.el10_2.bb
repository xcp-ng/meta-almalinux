# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-threadweaver"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-threadweaver \
 kf6-threadweaver-devel \
 kf6-threadweaver-doc \
 kf6-threadweaver-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-threadweaver-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b221e894a6dcedb57d07e386e321f9fc7208901fd0007731a24ee890b1da0bb2"

URI_x86_64_v2_kf6-threadweaver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-threadweaver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver}"
SRC_URI[x86_64_v2_kf6-threadweaver.sha256sum] = "0b5d13eb8198384be3bf07d7f8607615633a6be13e934486de81f54ff97b4149"

URI_x86_64_v2_kf6-threadweaver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-threadweaver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver-devel}"
SRC_URI[x86_64_v2_kf6-threadweaver-devel.sha256sum] = "42a8efd02cedefb9e2679e0ba39e09b93b3b2aaf0687c88b7c1494fa5cc78cb2"

URI_x86_64_v2_kf6-threadweaver-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-threadweaver-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver-doc}"
SRC_URI[x86_64_v2_kf6-threadweaver-doc.sha256sum] = "f015e756662d9576b744525ace479422b05ed7db6a4b534dee56d8a7c4997f34"

URI_x86_64_v2_kf6-threadweaver-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-threadweaver-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver-html}"
SRC_URI[x86_64_v2_kf6-threadweaver-html.sha256sum] = "ca17c800fe1acb35b1288cf304459fb7422b991f6d0cb50e2d85535563759e7e"

URI_aarch64_kf6-threadweaver = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-threadweaver;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver}"
SRC_URI[aarch64_kf6-threadweaver.sha256sum] = "957373bfd5e5a1be438705d7003e0fb1afc00776598185afc23c8bffd269743a"

URI_aarch64_kf6-threadweaver-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-threadweaver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver-devel}"
SRC_URI[aarch64_kf6-threadweaver-devel.sha256sum] = "c7fbe0d042a3576a3d0b3b2d03003e9c1937223de647557c8858c840d5482c39"

URI_aarch64_kf6-threadweaver-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-threadweaver-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver-doc}"
SRC_URI[aarch64_kf6-threadweaver-doc.sha256sum] = "5ea940e561afdfa2feb2ba486c6a4d0f557084d4d992ec3689ed3adfe4407815"

URI_aarch64_kf6-threadweaver-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-threadweaver-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver-html}"
SRC_URI[aarch64_kf6-threadweaver-html.sha256sum] = "fb974b927cf2eac0463117e27b9832222ec4abb0e23ee97129fb613a9ff7d9bb"

RDEPENDS:kf6-threadweaver = " \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-threadweaver-devel = " \
 cmake-filesystem \
 kf6-threadweaver \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-threadweaver-doc = " \
 "
RDEPENDS:kf6-threadweaver-html = " \
 "
