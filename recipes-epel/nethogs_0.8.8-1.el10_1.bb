# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nethogs"
PV = "0.8.8"
PR = "1.el10_1"
PACKAGES = " \
 nethogs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nethogs-0.8.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d31b04723f4cfef55770ea6b421945be7cdc929a80cb79c7b8c5097b6980fe54"

URI_x86_64_v2_nethogs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nethogs-0.8.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nethogs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nethogs}"
SRC_URI[x86_64_v2_nethogs.sha256sum] = "ff239b436dbd2e1dc89d5839edf548d36e99d224a9f36f982fde26d572d59863"

URI_aarch64_nethogs = "${EPEL_MIRROR}/aarch64/Packages/n/nethogs-0.8.8-1.el10_1.aarch64.rpm;name=aarch64_nethogs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nethogs}"
SRC_URI[aarch64_nethogs.sha256sum] = "c42535c9d07f3f34d89581939138d0d7ac4c9ee78e2128386f6e7b7b9ef7b73b"

RDEPENDS:nethogs = " \
 glibc \
 libgcc \
 libpcap \
 libstdc++ \
 ncurses \
 ncurses-libs \
 "
