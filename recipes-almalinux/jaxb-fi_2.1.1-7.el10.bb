# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jaxb-fi"
PV = "2.1.1"
PR = "7.el10"
PACKAGES = " \
 jaxb-fi \
 jaxb-fi-javadoc \
 jaxb-fi-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/jaxb-fi-2.1.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6e7016d8e2f94bf01de1f8c546ad133b90fee28a7a84c4babc997ece2ed3104"

URI_x86_64_v2_jaxb-fi = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jaxb-fi-2.1.1-7.el10.noarch.rpm;name=x86_64_v2_jaxb-fi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-fi}"
SRC_URI[x86_64_v2_jaxb-fi.sha256sum] = "ccf130fd76ac21a55e431e8a048281998bac912b8a9dab033bdf061f5e5abddc"

URI_x86_64_v2_jaxb-fi-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jaxb-fi-javadoc-2.1.1-7.el10.noarch.rpm;name=x86_64_v2_jaxb-fi-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-fi-javadoc}"
SRC_URI[x86_64_v2_jaxb-fi-javadoc.sha256sum] = "fd685854d1124927050fbcc1c3009e49f19ec0164a65eff5f7a390afc096496f"

URI_x86_64_v2_jaxb-fi-tests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jaxb-fi-tests-2.1.1-7.el10.noarch.rpm;name=x86_64_v2_jaxb-fi-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-fi-tests}"
SRC_URI[x86_64_v2_jaxb-fi-tests.sha256sum] = "4068e5011d3c91661150dc9b85c1422f22e47e7779c54af2fb66b1e0bdc01968"

URI_aarch64_jaxb-fi = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jaxb-fi-2.1.1-7.el10.noarch.rpm;name=aarch64_jaxb-fi;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-fi}"
SRC_URI[aarch64_jaxb-fi.sha256sum] = "ccf130fd76ac21a55e431e8a048281998bac912b8a9dab033bdf061f5e5abddc"

URI_aarch64_jaxb-fi-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jaxb-fi-javadoc-2.1.1-7.el10.noarch.rpm;name=aarch64_jaxb-fi-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-fi-javadoc}"
SRC_URI[aarch64_jaxb-fi-javadoc.sha256sum] = "fd685854d1124927050fbcc1c3009e49f19ec0164a65eff5f7a390afc096496f"

URI_aarch64_jaxb-fi-tests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jaxb-fi-tests-2.1.1-7.el10.noarch.rpm;name=aarch64_jaxb-fi-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-fi-tests}"
SRC_URI[aarch64_jaxb-fi-tests.sha256sum] = "4068e5011d3c91661150dc9b85c1422f22e47e7779c54af2fb66b1e0bdc01968"

RDEPENDS:jaxb-fi = " \
 javapackages-filesystem \
 "
RDEPENDS:jaxb-fi-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:jaxb-fi-tests = " \
 javapackages-filesystem \
 jaxb-fi \
 "
