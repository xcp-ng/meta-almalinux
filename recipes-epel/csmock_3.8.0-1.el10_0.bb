# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "csmock"
PV = "3.8.0"
PR = "1.el10_0"
PACKAGES = " \
 csbuild \
 csmock \
 csmock-common \
 csmock-plugin-bandit \
 csmock-plugin-cbmc \
 csmock-plugin-clang \
 csmock-plugin-clippy \
 csmock-plugin-cppcheck \
 csmock-plugin-divine \
 csmock-plugin-gitleaks \
 csmock-plugin-infer \
 csmock-plugin-pylint \
 csmock-plugin-semgrep \
 csmock-plugin-shellcheck \
 csmock-plugin-shellcheck-core \
 csmock-plugin-smatch \
 csmock-plugin-snyk \
 csmock-plugin-strace \
 csmock-plugin-symbiotic \
 csmock-plugin-unicontrol \
 csmock-plugin-valgrind \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/csmock-3.8.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "041238441991f84d7d5e425ddebbc0481c3e39a25786c5ce5f318dd362065886"

URI_x86_64_v2_csbuild = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csbuild-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csbuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csbuild}"
SRC_URI[x86_64_v2_csbuild.sha256sum] = "02c46555518afde85b201663e7b4c391da3277d29a601ea84f76096a42a5f26a"

URI_x86_64_v2_csmock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock}"
SRC_URI[x86_64_v2_csmock.sha256sum] = "59c7afeaded4facf848f7d0049e3803cdcad1b1a78850ecb56fc55376e13efe5"

URI_x86_64_v2_csmock-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-common-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-common}"
SRC_URI[x86_64_v2_csmock-common.sha256sum] = "a4b1a7f14d29ead952fdb1c9256329263f234a7fdf573e1058094b12c3371eaf"

URI_x86_64_v2_csmock-plugin-bandit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-bandit-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-bandit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-bandit}"
SRC_URI[x86_64_v2_csmock-plugin-bandit.sha256sum] = "55fbe3e1fd6aa5d25de73ff5069e0b42ff245fb22314fda63f50da46b84fb86d"

URI_x86_64_v2_csmock-plugin-cbmc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-cbmc-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-cbmc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-cbmc}"
SRC_URI[x86_64_v2_csmock-plugin-cbmc.sha256sum] = "3252ea3846077090b83ca3e1144c2d91599b553e1de4daaf5b2022aa6a060786"

URI_x86_64_v2_csmock-plugin-clang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-clang-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-clang}"
SRC_URI[x86_64_v2_csmock-plugin-clang.sha256sum] = "d2033b3d2ff9fb72c95c180dc3cd3487a52caab1cdb5c1e2256257458b73ae05"

URI_x86_64_v2_csmock-plugin-clippy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-clippy-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-clippy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-clippy}"
SRC_URI[x86_64_v2_csmock-plugin-clippy.sha256sum] = "cecae83cbc55bb7c1c3525840532204791c2979fdb65f922ec4a452efb66b489"

URI_x86_64_v2_csmock-plugin-cppcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-cppcheck-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-cppcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-cppcheck}"
SRC_URI[x86_64_v2_csmock-plugin-cppcheck.sha256sum] = "672fae3063e941e511ce5a813084483bdb4dde67ddfe2f4c422659edcea99c9d"

URI_x86_64_v2_csmock-plugin-divine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-divine-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-divine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-divine}"
SRC_URI[x86_64_v2_csmock-plugin-divine.sha256sum] = "5673a8062fb8fd3b0b076b9b6ba9da34b6aa9da62a3ed15581867660219e0c91"

URI_x86_64_v2_csmock-plugin-gitleaks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-gitleaks-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-gitleaks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-gitleaks}"
SRC_URI[x86_64_v2_csmock-plugin-gitleaks.sha256sum] = "b25520f3e1e2383ebd7746f118e9bbb4c32b52b9666ea060571e9358ab486c71"

URI_x86_64_v2_csmock-plugin-infer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-infer-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-infer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-infer}"
SRC_URI[x86_64_v2_csmock-plugin-infer.sha256sum] = "0707798865041f49811c37dbed06ea0e123b6dbbc8e64b648b26ce21c747911e"

URI_x86_64_v2_csmock-plugin-pylint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-pylint-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-pylint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-pylint}"
SRC_URI[x86_64_v2_csmock-plugin-pylint.sha256sum] = "6a220be36b1aa0a7ca7b821168c2f4538be53646ab5b3cd2e1e9d8b34c88c812"

URI_x86_64_v2_csmock-plugin-semgrep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-semgrep-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-semgrep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-semgrep}"
SRC_URI[x86_64_v2_csmock-plugin-semgrep.sha256sum] = "9a645f0d6d6fd7825d1cb2d1a22869bcd94dab1b4c93372607da1aa2016b5d86"

URI_x86_64_v2_csmock-plugin-shellcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-shellcheck-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-shellcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-shellcheck}"
SRC_URI[x86_64_v2_csmock-plugin-shellcheck.sha256sum] = "437aa1991e8b6e452f05a1c0f029cb24766d007884489e296e0fb3ef7fe2ce76"

URI_x86_64_v2_csmock-plugin-shellcheck-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-shellcheck-core-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-shellcheck-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-shellcheck-core}"
SRC_URI[x86_64_v2_csmock-plugin-shellcheck-core.sha256sum] = "4b5ef0b50a8bc001d71ad88b2dcd6b8ff821a994a023e16f189f646ec25d8027"

URI_x86_64_v2_csmock-plugin-smatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-smatch-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-smatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-smatch}"
SRC_URI[x86_64_v2_csmock-plugin-smatch.sha256sum] = "25c535e6a062736f0488cafeacbf372fe3599289e9cae12e90fde247b55a3cd0"

URI_x86_64_v2_csmock-plugin-snyk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-snyk-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-snyk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-snyk}"
SRC_URI[x86_64_v2_csmock-plugin-snyk.sha256sum] = "6a449a4947d9068a45b238a43692f222e7306386752c55d049de5362263ccb3f"

URI_x86_64_v2_csmock-plugin-strace = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-strace-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-strace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-strace}"
SRC_URI[x86_64_v2_csmock-plugin-strace.sha256sum] = "a11b9062942ea0841852043e28d2870973ed1f3ace75cfe992fafab70faf8754"

URI_x86_64_v2_csmock-plugin-symbiotic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-symbiotic-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-symbiotic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-symbiotic}"
SRC_URI[x86_64_v2_csmock-plugin-symbiotic.sha256sum] = "4b5d9e5845ebb6a78305c93516a00896dc18a7eb0eb458425ffa1020ca053d30"

URI_x86_64_v2_csmock-plugin-unicontrol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-unicontrol-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-unicontrol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-unicontrol}"
SRC_URI[x86_64_v2_csmock-plugin-unicontrol.sha256sum] = "ce843c09f1d15cc3298ce57144cb92f3f24bc84bd994bc6480ebc9513f819dee"

URI_x86_64_v2_csmock-plugin-valgrind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-valgrind-3.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-valgrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-valgrind}"
SRC_URI[x86_64_v2_csmock-plugin-valgrind.sha256sum] = "f3c0aefdc6da674eed3b8353d33e7ec53c641fb7a94f8689cb28017f30ad1668"

URI_aarch64_csbuild = "${EPEL_MIRROR}/aarch64/Packages/c/csbuild-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csbuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_csbuild}"
SRC_URI[aarch64_csbuild.sha256sum] = "610a68f94cf155ddf0bc7060527075087a6bee4ba5c16bee730936a4d5a67c59"

URI_aarch64_csmock = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock}"
SRC_URI[aarch64_csmock.sha256sum] = "4afb203aaf73efcc0cb3e8d1906e4717737679f4253f410429e6fc156d8e8806"

URI_aarch64_csmock-common = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-common-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-common}"
SRC_URI[aarch64_csmock-common.sha256sum] = "0f90edb4dddafd30b0ef8d506a40601e8c2588de187098f2de4fb93c15d39658"

URI_aarch64_csmock-plugin-bandit = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-bandit-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-bandit;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-bandit}"
SRC_URI[aarch64_csmock-plugin-bandit.sha256sum] = "88014085d2c86b26d5a25e660f1153dcdb88e3263d36f75728db0bc9d1ec5ab5"

URI_aarch64_csmock-plugin-cbmc = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-cbmc-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-cbmc;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-cbmc}"
SRC_URI[aarch64_csmock-plugin-cbmc.sha256sum] = "8c5c51dacb34943d78e79dc40ce0eaf50df6c1ac4ca7e411743944c5e73ce183"

URI_aarch64_csmock-plugin-clang = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-clang-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-clang}"
SRC_URI[aarch64_csmock-plugin-clang.sha256sum] = "8c140c5a7974c28de0da76d16c1e7369cced93447dfb3ebaf22726f2d6b3cc2a"

URI_aarch64_csmock-plugin-clippy = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-clippy-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-clippy;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-clippy}"
SRC_URI[aarch64_csmock-plugin-clippy.sha256sum] = "a8f1cae359d63fae1f6a56089ba44e3314ef19048bcf8ebac8d0c1f23d57166f"

URI_aarch64_csmock-plugin-cppcheck = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-cppcheck-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-cppcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-cppcheck}"
SRC_URI[aarch64_csmock-plugin-cppcheck.sha256sum] = "e6ce81653bf8658d113b9aa778590a650135d10dc7698ebf8c590cd5d749e8a6"

URI_aarch64_csmock-plugin-divine = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-divine-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-divine;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-divine}"
SRC_URI[aarch64_csmock-plugin-divine.sha256sum] = "ed77e02d48e7ab8904f66775e6f65d7b5e370d9582030d3bd06920027bb24f7d"

URI_aarch64_csmock-plugin-gitleaks = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-gitleaks-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-gitleaks;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-gitleaks}"
SRC_URI[aarch64_csmock-plugin-gitleaks.sha256sum] = "a9bd5f53b40d33610547a16768b528ee6994fe0d65742f67ab7b1c188f868dd5"

URI_aarch64_csmock-plugin-infer = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-infer-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-infer;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-infer}"
SRC_URI[aarch64_csmock-plugin-infer.sha256sum] = "9b786d18589ad47bee1fafd9d04416408740dad7c5e3f8c8620b8738364fb6f4"

URI_aarch64_csmock-plugin-pylint = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-pylint-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-pylint;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-pylint}"
SRC_URI[aarch64_csmock-plugin-pylint.sha256sum] = "0564df4076843b163e6ef8fc5f7157b0a6b921ccb2b9ab97a68c158377af6460"

URI_aarch64_csmock-plugin-semgrep = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-semgrep-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-semgrep;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-semgrep}"
SRC_URI[aarch64_csmock-plugin-semgrep.sha256sum] = "7c62775dd4b507e358e0891bf218fe59501a96b054dce7dff53fb54e48239a31"

URI_aarch64_csmock-plugin-shellcheck = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-shellcheck-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-shellcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-shellcheck}"
SRC_URI[aarch64_csmock-plugin-shellcheck.sha256sum] = "08a039d3ddcbd1a7982ddbd44fea4c20d9a84f01a9e54d4d0b6356106198aa7d"

URI_aarch64_csmock-plugin-shellcheck-core = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-shellcheck-core-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-shellcheck-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-shellcheck-core}"
SRC_URI[aarch64_csmock-plugin-shellcheck-core.sha256sum] = "54b34e66d3a065584262fb39c32da7434be9cc8fff03bf83068bfd9270df830e"

URI_aarch64_csmock-plugin-smatch = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-smatch-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-smatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-smatch}"
SRC_URI[aarch64_csmock-plugin-smatch.sha256sum] = "499aa86c1fd3ed85d3f08af2bb3d4368d40ab29326f675517e83e3e3f5a503e6"

URI_aarch64_csmock-plugin-snyk = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-snyk-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-snyk;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-snyk}"
SRC_URI[aarch64_csmock-plugin-snyk.sha256sum] = "67b8cc837a7f092b852c9b8eb7b20193ac8df9ab4291fb911a0667136b1c42d4"

URI_aarch64_csmock-plugin-strace = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-strace-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-strace;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-strace}"
SRC_URI[aarch64_csmock-plugin-strace.sha256sum] = "16962b3713c6717554afd1a6569d57f803e98500a0e82b42665d3f1de504ef5d"

URI_aarch64_csmock-plugin-symbiotic = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-symbiotic-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-symbiotic;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-symbiotic}"
SRC_URI[aarch64_csmock-plugin-symbiotic.sha256sum] = "bddfc24bf4213c9ab2cb4f2662f47d0f73841dcdc3af88de80b2506b75c0e9d4"

URI_aarch64_csmock-plugin-unicontrol = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-unicontrol-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-unicontrol;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-unicontrol}"
SRC_URI[aarch64_csmock-plugin-unicontrol.sha256sum] = "eb7ddedb9acbbc72c985fd3bc12e279f7d4941f3d9dc8767f51c7a462628e6cc"

URI_aarch64_csmock-plugin-valgrind = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-valgrind-3.8.0-1.el10_0.noarch.rpm;name=aarch64_csmock-plugin-valgrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-valgrind}"
SRC_URI[aarch64_csmock-plugin-valgrind.sha256sum] = "238f35b83828d5e81a2a6657f47395583b3789554491a8a75d1a4a01ee73010f"

RDEPENDS:csbuild = " \
 bash \
 csclng \
 cscppc \
 csdiff \
 csmock-common \
 cswrap \
 python3 \
 python3-GitPython \
 "
RDEPENDS:csmock = " \
 csmock-common \
 csmock-plugin-clang \
 csmock-plugin-cppcheck \
 csmock-plugin-gitleaks \
 csmock-plugin-shellcheck \
 "
RDEPENDS:csmock-common = " \
 bash \
 csdiff \
 csgcca \
 cswrap \
 mock \
 python3 \
 tar \
 xz \
 "
RDEPENDS:csmock-plugin-bandit = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-cbmc = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-clang = " \
 csclng \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-clippy = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-cppcheck = " \
 cscppc \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-divine = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-gitleaks = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-infer = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-pylint = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-semgrep = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-shellcheck = " \
 csmock-common \
 csmock-plugin-shellcheck-core \
 python3 \
 "
RDEPENDS:csmock-plugin-shellcheck-core = " \
 bash \
 "
RDEPENDS:csmock-plugin-smatch = " \
 csmatch \
 csmock-common \
 cswrap \
 python3 \
 "
RDEPENDS:csmock-plugin-snyk = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-strace = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-symbiotic = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-unicontrol = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-valgrind = " \
 csexec \
 csmock-common \
 python3 \
 "
