# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clang-sys"
PV = "1.8.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-clang-sys+clang_10_0-devel \
 rust-clang-sys+clang_11_0-devel \
 rust-clang-sys+clang_12_0-devel \
 rust-clang-sys+clang_13_0-devel \
 rust-clang-sys+clang_14_0-devel \
 rust-clang-sys+clang_15_0-devel \
 rust-clang-sys+clang_16_0-devel \
 rust-clang-sys+clang_17_0-devel \
 rust-clang-sys+clang_18_0-devel \
 rust-clang-sys+clang_3_5-devel \
 rust-clang-sys+clang_3_6-devel \
 rust-clang-sys+clang_3_7-devel \
 rust-clang-sys+clang_3_8-devel \
 rust-clang-sys+clang_3_9-devel \
 rust-clang-sys+clang_4_0-devel \
 rust-clang-sys+clang_5_0-devel \
 rust-clang-sys+clang_6_0-devel \
 rust-clang-sys+clang_7_0-devel \
 rust-clang-sys+clang_8_0-devel \
 rust-clang-sys+clang_9_0-devel \
 rust-clang-sys+default-devel \
 rust-clang-sys+libcpp-devel \
 rust-clang-sys+libloading-devel \
 rust-clang-sys+runtime-devel \
 rust-clang-sys+static-devel \
 rust-clang-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clang-sys-1.8.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f37055b484a583e02986ec3dba0a3991d5ffd5d1c766723fc710b5ac0c2b2c4"

URI_x86_64_v2_rust-clang-sys+clang_10_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_10_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_10_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_10_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_10_0-devel.sha256sum] = "72e26ba3592722a1f1957e8518ecbcc652f62882314c26da0f3dfba758c2a4fc"

URI_x86_64_v2_rust-clang-sys+clang_11_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_11_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_11_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_11_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_11_0-devel.sha256sum] = "1abee0dfc73275bef1d3ca5d62e192fd582d38aa181ca483014185547185fc6a"

URI_x86_64_v2_rust-clang-sys+clang_12_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_12_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_12_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_12_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_12_0-devel.sha256sum] = "d5a6f685ad7f69f56bf696634359d0a51ee9018899bdcacf27d50168f89de7d0"

URI_x86_64_v2_rust-clang-sys+clang_13_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_13_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_13_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_13_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_13_0-devel.sha256sum] = "49024c6af18509a0ba40496264bc128338745f70292039488da8473d495ecf3d"

URI_x86_64_v2_rust-clang-sys+clang_14_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_14_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_14_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_14_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_14_0-devel.sha256sum] = "0915615d46df0cc949b28ba42d7b8bdd6e4c81e74f5180e92404c9f598c471c4"

URI_x86_64_v2_rust-clang-sys+clang_15_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_15_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_15_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_15_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_15_0-devel.sha256sum] = "190a0a40624f4f2e085b4f7e12dbf7e1d33308b723c5d19466b98e329b11685d"

URI_x86_64_v2_rust-clang-sys+clang_16_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_16_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_16_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_16_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_16_0-devel.sha256sum] = "8e210b27f86b1619de582c8d042643ec91064cb995f934b3513a215edf8bfdf3"

URI_x86_64_v2_rust-clang-sys+clang_17_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_17_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_17_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_17_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_17_0-devel.sha256sum] = "bc16819cb4be534180d412db5e554985ddc83294ca234442e8531ba2d3d50956"

URI_x86_64_v2_rust-clang-sys+clang_18_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_18_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_18_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_18_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_18_0-devel.sha256sum] = "762b1cee6e668f84fe3e4aaf0da6910f5d70be5b780c53f6393cc34f9bcfd6c8"

URI_x86_64_v2_rust-clang-sys+clang_3_5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_5-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_3_5-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_5-devel.sha256sum] = "f65b56500c9c2bee12bd3625e01051dcfa482e63be9ee0ece9a958fa6d73d703"

URI_x86_64_v2_rust-clang-sys+clang_3_6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_6-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_3_6-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_6-devel.sha256sum] = "e5e1256ae652b827ad669536887c2ab8ff9661d3559f535e33b5f89b64919fb7"

URI_x86_64_v2_rust-clang-sys+clang_3_7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_7-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_3_7-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_7-devel.sha256sum] = "7ffaa838ca6aa63c5f5e0da73cfb72fe281b6795133316df342c3c08e573cb0f"

URI_x86_64_v2_rust-clang-sys+clang_3_8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_8-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_3_8-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_8-devel.sha256sum] = "af033d1274d2dc7f631189322de5cf8d2e9883eed272cbc5897d67aebe092fa1"

URI_x86_64_v2_rust-clang-sys+clang_3_9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_9-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_3_9-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_9-devel.sha256sum] = "82c47339d18736849a336375f0608974a923b952411b3b71d69297c01d75ed37"

URI_x86_64_v2_rust-clang-sys+clang_4_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_4_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_4_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_4_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_4_0-devel.sha256sum] = "c9f4963361f283462725dc1d7b99ec184159976d503212329c081ee1edad2119"

URI_x86_64_v2_rust-clang-sys+clang_5_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_5_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_5_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_5_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_5_0-devel.sha256sum] = "c0152b8688d3e2da849467dbc17fbe85e2814600e0cfe99cdd77fdf55b69a46d"

URI_x86_64_v2_rust-clang-sys+clang_6_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_6_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_6_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_6_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_6_0-devel.sha256sum] = "2ebd8e185217cb43b33e8419d215a1f5761804e69aa65d442dd0c2b994b670b7"

URI_x86_64_v2_rust-clang-sys+clang_7_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_7_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_7_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_7_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_7_0-devel.sha256sum] = "9873ac7f5484303a30f782c02adf2259996a73c832c863d82c8bca0b9e5de127"

URI_x86_64_v2_rust-clang-sys+clang_8_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_8_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_8_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_8_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_8_0-devel.sha256sum] = "937f766a6f1de430621ba3a5d4acc9ffa75af55f808ea3afb0a713578c99ed85"

URI_x86_64_v2_rust-clang-sys+clang_9_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_9_0-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_9_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+clang_9_0-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+clang_9_0-devel.sha256sum] = "b7f94cb21632108b14e359263039e5c922b2001b1c0b8438b662a20568043716"

URI_x86_64_v2_rust-clang-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+default-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+default-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+default-devel.sha256sum] = "a998ec14628d29e6f33988cf11bf4a28477130847f9a34df8e48fa691cdaa904"

URI_x86_64_v2_rust-clang-sys+libcpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+libcpp-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+libcpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+libcpp-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+libcpp-devel.sha256sum] = "93505ca1d4999f2de40c335244482f7999725dc4171d220afbb54b05fb2f4bb0"

URI_x86_64_v2_rust-clang-sys+libloading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+libloading-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+libloading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+libloading-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+libloading-devel.sha256sum] = "9f55cfbd56b50ce11e2d7b48c7c7c9daa16ec8a644a8569028fdc09c407d1cd2"

URI_x86_64_v2_rust-clang-sys+runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+runtime-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+runtime-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+runtime-devel.sha256sum] = "d94767a67d409d3b3c8d84c99a9f6eccac7357be7db1f5c09b5854ad335ac78b"

URI_x86_64_v2_rust-clang-sys+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+static-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys+static-devel}"
SRC_URI[x86_64_v2_rust-clang-sys+static-devel.sha256sum] = "d0f7713f9741050ab1e8a2cbf5370a2a71d1be1df7b0113f67c300436f5b5d0b"

URI_x86_64_v2_rust-clang-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-sys-devel}"
SRC_URI[x86_64_v2_rust-clang-sys-devel.sha256sum] = "e0a02e1eead17a91d46a035d38f49a23d579cc60866c8557728e0c7d0756a919"

URI_aarch64_rust-clang-sys+clang_10_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_10_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_10_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_10_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_10_0-devel.sha256sum] = "8902d31f1436bb0146edd6897a112d0b0a98c5a71862fe9686752fa431d6e567"

URI_aarch64_rust-clang-sys+clang_11_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_11_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_11_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_11_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_11_0-devel.sha256sum] = "da7125ae57cd6a0d6908adaae239cff6bd6bcc6fd62dcb94e5eb066a7bde5652"

URI_aarch64_rust-clang-sys+clang_12_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_12_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_12_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_12_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_12_0-devel.sha256sum] = "ccbfcbf9d4f26c261cef6b4386444e03b423ff27fb595afbf9f0e6c5ed7149ee"

URI_aarch64_rust-clang-sys+clang_13_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_13_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_13_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_13_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_13_0-devel.sha256sum] = "5bb28195d4cbacedc639d6a27240a4dd54874eb1843890d28966321bde43629f"

URI_aarch64_rust-clang-sys+clang_14_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_14_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_14_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_14_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_14_0-devel.sha256sum] = "b95703e32a49cae837009c834a58eba9cd8c7a9c09dab101bc1aab379b1f4310"

URI_aarch64_rust-clang-sys+clang_15_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_15_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_15_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_15_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_15_0-devel.sha256sum] = "eef7a7ea5461a0f63932ea28fd68ab6c12b6b1c4877f1375efea4e72e7e1c4ae"

URI_aarch64_rust-clang-sys+clang_16_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_16_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_16_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_16_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_16_0-devel.sha256sum] = "0a4cb070611537da748637b37b586a0c7baa918c4ce6fb9c90a227bd9ee4d4fa"

URI_aarch64_rust-clang-sys+clang_17_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_17_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_17_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_17_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_17_0-devel.sha256sum] = "9b268301e5a3e750a0b0f95a958eb7dbaffa5f711b58d7fe82237ca0682ce68d"

URI_aarch64_rust-clang-sys+clang_18_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_18_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_18_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_18_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_18_0-devel.sha256sum] = "0f50ca78e344aef6382634a350b8d91ec9b7599534c043bb33d93dc8e0466194"

URI_aarch64_rust-clang-sys+clang_3_5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_5-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_3_5-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_3_5-devel.sha256sum] = "5b01f97bab24c9e2ac82e4524c4d9a123d53f281b1b0fb79eaf2b966a7566392"

URI_aarch64_rust-clang-sys+clang_3_6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_6-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_3_6-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_3_6-devel.sha256sum] = "68998e220caa479637d0cec2cc285bb545159420d5e7ff56cecd9f47e90dd87b"

URI_aarch64_rust-clang-sys+clang_3_7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_7-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_3_7-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_3_7-devel.sha256sum] = "9755b8cc3317bb00a08d9dd1d2ecad15f33b2906bdf1cd16e93d947a5bcb6254"

URI_aarch64_rust-clang-sys+clang_3_8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_8-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_3_8-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_3_8-devel.sha256sum] = "42d0e7a04b7f4f4bb104190bff53f995416cb260059c36cd4f1b8ad08a777225"

URI_aarch64_rust-clang-sys+clang_3_9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_9-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_3_9-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_3_9-devel.sha256sum] = "15b9b15e8393c0912ced03d341c8b2d0c016dc2e0c34be7324e0737148b54b5c"

URI_aarch64_rust-clang-sys+clang_4_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_4_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_4_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_4_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_4_0-devel.sha256sum] = "6edbb67814d69fbf2a92e094ca8ecb457924220a43957351dd375274e0657ecb"

URI_aarch64_rust-clang-sys+clang_5_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_5_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_5_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_5_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_5_0-devel.sha256sum] = "08f53f9736b4f5352acfe1c0974b83430862318027094a0ca78c1d419d34c274"

URI_aarch64_rust-clang-sys+clang_6_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_6_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_6_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_6_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_6_0-devel.sha256sum] = "3212be2f2d9fb647c7f838bf9ce4de8dfefe3f922f3c343697e42e4263aa8a49"

URI_aarch64_rust-clang-sys+clang_7_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_7_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_7_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_7_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_7_0-devel.sha256sum] = "4a8feb38dfee19747953fca0d150747266426b94327fa8ee1f07fe92bb742f04"

URI_aarch64_rust-clang-sys+clang_8_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_8_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_8_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_8_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_8_0-devel.sha256sum] = "77ca8168d167578d999ebdc5e3d929bf441cc5e57f4dac7a24ea29349ac1d04a"

URI_aarch64_rust-clang-sys+clang_9_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_9_0-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+clang_9_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+clang_9_0-devel}"
SRC_URI[aarch64_rust-clang-sys+clang_9_0-devel.sha256sum] = "c9186288dfda8a07638a94bce21e0c090c7fc7ee0017c3fdffbe5f0e59111e26"

URI_aarch64_rust-clang-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+default-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+default-devel}"
SRC_URI[aarch64_rust-clang-sys+default-devel.sha256sum] = "49835474b552ebc2231af41800a051a3d9bcd233a8c3156943360297e34d21c4"

URI_aarch64_rust-clang-sys+libcpp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+libcpp-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+libcpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+libcpp-devel}"
SRC_URI[aarch64_rust-clang-sys+libcpp-devel.sha256sum] = "e39418ee17fb8d8326a4b14d2f20a4101359317c5d78d2a5cf3d47e71da4362a"

URI_aarch64_rust-clang-sys+libloading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+libloading-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+libloading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+libloading-devel}"
SRC_URI[aarch64_rust-clang-sys+libloading-devel.sha256sum] = "3caae31bb558ba1eb39c14c9d60161bccbf6336b904d72c6a142271c5ae559ae"

URI_aarch64_rust-clang-sys+runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+runtime-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+runtime-devel}"
SRC_URI[aarch64_rust-clang-sys+runtime-devel.sha256sum] = "fb8d59bae1325831cedc930f0f03211c2e083c141fd46d1663933534991071ed"

URI_aarch64_rust-clang-sys+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+static-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys+static-devel}"
SRC_URI[aarch64_rust-clang-sys+static-devel.sha256sum] = "458c9de62a67f2a4cbf7050201770292b6f937b9300128d3319631c079e81625"

URI_aarch64_rust-clang-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-clang-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-sys-devel}"
SRC_URI[aarch64_rust-clang-sys-devel.sha256sum] = "8436a04449aa7e0e27c5b72b13004df04599d053147eeb99d07ef77cac74fa88"

RDEPENDS:rust-clang-sys+clang_10_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_9_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_11_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_10_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_12_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_11_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_13_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_12_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_14_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_13_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_15_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_14_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_16_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_15_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_17_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_16_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_18_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_17_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_5-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_6-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_5-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_7-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_6-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_8-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_7-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_9-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_8-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_4_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_9-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_5_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_4_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_6_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_5_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_7_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_6_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_8_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_7_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_9_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_8_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+default-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+libcpp-devel = " \
 cargo \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+libloading-devel = " \
 cargo \
 rust-clang-sys-devel \
 rust-libloading0.8+default-devel \
 "
RDEPENDS:rust-clang-sys+runtime-devel = " \
 cargo \
 clang-libs \
 rust-clang-sys+libloading-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+static-devel = " \
 cargo \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys-devel = " \
 cargo \
 rust-glob+default-devel \
 rust-libc-devel \
 "
