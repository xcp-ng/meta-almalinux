# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pin-utils"
PV = "0.1.0"
PR = "12.el10_0"
PACKAGES = " \
 rust-pin-utils+default-devel \
 rust-pin-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pin-utils-0.1.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94278bf8fc0e9e3db7405c13e45f1a5b5671ccfaf872364f54edabd948156474"

URI_x86_64_v2_rust-pin-utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-utils+default-devel-0.1.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-utils+default-devel}"
SRC_URI[x86_64_v2_rust-pin-utils+default-devel.sha256sum] = "eaf08a9226b8e972a943b273c44781cb367e830aec3e365a50122d44125b6d41"

URI_x86_64_v2_rust-pin-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-utils-devel-0.1.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-utils-devel}"
SRC_URI[x86_64_v2_rust-pin-utils-devel.sha256sum] = "d1e364e98fd6969b1e591f733ada69cbec7b926fdd614f49d2ce2b051ddc164c"

URI_aarch64_rust-pin-utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-utils+default-devel-0.1.0-12.el10_0.noarch.rpm;name=aarch64_rust-pin-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-utils+default-devel}"
SRC_URI[aarch64_rust-pin-utils+default-devel.sha256sum] = "c249d40aa36d9fca2622c0b2f2dae22ce6301cb47c8f5b8397f5d4ffab286d4a"

URI_aarch64_rust-pin-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-utils-devel-0.1.0-12.el10_0.noarch.rpm;name=aarch64_rust-pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-utils-devel}"
SRC_URI[aarch64_rust-pin-utils-devel.sha256sum] = "d89fe61462895e68b33dc948967383f84408bc6e37846ee629e8cdb13138db9b"

RDEPENDS:rust-pin-utils+default-devel = " \
 cargo \
 rust-pin-utils-devel \
 "
RDEPENDS:rust-pin-utils-devel = " \
 cargo \
 "
