# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aom"
PV = "3.13.1"
PR = "1.el10_2"
PACKAGES = " \
 aom \
 libaom \
 libaom-devel \
 libaom-devel-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aom-3.13.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "573babe29760565204a3839ca7e1764fc39d2de6552ae92b59fc986d11aca94a"

URI_x86_64_v2_aom = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aom-3.13.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aom}"
SRC_URI[x86_64_v2_aom.sha256sum] = "cda9b059e2a043428e7cb8bdaf35ae3bbc62f3315051cee129cfa4590b5d201a"

URI_x86_64_v2_libaom = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaom-3.13.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaom}"
SRC_URI[x86_64_v2_libaom.sha256sum] = "6cc263103d390f1c825c6a8a73aa1671351db5cf640396d8a5d4d90988de798b"

URI_x86_64_v2_libaom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaom-devel-3.13.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaom-devel}"
SRC_URI[x86_64_v2_libaom-devel.sha256sum] = "a81cc005fa2bb21bca787a693f799fc32a26f61c7b28d8821da45666804ff858"

URI_x86_64_v2_libaom-devel-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaom-devel-docs-3.13.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaom-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaom-devel-docs}"
SRC_URI[x86_64_v2_libaom-devel-docs.sha256sum] = "3099ff5f3aab8cc5b1e500b65235474123c0a76eb4ec42e323e1e3b790cbbcec"

URI_aarch64_aom = "${EPEL_MIRROR}/aarch64/Packages/a/aom-3.13.1-1.el10_2.aarch64.rpm;name=aarch64_aom;unpack=0"
SRC_URI:append = " ${URI_aarch64_aom}"
SRC_URI[aarch64_aom.sha256sum] = "ab4b253a301f69073293d33112208e70256e0b5c3b83f3cea2c852393560aa9e"

URI_aarch64_libaom = "${EPEL_MIRROR}/aarch64/Packages/l/libaom-3.13.1-1.el10_2.aarch64.rpm;name=aarch64_libaom;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaom}"
SRC_URI[aarch64_libaom.sha256sum] = "a909d261deb4dff72998bd755b1e620f7206753af8c5595ebea27825563cc4eb"

URI_aarch64_libaom-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libaom-devel-3.13.1-1.el10_2.aarch64.rpm;name=aarch64_libaom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaom-devel}"
SRC_URI[aarch64_libaom-devel.sha256sum] = "f841fa63372ef12267a4eb7248cf8fc5019c13715d7b0c8b6425d2f1f9b2a447"

URI_aarch64_libaom-devel-docs = "${EPEL_MIRROR}/aarch64/Packages/l/libaom-devel-docs-3.13.1-1.el10_2.aarch64.rpm;name=aarch64_libaom-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaom-devel-docs}"
SRC_URI[aarch64_libaom-devel-docs.sha256sum] = "ec34913ab9ae81fa785e57c6e56366c66ddb17d60b377d00719dded84bc4778e"

RDEPENDS:aom = " \
 glibc \
 libaom \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libaom:x86_64_v2 = " \
 glibc \
 libvmaf \
"
RDEPENDS:libaom:aarch64 = " \
 glibc \
"
RDEPENDS:libaom-devel:x86_64_v2 = " \
 cmake-filesystem \
 libaom \
 libvmaf-devel \
 pkgconf-pkg-config \
"
RDEPENDS:libaom-devel:aarch64 = " \
 cmake-filesystem \
 libaom \
 pkgconf-pkg-config \
"
RDEPENDS:libaom-devel-docs = " \
 libaom-devel \
 "
