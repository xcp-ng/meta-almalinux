# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pefile"
PV = "2024.8.26"
PR = "1.el10"
PACKAGES = " \
 python3-pefile \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-pefile-2024.8.26-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acb055151db09f46ba83f3b4c1067daf96b86be614d96015cb5be8002dba690a"

URI_x86_64_v2_python3-pefile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pefile-2024.8.26-1.el10.noarch.rpm;name=x86_64_v2_python3-pefile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pefile}"
SRC_URI[x86_64_v2_python3-pefile.sha256sum] = "bd82fa1247b92c9f1398eefd3c8c3f5053d781fb8cf3218f437af2665a3f8a0e"

URI_aarch64_python3-pefile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pefile-2024.8.26-1.el10.noarch.rpm;name=aarch64_python3-pefile;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pefile}"
SRC_URI[aarch64_python3-pefile.sha256sum] = "bd82fa1247b92c9f1398eefd3c8c3f5053d781fb8cf3218f437af2665a3f8a0e"

RDEPENDS:python3-pefile = " \
 python3 \
 "
