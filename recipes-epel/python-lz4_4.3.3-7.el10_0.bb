# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-lz4"
PV = "4.3.3"
PR = "7.el10_0"
PACKAGES = " \
 python3-lz4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-lz4-4.3.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "838280d66c527fc7e0f9591dd9da286eceedaeede9e7709880e891a7c2e2d61b"

URI_x86_64_v2_python3-lz4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lz4-4.3.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lz4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lz4}"
SRC_URI[x86_64_v2_python3-lz4.sha256sum] = "ea576a61195ecbe7253a4f0fcccdffeb5b6c3cd6b90d52ea2e1a90c4eea398b5"

URI_aarch64_python3-lz4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lz4-4.3.3-7.el10_0.aarch64.rpm;name=aarch64_python3-lz4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lz4}"
SRC_URI[aarch64_python3-lz4.sha256sum] = "8051b97ed57d496bc1b1aa7f3cee6f983b810ee7fdc71f4d8b2215d63ef6d360"

RDEPENDS:python3-lz4 = " \
 glibc \
 lz4-libs \
 python3 \
 "
