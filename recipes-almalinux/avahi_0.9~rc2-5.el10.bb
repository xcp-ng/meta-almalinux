# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "avahi"
PV = "0.9~rc2"
PR = "5.el10"
PACKAGES = " \
 avahi \
 avahi-autoipd \
 avahi-compat-howl \
 avahi-compat-howl-devel \
 avahi-compat-libdns_sd \
 avahi-compat-libdns_sd-devel \
 avahi-devel \
 avahi-glib \
 avahi-glib-devel \
 avahi-gobject \
 avahi-gobject-devel \
 avahi-libs \
 avahi-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/avahi-0.9~rc2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5b12be46c4d15e151e4b16d4b2e355a926db0787e8e2d48f1a4fbf6a44f53c6e"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - avahi: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/avahi-0.9~rc2-5.el10.x86_64_v2.rpm;name=x86_64_v2_avahi;unpack=0"
SRC_URI[x86_64_v2_avahi.sha256sum] = "2d43a37775af2e9773b4afcd83fd3039b9dc60bd8b33c59a6a31e758ec940221"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-autoipd-0.9~rc2-5.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-autoipd;unpack=0"
SRC_URI[x86_64_v2_avahi-autoipd.sha256sum] = "ed14e4cb744adb2052da5e294e209c23f2130486a263dc541ede76ec3c43583c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-howl-0.9~rc2-5.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-howl;unpack=0"
SRC_URI[x86_64_v2_avahi-compat-howl.sha256sum] = "268f19d9fa1c34d6b079b3e41ba4c5f538b5ce98639f464559d13fb575e35812"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-howl-devel-0.9~rc2-5.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-howl-devel;unpack=0"
SRC_URI[x86_64_v2_avahi-compat-howl-devel.sha256sum] = "e86fe6b6d856788a1dac66fe35c0ccb517750352c4652d929f6d06210a7a401a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-libdns_sd-0.9~rc2-5.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-libdns_sd;unpack=0"
SRC_URI[x86_64_v2_avahi-compat-libdns_sd.sha256sum] = "91c198092227e9ac940b08461aecc87be2f081b1b252a0965b29649f6ca715fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-libdns_sd-devel-0.9~rc2-5.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-libdns_sd-devel;unpack=0"
SRC_URI[x86_64_v2_avahi-compat-libdns_sd-devel.sha256sum] = "3c23b7b6d9c0d8e53e5b9ade1f56859fd1cd752d66aaac145b5ab324e5787ea5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-devel-0.9~rc2-5.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-devel;unpack=0"
SRC_URI[x86_64_v2_avahi-devel.sha256sum] = "56d5035dfd9fabea187b472220cd27a21f02ebad4a1146416dbb127effcd372e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-glib-0.9~rc2-5.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-glib;unpack=0"
SRC_URI[x86_64_v2_avahi-glib.sha256sum] = "6311f6a86ccc5001f710d82152cd3b99f39ea8001801cb5e422b395bcd55b5b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-glib-devel-0.9~rc2-5.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-glib-devel;unpack=0"
SRC_URI[x86_64_v2_avahi-glib-devel.sha256sum] = "6286d6fba128ab6ff88c703ab75a4a4bfca7ab395bddfccd96698716dbc8f5c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-gobject-0.9~rc2-5.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-gobject;unpack=0"
SRC_URI[x86_64_v2_avahi-gobject.sha256sum] = "c8111c0b03faec16fc4d3c4f74b1b8a9802803c369208ac1f273a632bf6df189"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-gobject-devel-0.9~rc2-5.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-gobject-devel;unpack=0"
SRC_URI[x86_64_v2_avahi-gobject-devel.sha256sum] = "ece52c94fa404f760dd2394e27e53d48f56526e4e932bf3d7eaf9e77e2ba532b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/avahi-libs-0.9~rc2-5.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-libs;unpack=0"
SRC_URI[x86_64_v2_avahi-libs.sha256sum] = "855b64286c26dc9a059a7e8197c773ad0f7786f20aebfa1f63a2233517013ed5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-tools-0.9~rc2-5.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-tools;unpack=0"
SRC_URI[x86_64_v2_avahi-tools.sha256sum] = "8bb3eb1bf299ffe96712c5afd87964ca11d28dd5d0ca25d10fd7d8c35446fef0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/avahi-0.9~rc2-5.el10.aarch64.rpm;name=aarch64_avahi;unpack=0"
SRC_URI[aarch64_avahi.sha256sum] = "ed52fdf928106198a97fbd3933c18559fa3f532e580cdbca070d1fe6cb83876d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-autoipd-0.9~rc2-5.el10.aarch64.rpm;name=aarch64_avahi-autoipd;unpack=0"
SRC_URI[aarch64_avahi-autoipd.sha256sum] = "c1d7db28d4f2564c61d4df17ec10b03a9ce1aca01328786ea9eee4a16cb077a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-howl-0.9~rc2-5.el10.aarch64.rpm;name=aarch64_avahi-compat-howl;unpack=0"
SRC_URI[aarch64_avahi-compat-howl.sha256sum] = "470f71e28293365569731485aa4a091b9174b57fce8f2634b45749b1d69155cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-howl-devel-0.9~rc2-5.el10.aarch64.rpm;name=aarch64_avahi-compat-howl-devel;unpack=0"
SRC_URI[aarch64_avahi-compat-howl-devel.sha256sum] = "5c88179c829ff9491c70d4f24b897a745a1c36a996e1884d0996a1b29adc55b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-libdns_sd-0.9~rc2-5.el10.aarch64.rpm;name=aarch64_avahi-compat-libdns_sd;unpack=0"
SRC_URI[aarch64_avahi-compat-libdns_sd.sha256sum] = "4a5c2756197dab175d11364b8ce9060e150e90db66e038d8763a903e9eb7450d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-libdns_sd-devel-0.9~rc2-5.el10.aarch64.rpm;name=aarch64_avahi-compat-libdns_sd-devel;unpack=0"
SRC_URI[aarch64_avahi-compat-libdns_sd-devel.sha256sum] = "ee309cae331ae4e9c98fdbe4d4c513758bcf241a70283256e53cdb85a366a0c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-devel-0.9~rc2-5.el10.aarch64.rpm;name=aarch64_avahi-devel;unpack=0"
SRC_URI[aarch64_avahi-devel.sha256sum] = "a2164888d204501ff3b863b2bdfd5b2b957d9dacd610c95988bf5080dcf3e682"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-glib-0.9~rc2-5.el10.aarch64.rpm;name=aarch64_avahi-glib;unpack=0"
SRC_URI[aarch64_avahi-glib.sha256sum] = "2b8032702a03fb27830f28bbf9748feb521945f590ab89cd71e44bf6862d2efa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-glib-devel-0.9~rc2-5.el10.aarch64.rpm;name=aarch64_avahi-glib-devel;unpack=0"
SRC_URI[aarch64_avahi-glib-devel.sha256sum] = "20343daa19dd2d6bc7b1fce786b326b632eabc21ee929118d49dde280d2908eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-gobject-0.9~rc2-5.el10.aarch64.rpm;name=aarch64_avahi-gobject;unpack=0"
SRC_URI[aarch64_avahi-gobject.sha256sum] = "482588a6600f9eb64632cd5919a1d989a08d342e29d0d2b33804190703307dcb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-gobject-devel-0.9~rc2-5.el10.aarch64.rpm;name=aarch64_avahi-gobject-devel;unpack=0"
SRC_URI[aarch64_avahi-gobject-devel.sha256sum] = "c0aa1a9b8ee55c0c3bd0b08bd28237055c20f2be2291285d3efff802922ce043"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/avahi-libs-0.9~rc2-5.el10.aarch64.rpm;name=aarch64_avahi-libs;unpack=0"
SRC_URI[aarch64_avahi-libs.sha256sum] = "781ff76f6a41ee448e3e3ade56d1c7f4e6b6e8c83abadb63f384375f464a8f9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-tools-0.9~rc2-5.el10.aarch64.rpm;name=aarch64_avahi-tools;unpack=0"
SRC_URI[aarch64_avahi-tools.sha256sum] = "f1561caa3d388e79ab63f4cf2130a924517546256267db419353aa9b5348ddb1"

RDEPENDS:avahi:x86_64_v2 = " \
 avahi-libs \
 bash \
 dbus \
 dbus-libs \
 expat \
 glibc \
 libcap \
 libdaemon \
 shadow-utils \
 systemd-libs \
 virtual/coreutils \
"
RDEPENDS:avahi:aarch64 = " \
 avahi-libs \
 bash \
 dbus \
 dbus-libs \
 expat \
 glibc \
 libdaemon \
 shadow-utils \
 systemd-libs \
 virtual/coreutils \
"
RDEPENDS:avahi-autoipd = " \
 avahi-libs \
 bash \
 glibc \
 libdaemon \
 shadow-utils \
 "
RDEPENDS:avahi-compat-howl = " \
 avahi-libs \
 dbus-libs \
 glibc \
 "
RDEPENDS:avahi-compat-howl-devel = " \
 avahi-compat-howl \
 avahi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-compat-libdns_sd = " \
 avahi-libs \
 dbus-libs \
 glibc \
 "
RDEPENDS:avahi-compat-libdns_sd-devel = " \
 avahi-compat-libdns_sd \
 avahi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-devel = " \
 avahi \
 avahi-libs \
 dbus-devel \
 libevent-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-glib = " \
 avahi-libs \
 glib2 \
 glibc \
 "
RDEPENDS:avahi-glib-devel = " \
 avahi-devel \
 avahi-glib \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-gobject = " \
 avahi-glib \
 avahi-libs \
 dbus-libs \
 glib2 \
 glibc \
 "
RDEPENDS:avahi-gobject-devel = " \
 avahi-devel \
 avahi-glib-devel \
 avahi-gobject \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-libs = " \
 dbus-libs \
 glibc \
 libevent \
 "
RDEPENDS:avahi-tools = " \
 avahi \
 avahi-libs \
 gdbm-libs \
 glibc \
 "
