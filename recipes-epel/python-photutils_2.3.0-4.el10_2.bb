# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-photutils"
PV = "2.3.0"
PR = "4.el10_2"
PACKAGES = " \
 python3-photutils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-photutils-2.3.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1c7b6076157ecb129d4e28afcac3de2b3fce276482a18e887e4aefcbda4792f"

URI_x86_64_v2_python3-photutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-photutils-2.3.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-photutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-photutils}"
SRC_URI[x86_64_v2_python3-photutils.sha256sum] = "80ef09572351ef465d8ea9a4eaa1460c7cd39e39a13cbb7a56f4a88a83eef325"

URI_aarch64_python3-photutils = "${EPEL_MIRROR}/aarch64/Packages/p/python3-photutils-2.3.0-4.el10_2.aarch64.rpm;name=aarch64_python3-photutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-photutils}"
SRC_URI[aarch64_python3-photutils.sha256sum] = "4348575fa9b1907c9ea673548817fcfba92ddf3cd5acac7e2fa5d63ae31dd47e"

RDEPENDS:python3-photutils = " \
 glibc \
 python3 \
 python3-astropy \
 python3-numpy \
 python3-scipy \
 "
