# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krdp"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 krdp \
 krdp-devel \
 krdp-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krdp-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bf50cc990c8113d649652874ead796b77acc087f4eb66e43ffa28ccb51a5d22"

URI_x86_64_v2_krdp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdp}"
SRC_URI[x86_64_v2_krdp.sha256sum] = "9f8e8196696e9b4e246d23254d92a3f5dc2250546219ec0bc50f51e043c11270"

URI_x86_64_v2_krdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-devel-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdp-devel}"
SRC_URI[x86_64_v2_krdp-devel.sha256sum] = "99100dd3526a43915e779396706bbcb17f47d23688d17c5a8d10a4cd3b9251b9"

URI_x86_64_v2_krdp-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-libs-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdp-libs}"
SRC_URI[x86_64_v2_krdp-libs.sha256sum] = "281a73a3b2de971c57fcaec8c66c383fd84f7f25e36a574661ad43d1d9b4f794"

URI_aarch64_krdp = "${EPEL_MIRROR}/aarch64/Packages/k/krdp-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_krdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdp}"
SRC_URI[aarch64_krdp.sha256sum] = "5e6b7e172bea31a657314a8bf6d8cf886c521764da9e605a37f84a57a457e193"

URI_aarch64_krdp-devel = "${EPEL_MIRROR}/aarch64/Packages/k/krdp-devel-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_krdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdp-devel}"
SRC_URI[aarch64_krdp-devel.sha256sum] = "1d781416d5854a9f47208b91f1344ace0beba3f8d4f40f8e2d985fa4e5bc6004"

URI_aarch64_krdp-libs = "${EPEL_MIRROR}/aarch64/Packages/k/krdp-libs-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_krdp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdp-libs}"
SRC_URI[aarch64_krdp-libs.sha256sum] = "2aeff10802409e077a3fc11c3b98d63dd09ae0daf4a1b2cde42bdfc8047f1edf"

RDEPENDS:krdp = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kstatusnotifieritem \
 kpipewire \
 krdp-libs \
 libstdc++ \
 openssl \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:krdp-devel = " \
 cmake-filesystem \
 krdp-libs \
 "
RDEPENDS:krdp-libs = " \
 freerdp \
 freerdp-libs \
 glibc \
 kf6-kconfig \
 kpipewire \
 libstdc++ \
 libwayland-client \
 libwinpr \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwayland \
 "
