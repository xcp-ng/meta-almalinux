# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qpid-proton"
PV = "0.40.0"
PR = "4.el10_0"
PACKAGES = " \
 python-qpid-proton-docs \
 python3-qpid-proton \
 qpid-proton-c \
 qpid-proton-c-devel \
 qpid-proton-c-docs \
 qpid-proton-cpp \
 qpid-proton-cpp-devel \
 qpid-proton-cpp-docs \
 qpid-proton-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qpid-proton-0.40.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c916fcf744acd6c7e063acb38eeda768312c4109e986c1d14c5c2dd36e2a3b5"

URI_x86_64_v2_python-qpid-proton-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-qpid-proton-docs-0.40.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-qpid-proton-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-qpid-proton-docs}"
SRC_URI[x86_64_v2_python-qpid-proton-docs.sha256sum] = "b0ed3218ced49f70bbdd8a5230714ededf0a1b8099343c8514f653deece3befa"

URI_x86_64_v2_python3-qpid-proton = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-qpid-proton-0.40.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-qpid-proton;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-qpid-proton}"
SRC_URI[x86_64_v2_python3-qpid-proton.sha256sum] = "5d7179e72224efd3eb2e7259e3f1acc5c87f7d5929e8a179458eee80cbc7f582"

URI_x86_64_v2_qpid-proton-c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qpid-proton-c-0.40.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qpid-proton-c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qpid-proton-c}"
SRC_URI[x86_64_v2_qpid-proton-c.sha256sum] = "a43139851dc85c2c5a5ebb1bd829b4e739eb3298c9d22d8788ee8c7f906bb6fa"

URI_x86_64_v2_qpid-proton-c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qpid-proton-c-devel-0.40.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qpid-proton-c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qpid-proton-c-devel}"
SRC_URI[x86_64_v2_qpid-proton-c-devel.sha256sum] = "a342392fbc2457e05a5d60332993be5f41cde0ac85d5603790e301dab27d8e68"

URI_x86_64_v2_qpid-proton-c-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qpid-proton-c-docs-0.40.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qpid-proton-c-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qpid-proton-c-docs}"
SRC_URI[x86_64_v2_qpid-proton-c-docs.sha256sum] = "0f1f89c170b2fcce08e451ef0d4f5413ff70ed59b8c10fb12a4f41c24af332d9"

URI_x86_64_v2_qpid-proton-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qpid-proton-cpp-0.40.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qpid-proton-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qpid-proton-cpp}"
SRC_URI[x86_64_v2_qpid-proton-cpp.sha256sum] = "c7e2e9751c5104363d1dab3315525609dce40632e29711674640cf9aced7f19f"

URI_x86_64_v2_qpid-proton-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qpid-proton-cpp-devel-0.40.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qpid-proton-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qpid-proton-cpp-devel}"
SRC_URI[x86_64_v2_qpid-proton-cpp-devel.sha256sum] = "c012ceb572122e3a7b76c05302703940345c6001566b484b52b4e5cf49e3d330"

URI_x86_64_v2_qpid-proton-cpp-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qpid-proton-cpp-docs-0.40.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qpid-proton-cpp-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qpid-proton-cpp-docs}"
SRC_URI[x86_64_v2_qpid-proton-cpp-docs.sha256sum] = "c0484cad018d70ec93db8a73d0b30bc912774bf03167c804a60293b4066eed2b"

URI_x86_64_v2_qpid-proton-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qpid-proton-tests-0.40.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qpid-proton-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qpid-proton-tests}"
SRC_URI[x86_64_v2_qpid-proton-tests.sha256sum] = "6ad13eb7064cad3180a82b6e19b0c065692e738d679d1e225d4dd4a46f53bab9"

URI_aarch64_python-qpid-proton-docs = "${EPEL_MIRROR}/aarch64/Packages/p/python-qpid-proton-docs-0.40.0-4.el10_0.noarch.rpm;name=aarch64_python-qpid-proton-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-qpid-proton-docs}"
SRC_URI[aarch64_python-qpid-proton-docs.sha256sum] = "5c23c74a4bc7d56f79fe31090e8c1d4eff8adaf51708f8ca8441a7d0df9bae76"

URI_aarch64_python3-qpid-proton = "${EPEL_MIRROR}/aarch64/Packages/p/python3-qpid-proton-0.40.0-4.el10_0.aarch64.rpm;name=aarch64_python3-qpid-proton;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-qpid-proton}"
SRC_URI[aarch64_python3-qpid-proton.sha256sum] = "7cd34e48627e63b1ae9fcef6a1295f5e56afc0226ca7a8ccaf9b40811f09e8f4"

URI_aarch64_qpid-proton-c = "${EPEL_MIRROR}/aarch64/Packages/q/qpid-proton-c-0.40.0-4.el10_0.aarch64.rpm;name=aarch64_qpid-proton-c;unpack=0"
SRC_URI:append = " ${URI_aarch64_qpid-proton-c}"
SRC_URI[aarch64_qpid-proton-c.sha256sum] = "947e36898308f20d2fbebf65f459b86b5c51a32b4b2837e8a2736d6c7f406e0b"

URI_aarch64_qpid-proton-c-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qpid-proton-c-devel-0.40.0-4.el10_0.aarch64.rpm;name=aarch64_qpid-proton-c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qpid-proton-c-devel}"
SRC_URI[aarch64_qpid-proton-c-devel.sha256sum] = "5c0182b259d42997575bf8044bdfcf8ec634754cad3af3f00f48c47fc8404470"

URI_aarch64_qpid-proton-c-docs = "${EPEL_MIRROR}/aarch64/Packages/q/qpid-proton-c-docs-0.40.0-4.el10_0.noarch.rpm;name=aarch64_qpid-proton-c-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_qpid-proton-c-docs}"
SRC_URI[aarch64_qpid-proton-c-docs.sha256sum] = "aa97e6a1268cdc4e56bc2c67cd40d7afec23f456cef44b077e59fed32b748a6a"

URI_aarch64_qpid-proton-cpp = "${EPEL_MIRROR}/aarch64/Packages/q/qpid-proton-cpp-0.40.0-4.el10_0.aarch64.rpm;name=aarch64_qpid-proton-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_qpid-proton-cpp}"
SRC_URI[aarch64_qpid-proton-cpp.sha256sum] = "dbde30135bb983a2fa21028ae4d568c9765f66f8f15438354d469c666e8863f5"

URI_aarch64_qpid-proton-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qpid-proton-cpp-devel-0.40.0-4.el10_0.aarch64.rpm;name=aarch64_qpid-proton-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qpid-proton-cpp-devel}"
SRC_URI[aarch64_qpid-proton-cpp-devel.sha256sum] = "3ed6c0a7b968909285052cdacfd3b8e01290b74e9b5c1296a7b9fce93565920f"

URI_aarch64_qpid-proton-cpp-docs = "${EPEL_MIRROR}/aarch64/Packages/q/qpid-proton-cpp-docs-0.40.0-4.el10_0.noarch.rpm;name=aarch64_qpid-proton-cpp-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_qpid-proton-cpp-docs}"
SRC_URI[aarch64_qpid-proton-cpp-docs.sha256sum] = "137092a3c10703f0c7332f8b416a667711997d6bb9b03f266911d15c89e4422d"

URI_aarch64_qpid-proton-tests = "${EPEL_MIRROR}/aarch64/Packages/q/qpid-proton-tests-0.40.0-4.el10_0.noarch.rpm;name=aarch64_qpid-proton-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_qpid-proton-tests}"
SRC_URI[aarch64_qpid-proton-tests.sha256sum] = "fb50d2bf0f5770081091e3f055eac499522b5a7e366ad32e3f8691317722e020"

RDEPENDS:python-qpid-proton-docs = " \
 "
RDEPENDS:python3-qpid-proton = " \
 cyrus-sasl-lib \
 glibc \
 openssl-libs \
 python3 \
 python3-cffi \
 qpid-proton-c \
 "
RDEPENDS:qpid-proton-c = " \
 cyrus-sasl-lib \
 glibc \
 openssl-libs \
 "
RDEPENDS:qpid-proton-c-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qpid-proton-c \
 qpid-proton-c-devel \
 "
RDEPENDS:qpid-proton-c-docs = " \
 "
RDEPENDS:qpid-proton-cpp = " \
 glibc \
 jsoncpp \
 libgcc \
 libstdc++ \
 qpid-proton-c \
 "
RDEPENDS:qpid-proton-cpp-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qpid-proton-c-devel \
 qpid-proton-cpp \
 "
RDEPENDS:qpid-proton-cpp-docs = " \
 "
RDEPENDS:qpid-proton-tests = " \
 "
