# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konquest"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 konquest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konquest-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1675f137f37b27f08d8cea7f7f9435656a94d33ae4ecd17980e36869ef90528"

URI_x86_64_v2_konquest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konquest-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konquest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konquest}"
SRC_URI[x86_64_v2_konquest.sha256sum] = "19dd2116ae5acc0f491389ccad165f2debe6b01ae1f4a6ee7c2275f5e36d04e1"

URI_aarch64_konquest = "${EPEL_MIRROR}/aarch64/Packages/k/konquest-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_konquest;unpack=0"
SRC_URI:append = " ${URI_aarch64_konquest}"
SRC_URI[aarch64_konquest.sha256sum] = "9d6ab82dfeb363cca7dc75c4e39816ce1b780010f45e0ac71fb56d2a5d690019"

RDEPENDS:konquest = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtscxml \
 qt6-qtsvg \
 "
