# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-suds"
PV = "1.2.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-suds \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-suds-1.2.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d2552f26a4b4f66af45ec3c9ad3f4fbb1dbbd8b54131f887d98db1d84808d70"

URI_x86_64_v2_python3-suds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-suds-1.2.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-suds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-suds}"
SRC_URI[x86_64_v2_python3-suds.sha256sum] = "f1ff6eedbcef641962ccc0eb990e08d4d393f6186660ab8ffa09be3263060ed0"

URI_aarch64_python3-suds = "${EPEL_MIRROR}/aarch64/Packages/p/python3-suds-1.2.0-2.el10_1.noarch.rpm;name=aarch64_python3-suds;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-suds}"
SRC_URI[aarch64_python3-suds.sha256sum] = "916128e2d2da852d9fef10a47b8fdb6320f5847db546d3a4dc8b9072e668065f"

RDEPENDS:python3-suds = " \
 python3 \
 "
