# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c-icap"
PV = "0.6.3"
PR = "2.el10_0"
PACKAGES = " \
 c-icap \
 c-icap-devel \
 c-icap-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/c-icap-0.6.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ec7ed53b54688a9f012ea716a99065805ff44fe77500f03a1cb9127934e8e09"

URI_x86_64_v2_c-icap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c-icap-0.6.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c-icap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c-icap}"
SRC_URI[x86_64_v2_c-icap.sha256sum] = "6808a8743ce0bfee179942f3e04587aa9366cfbd26e4f80372da008d7967eb0a"

URI_x86_64_v2_c-icap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c-icap-devel-0.6.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c-icap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c-icap-devel}"
SRC_URI[x86_64_v2_c-icap-devel.sha256sum] = "474a81771cd1af92e1e0588ddfd137663c2c557aa079d4acc531a8e0d9ccef46"

URI_x86_64_v2_c-icap-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c-icap-libs-0.6.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c-icap-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c-icap-libs}"
SRC_URI[x86_64_v2_c-icap-libs.sha256sum] = "592e4835aef310fb18bf6499cb0894f2d87af778595039d9eac65cad62346ae0"

URI_aarch64_c-icap = "${EPEL_MIRROR}/aarch64/Packages/c/c-icap-0.6.3-2.el10_0.aarch64.rpm;name=aarch64_c-icap;unpack=0"
SRC_URI:append = " ${URI_aarch64_c-icap}"
SRC_URI[aarch64_c-icap.sha256sum] = "4440807a4b043d2bf6ad279a99edd599c9b1ccaa425efaf0f8b722de4b264988"

URI_aarch64_c-icap-devel = "${EPEL_MIRROR}/aarch64/Packages/c/c-icap-devel-0.6.3-2.el10_0.aarch64.rpm;name=aarch64_c-icap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_c-icap-devel}"
SRC_URI[aarch64_c-icap-devel.sha256sum] = "e6cf4a5d26f48f1e8b73a82519c9017766899d3d630ed398728ee3547f794b22"

URI_aarch64_c-icap-libs = "${EPEL_MIRROR}/aarch64/Packages/c/c-icap-libs-0.6.3-2.el10_0.aarch64.rpm;name=aarch64_c-icap-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_c-icap-libs}"
SRC_URI[aarch64_c-icap-libs.sha256sum] = "eb3a6392804738223d0e61715d9bdd4a49efd1ab558adc961780d1696c5e060a"

RDEPENDS:c-icap = " \
 bash \
 c-icap-libs \
 glibc \
 libatomic \
 lmdb-libs \
 logrotate \
 openldap \
 shadow-utils \
 "
RDEPENDS:c-icap-devel = " \
 bash \
 c-icap-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:c-icap-libs = " \
 bzip2-libs \
 glibc \
 libatomic \
 libbrotli \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
