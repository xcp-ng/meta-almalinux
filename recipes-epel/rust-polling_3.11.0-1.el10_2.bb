# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-polling"
PV = "3.11.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-polling+default-devel \
 rust-polling+tracing-devel \
 rust-polling-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-polling-3.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fb788f8b5dc57ed43a15251cfd039343f25d46aede14b63d5a743acd8e0ee36"

URI_x86_64_v2_rust-polling+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polling+default-devel-3.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polling+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polling+default-devel}"
SRC_URI[x86_64_v2_rust-polling+default-devel.sha256sum] = "3ddf026f084378ff25b29cd3cc85d6d441d84ccd568e5e5cdfc19e657a32a503"

URI_x86_64_v2_rust-polling+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polling+tracing-devel-3.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polling+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polling+tracing-devel}"
SRC_URI[x86_64_v2_rust-polling+tracing-devel.sha256sum] = "cb1f119f9ea7dc8decc9adf52814d351bd9ef8a6a0d613d7a129af7a00d49df6"

URI_x86_64_v2_rust-polling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polling-devel-3.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polling-devel}"
SRC_URI[x86_64_v2_rust-polling-devel.sha256sum] = "b7aae49c5f60edc8988b32cc0cb4af796a6b1aaab838bb0e83d9844d5781686f"

URI_aarch64_rust-polling+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polling+default-devel-3.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-polling+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polling+default-devel}"
SRC_URI[aarch64_rust-polling+default-devel.sha256sum] = "b311813155d210c935ec1452bfbdfff660775287efcd39d5a044114dc75a6322"

URI_aarch64_rust-polling+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polling+tracing-devel-3.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-polling+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polling+tracing-devel}"
SRC_URI[aarch64_rust-polling+tracing-devel.sha256sum] = "b055bba754e04415a4983fbcbe29ca7dc6c1312966600546cb71ee6483d2cc4c"

URI_aarch64_rust-polling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polling-devel-3.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-polling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polling-devel}"
SRC_URI[aarch64_rust-polling-devel.sha256sum] = "9874931017a496697185819248d83ef6dfc9f917197d6b4afec228713bdec1d8"

RDEPENDS:rust-polling+default-devel = " \
 cargo \
 rust-polling-devel \
 "
RDEPENDS:rust-polling+tracing-devel = " \
 cargo \
 rust-polling-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-polling-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+std-devel \
 rust-rustix+time-devel \
 rust-rustix-devel \
 "
