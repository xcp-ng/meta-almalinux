# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpki-client"
PV = "9.8"
PR = "1.el10_1"
PACKAGES = " \
 rpki-client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rpki-client-9.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "488a82a171a9dac0096c7decc7872a1e54c6842ee405b5e9ee479355dd4bfebd"

URI_x86_64_v2_rpki-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpki-client-9.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rpki-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpki-client}"
SRC_URI[x86_64_v2_rpki-client.sha256sum] = "087daaa51a060e1292e25865b4b683222ccb6d6956fd1d7a43a2146d5abc1d85"

URI_aarch64_rpki-client = "${EPEL_MIRROR}/aarch64/Packages/r/rpki-client-9.8-1.el10_1.aarch64.rpm;name=aarch64_rpki-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpki-client}"
SRC_URI[aarch64_rpki-client.sha256sum] = "8923c09e512fbd37bec091030d0c2b872c4a54fcdf2257b3689e7a33ff85b10e"

RDEPENDS:rpki-client = " \
 bash \
 expat \
 glibc \
 libretls \
 openssl-libs \
 rsync \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
