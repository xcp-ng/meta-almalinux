# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kpackage"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kpackage \
 kf6-kpackage-devel \
 kf6-kpackage-doc \
 kf6-kpackage-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kpackage-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e2f25694a767e1b6b8c7cb0550fb4eefba46bcabb1a2792dbb0b7614d5e47c61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpackage;unpack=0"
SRC_URI[x86_64_v2_kf6-kpackage.sha256sum] = "1d1b537a22d8ce570fd734a1605491d51a1d3ae1b6f5c51dd6d4eaa1a6238a33"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpackage-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kpackage-devel.sha256sum] = "6d78dcefd52ab604b1b7bb523d44688a44b5aef064cccc1e18b68920c45f4735"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpackage-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kpackage-doc.sha256sum] = "4f36f37cb23c952a14389b61380bad5c8a63c59abad78a4738893f5e18abeefc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpackage-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kpackage-html.sha256sum] = "2ca9b89086052aa222ed67fda7c27aa3860e43145ebd677c32edf433ab19300d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kpackage;unpack=0"
SRC_URI[aarch64_kf6-kpackage.sha256sum] = "63e08f85c8c5dcc4358da61e15e23d262d4f6f797302c659102970ee7d7eaa69"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kpackage-devel;unpack=0"
SRC_URI[aarch64_kf6-kpackage-devel.sha256sum] = "3a0e09e2c9bf253a5970002f37d7dcf96e3a1abfeee5c4ec528b04ed040dbbc1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kpackage-doc;unpack=0"
SRC_URI[aarch64_kf6-kpackage-doc.sha256sum] = "0483b7ab56505a58f29fc8edddc2c7e178cf2323c8edcea55c7bcd6befe93955"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kpackage-html;unpack=0"
SRC_URI[aarch64_kf6-kpackage-html.sha256sum] = "667711986a2b880036f65af99809a8b51bb6eec60246ca1e055467675b2926e6"

RDEPENDS:kf6-kpackage = " \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kpackage-devel = " \
 cmake-filesystem \
 kf6-kpackage \
 "
RDEPENDS:kf6-kpackage-doc = " \
 "
RDEPENDS:kf6-kpackage-html = " \
 "
