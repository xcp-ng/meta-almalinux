# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kuserfeedback"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kuserfeedback \
 kf6-kuserfeedback-console \
 kf6-kuserfeedback-devel \
 kf6-kuserfeedback-doc \
 kf6-kuserfeedback-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kuserfeedback-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9212c0b26557305e84fa72aff3d55b41d5df84f9988e1a8348a1d26f0bc17117"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback;unpack=0"
SRC_URI[x86_64_v2_kf6-kuserfeedback.sha256sum] = "db0281b564e0d7af3f58239882254c850c4314c9a7221fe7e3f2452fc067d949"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-console-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback-console;unpack=0"
SRC_URI[x86_64_v2_kf6-kuserfeedback-console.sha256sum] = "8dcd274596a92dd9dd4795b6e20c5c910ed70e35eb9a73de167370727b7f5e38"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kuserfeedback-devel.sha256sum] = "ee0c68e32ec379c5fbd56767b92ef2c4ff9407b99a5acdd9d51deb2852cc3885"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kuserfeedback-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kuserfeedback-doc.sha256sum] = "1f368bf158ea492d37c7c33680f86d253a853f75f6680434edc3b49ed8543bbf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kuserfeedback-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kuserfeedback-html.sha256sum] = "ef2ace4fbe05f01f186a3b69ea0ed70702f1a5ecea5b00cf605c5ded5de23fd0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kuserfeedback;unpack=0"
SRC_URI[aarch64_kf6-kuserfeedback.sha256sum] = "356f0633f576cd04f983a4ecc3b8214f9433eb81731e7956c220be4044e9a63e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-console-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kuserfeedback-console;unpack=0"
SRC_URI[aarch64_kf6-kuserfeedback-console.sha256sum] = "f67104e60d59bad34a9d720c8d0a2db032c59ae91c84b971ae9ede08b8b58b22"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kuserfeedback-devel;unpack=0"
SRC_URI[aarch64_kf6-kuserfeedback-devel.sha256sum] = "649dcc3c0a83d068a7f6aeb75b6e91f12857d1f8b02dc7774aecc0c8d3d227f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kuserfeedback-doc;unpack=0"
SRC_URI[aarch64_kf6-kuserfeedback-doc.sha256sum] = "ec1aebd76fdc374f0be2033299b285710bee5159c376aff4cc2a3865c5d29529"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kuserfeedback-html;unpack=0"
SRC_URI[aarch64_kf6-kuserfeedback-html.sha256sum] = "0fbbfd1ad536131db7e05ec4a46d602ee38a84e07fb24dff97e6996f12f92a99"

RDEPENDS:kf6-kuserfeedback = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kuserfeedback-console = " \
 glibc \
 kf6-kuserfeedback \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtsvg \
 "
RDEPENDS:kf6-kuserfeedback-devel = " \
 cmake-filesystem \
 kf6-kuserfeedback \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kuserfeedback-doc = " \
 "
RDEPENDS:kf6-kuserfeedback-html = " \
 "
