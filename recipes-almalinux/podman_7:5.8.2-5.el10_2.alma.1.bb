# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "podman"
PE = "7"
PV = "5.8.2"
PR = "5.el10_2.alma.1"
PACKAGES = " \
 podman \
 podman-docker \
 podman-remote \
 podman-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/podman-5.8.2-5.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b34e1f05ce03ee416399e51992f14bdd785b4d88de90d95ddc1b53ff59efe5a"

URI_x86_64_v2_podman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-5.8.2-5.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman}"
SRC_URI[x86_64_v2_podman.sha256sum] = "632f46af926fd00a939ebe765469e37d8d291ad078d2dbe977868aeea8954e64"
RPROVIDES:podman:x86_64_v2 = "virtual/podman_or_/usr/bin/docker"

URI_x86_64_v2_podman-docker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-docker-5.8.2-5.el10_2.alma.1.noarch.rpm;name=x86_64_v2_podman-docker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-docker}"
SRC_URI[x86_64_v2_podman-docker.sha256sum] = "6d642e7bf54d7d8737244e959bd94e167100278c8303a9671587b40898d8f8a0"
RPROVIDES:podman-docker:x86_64_v2 = "virtual/podman_or_/usr/bin/docker"

URI_x86_64_v2_podman-remote = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-remote-5.8.2-5.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman-remote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-remote}"
SRC_URI[x86_64_v2_podman-remote.sha256sum] = "deaf61ef369e1c9a70ade6241a9d8fd787eedfacd302b99a507f5fd24094790f"

URI_x86_64_v2_podman-tests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/podman-tests-5.8.2-5.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-tests}"
SRC_URI[x86_64_v2_podman-tests.sha256sum] = "274fd72b61613d6d08bef904caab13fcd970077a0e8313d4ddca6e1a8a84b65d"

URI_aarch64_podman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-5.8.2-5.el10_2.alma.1.aarch64.rpm;name=aarch64_podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman}"
SRC_URI[aarch64_podman.sha256sum] = "841b551aacd67cc91acd700aca7d555797ec895fda83e3476d1b46da1dcb4704"
RPROVIDES:podman:aarch64 = "virtual/podman_or_/usr/bin/docker"

URI_aarch64_podman-docker = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-docker-5.8.2-5.el10_2.alma.1.noarch.rpm;name=aarch64_podman-docker;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-docker}"
SRC_URI[aarch64_podman-docker.sha256sum] = "6d642e7bf54d7d8737244e959bd94e167100278c8303a9671587b40898d8f8a0"
RPROVIDES:podman-docker:aarch64 = "virtual/podman_or_/usr/bin/docker"

URI_aarch64_podman-remote = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-remote-5.8.2-5.el10_2.alma.1.aarch64.rpm;name=aarch64_podman-remote;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-remote}"
SRC_URI[aarch64_podman-remote.sha256sum] = "4ece61580de876de879294c8afe6b08e3cfc4489c9d51f66ab4693b274417f4c"

URI_aarch64_podman-tests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/podman-tests-5.8.2-5.el10_2.alma.1.aarch64.rpm;name=aarch64_podman-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-tests}"
SRC_URI[aarch64_podman-tests.sha256sum] = "ecd1e493ac6f3956996711cc4db4b6e76ad66988adf019aefe4df4e3fa74f373"

RDEPENDS:podman = " \
 catatonit \
 conmon \
 containers-common-extra \
 glibc \
 gpgme \
 libgcc \
 libseccomp \
 podman-sequoia \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:podman-docker = " \
 bash \
 podman \
 "
RDEPENDS:podman-remote = " \
 glibc \
 gpgme \
 libgcc \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:podman-tests = " \
 attr \
 bash \
 buildah \
 glibc \
 gnupg2 \
 gpgme \
 httpd-tools \
 jq \
 libgcc \
 libseccomp \
 nmap-ncat \
 openssl \
 podman \
 shadow-utils-subid \
 skopeo \
 slirp4netns \
 socat \
 sqlite-libs \
 xfsprogs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/podman_or_/usr/bin/docker"

PROVIDES:append:aarch64 = " rpm/virtual/podman_or_/usr/bin/docker"
