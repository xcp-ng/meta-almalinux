# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openapi-core"
PV = "0.19.5"
PR = "13.el10_3"
PACKAGES = " \
 python3-openapi-core \
 python3-openapi-core+aiohttp \
 python3-openapi-core+falcon \
 python3-openapi-core+fastapi \
 python3-openapi-core+flask \
 python3-openapi-core+requests \
 python3-openapi-core+starlette \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openapi-core-0.19.5-13.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2829cd4ce90520fe57cd65e277daaa7cb32fdd65b86a13575032e0e1c9373ae9"

URI_x86_64_v2_python3-openapi-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-core-0.19.5-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-core}"
SRC_URI[x86_64_v2_python3-openapi-core.sha256sum] = "43d49249f67abfbd51f7b007c469f77fef3dcead7e13d7b8d9683783efc445e5"

URI_x86_64_v2_python3-openapi-core+aiohttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-core+aiohttp-0.19.5-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-core+aiohttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-core+aiohttp}"
SRC_URI[x86_64_v2_python3-openapi-core+aiohttp.sha256sum] = "d235b629732ab061d4bf20e98f46096332daa5189e6b5247c225c276162b8524"

URI_x86_64_v2_python3-openapi-core+falcon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-core+falcon-0.19.5-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-core+falcon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-core+falcon}"
SRC_URI[x86_64_v2_python3-openapi-core+falcon.sha256sum] = "8073c7e6fe01d7a241860660520bb6101a176f867241b029f8a2ca1f62f4ad81"

URI_x86_64_v2_python3-openapi-core+fastapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-core+fastapi-0.19.5-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-core+fastapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-core+fastapi}"
SRC_URI[x86_64_v2_python3-openapi-core+fastapi.sha256sum] = "c73678cdba09a3d3102d0f7f3ae9e306256978dadbe2c6fea45caa79ebb232fc"

URI_x86_64_v2_python3-openapi-core+flask = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-core+flask-0.19.5-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-core+flask;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-core+flask}"
SRC_URI[x86_64_v2_python3-openapi-core+flask.sha256sum] = "2adde8ddba5d4117446afbd370ecfeb4d853cce7484601583095d7dfa126be01"

URI_x86_64_v2_python3-openapi-core+requests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-core+requests-0.19.5-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-core+requests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-core+requests}"
SRC_URI[x86_64_v2_python3-openapi-core+requests.sha256sum] = "0095afa69c918e48c50b6dbe2f5e3c9a929aa7ec648b55314e8b34e9fef0173e"

URI_x86_64_v2_python3-openapi-core+starlette = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-core+starlette-0.19.5-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-core+starlette;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-core+starlette}"
SRC_URI[x86_64_v2_python3-openapi-core+starlette.sha256sum] = "34bb4a85edb659ecebc95b5ad5bdb871e8d04b0653854098f466a6a47083d16a"

URI_aarch64_python3-openapi-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-core-0.19.5-13.el10_3.noarch.rpm;name=aarch64_python3-openapi-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-core}"
SRC_URI[aarch64_python3-openapi-core.sha256sum] = "f85332ff50964fe4adfe0bb7db8f250d8273cd62fefa7ed4dd9131609bac521f"

URI_aarch64_python3-openapi-core+aiohttp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-core+aiohttp-0.19.5-13.el10_3.noarch.rpm;name=aarch64_python3-openapi-core+aiohttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-core+aiohttp}"
SRC_URI[aarch64_python3-openapi-core+aiohttp.sha256sum] = "420e8ab3114c07fd53c59b2777a2cd0ec4ad9041f2047d025800aa89551e9bf8"

URI_aarch64_python3-openapi-core+falcon = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-core+falcon-0.19.5-13.el10_3.noarch.rpm;name=aarch64_python3-openapi-core+falcon;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-core+falcon}"
SRC_URI[aarch64_python3-openapi-core+falcon.sha256sum] = "7ca4aea443482458043e1ddcad041557ae5b02010a30dc92ee8bacba7e60d898"

URI_aarch64_python3-openapi-core+fastapi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-core+fastapi-0.19.5-13.el10_3.noarch.rpm;name=aarch64_python3-openapi-core+fastapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-core+fastapi}"
SRC_URI[aarch64_python3-openapi-core+fastapi.sha256sum] = "198f482b0ae3c92430fd798e8546c3ae54ddc39f95917ea96b5e393d5ac826ae"

URI_aarch64_python3-openapi-core+flask = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-core+flask-0.19.5-13.el10_3.noarch.rpm;name=aarch64_python3-openapi-core+flask;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-core+flask}"
SRC_URI[aarch64_python3-openapi-core+flask.sha256sum] = "71c1e1e5fa1f37cce0033093da99f166f0380205b3d587910dacd6cfbb868af7"

URI_aarch64_python3-openapi-core+requests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-core+requests-0.19.5-13.el10_3.noarch.rpm;name=aarch64_python3-openapi-core+requests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-core+requests}"
SRC_URI[aarch64_python3-openapi-core+requests.sha256sum] = "141d47ae19c102ff0abb3e30614f9307cf2a28bf0378d64e1939402183992631"

URI_aarch64_python3-openapi-core+starlette = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-core+starlette-0.19.5-13.el10_3.noarch.rpm;name=aarch64_python3-openapi-core+starlette;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-core+starlette}"
SRC_URI[aarch64_python3-openapi-core+starlette.sha256sum] = "09568a71a7c9c0932d052d0c4e50961e4620fa018d0ba6e7b9ecb854171dd207"

RDEPENDS:python3-openapi-core = " \
 python3 \
 python3-isodate \
 python3-jsonschema \
 python3-jsonschema-path \
 python3-more-itertools \
 python3-openapi-schema-validator \
 python3-openapi-spec-validator \
 python3-parse \
 python3-typing-extensions \
 python3-werkzeug \
 "
RDEPENDS:python3-openapi-core+aiohttp = " \
 python3 \
 python3-aiohttp \
 python3-multidict \
 python3-openapi-core \
 "
RDEPENDS:python3-openapi-core+falcon = " \
 python3 \
 python3-falcon \
 python3-openapi-core \
 "
RDEPENDS:python3-openapi-core+fastapi = " \
 python3 \
 python3-fastapi \
 python3-openapi-core \
 "
RDEPENDS:python3-openapi-core+flask = " \
 python3 \
 python3-flask \
 python3-openapi-core \
 "
RDEPENDS:python3-openapi-core+requests = " \
 python3 \
 python3-openapi-core \
 python3-requests \
 "
RDEPENDS:python3-openapi-core+starlette = " \
 python3 \
 python3-aioitertools \
 python3-openapi-core \
 python3-starlette \
 "
