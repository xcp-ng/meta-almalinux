# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onefetch"
PV = "2.23.1"
PR = "2.el10_0"
PACKAGES = " \
 onefetch \
 rust-onefetch+default-devel \
 rust-onefetch+fail-on-deprecated-devel \
 rust-onefetch-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onefetch-2.23.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ead9cd10e975dd5ec903354796e20f315f258af15edfd177733818c13b11b14a"

URI_x86_64_v2_onefetch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/onefetch-2.23.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_onefetch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_onefetch}"
SRC_URI[x86_64_v2_onefetch.sha256sum] = "9ac2e7aac883fdad1ca15a31e561becc384afd2cec90432560148c79204d4014"

URI_x86_64_v2_rust-onefetch+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch+default-devel-2.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch+default-devel}"
SRC_URI[x86_64_v2_rust-onefetch+default-devel.sha256sum] = "beb76c05befe9057792737cadddbf2695a55ed9f463cc34288273bbdfd575bd2"

URI_x86_64_v2_rust-onefetch+fail-on-deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch+fail-on-deprecated-devel-2.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch+fail-on-deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch+fail-on-deprecated-devel}"
SRC_URI[x86_64_v2_rust-onefetch+fail-on-deprecated-devel.sha256sum] = "5d0f19f818da4b95e838dc12b2f72685041e3883c96830e8f4213c07c044c920"

URI_x86_64_v2_rust-onefetch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-devel-2.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-devel}"
SRC_URI[x86_64_v2_rust-onefetch-devel.sha256sum] = "55072670eca71a9cc405e1a6c4d32d7ef8fe62359e906983714380ef807bd50a"

URI_aarch64_onefetch = "${EPEL_MIRROR}/aarch64/Packages/o/onefetch-2.23.1-2.el10_0.aarch64.rpm;name=aarch64_onefetch;unpack=0"
SRC_URI:append = " ${URI_aarch64_onefetch}"
SRC_URI[aarch64_onefetch.sha256sum] = "8a2187159dcee64b863893ed1adb1cf64d74cdd61ffdf02efafdebc8494176e2"

URI_aarch64_rust-onefetch+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch+default-devel-2.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-onefetch+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch+default-devel}"
SRC_URI[aarch64_rust-onefetch+default-devel.sha256sum] = "bf43d6886dc8a3986f4852921e02451c2bc8bd8477a82c86a7550da012f166a9"

URI_aarch64_rust-onefetch+fail-on-deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch+fail-on-deprecated-devel-2.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-onefetch+fail-on-deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch+fail-on-deprecated-devel}"
SRC_URI[aarch64_rust-onefetch+fail-on-deprecated-devel.sha256sum] = "1a3deec23276082ec54110e2719f74e7ee16124c717562a3e775ecd66cbcd47b"

URI_aarch64_rust-onefetch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-devel-2.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-onefetch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-devel}"
SRC_URI[aarch64_rust-onefetch-devel.sha256sum] = "070515c2fb03fbaba1243971dfeb39a370461b998470cd9b33bd3d67a596e55e"

RDEPENDS:onefetch = " \
 glibc \
 libgcc \
 libzstd \
 zlib-ng \
 "
RDEPENDS:rust-onefetch+default-devel = " \
 cargo \
 rust-onefetch-devel \
 "
RDEPENDS:rust-onefetch+fail-on-deprecated-devel = " \
 cargo \
 rust-onefetch-devel \
 "
RDEPENDS:rust-onefetch-devel = " \
 cargo \
 ruby \
 rust \
 rust-anyhow+default-devel \
 rust-askalono+default-devel \
 rust-byte-unit+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap_complete+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-gix+blob-diff-devel \
 rust-gix+index-devel \
 rust-gix+mailmap-devel \
 rust-gix+max-performance-safe-devel \
 rust-gix+status-devel \
 rust-gix-devel \
 rust-gix-features+default-devel \
 rust-gix-features+zlib-ng-devel \
 rust-globset+default-devel \
 rust-human-panic+default-devel \
 rust-image+color_quant-devel \
 rust-image+jpeg-devel \
 rust-image+png-devel \
 rust-image+webp-devel \
 rust-image-devel \
 rust-lazy_static+default-devel \
 rust-num-format+default-devel \
 rust-onefetch-ascii+default-devel \
 rust-onefetch-image+default-devel \
 rust-onefetch-manifest+default-devel \
 rust-owo-colors+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 rust-serde_yaml+default-devel \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 rust-tera-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time-humanize+default-devel \
 rust-time-humanize+time-devel \
 rust-tokei+default-devel \
 rust-typetag+default-devel \
 "
