# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-psl"
PV = "2.1.238"
PR = "1.el10_2"
PACKAGES = " \
 rust-psl+default-devel \
 rust-psl+helpers-devel \
 rust-psl-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-psl-2.1.238-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d5342830edc68a5842b35b47dc24ddd0326e6cc7b1d2d97c136749c10fd2a10"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl+default-devel-2.1.238-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-psl+default-devel.sha256sum] = "d940782c51eafa67f48c01a3e8d7dae7aa6bfeb4c92cd0bd11ef584970378d2b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl+helpers-devel-2.1.238-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl+helpers-devel;unpack=0"
SRC_URI[x86_64_v2_rust-psl+helpers-devel.sha256sum] = "a0fe705add4953907d7d708a94fa5c090e767cc4bff44132026da4aedc919433"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl-devel-2.1.238-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-psl-devel.sha256sum] = "4981cce4cc231d95d27b7403b80ef1b8df559c717cc84481f657cf97493d2bf9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-psl+default-devel-2.1.238-1.el10_2.noarch.rpm;name=aarch64_rust-psl+default-devel;unpack=0"
SRC_URI[aarch64_rust-psl+default-devel.sha256sum] = "afe353ae8c4f8f9c728023e4baf9978bb37f4c75966ff3a058f32d2618f0850f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-psl+helpers-devel-2.1.238-1.el10_2.noarch.rpm;name=aarch64_rust-psl+helpers-devel;unpack=0"
SRC_URI[aarch64_rust-psl+helpers-devel.sha256sum] = "e71031221f51d09e6a4093662a5a987242fb15533e13ca9277714e76eef2bb2f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-psl-devel-2.1.238-1.el10_2.noarch.rpm;name=aarch64_rust-psl-devel;unpack=0"
SRC_URI[aarch64_rust-psl-devel.sha256sum] = "0272f2c308c72d59c5cd5bfff089451db5973ecc43161337e4f7a74c1ae2861e"

RDEPENDS:rust-psl+default-devel = " \
 cargo \
 rust-psl+helpers-devel \
 rust-psl-devel \
 "
RDEPENDS:rust-psl+helpers-devel = " \
 cargo \
 rust-psl-devel \
 "
RDEPENDS:rust-psl-devel = " \
 cargo \
 rust-psl-types+default-devel \
 "
