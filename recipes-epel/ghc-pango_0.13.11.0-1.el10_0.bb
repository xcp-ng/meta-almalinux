# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-pango"
PV = "0.13.11.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-pango \
 ghc-pango-devel \
 ghc-pango-doc \
 ghc-pango-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-pango-0.13.11.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "baf03ec725667d37cd590ff72c2bafd4e9a1d418d97511bb53b61bff97341c8a"

URI_x86_64_v2_ghc-pango = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pango-0.13.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pango;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pango}"
SRC_URI[x86_64_v2_ghc-pango.sha256sum] = "ec770cbbc8eb294507ab3e92e124bdb600ffcf0e35a007e48cc5d0eeab9d54d6"

URI_x86_64_v2_ghc-pango-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pango-devel-0.13.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pango-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pango-devel}"
SRC_URI[x86_64_v2_ghc-pango-devel.sha256sum] = "c526e8133c6f2d1f7b4265706e7b7e3fc46d61f55280f42409537083cda03399"

URI_x86_64_v2_ghc-pango-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pango-doc-0.13.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pango-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pango-doc}"
SRC_URI[x86_64_v2_ghc-pango-doc.sha256sum] = "b994a7c035ba0c7b4a5ae52a2581396aa619814a3e98875b71325f00279f4d62"

URI_x86_64_v2_ghc-pango-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pango-prof-0.13.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pango-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pango-prof}"
SRC_URI[x86_64_v2_ghc-pango-prof.sha256sum] = "9c183971b20cbda0a3734d5b2f9d23c6c60c55d1d89e761184519a89e0ea6e7a"

URI_aarch64_ghc-pango = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pango-0.13.11.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-pango;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pango}"
SRC_URI[aarch64_ghc-pango.sha256sum] = "aa0c1c9534a2eff97bc1d4090d1921f160d1bbb9f0a2775c92649d54661d07be"

URI_aarch64_ghc-pango-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pango-devel-0.13.11.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-pango-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pango-devel}"
SRC_URI[aarch64_ghc-pango-devel.sha256sum] = "219d88444962b5b4708af42d11dd128f42e8e752b333a1138247f267f8f7c898"

URI_aarch64_ghc-pango-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pango-doc-0.13.11.0-1.el10_0.noarch.rpm;name=aarch64_ghc-pango-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pango-doc}"
SRC_URI[aarch64_ghc-pango-doc.sha256sum] = "e491cdccecb56298a7b43bd5f56cbf47068f4deeff029c51ec11e3f7970837cd"

URI_aarch64_ghc-pango-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pango-prof-0.13.11.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-pango-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pango-prof}"
SRC_URI[aarch64_ghc-pango-prof.sha256sum] = "0129274346b2154428a2357daec53f94260e567eef24aeaa74dbea64b9eb7661"

RDEPENDS:ghc-pango = " \
 cairo \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-cairo \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-glib \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-utf8-string \
 glib2 \
 glibc \
 gmp \
 harfbuzz \
 libpng \
 pango \
 zlib-ng-compat \
 "
RDEPENDS:ghc-pango-devel = " \
 cairo-devel \
 ghc-array-devel \
 ghc-base-devel \
 ghc-cairo-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-directory-devel \
 ghc-glib-devel \
 ghc-mtl-devel \
 ghc-pango \
 ghc-pretty-devel \
 ghc-process-devel \
 ghc-text-devel \
 pango-devel \
 "
RDEPENDS:ghc-pango-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pango-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-cairo-prof \
 ghc-containers-prof \
 ghc-directory-prof \
 ghc-glib-prof \
 ghc-mtl-prof \
 ghc-pango-devel \
 ghc-pretty-prof \
 ghc-process-prof \
 ghc-text-prof \
 "
