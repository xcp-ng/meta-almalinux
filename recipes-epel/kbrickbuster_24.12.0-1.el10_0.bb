# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbrickbuster"
PV = "24.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kbrickbuster \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbrickbuster-24.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2a1bd8207b8cbce1d3e74828ed8688cf2f2e14a6213cdf55ad0a435fd5e753e"

URI_x86_64_v2_kbrickbuster = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbrickbuster-24.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbrickbuster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbrickbuster}"
SRC_URI[x86_64_v2_kbrickbuster.sha256sum] = "481f4222f483ead2df81f1959b3ee9d9720c9d3caf389f59bb07ee9ce8a8553d"

URI_aarch64_kbrickbuster = "${EPEL_MIRROR}/aarch64/Packages/k/kbrickbuster-24.12.0-1.el10_0.aarch64.rpm;name=aarch64_kbrickbuster;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbrickbuster}"
SRC_URI[aarch64_kbrickbuster.sha256sum] = "49942ae6543d50127f78da61d8ddfc9bd90384506d467dd6b270d7423fc9c540"

RDEPENDS:kbrickbuster = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
