# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rusqlite"
PV = "0.38.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rusqlite+array-devel \
 rust-rusqlite+backup-devel \
 rust-rusqlite+blob-devel \
 rust-rusqlite+buildtime_bindgen-devel \
 rust-rusqlite+cache-devel \
 rust-rusqlite+chrono-devel \
 rust-rusqlite+collation-devel \
 rust-rusqlite+column_decltype-devel \
 rust-rusqlite+column_metadata-devel \
 rust-rusqlite+csv-devel \
 rust-rusqlite+csvtab-devel \
 rust-rusqlite+default-devel \
 rust-rusqlite+extra_check-devel \
 rust-rusqlite+fallible_uint-devel \
 rust-rusqlite+functions-devel \
 rust-rusqlite+hashlink-devel \
 rust-rusqlite+hooks-devel \
 rust-rusqlite+i128_blob-devel \
 rust-rusqlite+jiff-devel \
 rust-rusqlite+limits-devel \
 rust-rusqlite+load_extension-devel \
 rust-rusqlite+modern-full-devel \
 rust-rusqlite+modern_sqlite-devel \
 rust-rusqlite+preupdate_hook-devel \
 rust-rusqlite+serde_json-devel \
 rust-rusqlite+serialize-devel \
 rust-rusqlite+series-devel \
 rust-rusqlite+session-devel \
 rust-rusqlite+time-devel \
 rust-rusqlite+trace-devel \
 rust-rusqlite+unlock_notify-devel \
 rust-rusqlite+url-devel \
 rust-rusqlite+uuid-devel \
 rust-rusqlite+vtab-devel \
 rust-rusqlite+window-devel \
 rust-rusqlite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rusqlite-0.38.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a11c31b9c5ee08d41e3422104565d86b6f70659082a98092682e8ad75409b99"

URI_x86_64_v2_rust-rusqlite+array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+array-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+array-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+array-devel.sha256sum] = "17072e8a148bedb10cb446a0e97fa4f1864b1477c820170ced0ff5770dd383b9"

URI_x86_64_v2_rust-rusqlite+backup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+backup-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+backup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+backup-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+backup-devel.sha256sum] = "1ee0417dc83fcf74e580d07455358469668a7534cba6f0d375629de7f9e6f0ca"

URI_x86_64_v2_rust-rusqlite+blob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+blob-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+blob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+blob-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+blob-devel.sha256sum] = "f2e258a0214106ab12316c4d4b643c2fb863f80cdbdcb182214265498b4a019c"

URI_x86_64_v2_rust-rusqlite+buildtime_bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+buildtime_bindgen-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+buildtime_bindgen-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+buildtime_bindgen-devel.sha256sum] = "0b40d0f008bad52ef5acd9083efbea6240bb2601f075f6981d1ef4d213e1cd02"

URI_x86_64_v2_rust-rusqlite+cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+cache-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+cache-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+cache-devel.sha256sum] = "edd5f7ad8b1bb7dd901f8f08203b22f5a4e383cf01d52a1814cf0b077d734444"

URI_x86_64_v2_rust-rusqlite+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+chrono-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+chrono-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+chrono-devel.sha256sum] = "cc642bdc565e1cd28eec874857f5b0d515312c7cb918512ce1bdeec0a8bb4f29"

URI_x86_64_v2_rust-rusqlite+collation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+collation-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+collation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+collation-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+collation-devel.sha256sum] = "1192e952e37f9f3a8137e51e75785de1e2327dcaa5be0b0d26f97f67f8c66678"

URI_x86_64_v2_rust-rusqlite+column_decltype-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+column_decltype-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+column_decltype-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+column_decltype-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+column_decltype-devel.sha256sum] = "4a8caf2fc5d4138c090f6eb6a007c35b94d6284f9949f620cfb41766ca54ca4d"

URI_x86_64_v2_rust-rusqlite+column_metadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+column_metadata-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+column_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+column_metadata-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+column_metadata-devel.sha256sum] = "b34d8586f357e61526377a917f28e4398e6fa2bbdd8cdc9dcefc2d1f11636181"

URI_x86_64_v2_rust-rusqlite+csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+csv-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+csv-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+csv-devel.sha256sum] = "e910f085fc7bb04595fc26b1f75aa9d1344b1f1b0ebd5c747aa9a3017ae328ef"

URI_x86_64_v2_rust-rusqlite+csvtab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+csvtab-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+csvtab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+csvtab-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+csvtab-devel.sha256sum] = "85cb207d29920268c768029e69b1cad6bb2f2f5b8695097a896692d3d3112a78"

URI_x86_64_v2_rust-rusqlite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+default-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+default-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+default-devel.sha256sum] = "5d2f478873e0e1175b973766880806db7d74fd3d16af0bb92672202de8708a1a"

URI_x86_64_v2_rust-rusqlite+extra_check-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+extra_check-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+extra_check-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+extra_check-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+extra_check-devel.sha256sum] = "78099ce1660195170c330395a61aaa0fea4f3495393ac08b268e740b6f4045f6"

URI_x86_64_v2_rust-rusqlite+fallible_uint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+fallible_uint-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+fallible_uint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+fallible_uint-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+fallible_uint-devel.sha256sum] = "3cc5292ac5a4b9f2071182f927ad92fc20b3d20df643c147522a095bb295a349"

URI_x86_64_v2_rust-rusqlite+functions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+functions-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+functions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+functions-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+functions-devel.sha256sum] = "9d820c4205dd67f5d8d55b76f10b5bc627be3354fa959f26f6f22dee96b7d64a"

URI_x86_64_v2_rust-rusqlite+hashlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+hashlink-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+hashlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+hashlink-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+hashlink-devel.sha256sum] = "e79031d4a7e0d3a54985ef74b8cce5658f0bbb8bcfab930ab1dcdd7d0ae17f3c"

URI_x86_64_v2_rust-rusqlite+hooks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+hooks-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+hooks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+hooks-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+hooks-devel.sha256sum] = "9ebbe03954c1d660f768d37f5ce552e209d69c37dad87b946e55f1e8b640ef91"

URI_x86_64_v2_rust-rusqlite+i128_blob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+i128_blob-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+i128_blob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+i128_blob-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+i128_blob-devel.sha256sum] = "c39bf0fc9f9a9fb1bc8beec04f80fed101f7b3aa8461ca538966d386f7bec789"

URI_x86_64_v2_rust-rusqlite+jiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+jiff-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+jiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+jiff-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+jiff-devel.sha256sum] = "5efbab585d79c0a05f6be2d96d888dc309af9d680796ad0e59d22efb37036e4f"

URI_x86_64_v2_rust-rusqlite+limits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+limits-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+limits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+limits-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+limits-devel.sha256sum] = "8cef38a9feb3fe1c4fdeea67f2edf401d8757e458dfb7f87600e91bc21e134ea"

URI_x86_64_v2_rust-rusqlite+load_extension-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+load_extension-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+load_extension-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+load_extension-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+load_extension-devel.sha256sum] = "64e7a8db023f4d0dc398a90d7e9d680ca601b4281d53cab9315bbc989affaa58"

URI_x86_64_v2_rust-rusqlite+modern-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+modern-full-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+modern-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+modern-full-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+modern-full-devel.sha256sum] = "a4c5900a0717864901ce30cae63ab5c7532c368434deb76cba3dd7c12b8a7f22"

URI_x86_64_v2_rust-rusqlite+modern_sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+modern_sqlite-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+modern_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+modern_sqlite-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+modern_sqlite-devel.sha256sum] = "96444f63eba3ac7f3dcbf65f207f5784edbbca419e7675909765ef0908a74cca"

URI_x86_64_v2_rust-rusqlite+preupdate_hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+preupdate_hook-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+preupdate_hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+preupdate_hook-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+preupdate_hook-devel.sha256sum] = "287cbce3a8b0978b645a697af293b4825276b9981c4def8e5c11d62e1ea0b6ad"

URI_x86_64_v2_rust-rusqlite+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+serde_json-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+serde_json-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+serde_json-devel.sha256sum] = "120fd4ae7fb75b1deaa0b251bbc283a94d8e8781cd64dcf4ef47e5f46a40f1bf"

URI_x86_64_v2_rust-rusqlite+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+serialize-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+serialize-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+serialize-devel.sha256sum] = "48f44be1746a1fb2271d9740c9682c0aa4860a44c8c297a5420a4b480ae4c546"

URI_x86_64_v2_rust-rusqlite+series-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+series-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+series-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+series-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+series-devel.sha256sum] = "11792f0af02a7bd19f188bf5ba56165adf70ce1756dcee6358f581437385a087"

URI_x86_64_v2_rust-rusqlite+session-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+session-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+session-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+session-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+session-devel.sha256sum] = "cd8db3c37784fdef01733557d40805587de9739ca5e51531953710746fb5cf33"

URI_x86_64_v2_rust-rusqlite+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+time-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+time-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+time-devel.sha256sum] = "b531f0d1a2be74dcecc7bf3d47845ae5edf186eef751d5990b1b4d3daf0a5fd1"

URI_x86_64_v2_rust-rusqlite+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+trace-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+trace-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+trace-devel.sha256sum] = "129788e00e69c35bf58283a2722ef88d3cc72d81ffff12bf2955f1bf722b9f78"

URI_x86_64_v2_rust-rusqlite+unlock_notify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+unlock_notify-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+unlock_notify-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+unlock_notify-devel.sha256sum] = "bf8817cc5208911007b49bfcbf226df60498fc93b8f890d2d7f913a7f0f774b3"

URI_x86_64_v2_rust-rusqlite+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+url-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+url-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+url-devel.sha256sum] = "dde9c8e82176aaaace711eea74e02e7a0d7f05608e81ccfedd305faa08a52932"

URI_x86_64_v2_rust-rusqlite+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+uuid-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+uuid-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+uuid-devel.sha256sum] = "235a28234722550be65655f1322573353321d3f5b01b920c509ae3db1dcc6adb"

URI_x86_64_v2_rust-rusqlite+vtab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+vtab-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+vtab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+vtab-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+vtab-devel.sha256sum] = "cb986578444af6c52f097a64e06a5c61db3ab6decf799f8e8f34d7da3579494d"

URI_x86_64_v2_rust-rusqlite+window-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+window-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+window-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+window-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+window-devel.sha256sum] = "71f64eb0109a93909b0d44124bb40a7c01f28c8c2b6b51e6517f4cfb5a957ece"

URI_x86_64_v2_rust-rusqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite-devel-0.38.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite-devel}"
SRC_URI[x86_64_v2_rust-rusqlite-devel.sha256sum] = "70dabf6ccdcf0b111a4fdf09c56cb6bcf8b7bf8432909820a2dc49be125a1105"

URI_aarch64_rust-rusqlite+array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+array-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+array-devel}"
SRC_URI[aarch64_rust-rusqlite+array-devel.sha256sum] = "755238f9850ab4dc6aa1886f394248bc1a193a5ea10e0d68eac1beb1c6d24730"

URI_aarch64_rust-rusqlite+backup-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+backup-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+backup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+backup-devel}"
SRC_URI[aarch64_rust-rusqlite+backup-devel.sha256sum] = "276aae0a4ff27285317c088f6f8fa2bd2095e7d2d02ad5afbdd0188559586d2d"

URI_aarch64_rust-rusqlite+blob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+blob-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+blob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+blob-devel}"
SRC_URI[aarch64_rust-rusqlite+blob-devel.sha256sum] = "bcbb8f05a1836e3f475437151305347b546853988c624b3cf73fb5140825b733"

URI_aarch64_rust-rusqlite+buildtime_bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+buildtime_bindgen-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+buildtime_bindgen-devel}"
SRC_URI[aarch64_rust-rusqlite+buildtime_bindgen-devel.sha256sum] = "b31dc6ba6287713d9e5cd53e6937515d562c4a543ace08db12566b29ccb2d67b"

URI_aarch64_rust-rusqlite+cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+cache-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+cache-devel}"
SRC_URI[aarch64_rust-rusqlite+cache-devel.sha256sum] = "2b8423cc499bdd388267087e76fee21154a2323740b09e5a0fcc8f0d987458c2"

URI_aarch64_rust-rusqlite+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+chrono-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+chrono-devel}"
SRC_URI[aarch64_rust-rusqlite+chrono-devel.sha256sum] = "492f7fab653ba0e78c30dbc009573f2a2106d9b941c684d1997dc99b068ca4c5"

URI_aarch64_rust-rusqlite+collation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+collation-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+collation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+collation-devel}"
SRC_URI[aarch64_rust-rusqlite+collation-devel.sha256sum] = "6c40c7ab316a6c48b79e15993e3aee0e25e80c75c4b232414876aa18f66a2828"

URI_aarch64_rust-rusqlite+column_decltype-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+column_decltype-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+column_decltype-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+column_decltype-devel}"
SRC_URI[aarch64_rust-rusqlite+column_decltype-devel.sha256sum] = "ad7cba83ffc059023a1f7866c264a08533f9ea1a79ea3cf766a1bfc7b9abc632"

URI_aarch64_rust-rusqlite+column_metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+column_metadata-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+column_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+column_metadata-devel}"
SRC_URI[aarch64_rust-rusqlite+column_metadata-devel.sha256sum] = "9ec442451322bc8a0a88e6fb4e8767ce655abdd063dd9fdf1c471cf39849786a"

URI_aarch64_rust-rusqlite+csv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+csv-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+csv-devel}"
SRC_URI[aarch64_rust-rusqlite+csv-devel.sha256sum] = "1fd96256386c776152ddc4c602342351770c10f3766493e00024ff85223730b8"

URI_aarch64_rust-rusqlite+csvtab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+csvtab-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+csvtab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+csvtab-devel}"
SRC_URI[aarch64_rust-rusqlite+csvtab-devel.sha256sum] = "3552ad884e1271232af56109c2b9d0e9420ea6fd630afec112768d84aedc7d5a"

URI_aarch64_rust-rusqlite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+default-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+default-devel}"
SRC_URI[aarch64_rust-rusqlite+default-devel.sha256sum] = "6c24547e48afd87609e63caf5de47d166acdfdf3418a65632e02a40fd1a60b6f"

URI_aarch64_rust-rusqlite+extra_check-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+extra_check-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+extra_check-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+extra_check-devel}"
SRC_URI[aarch64_rust-rusqlite+extra_check-devel.sha256sum] = "1fee927d19fa9a3c703da00401c98ab2a734d0ba3bbb7dcdc872c71e6449305d"

URI_aarch64_rust-rusqlite+fallible_uint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+fallible_uint-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+fallible_uint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+fallible_uint-devel}"
SRC_URI[aarch64_rust-rusqlite+fallible_uint-devel.sha256sum] = "28ce6bab0e62e3d4bd18fa0cc1d36a5f5cdefe6808e3748c45b85cd7f4ced1aa"

URI_aarch64_rust-rusqlite+functions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+functions-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+functions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+functions-devel}"
SRC_URI[aarch64_rust-rusqlite+functions-devel.sha256sum] = "4f7b75b936d2ebbf37b5f6d85c1cf08e1aef1ec0aec0bc81adec532ae084bbbf"

URI_aarch64_rust-rusqlite+hashlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+hashlink-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+hashlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+hashlink-devel}"
SRC_URI[aarch64_rust-rusqlite+hashlink-devel.sha256sum] = "e05ceec87a8a3c3340e5ce5fd4f0ec6757a10ca229f06498e2a35cd1893f2911"

URI_aarch64_rust-rusqlite+hooks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+hooks-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+hooks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+hooks-devel}"
SRC_URI[aarch64_rust-rusqlite+hooks-devel.sha256sum] = "b6e0eed6d3e6b97a4fe808cfe81a94f4680116a96cfa4b3c431d9b8f8173cd56"

URI_aarch64_rust-rusqlite+i128_blob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+i128_blob-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+i128_blob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+i128_blob-devel}"
SRC_URI[aarch64_rust-rusqlite+i128_blob-devel.sha256sum] = "ead18940a53997994dbd3bdd20e5e1cd1c747296cf2b658b84c7964fb6cde495"

URI_aarch64_rust-rusqlite+jiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+jiff-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+jiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+jiff-devel}"
SRC_URI[aarch64_rust-rusqlite+jiff-devel.sha256sum] = "fbfe33b8690f29f07e7ac527279380b7a75d2a471fc2c88bd0321aa3a04772eb"

URI_aarch64_rust-rusqlite+limits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+limits-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+limits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+limits-devel}"
SRC_URI[aarch64_rust-rusqlite+limits-devel.sha256sum] = "7c559ed683c344496b24116d96671d17ac172017cca8a88fbd9cfd60132deeb3"

URI_aarch64_rust-rusqlite+load_extension-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+load_extension-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+load_extension-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+load_extension-devel}"
SRC_URI[aarch64_rust-rusqlite+load_extension-devel.sha256sum] = "da0c8bc8837b966574c9bf980d7fbaa8319f4a98f41d850908f01761fc38729d"

URI_aarch64_rust-rusqlite+modern-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+modern-full-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+modern-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+modern-full-devel}"
SRC_URI[aarch64_rust-rusqlite+modern-full-devel.sha256sum] = "600193a1ad9b635e6772310a86f5501687af150231615a65d184d1898433a138"

URI_aarch64_rust-rusqlite+modern_sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+modern_sqlite-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+modern_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+modern_sqlite-devel}"
SRC_URI[aarch64_rust-rusqlite+modern_sqlite-devel.sha256sum] = "351b192ea912200ccc6d8c7598d35abb8f450cbae530fa78ea646eebfb7781d1"

URI_aarch64_rust-rusqlite+preupdate_hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+preupdate_hook-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+preupdate_hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+preupdate_hook-devel}"
SRC_URI[aarch64_rust-rusqlite+preupdate_hook-devel.sha256sum] = "d2e546709f58dbb5f5e1dceae76bdaeb7f644b1bd31f684667e8744ee788240e"

URI_aarch64_rust-rusqlite+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+serde_json-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+serde_json-devel}"
SRC_URI[aarch64_rust-rusqlite+serde_json-devel.sha256sum] = "3951e55d18fc42bd4c86a09394b114816015276d09161307db9ea810c19f0a54"

URI_aarch64_rust-rusqlite+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+serialize-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+serialize-devel}"
SRC_URI[aarch64_rust-rusqlite+serialize-devel.sha256sum] = "16eaac773d46e216ed3519aecf5564e50cc7758df92ff71e0f420955c34d9edc"

URI_aarch64_rust-rusqlite+series-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+series-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+series-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+series-devel}"
SRC_URI[aarch64_rust-rusqlite+series-devel.sha256sum] = "693037cfc6b1d39d22c958abc77f1589880fb1f3949e97a279e5d8b0fc433332"

URI_aarch64_rust-rusqlite+session-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+session-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+session-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+session-devel}"
SRC_URI[aarch64_rust-rusqlite+session-devel.sha256sum] = "deac81ca52e1e1f854706fb21a855ba4eef08b01f172be90a52e642269ce4757"

URI_aarch64_rust-rusqlite+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+time-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+time-devel}"
SRC_URI[aarch64_rust-rusqlite+time-devel.sha256sum] = "bf7fefbabf55352a376b21cb6638090a67e00fcbe43cc09cd6483af8465fea00"

URI_aarch64_rust-rusqlite+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+trace-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+trace-devel}"
SRC_URI[aarch64_rust-rusqlite+trace-devel.sha256sum] = "4281c1ddd2c121e1fbceeb1e9d52b392e1767cf456179b502019942f9fdc2df2"

URI_aarch64_rust-rusqlite+unlock_notify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+unlock_notify-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+unlock_notify-devel}"
SRC_URI[aarch64_rust-rusqlite+unlock_notify-devel.sha256sum] = "606775f8d47e59b009c1f4cd630c508582c6dbff388f279227809255d6d13b35"

URI_aarch64_rust-rusqlite+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+url-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+url-devel}"
SRC_URI[aarch64_rust-rusqlite+url-devel.sha256sum] = "7e789d2b4f3571c0f47c3330c864d42cb5bb40c951cfb82ded4b6d22c4c4ef33"

URI_aarch64_rust-rusqlite+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+uuid-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+uuid-devel}"
SRC_URI[aarch64_rust-rusqlite+uuid-devel.sha256sum] = "e4314f460538d954222c5d6daef2e7df215348bd86d66774189b4514ca1604a4"

URI_aarch64_rust-rusqlite+vtab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+vtab-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+vtab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+vtab-devel}"
SRC_URI[aarch64_rust-rusqlite+vtab-devel.sha256sum] = "f233b981328c9942156dd9663187117a519509bdb67620849c0004ef9549367c"

URI_aarch64_rust-rusqlite+window-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+window-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite+window-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+window-devel}"
SRC_URI[aarch64_rust-rusqlite+window-devel.sha256sum] = "e8fd3e13954430f9f8470159a13bda972c692ac04c049df99760285eb3a7df4d"

URI_aarch64_rust-rusqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite-devel-0.38.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite-devel}"
SRC_URI[aarch64_rust-rusqlite-devel.sha256sum] = "929943c8d6c8e6ebca4fa9dbcb36ac6bedc4f825826678c0e9771ae56c3df127"

RDEPENDS:rust-rusqlite+array-devel = " \
 cargo \
 rust-rusqlite+vtab-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+backup-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+blob-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+buildtime_bindgen-devel = " \
 cargo \
 rust-libsqlite3-sys+buildtime_bindgen-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+cache-devel = " \
 cargo \
 rust-rusqlite+hashlink-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+collation-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+column_decltype-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+column_metadata-devel = " \
 cargo \
 rust-libsqlite3-sys+column_metadata-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+csv-devel = " \
 cargo \
 rust-csv+default-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+csvtab-devel = " \
 cargo \
 rust-rusqlite+csv-devel \
 rust-rusqlite+vtab-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+default-devel = " \
 cargo \
 rust-rusqlite+cache-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+extra_check-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+fallible_uint-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+functions-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+hashlink-devel = " \
 cargo \
 rust-hashlink+default-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+hooks-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+i128_blob-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+jiff-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+limits-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+load_extension-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+modern-full-devel = " \
 cargo \
 rust-rusqlite+array-devel \
 rust-rusqlite+backup-devel \
 rust-rusqlite+blob-devel \
 rust-rusqlite+chrono-devel \
 rust-rusqlite+collation-devel \
 rust-rusqlite+column_decltype-devel \
 rust-rusqlite+column_metadata-devel \
 rust-rusqlite+csvtab-devel \
 rust-rusqlite+extra_check-devel \
 rust-rusqlite+functions-devel \
 rust-rusqlite+hooks-devel \
 rust-rusqlite+i128_blob-devel \
 rust-rusqlite+jiff-devel \
 rust-rusqlite+limits-devel \
 rust-rusqlite+load_extension-devel \
 rust-rusqlite+modern_sqlite-devel \
 rust-rusqlite+serde_json-devel \
 rust-rusqlite+serialize-devel \
 rust-rusqlite+series-devel \
 rust-rusqlite+time-devel \
 rust-rusqlite+trace-devel \
 rust-rusqlite+unlock_notify-devel \
 rust-rusqlite+url-devel \
 rust-rusqlite+uuid-devel \
 rust-rusqlite+vtab-devel \
 rust-rusqlite+window-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+modern_sqlite-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+preupdate_hook-devel = " \
 cargo \
 rust-libsqlite3-sys+preupdate_hook-devel \
 rust-rusqlite+hooks-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+serde_json-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-rusqlite+serialize-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+series-devel = " \
 cargo \
 rust-rusqlite+vtab-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+session-devel = " \
 cargo \
 rust-libsqlite3-sys+session-devel \
 rust-rusqlite+hooks-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+time-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-rusqlite+trace-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+unlock_notify-devel = " \
 cargo \
 rust-libsqlite3-sys+unlock_notify-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+url-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-url+default-devel \
 "
RDEPENDS:rust-rusqlite+uuid-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-rusqlite+vtab-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+window-devel = " \
 cargo \
 rust-rusqlite+functions-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-fallible-iterator+default-devel \
 rust-fallible-streaming-iterator+default-devel \
 rust-libsqlite3-sys+default-devel \
 rust-smallvec+default-devel \
 "
