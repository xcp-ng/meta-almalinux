# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode_names2_generator"
PV = "1.3.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-unicode_names2_generator+default-devel \
 rust-unicode_names2_generator+time-devel \
 rust-unicode_names2_generator+timing-devel \
 rust-unicode_names2_generator+unstable-devel \
 rust-unicode_names2_generator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode_names2_generator-1.3.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c57aa5d980cac68e971edf387009afc51d5e909e95b74ff11b0cfcbbd588120"

URI_x86_64_v2_rust-unicode_names2_generator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode_names2_generator+default-devel-1.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode_names2_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode_names2_generator+default-devel}"
SRC_URI[x86_64_v2_rust-unicode_names2_generator+default-devel.sha256sum] = "09a9cdd147eb84f09d03d453201574608bde569573a3286c572b1cd9ec4bd3f1"

URI_x86_64_v2_rust-unicode_names2_generator+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode_names2_generator+time-devel-1.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode_names2_generator+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode_names2_generator+time-devel}"
SRC_URI[x86_64_v2_rust-unicode_names2_generator+time-devel.sha256sum] = "cdc6105ac3d76a96bdf846d8585099296d088a7301120e10a1aaa87e51c97c57"

URI_x86_64_v2_rust-unicode_names2_generator+timing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode_names2_generator+timing-devel-1.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode_names2_generator+timing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode_names2_generator+timing-devel}"
SRC_URI[x86_64_v2_rust-unicode_names2_generator+timing-devel.sha256sum] = "bf0850f95f11fa699b3dac29b611776236ebc0a8825e5fbe7afaa025cdd00d60"

URI_x86_64_v2_rust-unicode_names2_generator+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode_names2_generator+unstable-devel-1.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode_names2_generator+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode_names2_generator+unstable-devel}"
SRC_URI[x86_64_v2_rust-unicode_names2_generator+unstable-devel.sha256sum] = "e9754526caf2db2a24c58970abc1707b143b67609bd5d372544ff1afa232a6a1"

URI_x86_64_v2_rust-unicode_names2_generator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode_names2_generator-devel-1.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode_names2_generator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode_names2_generator-devel}"
SRC_URI[x86_64_v2_rust-unicode_names2_generator-devel.sha256sum] = "2b7c2543af1aa2e04fc155744f3d202f359d6fb65ece1f0103928db47f2211ad"

URI_aarch64_rust-unicode_names2_generator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode_names2_generator+default-devel-1.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-unicode_names2_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode_names2_generator+default-devel}"
SRC_URI[aarch64_rust-unicode_names2_generator+default-devel.sha256sum] = "5e96eba94d83b0081e4bf7cf4bed6ae9afd975494e85bd28a35ed5396254e8cc"

URI_aarch64_rust-unicode_names2_generator+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode_names2_generator+time-devel-1.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-unicode_names2_generator+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode_names2_generator+time-devel}"
SRC_URI[aarch64_rust-unicode_names2_generator+time-devel.sha256sum] = "7f3887ebbfc68a8a230f1f80805fcd687101f040c3e5287c58f67526e265c055"

URI_aarch64_rust-unicode_names2_generator+timing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode_names2_generator+timing-devel-1.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-unicode_names2_generator+timing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode_names2_generator+timing-devel}"
SRC_URI[aarch64_rust-unicode_names2_generator+timing-devel.sha256sum] = "8d195fa559157ca6e9bfd8680acceff22f3c2cb0c513d4094bd528c503599c34"

URI_aarch64_rust-unicode_names2_generator+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode_names2_generator+unstable-devel-1.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-unicode_names2_generator+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode_names2_generator+unstable-devel}"
SRC_URI[aarch64_rust-unicode_names2_generator+unstable-devel.sha256sum] = "958507ab2dfa4ae264159ad6d7f73848d935ac19f1ae542660d3fcfd443efd0c"

URI_aarch64_rust-unicode_names2_generator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode_names2_generator-devel-1.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-unicode_names2_generator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode_names2_generator-devel}"
SRC_URI[aarch64_rust-unicode_names2_generator-devel.sha256sum] = "c71044fb4ca6207bbd2e58065be3af36c3ba227599a330a765df35f8b7b9fc3b"

RDEPENDS:rust-unicode_names2_generator+default-devel = " \
 cargo \
 rust-unicode_names2_generator-devel \
 "
RDEPENDS:rust-unicode_names2_generator+time-devel = " \
 cargo \
 rust-time+default-devel \
 rust-unicode_names2_generator-devel \
 "
RDEPENDS:rust-unicode_names2_generator+timing-devel = " \
 cargo \
 rust-unicode_names2_generator+time-devel \
 rust-unicode_names2_generator-devel \
 "
RDEPENDS:rust-unicode_names2_generator+unstable-devel = " \
 cargo \
 rust-unicode_names2_generator-devel \
 "
RDEPENDS:rust-unicode_names2_generator-devel = " \
 cargo \
 rust \
 rust-getopts+default-devel \
 rust-log+default-devel \
 rust-phf_codegen0.11+default-devel \
 rust-rand0.8+default-devel \
 "
