# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-greenlet"
PV = "3.0.3"
PR = "5.el10.alma.1"
PACKAGES = " \
 python3-greenlet \
 python3-greenlet-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-greenlet-3.0.3-5.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9544c1f69a604c77acb718aec4932ecc301ed3deb64de0e5502a7b39bf469651"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-greenlet-3.0.3-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-greenlet;unpack=0"
SRC_URI[x86_64_v2_python3-greenlet.sha256sum] = "7ac222e0871d433138b9277665f19bea387545a2be8e5dbd63e20b198446ffd9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-greenlet-devel-3.0.3-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-greenlet-devel;unpack=0"
SRC_URI[x86_64_v2_python3-greenlet-devel.sha256sum] = "d56ca613b0ecc4e35d224e075233f02a418541eda3ac185aeb694f62dd47e999"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-greenlet-3.0.3-5.el10.alma.1.aarch64.rpm;name=aarch64_python3-greenlet;unpack=0"
SRC_URI[aarch64_python3-greenlet.sha256sum] = "20c71648d4a18b8cfc9d90336be1083bce2819b4b22569d9ff6bd401cfada351"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-greenlet-devel-3.0.3-5.el10.alma.1.aarch64.rpm;name=aarch64_python3-greenlet-devel;unpack=0"
SRC_URI[aarch64_python3-greenlet-devel.sha256sum] = "445f5616702d93cc910d4813c1e8cca14287e351a37f231bd3de2e8a2dd985e6"

RDEPENDS:python3-greenlet = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:python3-greenlet-devel = " \
 python3-greenlet \
 "
