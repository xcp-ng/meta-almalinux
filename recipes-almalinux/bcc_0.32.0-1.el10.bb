# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bcc"
PV = "0.32.0"
PR = "1.el10"
PACKAGES = " \
 bcc \
 bcc-devel \
 bcc-doc \
 bcc-tools \
 libbpf-tools \
 python3-bcc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bcc-0.32.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d87f2bdcbffc7d3bf1bb5cae4c564bb7895e8df91e00f984168a9e6bce3ee045"

URI_x86_64_v2_bcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bcc-0.32.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_bcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcc}"
SRC_URI[x86_64_v2_bcc.sha256sum] = "d8082b523d3aca00e39380c9f7c8fd0bfe45c821c4bb9ea785343718a88eac93"

URI_x86_64_v2_bcc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bcc-devel-0.32.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_bcc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcc-devel}"
SRC_URI[x86_64_v2_bcc-devel.sha256sum] = "a09a5a164ca6cb8baf9b9b470ca1bb85c8a3ec0e39f858397192dc4ccdadbfb4"

URI_x86_64_v2_bcc-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bcc-doc-0.32.0-1.el10.noarch.rpm;name=x86_64_v2_bcc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcc-doc}"
SRC_URI[x86_64_v2_bcc-doc.sha256sum] = "717e63db7f3ad0dfae4b88a02e565ebf7d713089badad7be7150c46381e29aac"

URI_x86_64_v2_bcc-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bcc-tools-0.32.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_bcc-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcc-tools}"
SRC_URI[x86_64_v2_bcc-tools.sha256sum] = "c158e89b04f955b117ed7b0162cfa021d5bd696d7a1baa48df4590bc41faa7df"

URI_x86_64_v2_libbpf-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libbpf-tools-0.32.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libbpf-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbpf-tools}"
SRC_URI[x86_64_v2_libbpf-tools.sha256sum] = "0e7487eebbe938ccb8d39a060fe2704ec0de9ef3c8c23bcfda877aea127de6ec"

URI_x86_64_v2_python3-bcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-bcc-0.32.0-1.el10.noarch.rpm;name=x86_64_v2_python3-bcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bcc}"
SRC_URI[x86_64_v2_python3-bcc.sha256sum] = "f08ad77d4dc1f72841b161aa6241268bf76c8121566907b96023cac6ecd5d092"

URI_aarch64_bcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bcc-0.32.0-1.el10.aarch64.rpm;name=aarch64_bcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcc}"
SRC_URI[aarch64_bcc.sha256sum] = "81beaa4471960dd40e1fc3bda6c950e1c94cbd7060963a57259d58179fac4fe6"

URI_aarch64_bcc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bcc-devel-0.32.0-1.el10.aarch64.rpm;name=aarch64_bcc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcc-devel}"
SRC_URI[aarch64_bcc-devel.sha256sum] = "fe5db278dd34d90187327e2408497e7231971156f0a5384e6a1e3d8b7d87d561"

URI_aarch64_bcc-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bcc-doc-0.32.0-1.el10.noarch.rpm;name=aarch64_bcc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcc-doc}"
SRC_URI[aarch64_bcc-doc.sha256sum] = "717e63db7f3ad0dfae4b88a02e565ebf7d713089badad7be7150c46381e29aac"

URI_aarch64_bcc-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bcc-tools-0.32.0-1.el10.aarch64.rpm;name=aarch64_bcc-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcc-tools}"
SRC_URI[aarch64_bcc-tools.sha256sum] = "f443f0f724dc78c131f8d92e91aed7ab12920d386275a4203a0b7e59985625f2"

URI_aarch64_libbpf-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libbpf-tools-0.32.0-1.el10.aarch64.rpm;name=aarch64_libbpf-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbpf-tools}"
SRC_URI[aarch64_libbpf-tools.sha256sum] = "737e239135b46d649e751a1023443dfdb18e32c33a65f027c5ff98870a99b543"

URI_aarch64_python3-bcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-bcc-0.32.0-1.el10.noarch.rpm;name=aarch64_python3-bcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bcc}"
SRC_URI[aarch64_python3-bcc.sha256sum] = "f08ad77d4dc1f72841b161aa6241268bf76c8121566907b96023cac6ecd5d092"

RDEPENDS:bcc = " \
 clang-libs \
 elfutils-debuginfod-client \
 elfutils-libelf \
 glibc \
 libbpf \
 libgcc \
 libstdc++ \
 llvm-libs \
 tar \
 xz-libs \
 "
RDEPENDS:bcc-devel = " \
 bcc \
 pkgconf-pkg-config \
 "
RDEPENDS:bcc-doc = " \
 "
RDEPENDS:bcc-tools = " \
 bash \
 bcc \
 glibc \
 libbpf \
 python3 \
 python3-bcc \
 python3-netaddr \
 "
RDEPENDS:libbpf-tools = " \
 elfutils-libelf \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:python3-bcc = " \
 bcc \
 python3 \
 "
