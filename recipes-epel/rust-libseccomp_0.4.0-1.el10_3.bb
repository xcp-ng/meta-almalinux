# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libseccomp"
PV = "0.4.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-libseccomp+cfg-if-devel \
 rust-libseccomp+const-syscall-devel \
 rust-libseccomp+default-devel \
 rust-libseccomp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libseccomp-0.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf1d4f47ebde4af06ab2c2cc7ca19aed247d382fe594f24dd2a443cca168111c"

URI_x86_64_v2_rust-libseccomp+cfg-if-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libseccomp+cfg-if-devel-0.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libseccomp+cfg-if-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libseccomp+cfg-if-devel}"
SRC_URI[x86_64_v2_rust-libseccomp+cfg-if-devel.sha256sum] = "369d4016695ce1e6001bec7bfc3ae35ca094f16a426e14eac51e215ccfd9f474"

URI_x86_64_v2_rust-libseccomp+const-syscall-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libseccomp+const-syscall-devel-0.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libseccomp+const-syscall-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libseccomp+const-syscall-devel}"
SRC_URI[x86_64_v2_rust-libseccomp+const-syscall-devel.sha256sum] = "c0f502d936b967e2ef0bcb17bb41f957f4adea4dbcd3096cbcc32970d9db7af0"

URI_x86_64_v2_rust-libseccomp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libseccomp+default-devel-0.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libseccomp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libseccomp+default-devel}"
SRC_URI[x86_64_v2_rust-libseccomp+default-devel.sha256sum] = "6721c97ada9514fe4f58a0e7849ebf54a40c24cb412410b1e93e0b7f0c7e18c9"

URI_x86_64_v2_rust-libseccomp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libseccomp-devel-0.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libseccomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libseccomp-devel}"
SRC_URI[x86_64_v2_rust-libseccomp-devel.sha256sum] = "ea67266ad062d9ca6f9aefe6b051cc668d13ed0f05b1b49498b426c1f807f372"

URI_aarch64_rust-libseccomp+cfg-if-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libseccomp+cfg-if-devel-0.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-libseccomp+cfg-if-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libseccomp+cfg-if-devel}"
SRC_URI[aarch64_rust-libseccomp+cfg-if-devel.sha256sum] = "e9f6ff673a6645636599d2d96ce09c9177756a45467207865cc3a3b45b820f52"

URI_aarch64_rust-libseccomp+const-syscall-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libseccomp+const-syscall-devel-0.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-libseccomp+const-syscall-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libseccomp+const-syscall-devel}"
SRC_URI[aarch64_rust-libseccomp+const-syscall-devel.sha256sum] = "8c1a17abcf693a85f629ebeff8ec974f44851618153ffdc6e19fe77a5aef0aea"

URI_aarch64_rust-libseccomp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libseccomp+default-devel-0.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-libseccomp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libseccomp+default-devel}"
SRC_URI[aarch64_rust-libseccomp+default-devel.sha256sum] = "36239af207bb7aeee73573f1c241b80402b3091a46bb37b80b4bfc5bd4b95c50"

URI_aarch64_rust-libseccomp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libseccomp-devel-0.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-libseccomp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libseccomp-devel}"
SRC_URI[aarch64_rust-libseccomp-devel.sha256sum] = "c3c94efe2565a67fba721e8bf4f3387402a980cd5f53ff805f28d9333bd9dba9"

RDEPENDS:rust-libseccomp+cfg-if-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-libseccomp-devel \
 "
RDEPENDS:rust-libseccomp+const-syscall-devel = " \
 cargo \
 rust-libseccomp+cfg-if-devel \
 rust-libseccomp-devel \
 "
RDEPENDS:rust-libseccomp+default-devel = " \
 cargo \
 rust-libseccomp-devel \
 "
RDEPENDS:rust-libseccomp-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-libc+default-devel \
 rust-libseccomp-sys+default-devel \
 rust-pkg-config+default-devel \
 "
