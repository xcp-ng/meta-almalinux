# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwordquiz"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kwordquiz \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kwordquiz-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9a7b97a043ab2f1004dad903625d83ee88f97a5521b7f74f98fbe4ca9bf829b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwordquiz-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwordquiz;unpack=0"
SRC_URI[x86_64_v2_kwordquiz.sha256sum] = "4ad521ed0742bd2370fabd6804575beb014f56b7cb1cb4ad9916b13504d3651f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kwordquiz-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kwordquiz;unpack=0"
SRC_URI[aarch64_kwordquiz.sha256sum] = "21ddd8e780e0321f78e6455dd6272b17c30e8c0ea42ff12821c110a69c633cdc"

RDEPENDS:kwordquiz = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knewstuff \
 libkeduvocdocument \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
