# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clock-steering"
PV = "0.2.1"
PR = "3.el10_2"
PACKAGES = " \
 rust-clock-steering+default-devel \
 rust-clock-steering-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clock-steering-0.2.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98a61789796e1834e1aa7b7860408caba497cf4ff13b2cb441b9c2673c158d1c"

URI_x86_64_v2_rust-clock-steering+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clock-steering+default-devel-0.2.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clock-steering+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clock-steering+default-devel}"
SRC_URI[x86_64_v2_rust-clock-steering+default-devel.sha256sum] = "034aa3d43d404875549e88c091e5a34bf4d3418619f62f17155099f0a19a3e84"

URI_x86_64_v2_rust-clock-steering-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clock-steering-devel-0.2.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clock-steering-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clock-steering-devel}"
SRC_URI[x86_64_v2_rust-clock-steering-devel.sha256sum] = "cbfd92e40ebb31a6398be58782f7e40b727cee020bd99f6d38df967506041e44"

URI_aarch64_rust-clock-steering+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clock-steering+default-devel-0.2.1-3.el10_2.noarch.rpm;name=aarch64_rust-clock-steering+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clock-steering+default-devel}"
SRC_URI[aarch64_rust-clock-steering+default-devel.sha256sum] = "7d46be9c660f0dd59ae3311a05dde458bff05c150474af2f7862c3701f1109f4"

URI_aarch64_rust-clock-steering-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clock-steering-devel-0.2.1-3.el10_2.noarch.rpm;name=aarch64_rust-clock-steering-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clock-steering-devel}"
SRC_URI[aarch64_rust-clock-steering-devel.sha256sum] = "55637c55590f6eedba6de00f678b095304243914b37c8871039fad7968b41901"

RDEPENDS:rust-clock-steering+default-devel = " \
 cargo \
 rust-clock-steering-devel \
 "
RDEPENDS:rust-clock-steering-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
