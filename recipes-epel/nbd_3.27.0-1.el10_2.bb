# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nbd"
PV = "3.27.0"
PR = "1.el10_2"
PACKAGES = " \
 nbd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nbd-3.27.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de68449392f52e465c2c95ab78136de249c8e4498ca49d7186a682c3a71ea321"

URI_x86_64_v2_nbd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nbd-3.27.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbd}"
SRC_URI[x86_64_v2_nbd.sha256sum] = "b4a82696fc2076f47e24aabbd7ce69ba858857f3aa57c09922ddffb3c0de6c29"

URI_aarch64_nbd = "${EPEL_MIRROR}/aarch64/Packages/n/nbd-3.27.0-1.el10_2.aarch64.rpm;name=aarch64_nbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbd}"
SRC_URI[aarch64_nbd.sha256sum] = "71b3174185946b36d366d5bf5a843933801b377ac2bcb1a65899c3601a3d9599"

RDEPENDS:nbd = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 libnl3 \
 systemd \
 "
