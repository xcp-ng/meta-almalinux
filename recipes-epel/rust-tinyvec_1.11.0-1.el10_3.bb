# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tinyvec"
PV = "1.11.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+arbitrary-devel \
 rust-tinyvec+default-devel \
 rust-tinyvec+experimental_write_impl-devel \
 rust-tinyvec+grab_spare_slice-devel \
 rust-tinyvec+nightly_slice_partition_dedup-devel \
 rust-tinyvec+rustc_1_40-devel \
 rust-tinyvec+rustc_1_55-devel \
 rust-tinyvec+rustc_1_57-devel \
 rust-tinyvec+rustc_1_61-devel \
 rust-tinyvec+serde-devel \
 rust-tinyvec+std-devel \
 rust-tinyvec+tinyvec_macros-devel \
 rust-tinyvec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tinyvec-1.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27ea81d59d31df40356b8d5e0a25e24a55f0d339bd3b39bf16efaab892052c9d"

URI_x86_64_v2_rust-tinyvec+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+alloc-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+alloc-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+alloc-devel.sha256sum] = "137457477a6a67006b9c1c65d6f5d9043f28c0cf6a7246a4995a254ab0ae4cbb"

URI_x86_64_v2_rust-tinyvec+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+arbitrary-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+arbitrary-devel.sha256sum] = "cca0429a35391478aff9ce48dcb35787c2b7603db24689c377bfe7a514841d2b"

URI_x86_64_v2_rust-tinyvec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+default-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+default-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+default-devel.sha256sum] = "185cfdd559694bd87da8c88b5f5bedcccac1fd51be7fbb92f12feaf33d40b12e"

URI_x86_64_v2_rust-tinyvec+experimental_write_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+experimental_write_impl-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+experimental_write_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+experimental_write_impl-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+experimental_write_impl-devel.sha256sum] = "8341469d6e11b619f98654df52594b0857f58c44c17d82f973671016a4f75a5b"

URI_x86_64_v2_rust-tinyvec+grab_spare_slice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+grab_spare_slice-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+grab_spare_slice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+grab_spare_slice-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+grab_spare_slice-devel.sha256sum] = "4931016dfeda09009985695b79e07bb7a60f47ca12e21eac1acadff0287c6de2"

URI_x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+nightly_slice_partition_dedup-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel.sha256sum] = "7d2989be09ec9507e6e695f445de69486a77df2d0be50a5a48229e4a32d3a0ad"

URI_x86_64_v2_rust-tinyvec+rustc_1_40-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_40-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_40-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_40-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_40-devel.sha256sum] = "ea1ca27c794fb508adc265504e1e861b88633d463bdc16528c98d716ddd801c3"

URI_x86_64_v2_rust-tinyvec+rustc_1_55-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_55-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_55-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_55-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_55-devel.sha256sum] = "c1eebce11aaf0e618abb177363a0fedc69d05b5c4bdc5ef63d4e40e11a8d38b1"

URI_x86_64_v2_rust-tinyvec+rustc_1_57-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_57-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_57-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_57-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_57-devel.sha256sum] = "41cf4460b5b34eb28af8e2319dbe955b5072cddbfcfb6b35cbf26244f52d7bf6"

URI_x86_64_v2_rust-tinyvec+rustc_1_61-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_61-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_61-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_61-devel.sha256sum] = "28ebc27da702278c57667e2da3dcf3c390283e73abe17786f05e495e54490585"

URI_x86_64_v2_rust-tinyvec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+serde-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+serde-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+serde-devel.sha256sum] = "f64bd3a9f9e869551defb3b3a6ef780262ba141cbb394021ee0fbd2fcea77c01"

URI_x86_64_v2_rust-tinyvec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+std-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+std-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+std-devel.sha256sum] = "3823a6e3920e9f28373fede0f1ea82bd010ba1b107cac6e01387042a03db1365"

URI_x86_64_v2_rust-tinyvec+tinyvec_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+tinyvec_macros-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+tinyvec_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+tinyvec_macros-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+tinyvec_macros-devel.sha256sum] = "f7d9555cfdc9acd39340d7a25814bd4dbe50894f2beaec83837b1fca81d7f7ef"

URI_x86_64_v2_rust-tinyvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec-devel}"
SRC_URI[x86_64_v2_rust-tinyvec-devel.sha256sum] = "47239e48931d21367ea3fc7a54e6717c6886a191fcc35ecaef6d298bb6afaed0"

URI_aarch64_rust-tinyvec+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+alloc-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-tinyvec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+alloc-devel}"
SRC_URI[aarch64_rust-tinyvec+alloc-devel.sha256sum] = "ec92e72886f72b3edcdb658eb94d4a581198bd03fca3719e8a5f624dc7c7c002"

URI_aarch64_rust-tinyvec+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+arbitrary-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-tinyvec+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+arbitrary-devel}"
SRC_URI[aarch64_rust-tinyvec+arbitrary-devel.sha256sum] = "a3a23b0669f77389e45bd0014d64861dd648f62fc749f2683e813119ce2f81ed"

URI_aarch64_rust-tinyvec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+default-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-tinyvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+default-devel}"
SRC_URI[aarch64_rust-tinyvec+default-devel.sha256sum] = "b2fd0edd667aa63f55c3a10002aaf6749691d2adfd5ac5e583c4aaea5f0cb3c3"

URI_aarch64_rust-tinyvec+experimental_write_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+experimental_write_impl-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-tinyvec+experimental_write_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+experimental_write_impl-devel}"
SRC_URI[aarch64_rust-tinyvec+experimental_write_impl-devel.sha256sum] = "765d7e84b3c563efac577e02af1907aa4c24707cf2c82f4b98bdec989aef6f44"

URI_aarch64_rust-tinyvec+grab_spare_slice-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+grab_spare_slice-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-tinyvec+grab_spare_slice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+grab_spare_slice-devel}"
SRC_URI[aarch64_rust-tinyvec+grab_spare_slice-devel.sha256sum] = "8491d575d818adbfa5f4db79f652083b2822ad39573465c01fef7b2fac44bcb5"

URI_aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+nightly_slice_partition_dedup-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel}"
SRC_URI[aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel.sha256sum] = "ba757d131788ee178eb13d6c6541a45b57719cfcf7b6160741c7cb8450a9347c"

URI_aarch64_rust-tinyvec+rustc_1_40-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_40-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_40-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_40-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_40-devel.sha256sum] = "be9953a5b1a6862faff3b2cb5dde1024e0cc4bb6b3a619cec1cba3a6726968ac"

URI_aarch64_rust-tinyvec+rustc_1_55-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_55-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_55-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_55-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_55-devel.sha256sum] = "60cac71d161b3575084a6698a6f8e16ee9b7a6b36445d71f5589ffdbac05f3ac"

URI_aarch64_rust-tinyvec+rustc_1_57-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_57-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_57-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_57-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_57-devel.sha256sum] = "fadcccc4b1a82985bd91a039d0e7ce562fb58dac62d657a7aabf6430a0269a0c"

URI_aarch64_rust-tinyvec+rustc_1_61-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_61-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_61-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_61-devel.sha256sum] = "0d592e94b217eb934b4b1812a0ad496572a824e83fad0c50bb79a205de6aa69e"

URI_aarch64_rust-tinyvec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+serde-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-tinyvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+serde-devel}"
SRC_URI[aarch64_rust-tinyvec+serde-devel.sha256sum] = "abd293f88299fcd8a608df8c5842747a18c67db6f5cf6b8d77ea7763aa71f595"

URI_aarch64_rust-tinyvec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+std-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-tinyvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+std-devel}"
SRC_URI[aarch64_rust-tinyvec+std-devel.sha256sum] = "bdbd4a259221424e28f8ce37ea5a9a801dbd053d5c45238f403bd5f4c114b017"

URI_aarch64_rust-tinyvec+tinyvec_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+tinyvec_macros-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-tinyvec+tinyvec_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+tinyvec_macros-devel}"
SRC_URI[aarch64_rust-tinyvec+tinyvec_macros-devel.sha256sum] = "99e8da418ee49a969a57377d6afe76ee46ee99184ab366fdc3b003bedebe249d"

URI_aarch64_rust-tinyvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-tinyvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec-devel}"
SRC_URI[aarch64_rust-tinyvec-devel.sha256sum] = "df24d6ec57a16be06a50b38f521f9c1ba9a811d1b2fa5c7a594944497999ddea"

RDEPENDS:rust-tinyvec+alloc-devel = " \
 cargo \
 rust-tinyvec+tinyvec_macros-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+default-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+experimental_write_impl-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+grab_spare_slice-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+nightly_slice_partition_dedup-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_40-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_55-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_57-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_61-devel = " \
 cargo \
 rust-tinyvec+rustc_1_57-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+std-devel = " \
 cargo \
 rust-tinyvec+alloc-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+tinyvec_macros-devel = " \
 cargo \
 rust-tinyvec-devel \
 rust-tinyvec_macros+default-devel \
 "
RDEPENDS:rust-tinyvec-devel = " \
 cargo \
 "
