# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kaccounts-integration"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kaccounts-integration-qt6 \
 kaccounts-integration-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kaccounts-integration-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f02468ec67d0f7d4dc3ea0d14556b544d52c147bed13d9f95331b73bbbab10f"

URI_x86_64_v2_kaccounts-integration-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaccounts-integration-qt6-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaccounts-integration-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaccounts-integration-qt6}"
SRC_URI[x86_64_v2_kaccounts-integration-qt6.sha256sum] = "37072e5cad8b3645cd5428e00e06016b63e811faff9c279998a39a377ec0bab2"

URI_x86_64_v2_kaccounts-integration-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaccounts-integration-qt6-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaccounts-integration-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaccounts-integration-qt6-devel}"
SRC_URI[x86_64_v2_kaccounts-integration-qt6-devel.sha256sum] = "d11e9ec2d1d26fb214ed2e1b3aa839f3be2a9decf7e82e416aeb859ee478e1ed"

URI_aarch64_kaccounts-integration-qt6 = "${EPEL_MIRROR}/aarch64/Packages/k/kaccounts-integration-qt6-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kaccounts-integration-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaccounts-integration-qt6}"
SRC_URI[aarch64_kaccounts-integration-qt6.sha256sum] = "b8b95b64ebcfa7b20701321f7bae70aa3cb4ac66bcf23bac8341c36bfae8f1ac"

URI_aarch64_kaccounts-integration-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kaccounts-integration-qt6-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kaccounts-integration-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaccounts-integration-qt6-devel}"
SRC_URI[aarch64_kaccounts-integration-qt6-devel.sha256sum] = "e71c539896affff61b07e5ed44e592eb6a441eb4af1c835c1e177197c0f65746"

RDEPENDS:kaccounts-integration-qt6 = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwallet-libs \
 libaccounts-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 signon-qt6 \
 "
RDEPENDS:kaccounts-integration-qt6-devel = " \
 cmake-filesystem \
 intltool \
 kaccounts-integration-qt6 \
 kf6-kcoreaddons-devel \
 libaccounts-glib-devel \
 libaccounts-qt6-devel \
 qt6-qtbase-devel \
 signon-qt6-devel \
 "
