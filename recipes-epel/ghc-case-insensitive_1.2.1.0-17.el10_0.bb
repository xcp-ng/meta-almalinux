# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-case-insensitive"
PV = "1.2.1.0"
PR = "17.el10_0"
PACKAGES = " \
 ghc-case-insensitive \
 ghc-case-insensitive-devel \
 ghc-case-insensitive-doc \
 ghc-case-insensitive-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-case-insensitive-1.2.1.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64d2d2937c8a9457433dcfdeab992f9c356048387607e09314b0fc91ef7c26f3"

URI_x86_64_v2_ghc-case-insensitive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-case-insensitive-1.2.1.0-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-case-insensitive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-case-insensitive}"
SRC_URI[x86_64_v2_ghc-case-insensitive.sha256sum] = "421628a0e969da9bbf68be46c20e1d80be045529ac9d022b73ee9a801d520ce5"

URI_x86_64_v2_ghc-case-insensitive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-case-insensitive-devel-1.2.1.0-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-case-insensitive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-case-insensitive-devel}"
SRC_URI[x86_64_v2_ghc-case-insensitive-devel.sha256sum] = "c34e31d9ae18bb5dc6f11f4ba7d4fd75ebbc6123f67c26b0a53c79cb3e826449"

URI_x86_64_v2_ghc-case-insensitive-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-case-insensitive-doc-1.2.1.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-case-insensitive-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-case-insensitive-doc}"
SRC_URI[x86_64_v2_ghc-case-insensitive-doc.sha256sum] = "1fef791fb00e37a7a316ea5ca42d79926b4a82527270d36c0b78cb5a25f9e5c0"

URI_x86_64_v2_ghc-case-insensitive-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-case-insensitive-prof-1.2.1.0-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-case-insensitive-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-case-insensitive-prof}"
SRC_URI[x86_64_v2_ghc-case-insensitive-prof.sha256sum] = "5316803fb5c88e4d940b8e8568f2660ace73ec6a78ef6df964b0776bd3f9b7f1"

URI_aarch64_ghc-case-insensitive = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-case-insensitive-1.2.1.0-17.el10_0.aarch64.rpm;name=aarch64_ghc-case-insensitive;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-case-insensitive}"
SRC_URI[aarch64_ghc-case-insensitive.sha256sum] = "b0a7501366ada24348795ba855bae7b09b034010c4364095357beb54e15cc6c7"

URI_aarch64_ghc-case-insensitive-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-case-insensitive-devel-1.2.1.0-17.el10_0.aarch64.rpm;name=aarch64_ghc-case-insensitive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-case-insensitive-devel}"
SRC_URI[aarch64_ghc-case-insensitive-devel.sha256sum] = "2272e36207710a90ceff87b996fd49703d928d333e9f15c2e15964127576a0ff"

URI_aarch64_ghc-case-insensitive-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-case-insensitive-doc-1.2.1.0-17.el10_0.noarch.rpm;name=aarch64_ghc-case-insensitive-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-case-insensitive-doc}"
SRC_URI[aarch64_ghc-case-insensitive-doc.sha256sum] = "a0936136da61ee2dd29659dd19f62dbd96d0412502a7b01747798de31abf7012"

URI_aarch64_ghc-case-insensitive-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-case-insensitive-prof-1.2.1.0-17.el10_0.aarch64.rpm;name=aarch64_ghc-case-insensitive-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-case-insensitive-prof}"
SRC_URI[aarch64_ghc-case-insensitive-prof.sha256sum] = "320de3dfd4273d089a54566804f19cc850ace1538f3b30b2446cc6f77e7acab1"

RDEPENDS:ghc-case-insensitive = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-case-insensitive-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-hashable-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-case-insensitive-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-case-insensitive-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-devel \
 ghc-deepseq-prof \
 ghc-hashable-prof \
 ghc-text-prof \
 "
