# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grass"
PV = "8.4.1"
PR = "1.el10_1"
PACKAGES = " \
 grass \
 grass-devel \
 grass-gui \
 grass-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grass-8.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "319dc2f3f45c11caa85f7ba3bb9b91bdb31f153e52e3c2bcef5fca0ce864d068"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - grass-libs: libgeos_c.so.1()(64bit)
# - grass: geos
# - grass: libgeos_c.so.1()(64bit)

URI_x86_64_v2_grass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grass-8.4.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grass}"
SRC_URI[x86_64_v2_grass.sha256sum] = "84078fd3ca63ec57e4148e7b304e6480b7725113f93fbfefd03cc1e84a618a46"

URI_x86_64_v2_grass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grass-devel-8.4.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grass-devel}"
SRC_URI[x86_64_v2_grass-devel.sha256sum] = "c6f426018c98d091047229be65b7db63b029a59a7efeb3eddd9e6f6f961bb001"

URI_x86_64_v2_grass-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grass-gui-8.4.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grass-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grass-gui}"
SRC_URI[x86_64_v2_grass-gui.sha256sum] = "21f3db935749dc7a2e61103fe50969d41363dbfbb73611e5ce75276c4efb331e"

URI_x86_64_v2_grass-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grass-libs-8.4.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grass-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grass-libs}"
SRC_URI[x86_64_v2_grass-libs.sha256sum] = "e67da68a0bf3171654acb7f32adf6d7da8a04f096cc31436343543cebeb97e96"

URI_aarch64_grass = "${EPEL_MIRROR}/aarch64/Packages/g/grass-8.4.1-1.el10_1.aarch64.rpm;name=aarch64_grass;unpack=0"
SRC_URI:append = " ${URI_aarch64_grass}"
SRC_URI[aarch64_grass.sha256sum] = "9c32399191a533ab72a90d8525e9f668986e331217f76a663e43bdc717f43100"

URI_aarch64_grass-devel = "${EPEL_MIRROR}/aarch64/Packages/g/grass-devel-8.4.1-1.el10_1.aarch64.rpm;name=aarch64_grass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_grass-devel}"
SRC_URI[aarch64_grass-devel.sha256sum] = "563b891b6df79e0432f997a30c29158f2e30c690c2e62cd81ee21cc9a949f814"

URI_aarch64_grass-gui = "${EPEL_MIRROR}/aarch64/Packages/g/grass-gui-8.4.1-1.el10_1.aarch64.rpm;name=aarch64_grass-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_grass-gui}"
SRC_URI[aarch64_grass-gui.sha256sum] = "1c51a59dbe4273f2cb562967b2d45606bfa30e94012ac7250232e48f7d176da3"

URI_aarch64_grass-libs = "${EPEL_MIRROR}/aarch64/Packages/g/grass-libs-8.4.1-1.el10_1.aarch64.rpm;name=aarch64_grass-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_grass-libs}"
SRC_URI[aarch64_grass-libs.sha256sum] = "631b96ddede092afbc4406641ec092fd7aea3fc519e7184c2c841da5033707f6"

RDEPENDS:grass:x86_64_v2 = " \
 PDAL \
 PDAL-libs \
 bzip2-libs \
 cairo \
 freetype \
 gdal-libs \
 glibc \
 grass-libs \
 libX11 \
 libgcc \
 libgomp \
 libpng \
 libpq \
 libstdc++ \
 libzstd \
 netcdf \
 proj \
 python3 \
 python3-dateutil \
 python3-numpy \
 python3-wxpython4 \
 readline \
"
RDEPENDS:grass:aarch64 = " \
 PDAL \
 PDAL-libs \
 bzip2-libs \
 cairo \
 freetype \
 gdal-libs \
 geos \
 glibc \
 grass-libs \
 libX11 \
 libgcc \
 libgomp \
 libpng \
 libpq \
 libstdc++ \
 libzstd \
 netcdf \
 proj \
 python3 \
 python3-dateutil \
 python3-numpy \
 python3-wxpython4 \
 readline \
"
RDEPENDS:grass-devel = " \
 grass-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:grass-gui = " \
 grass \
 python3 \
 "
RDEPENDS:grass-libs:x86_64_v2 = " \
 bzip2-libs \
 cairo \
 fftw-libs-double \
 flexiblas-netlib \
 fontconfig \
 freetype \
 gdal-libs \
 glibc \
 libX11 \
 libgcc \
 libglvnd-glx \
 libgomp \
 libpng \
 libpq \
 libstdc++ \
 libtiff \
 libzstd \
 mesa-libGLU \
 proj \
 sqlite-libs \
 unixODBC \
 zlib-ng-compat \
"
RDEPENDS:grass-libs:aarch64 = " \
 bzip2-libs \
 cairo \
 fftw-libs-double \
 flexiblas-netlib \
 fontconfig \
 freetype \
 gdal-libs \
 geos \
 glibc \
 libX11 \
 libgcc \
 libglvnd-glx \
 libgomp \
 libpng \
 libpq \
 libstdc++ \
 libtiff \
 libzstd \
 mesa-libGLU \
 proj \
 sqlite-libs \
 unixODBC \
 zlib-ng-compat \
"
