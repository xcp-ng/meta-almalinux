# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zmap"
PV = "4.3.4"
PR = "1.el10_1"
PACKAGES = " \
 zmap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zmap-4.3.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7749ca1390df571d91b419b11e1dd8d9f881c6ae5d54926accc6f5934cd0918d"

URI_x86_64_v2_zmap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zmap-4.3.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zmap}"
SRC_URI[x86_64_v2_zmap.sha256sum] = "dea898b6373cbadafa09c08d97ade402ef0156b8f83d04ae6981b1d5e1792f48"

URI_aarch64_zmap = "${EPEL_MIRROR}/aarch64/Packages/z/zmap-4.3.4-1.el10_1.aarch64.rpm;name=aarch64_zmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_zmap}"
SRC_URI[aarch64_zmap.sha256sum] = "a89b9e320cecb0030a92264020ebf8f01ce4c9bbab9a1a381803ebe0a14f122b"

RDEPENDS:zmap = " \
 Judy \
 glibc \
 gmp \
 json-c \
 libpcap \
 libunistring \
 "
