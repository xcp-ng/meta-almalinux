# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-pathspec"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-pathspec+default-devel \
 rust-gix-pathspec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-pathspec-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "301686ffcaf66320ab1b2a557920dc1e3e7e765acbe7aaa3d9a6923691f93a3c"

URI_x86_64_v2_rust-gix-pathspec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pathspec+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pathspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pathspec+default-devel}"
SRC_URI[x86_64_v2_rust-gix-pathspec+default-devel.sha256sum] = "c1d5e1e18963455b690a10c477aec3ed9d4e0c7734db9ba25c3c388c06bb7b43"

URI_x86_64_v2_rust-gix-pathspec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pathspec-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pathspec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pathspec-devel}"
SRC_URI[x86_64_v2_rust-gix-pathspec-devel.sha256sum] = "a3d1f279045ed93fbf00e5ebcd1cbf993d5dba1fdf51035bd8ed1655f2663aec"

URI_aarch64_rust-gix-pathspec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pathspec+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-pathspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pathspec+default-devel}"
SRC_URI[aarch64_rust-gix-pathspec+default-devel.sha256sum] = "3497493fb018bc5381ae25c7e2c415e5505530f82a05020cea82fcb1eebc1c87"

URI_aarch64_rust-gix-pathspec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pathspec-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-pathspec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pathspec-devel}"
SRC_URI[aarch64_rust-gix-pathspec-devel.sha256sum] = "1c85d3ff46607b710d9db9248d008ddc1c99a3cedf8fa957f74454fcb24c34c5"

RDEPENDS:rust-gix-pathspec+default-devel = " \
 cargo \
 rust-gix-pathspec-devel \
 "
RDEPENDS:rust-gix-pathspec-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-attributes+default-devel \
 rust-gix-config-value+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-thiserror+default-devel \
 "
