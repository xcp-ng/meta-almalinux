# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-fvbommel-sortorder"
PV = "1.1.0"
PR = "7.el10_0"
PACKAGES = " \
 golang-github-fvbommel-sortorder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-fvbommel-sortorder-1.1.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9720c4f3d8dd7d1b9a403a503e89da93047fbd4c267b43ac1fada0d6edc0c44"

URI_x86_64_v2_golang-github-fvbommel-sortorder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-fvbommel-sortorder-devel-1.1.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-fvbommel-sortorder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-fvbommel-sortorder-devel}"
SRC_URI[x86_64_v2_golang-github-fvbommel-sortorder-devel.sha256sum] = "eed2b539feb6b2f56c9a7e00948099d27aa3bd7f52b97bb700c4f4881836a11a"

URI_aarch64_golang-github-fvbommel-sortorder-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-fvbommel-sortorder-devel-1.1.0-7.el10_0.noarch.rpm;name=aarch64_golang-github-fvbommel-sortorder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-fvbommel-sortorder-devel}"
SRC_URI[aarch64_golang-github-fvbommel-sortorder-devel.sha256sum] = "f6cc6eaffe6dd0f5b96147c020f9ea7c2de69f77e3549227f3a75c76388810db"

RDEPENDS:golang-github-fvbommel-sortorder-devel = " \
 go-filesystem \
 "
