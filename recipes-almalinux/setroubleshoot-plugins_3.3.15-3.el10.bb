# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setroubleshoot-plugins"
PV = "3.3.15"
PR = "3.el10"
PACKAGES = " \
 setroubleshoot-plugins \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/setroubleshoot-plugins-3.3.15-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "beee02d6aa12e911e0b2d84c58aed8e25427204674c8077f4f90e4da3dc2ba36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setroubleshoot-plugins-3.3.15-3.el10.noarch.rpm;name=x86_64_v2_setroubleshoot-plugins;unpack=0"
SRC_URI[x86_64_v2_setroubleshoot-plugins.sha256sum] = "4b127b8c2fd92e715a79dd06369974299cd7ad37f1cdde7024209ac80fcb15bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setroubleshoot-plugins-3.3.15-3.el10.noarch.rpm;name=aarch64_setroubleshoot-plugins;unpack=0"
SRC_URI[aarch64_setroubleshoot-plugins.sha256sum] = "4b127b8c2fd92e715a79dd06369974299cd7ad37f1cdde7024209ac80fcb15bc"

RDEPENDS:setroubleshoot-plugins = " \
 "
