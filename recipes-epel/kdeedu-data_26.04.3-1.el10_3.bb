# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdeedu-data"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdeedu-data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdeedu-data-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f6a11277b0dde2857958f0d509b3be21c0a0f6816b359dcca2cad829e59ef03"

URI_x86_64_v2_kdeedu-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeedu-data-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kdeedu-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdeedu-data}"
SRC_URI[x86_64_v2_kdeedu-data.sha256sum] = "5aaa59dc99ab5a1a566872859ee932e97c702b92e2cc4481d2c65ce376c59a81"

URI_aarch64_kdeedu-data = "${EPEL_MIRROR}/aarch64/Packages/k/kdeedu-data-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kdeedu-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdeedu-data}"
SRC_URI[aarch64_kdeedu-data.sha256sum] = "76ff820d024e334ae0d18d0162f269e00c6dbcf640ad6b5277d97563fa36945f"

RDEPENDS:kdeedu-data = " \
 hicolor-icon-theme \
 "
