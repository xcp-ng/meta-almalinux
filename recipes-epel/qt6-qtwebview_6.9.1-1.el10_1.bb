# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwebview"
PV = "6.9.1"
PR = "1.el10_1"
PACKAGES = " \
 qt6-qtwebview \
 qt6-qtwebview-devel \
 qt6-qtwebview-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtwebview-6.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba647097b9cad5e362aa1e32931ee337715b62cd17a879ed516573eefce93567"

URI_x86_64_v2_qt6-qtwebview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebview-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebview}"
SRC_URI[x86_64_v2_qt6-qtwebview.sha256sum] = "eea983d41176cdeed0c4a840bdccd4208327c666965c182dee45e31fce822924"

URI_x86_64_v2_qt6-qtwebview-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebview-devel-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebview-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebview-devel}"
SRC_URI[x86_64_v2_qt6-qtwebview-devel.sha256sum] = "d510e500e3cb73615ae51b01803797f3f4f972e5066c3c7d799b506e218b5069"

URI_x86_64_v2_qt6-qtwebview-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebview-examples-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebview-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebview-examples}"
SRC_URI[x86_64_v2_qt6-qtwebview-examples.sha256sum] = "f3d2663fbe894de222d58e3f82e87bb393868e497d65b72f5af0fe574624cfe7"

URI_aarch64_qt6-qtwebview = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebview-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtwebview;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebview}"
SRC_URI[aarch64_qt6-qtwebview.sha256sum] = "379f2098b908020ea04cbd5dd36b0ffca5bcfdb8255106e183ac1888ac0605a1"

URI_aarch64_qt6-qtwebview-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebview-devel-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtwebview-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebview-devel}"
SRC_URI[aarch64_qt6-qtwebview-devel.sha256sum] = "d34eee4ec2eada59bd8341888fc4c8c87f1109ae82a2eed7f44feeef355a31aa"

URI_aarch64_qt6-qtwebview-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebview-examples-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtwebview-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebview-examples}"
SRC_URI[aarch64_qt6-qtwebview-examples.sha256sum] = "8a564fc060d8a6f392725c7f4cba6cdcc8b95e2e65078a00b4101d0f13002255"

RDEPENDS:qt6-qtwebview = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 "
RDEPENDS:qt6-qtwebview-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtwebview \
 "
RDEPENDS:qt6-qtwebview-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebview \
 "
