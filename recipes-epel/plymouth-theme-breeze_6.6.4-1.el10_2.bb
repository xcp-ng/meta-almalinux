# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plymouth-theme-breeze"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plymouth-theme-breeze \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plymouth-theme-breeze-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "137d1be9348b76bc86867a28eaf9e1caa4dec74682fe070bb211f206fc63cf97"

URI_x86_64_v2_plymouth-theme-breeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plymouth-theme-breeze-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-breeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-breeze}"
SRC_URI[x86_64_v2_plymouth-theme-breeze.sha256sum] = "87070b18dffc8786a8fe14dd5cce3c27c74f32245f865095517a6011f1aa7f46"

URI_aarch64_plymouth-theme-breeze = "${EPEL_MIRROR}/aarch64/Packages/p/plymouth-theme-breeze-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plymouth-theme-breeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-breeze}"
SRC_URI[aarch64_plymouth-theme-breeze.sha256sum] = "bbd5d03451e7002b14ca870a2c05cab4699375745158b0505e97f5f373e3b0b4"

RDEPENDS:plymouth-theme-breeze = " \
 glibc \
 plymouth \
 plymouth-core-libs \
 plymouth-plugin-script \
 "
