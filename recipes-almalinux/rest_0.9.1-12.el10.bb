# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rest"
PV = "0.9.1"
PR = "12.el10"
PACKAGES = " \
 rest \
 rest-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rest-0.9.1-12.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e0de9b795b3205098a512566833f4939538a7097b63fd560c5b9058f7bfeea85"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rest-0.9.1-12.el10.x86_64_v2.rpm;name=x86_64_v2_rest;unpack=0"
SRC_URI[x86_64_v2_rest.sha256sum] = "b10ed6e8dbda7163b6ec671e72dc9e05de3e62e6b408988e612b9baf14a06cf0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rest-devel-0.9.1-12.el10.x86_64_v2.rpm;name=x86_64_v2_rest-devel;unpack=0"
SRC_URI[x86_64_v2_rest-devel.sha256sum] = "c8486ac7ac8039ded30c7016538feacac238fa2aa0255eaa3c9a6b24cc0efa46"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rest-0.9.1-12.el10.aarch64.rpm;name=aarch64_rest;unpack=0"
SRC_URI[aarch64_rest.sha256sum] = "79144c5c6f9f03bdf9f12a33639cb2d651a8c8dbd165f9f46704c7bce1291bf3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rest-devel-0.9.1-12.el10.aarch64.rpm;name=aarch64_rest-devel;unpack=0"
SRC_URI[aarch64_rest-devel.sha256sum] = "8da7bd74d07d1a53fe7a465e13f5f31c70b32c2147dbf32b803d17c908a99242"

RDEPENDS:rest = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 libsoup3 \
 libxml2 \
 "
RDEPENDS:rest-devel = " \
 glib2-devel \
 json-glib-devel \
 libsoup3-devel \
 libxml2-devel \
 pkgconf-pkg-config \
 rest \
 rest-devel \
 "
