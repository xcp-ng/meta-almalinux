# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ordered-float"
PV = "5.3.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-ordered-float+arbitrary-devel \
 rust-ordered-float+bytemuck-devel \
 rust-ordered-float+default-devel \
 rust-ordered-float+libm-devel \
 rust-ordered-float+proptest-devel \
 rust-ordered-float+rand-devel \
 rust-ordered-float+randtest-devel \
 rust-ordered-float+rkyv_08-devel \
 rust-ordered-float+rkyv_08_16-devel \
 rust-ordered-float+rkyv_08_32-devel \
 rust-ordered-float+rkyv_08_64-devel \
 rust-ordered-float+rkyv_08_ck-devel \
 rust-ordered-float+serde-devel \
 rust-ordered-float+std-devel \
 rust-ordered-float-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ordered-float-5.3.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1416f185c017948442d66a591c11d10a7b0f49f7e07f7c161241537b14293f62"

URI_x86_64_v2_rust-ordered-float+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+arbitrary-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+arbitrary-devel.sha256sum] = "26e06996ea95a7787815aeb2af339ef1ff215eb6bb2bafb12338490f5e899528"

URI_x86_64_v2_rust-ordered-float+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+bytemuck-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+bytemuck-devel.sha256sum] = "61ac40b97215777c3fa445b175b15801494908fe1d12b5b330a4042e73d75353"

URI_x86_64_v2_rust-ordered-float+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+default-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+default-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+default-devel.sha256sum] = "cc26129d19fc90c7cb0efc2072e14293376582405ac589ef182d2f21bce3e7bb"

URI_x86_64_v2_rust-ordered-float+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+libm-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+libm-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+libm-devel.sha256sum] = "4d76e317291541e5495d7f4f026bee045925f904bd3db9195dff5e2f84abf8ae"

URI_x86_64_v2_rust-ordered-float+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+proptest-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+proptest-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+proptest-devel.sha256sum] = "6e5e8d9a58bc3f9c1d57bcdc7404f51a367362a1726718e841e26d7217bba7ce"

URI_x86_64_v2_rust-ordered-float+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rand-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rand-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rand-devel.sha256sum] = "7dae132a0bc3fbc29cf9134ea39db5478090613e168ce986b205a8638f1f7e27"

URI_x86_64_v2_rust-ordered-float+randtest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+randtest-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+randtest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+randtest-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+randtest-devel.sha256sum] = "da80c88d96303c83bbd95f77f0af1b671129692494dc371e2d93a2220f9e06f7"

URI_x86_64_v2_rust-ordered-float+rkyv_08-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv_08-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv_08-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv_08-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv_08-devel.sha256sum] = "bff1564c8f50720836b8d9f7a2f210a5769f29d148717f7bd6abbf3b32fed12e"

URI_x86_64_v2_rust-ordered-float+rkyv_08_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv_08_16-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv_08_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv_08_16-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv_08_16-devel.sha256sum] = "8c56820b79e2e95e5490d7726e08fc47788ccfba73017aacc39c8e944ab1305f"

URI_x86_64_v2_rust-ordered-float+rkyv_08_32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv_08_32-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv_08_32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv_08_32-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv_08_32-devel.sha256sum] = "a8946ace6f8c6fff98664c180163b1b08ff34fba2e607766e6ec8b73e23e59d8"

URI_x86_64_v2_rust-ordered-float+rkyv_08_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv_08_64-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv_08_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv_08_64-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv_08_64-devel.sha256sum] = "a5f30d3243614772948b0474cfc20d4e3959c79cea30da0ed7e4e0d27e9706c6"

URI_x86_64_v2_rust-ordered-float+rkyv_08_ck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv_08_ck-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv_08_ck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv_08_ck-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv_08_ck-devel.sha256sum] = "96d8e4bee7364546103f71465e49fdadc53ac3277895211bff0b487344288307"

URI_x86_64_v2_rust-ordered-float+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+serde-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+serde-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+serde-devel.sha256sum] = "3d0913cf8516d053e5b8034f1c56cd721a698a8d8c7c4287e612335ae4c486ba"

URI_x86_64_v2_rust-ordered-float+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+std-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+std-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+std-devel.sha256sum] = "8cfd757a5f2b7008989f337b48e3be90c799932fc56f7fdb689c0230b878af5c"

URI_x86_64_v2_rust-ordered-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float-devel-5.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float-devel}"
SRC_URI[x86_64_v2_rust-ordered-float-devel.sha256sum] = "2bee3466122d9dee26342e66beb2c4849dbeca75b706d58f7a2250ae2ac09571"

URI_aarch64_rust-ordered-float+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+arbitrary-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+arbitrary-devel}"
SRC_URI[aarch64_rust-ordered-float+arbitrary-devel.sha256sum] = "58cd03b29d0cc6db53efea1a3e2dd775691c82d3a9bb1a20248d2b35abb594fb"

URI_aarch64_rust-ordered-float+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+bytemuck-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+bytemuck-devel}"
SRC_URI[aarch64_rust-ordered-float+bytemuck-devel.sha256sum] = "c554445b995fdc0e119678e6ad3b59438dfe44572d626a0e143ca0e551c99bff"

URI_aarch64_rust-ordered-float+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+default-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+default-devel}"
SRC_URI[aarch64_rust-ordered-float+default-devel.sha256sum] = "2a428d9f473155019a2d7be4be8f3ed7026d74468e5a55aa461014191c69fdb6"

URI_aarch64_rust-ordered-float+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+libm-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+libm-devel}"
SRC_URI[aarch64_rust-ordered-float+libm-devel.sha256sum] = "c4afde1f0d46426007023b060f37cb5a97f17b9a83dfd7b2c221880ebdeba8d4"

URI_aarch64_rust-ordered-float+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+proptest-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+proptest-devel}"
SRC_URI[aarch64_rust-ordered-float+proptest-devel.sha256sum] = "cccf1df58e8163832dc406745586748cc3e77022366e4bb06e9c9f7d86a36f13"

URI_aarch64_rust-ordered-float+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rand-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rand-devel}"
SRC_URI[aarch64_rust-ordered-float+rand-devel.sha256sum] = "d5c72a11788f39dfbaf489a91ebef4886f5c22a7e9a3cc14b176a53f9612a3e3"

URI_aarch64_rust-ordered-float+randtest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+randtest-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float+randtest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+randtest-devel}"
SRC_URI[aarch64_rust-ordered-float+randtest-devel.sha256sum] = "0a2ce0e2d0f146bfbd10a6769bfaf213e8ab2314741b2e9bce2970d146393684"

URI_aarch64_rust-ordered-float+rkyv_08-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv_08-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float+rkyv_08-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv_08-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv_08-devel.sha256sum] = "385eaef8f68de46f07bf3ce2b91370a8612bae22254047230ec0d3f1819c65d5"

URI_aarch64_rust-ordered-float+rkyv_08_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv_08_16-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float+rkyv_08_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv_08_16-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv_08_16-devel.sha256sum] = "9ce203cea8c397d7bf6faaa12783107a675c3eee3d41bf3b08bbcd8eda75795f"

URI_aarch64_rust-ordered-float+rkyv_08_32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv_08_32-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float+rkyv_08_32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv_08_32-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv_08_32-devel.sha256sum] = "6e43caeb51064be1baa64279d1a9dc910720a3e681d76ba31569b5917cfd6afa"

URI_aarch64_rust-ordered-float+rkyv_08_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv_08_64-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float+rkyv_08_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv_08_64-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv_08_64-devel.sha256sum] = "4eb0238ff5fc042a5407f4aba1fcd18e068780ebc86663bf23fff209d24dd509"

URI_aarch64_rust-ordered-float+rkyv_08_ck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv_08_ck-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float+rkyv_08_ck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv_08_ck-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv_08_ck-devel.sha256sum] = "bdd84e2bd59b7e147f183cf18920c037dfa0d78f860351434d29736a457a2548"

URI_aarch64_rust-ordered-float+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+serde-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+serde-devel}"
SRC_URI[aarch64_rust-ordered-float+serde-devel.sha256sum] = "6163f34732031e32faa10464ace82bb4c0121765d8460af6a7db905bbb0dd37e"

URI_aarch64_rust-ordered-float+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+std-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+std-devel}"
SRC_URI[aarch64_rust-ordered-float+std-devel.sha256sum] = "6d0afe57e297ec66bdd30a0ba3d81beb41069d2b3d07fbc33f5f1baca5baf8e6"

URI_aarch64_rust-ordered-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float-devel-5.3.0-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float-devel}"
SRC_URI[aarch64_rust-ordered-float-devel.sha256sum] = "fea8503fa8bf560d3fa853bc82867bf0155c23db89e10bf3839c22a7e72aae73"

RDEPENDS:rust-ordered-float+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+bytemuck-devel = " \
 cargo \
 rust-bytemuck-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+default-devel = " \
 cargo \
 rust-ordered-float+std-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+libm-devel = " \
 cargo \
 rust-num-traits+libm-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+proptest-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-ordered-float+rand-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-ordered-float+randtest-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-ordered-float+rkyv_08-devel = " \
 cargo \
 rust-ordered-float+rkyv_08_32-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+rkyv_08_16-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rkyv+pointer_width_16-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-ordered-float+rkyv_08_32-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rkyv+pointer_width_32-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-ordered-float+rkyv_08_64-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rkyv+pointer_width_64-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-ordered-float+rkyv_08_ck-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rkyv+bytecheck-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-ordered-float+serde-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rand0.8+serde1-devel \
 rust-rand0.8-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ordered-float+std-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float-devel = " \
 cargo \
 rust \
 rust-num-traits-devel \
 "
