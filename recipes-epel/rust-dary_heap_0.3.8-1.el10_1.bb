# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dary_heap"
PV = "0.3.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-dary_heap+default-devel \
 rust-dary_heap+extra-devel \
 rust-dary_heap+serde-devel \
 rust-dary_heap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dary_heap-0.3.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e905ee6e596162cdf30366d22cc1de5ba1e1a67737e2dabc6bd13eebce784a8"

URI_x86_64_v2_rust-dary_heap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dary_heap+default-devel-0.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dary_heap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dary_heap+default-devel}"
SRC_URI[x86_64_v2_rust-dary_heap+default-devel.sha256sum] = "5c9daa1073e9b6b17911e61c0affb94ab3a4493d33c70f899e77cce65720346e"

URI_x86_64_v2_rust-dary_heap+extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dary_heap+extra-devel-0.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dary_heap+extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dary_heap+extra-devel}"
SRC_URI[x86_64_v2_rust-dary_heap+extra-devel.sha256sum] = "5a6de6a0aa48d7ef5b3053f327a206490e568ab310ccaa727a897f889c8f02a2"

URI_x86_64_v2_rust-dary_heap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dary_heap+serde-devel-0.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dary_heap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dary_heap+serde-devel}"
SRC_URI[x86_64_v2_rust-dary_heap+serde-devel.sha256sum] = "1e6cfddb14a1c2b1b71775e832d154a91ca25272278a736ad48289413678a49a"

URI_x86_64_v2_rust-dary_heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dary_heap-devel-0.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dary_heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dary_heap-devel}"
SRC_URI[x86_64_v2_rust-dary_heap-devel.sha256sum] = "37428e3a676adae764a423d2f711993aed46f6584485aead24d8274cc1f83e51"

URI_aarch64_rust-dary_heap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dary_heap+default-devel-0.3.8-1.el10_1.noarch.rpm;name=aarch64_rust-dary_heap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dary_heap+default-devel}"
SRC_URI[aarch64_rust-dary_heap+default-devel.sha256sum] = "477a5733c0c21a0664406ab81f95e9ef2f24691664e618cf728dd4e8ad896f78"

URI_aarch64_rust-dary_heap+extra-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dary_heap+extra-devel-0.3.8-1.el10_1.noarch.rpm;name=aarch64_rust-dary_heap+extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dary_heap+extra-devel}"
SRC_URI[aarch64_rust-dary_heap+extra-devel.sha256sum] = "dd8783b8d6afabc9f24df91644820d2ee51321fb44b943e53ee524a42a223e98"

URI_aarch64_rust-dary_heap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dary_heap+serde-devel-0.3.8-1.el10_1.noarch.rpm;name=aarch64_rust-dary_heap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dary_heap+serde-devel}"
SRC_URI[aarch64_rust-dary_heap+serde-devel.sha256sum] = "a12cfd62a652850be29fdbf6e0dec786a00082230da8cb9c861dd561445ea934"

URI_aarch64_rust-dary_heap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dary_heap-devel-0.3.8-1.el10_1.noarch.rpm;name=aarch64_rust-dary_heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dary_heap-devel}"
SRC_URI[aarch64_rust-dary_heap-devel.sha256sum] = "2ec53b5535b04569802acfc98a9424c8b5be01b479a103021bf4ef573196a5a3"

RDEPENDS:rust-dary_heap+default-devel = " \
 cargo \
 rust-dary_heap-devel \
 "
RDEPENDS:rust-dary_heap+extra-devel = " \
 cargo \
 rust-dary_heap-devel \
 "
RDEPENDS:rust-dary_heap+serde-devel = " \
 cargo \
 rust-dary_heap-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-dary_heap-devel = " \
 cargo \
 "
