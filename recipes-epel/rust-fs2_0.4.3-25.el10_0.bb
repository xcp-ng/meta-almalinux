# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fs2"
PV = "0.4.3"
PR = "25.el10_0"
PACKAGES = " \
 rust-fs2+default-devel \
 rust-fs2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fs2-0.4.3-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "983ae01561e9fbb9f939777b6fea53d408461cfb7c0052ea32991bc04ef312a5"

URI_x86_64_v2_rust-fs2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs2+default-devel-0.4.3-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs2+default-devel}"
SRC_URI[x86_64_v2_rust-fs2+default-devel.sha256sum] = "384a7be8dd5632ad7d44afcd55bbd49cc7de02628bdea3771e3d9a369d54bf00"

URI_x86_64_v2_rust-fs2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs2-devel-0.4.3-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs2-devel}"
SRC_URI[x86_64_v2_rust-fs2-devel.sha256sum] = "4f4e18834eb9fc09e465d93289541709a7567edfeb55e059338fce13c2bf7314"

URI_aarch64_rust-fs2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs2+default-devel-0.4.3-25.el10_0.noarch.rpm;name=aarch64_rust-fs2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs2+default-devel}"
SRC_URI[aarch64_rust-fs2+default-devel.sha256sum] = "7cf8c32d6337323ebb1dbf555e3cb95f1234ed87c135816264cefbd11c2aea9e"

URI_aarch64_rust-fs2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs2-devel-0.4.3-25.el10_0.noarch.rpm;name=aarch64_rust-fs2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs2-devel}"
SRC_URI[aarch64_rust-fs2-devel.sha256sum] = "8cbbd20206141cbefca09a1d03f83afb9df4720490f2909d4f453da5405475b5"

RDEPENDS:rust-fs2+default-devel = " \
 cargo \
 rust-fs2-devel \
 "
RDEPENDS:rust-fs2-devel = " \
 cargo \
 rust-libc+default-devel \
 "
