# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "blivet-gui"
PV = "2.6.0"
PR = "1.el10_1"
PACKAGES = " \
 blivet-gui \
 blivet-gui-runtime \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/blivet-gui-2.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e43c230e209ba5abb10ea79850f45af6bfba98561bffe022d9d7b8669d3dca43"

URI_x86_64_v2_blivet-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blivet-gui-2.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_blivet-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blivet-gui}"
SRC_URI[x86_64_v2_blivet-gui.sha256sum] = "9134cf5621338cebfbf76125f567e554e2c8e6250341fb5866e1f763b9d92148"

URI_x86_64_v2_blivet-gui-runtime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blivet-gui-runtime-2.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_blivet-gui-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blivet-gui-runtime}"
SRC_URI[x86_64_v2_blivet-gui-runtime.sha256sum] = "08e4ebd226387e55efb00c1f0965e4cd0c249fb6dfa41a25ef41c364ce1f76c4"

URI_aarch64_blivet-gui = "${EPEL_MIRROR}/aarch64/Packages/b/blivet-gui-2.6.0-1.el10_1.noarch.rpm;name=aarch64_blivet-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_blivet-gui}"
SRC_URI[aarch64_blivet-gui.sha256sum] = "44d65c43b056095492713b7534aa6b3f02e5ec6b70d1f2a85bdaf36a971aecbc"

URI_aarch64_blivet-gui-runtime = "${EPEL_MIRROR}/aarch64/Packages/b/blivet-gui-runtime-2.6.0-1.el10_1.noarch.rpm;name=aarch64_blivet-gui-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_blivet-gui-runtime}"
SRC_URI[aarch64_blivet-gui-runtime.sha256sum] = "b12a0b21d456431d1b0f5812b913e2dc5a4d7cefdb56d69aef1173a6f8a44f65"

RDEPENDS:blivet-gui = " \
 blivet-gui-runtime \
 libblockdev-plugins-all \
 polkit \
 virtual/PolicyKit-authentication-agent \
 "
RDEPENDS:blivet-gui-runtime = " \
 gtk3 \
 python3 \
 python3-blivet \
 python3-gobject \
 python3-pid \
 "
