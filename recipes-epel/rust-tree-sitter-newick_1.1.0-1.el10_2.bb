# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-newick"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-newick+default-devel \
 rust-tree-sitter-newick-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-newick-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f173d8ae887e70eb2df941fe47be539ceb571fd8a83c2adac0e7162b020051e"

URI_x86_64_v2_rust-tree-sitter-newick+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-newick+default-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-newick+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-newick+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-newick+default-devel.sha256sum] = "d64436916bbe3b00efb5523594bb679770e13ee98fd01b3e4d06de78135b6d52"

URI_x86_64_v2_rust-tree-sitter-newick-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-newick-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-newick-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-newick-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-newick-devel.sha256sum] = "7b11f580134d98f5bbcf6fb4fac7fbdf7a446bade1738ef9aedb0b252c7815cc"

URI_aarch64_rust-tree-sitter-newick+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-newick+default-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-newick+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-newick+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-newick+default-devel.sha256sum] = "2ad41a33002362c19d3319ee11feb1e8e091c6cdd08e20f8440cecdc39ce7aab"

URI_aarch64_rust-tree-sitter-newick-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-newick-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-newick-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-newick-devel}"
SRC_URI[aarch64_rust-tree-sitter-newick-devel.sha256sum] = "60ad982010f580c9ee8742e37fa645286e1250304b93db78eed91512e49db73e"

RDEPENDS:rust-tree-sitter-newick+default-devel = " \
 cargo \
 rust-tree-sitter-newick-devel \
 "
RDEPENDS:rust-tree-sitter-newick-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
