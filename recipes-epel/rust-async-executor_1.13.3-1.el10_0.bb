# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-executor"
PV = "1.13.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-async-executor+default-devel \
 rust-async-executor+static-devel \
 rust-async-executor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-executor-1.13.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5af003a2683a61fb88af07aaad7c0157c4b0ecbe4bf023b5a5a2fd30ac0ca2c8"

URI_x86_64_v2_rust-async-executor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-executor+default-devel-1.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-executor+default-devel}"
SRC_URI[x86_64_v2_rust-async-executor+default-devel.sha256sum] = "d5dae4bd079af0eef7866705b949a9dd3ff3490ebfbff94f5d5374f2f62d62d3"

URI_x86_64_v2_rust-async-executor+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-executor+static-devel-1.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-executor+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-executor+static-devel}"
SRC_URI[x86_64_v2_rust-async-executor+static-devel.sha256sum] = "87248e9412a82b032f3b60526ef85b7de18414e05bc7da8bf0febb72117518cf"

URI_x86_64_v2_rust-async-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-executor-devel-1.13.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-executor-devel}"
SRC_URI[x86_64_v2_rust-async-executor-devel.sha256sum] = "e47c88299be6443ec457782319265686a17d832665619e72817489ef0e26c31c"

URI_aarch64_rust-async-executor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-executor+default-devel-1.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-async-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-executor+default-devel}"
SRC_URI[aarch64_rust-async-executor+default-devel.sha256sum] = "e9c5dc6bf823c529787b32fb5500498ba2b3c62bac5528c82f97cbfd3694eefd"

URI_aarch64_rust-async-executor+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-executor+static-devel-1.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-async-executor+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-executor+static-devel}"
SRC_URI[aarch64_rust-async-executor+static-devel.sha256sum] = "9ca8f7b7c29e1663812a2bfdf7a4a4d0193300482de916b9a4f9f99a1e497663"

URI_aarch64_rust-async-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-executor-devel-1.13.3-1.el10_0.noarch.rpm;name=aarch64_rust-async-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-executor-devel}"
SRC_URI[aarch64_rust-async-executor-devel.sha256sum] = "afb869eae56e57161925f05cf4b0f06fc07741b588e884b7340de7058f10cce1"

RDEPENDS:rust-async-executor+default-devel = " \
 cargo \
 rust-async-executor-devel \
 "
RDEPENDS:rust-async-executor+static-devel = " \
 cargo \
 rust-async-executor-devel \
 "
RDEPENDS:rust-async-executor-devel = " \
 cargo \
 rust \
 rust-async-task+default-devel \
 rust-concurrent-queue+default-devel \
 rust-fastrand+default-devel \
 rust-futures-lite-devel \
 rust-pin-project-lite+default-devel \
 rust-slab+default-devel \
 "
