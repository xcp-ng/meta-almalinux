# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dlib"
PV = "0.5.2"
PR = "4.el10_0"
PACKAGES = " \
 rust-dlib+default-devel \
 rust-dlib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dlib-0.5.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f61fafe97d9a8fc172050e7d1d0018b0ffe632f9e52b026f89233ee3267aae6"

URI_x86_64_v2_rust-dlib+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dlib+default-devel-0.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dlib+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dlib+default-devel}"
SRC_URI[x86_64_v2_rust-dlib+default-devel.sha256sum] = "63dd53028a95bb518b4238c7ae4b6f60de0e94733a052ec68f94bedbfb84043f"

URI_x86_64_v2_rust-dlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dlib-devel-0.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dlib-devel}"
SRC_URI[x86_64_v2_rust-dlib-devel.sha256sum] = "50603890e858ed841c546dd33e3519a71528dfe1668021193e308f31da55d8c6"

URI_aarch64_rust-dlib+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dlib+default-devel-0.5.2-4.el10_0.noarch.rpm;name=aarch64_rust-dlib+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dlib+default-devel}"
SRC_URI[aarch64_rust-dlib+default-devel.sha256sum] = "680dcd8b1443ab256c1de8b013c887f9af115c79496252db005f623569d66db7"

URI_aarch64_rust-dlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dlib-devel-0.5.2-4.el10_0.noarch.rpm;name=aarch64_rust-dlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dlib-devel}"
SRC_URI[aarch64_rust-dlib-devel.sha256sum] = "7a881355bfbcae8b47e062759804570a225bc5b79b3a8644d2b1328d4697c380"

RDEPENDS:rust-dlib+default-devel = " \
 cargo \
 rust-dlib-devel \
 "
RDEPENDS:rust-dlib-devel = " \
 cargo \
 virtual/crate_libloading/default__ge_0.7.0_with_crate_libloading/default__lt_0.9.0~ \
 "
