# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-memcached"
PV = "1.62"
PR = "1.el10_2"
PACKAGES = " \
 python3-memcached \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-memcached-1.62-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3576820d58fe7dfb4780c4c8563603eafe465278b3f1b779be8d6a1c5c15669"

URI_x86_64_v2_python3-memcached = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-memcached-1.62-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-memcached;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-memcached}"
SRC_URI[x86_64_v2_python3-memcached.sha256sum] = "5761d55178afca9793d92de59800a46ebdbd4304f8cab44a215f1e6df0846a56"

URI_aarch64_python3-memcached = "${EPEL_MIRROR}/aarch64/Packages/p/python3-memcached-1.62-1.el10_2.noarch.rpm;name=aarch64_python3-memcached;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-memcached}"
SRC_URI[aarch64_python3-memcached.sha256sum] = "eb7a085c82e077ffaa705dc6104435e76deeefa12ae58f3df0cda23910ced428"

RDEPENDS:python3-memcached = " \
 python3 \
 "
