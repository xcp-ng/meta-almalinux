# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-Generator"
PV = "1.13"
PR = "7.el10_0"
PACKAGES = " \
 perl-XML-Generator \
 perl-XML-Generator-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XML-Generator-1.13-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c839ec724eaa15fc791c4bc2f22629ec3ab212ad9c170271ad41f6065eec9a5c"

URI_x86_64_v2_perl-XML-Generator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-Generator-1.13-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-Generator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-Generator}"
SRC_URI[x86_64_v2_perl-XML-Generator.sha256sum] = "79b00992c018cd17606d935835e6ec0a719de936c6101b8aebe2a07b58bf444b"

URI_x86_64_v2_perl-XML-Generator-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-Generator-tests-1.13-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-Generator-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-Generator-tests}"
SRC_URI[x86_64_v2_perl-XML-Generator-tests.sha256sum] = "873b4871dc7aa92c3499c1d9db8df622d5ebda977e2e935a14d10c1d1d1dd223"

URI_aarch64_perl-XML-Generator = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-Generator-1.13-7.el10_0.noarch.rpm;name=aarch64_perl-XML-Generator;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-Generator}"
SRC_URI[aarch64_perl-XML-Generator.sha256sum] = "a7f325d4bd686cf4d262cae874f3d985dfaa64d4c99e7bfea30c6a624acc7868"

URI_aarch64_perl-XML-Generator-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-Generator-tests-1.13-7.el10_0.noarch.rpm;name=aarch64_perl-XML-Generator-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-Generator-tests}"
SRC_URI[aarch64_perl-XML-Generator-tests.sha256sum] = "2c31f0142c83b2128ef515055f98e7bcb375dc84e960c31232ba38324ad63ad1"

RDEPENDS:perl-XML-Generator = " \
 perl-Carp \
 perl-XML-DOM \
 perl-XML-Generator \
 perl-base \
 perl-constant \
 perl-libs \
 perl-overload \
 perl-vars \
 "
RDEPENDS:perl-XML-Generator-tests = " \
 bash \
 perl-Test \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Tie-IxHash \
 perl-XML-DOM \
 perl-XML-Generator \
 perl-interpreter \
 perl-libs \
 "
