# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-meson"
PV = "0.4.5"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-meson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-meson-0.4.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1eda2d17f6bad8dd195cac02c6d640c7564cc94269c773a613c1c1baacec4094"

URI_x86_64_v2_python3-colcon-meson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-meson-0.4.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-meson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-meson}"
SRC_URI[x86_64_v2_python3-colcon-meson.sha256sum] = "6678c8c9e279457f97ea019720aee3b3425fa5ea75c38187a8ae4815b910b3f9"

URI_aarch64_python3-colcon-meson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-meson-0.4.5-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-meson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-meson}"
SRC_URI[aarch64_python3-colcon-meson.sha256sum] = "e1c0c6a2f361aa17524bf10beee9d3aa20d3ed38f82b7a8f7873abd1ad1b7003"

RDEPENDS:python3-colcon-meson = " \
 meson \
 python3 \
 python3-colcon-core \
 python3-colcon-library-path \
 "
