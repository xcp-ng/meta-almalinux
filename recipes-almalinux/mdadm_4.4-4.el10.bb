# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mdadm"
PV = "4.4"
PR = "4.el10"
PACKAGES = " \
 mdadm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mdadm-4.4-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a74e59d8d9b2ed7ad0b76871851be5ab1447474fa6a597f5d27616159e92b9f3"

URI_x86_64_v2_mdadm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mdadm-4.4-4.el10.x86_64_v2.rpm;name=x86_64_v2_mdadm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mdadm}"
SRC_URI[x86_64_v2_mdadm.sha256sum] = "c0aaea0f3b47bc74649c1be09c6c46044b8aadae60b9cf58f60f276b03fc544b"

URI_aarch64_mdadm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mdadm-4.4-4.el10.aarch64.rpm;name=aarch64_mdadm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mdadm}"
SRC_URI[aarch64_mdadm.sha256sum] = "63c61c5cee00c777f37d81ee600834fcb94eab908c1b0779d7b7ba250ce39036"

RDEPENDS:mdadm = " \
 bash \
 glibc \
 systemd \
 systemd-libs \
 virtual/coreutils \
 "
