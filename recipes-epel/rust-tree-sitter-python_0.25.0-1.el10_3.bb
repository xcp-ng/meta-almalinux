# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-python"
PV = "0.25.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-python+default-devel \
 rust-tree-sitter-python-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-python-0.25.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a66664279c32bdc9139466925088616ee7daac092f96a327054650156edc8e6"

URI_x86_64_v2_rust-tree-sitter-python+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-python+default-devel-0.25.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-python+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-python+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-python+default-devel.sha256sum] = "a868de19fe9dfb46d21bbf52d1f16257867a3694ccf1d759bc15d9d09287df20"

URI_x86_64_v2_rust-tree-sitter-python-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-python-devel-0.25.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-python-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-python-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-python-devel.sha256sum] = "cc0b2ea70ce4b79185938ec2d969054e6137aba79c62ae713c309c957306958e"

URI_aarch64_rust-tree-sitter-python+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-python+default-devel-0.25.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-python+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-python+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-python+default-devel.sha256sum] = "5ee3e03d8ed48988a857f27fbe870c64879c208afb02dd0d48189191b730e9bd"

URI_aarch64_rust-tree-sitter-python-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-python-devel-0.25.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-python-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-python-devel}"
SRC_URI[aarch64_rust-tree-sitter-python-devel.sha256sum] = "609254ce7d9337885201f3a81ef9b1270e159c76a422c8f03dd76fe4b9147535"

RDEPENDS:rust-tree-sitter-python+default-devel = " \
 cargo \
 rust-tree-sitter-python-devel \
 "
RDEPENDS:rust-tree-sitter-python-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
