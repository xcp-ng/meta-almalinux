# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerotrie"
PV = "0.2.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-zerotrie+alloc-devel \
 rust-zerotrie+databake-devel \
 rust-zerotrie+default-devel \
 rust-zerotrie+dense-devel \
 rust-zerotrie+litemap-devel \
 rust-zerotrie+serde-devel \
 rust-zerotrie+yoke-devel \
 rust-zerotrie+zerofrom-devel \
 rust-zerotrie+zerovec-devel \
 rust-zerotrie-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerotrie-0.2.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99557484b4bdd241165eef560ea21164e92e08a502295d7beda9dcd0f66a485c"

URI_x86_64_v2_rust-zerotrie+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+alloc-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+alloc-devel.sha256sum] = "69d341bd9597f5e5b2f6d0e3c9e0047a85defc07d9d98ef4a0a044d4a5f312ed"

URI_x86_64_v2_rust-zerotrie+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+databake-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+databake-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+databake-devel.sha256sum] = "d5976cdcc335930af014e26e7da816806616d8e5c47f2acdab68b3bc17ace24b"

URI_x86_64_v2_rust-zerotrie+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+default-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+default-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+default-devel.sha256sum] = "0abf283b30afd60d7bb3e8ef9e12cb1a19bddb136fb41d54f78451009f084da9"

URI_x86_64_v2_rust-zerotrie+dense-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+dense-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+dense-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+dense-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+dense-devel.sha256sum] = "4de541921be802c7abb261d28b0295eb29593f4e34266c52616a0fbe1e7bdfd9"

URI_x86_64_v2_rust-zerotrie+litemap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+litemap-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+litemap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+litemap-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+litemap-devel.sha256sum] = "b310f1213f2bc23a4a2b222325749b5394eb72ec672e75321f8f879b7be10b81"

URI_x86_64_v2_rust-zerotrie+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+serde-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+serde-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+serde-devel.sha256sum] = "ebf2f82adf51c20cb66c450c64ba4302c569294e3a5c5442bb0fa17784733a41"

URI_x86_64_v2_rust-zerotrie+yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+yoke-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+yoke-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+yoke-devel.sha256sum] = "1b88a38fa06544b604e8853f604760dc3c15e0e9aeacf02e24809c0060c4d8dc"

URI_x86_64_v2_rust-zerotrie+zerofrom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+zerofrom-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+zerofrom-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+zerofrom-devel.sha256sum] = "ae0cf6eea0de4a38c3f3392b5aaf77562c88577906ae4529e59d6827c99740c5"

URI_x86_64_v2_rust-zerotrie+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+zerovec-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+zerovec-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+zerovec-devel.sha256sum] = "3d4b566a89a0a9641d3bcbd253b9235109634c87bc2d956fe905335f49cc0741"

URI_x86_64_v2_rust-zerotrie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie-devel}"
SRC_URI[x86_64_v2_rust-zerotrie-devel.sha256sum] = "70a97f1f0851345836af61ba20435b87f46567fdc1fd9291d94f30801579c6cb"

URI_aarch64_rust-zerotrie+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+alloc-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+alloc-devel}"
SRC_URI[aarch64_rust-zerotrie+alloc-devel.sha256sum] = "29f9cf980734d923bdc41d8cb616993a1bd26b1654ab193166ed73a3b43045be"

URI_aarch64_rust-zerotrie+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+databake-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+databake-devel}"
SRC_URI[aarch64_rust-zerotrie+databake-devel.sha256sum] = "7b330fba6768c20ff803bff5002a48d3e2eba88da31f43a01563188a239d0efc"

URI_aarch64_rust-zerotrie+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+default-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+default-devel}"
SRC_URI[aarch64_rust-zerotrie+default-devel.sha256sum] = "a0b960a6ac2d222cd5fba0f68a08c05f7fbc05772852e738148540b76b261cba"

URI_aarch64_rust-zerotrie+dense-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+dense-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+dense-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+dense-devel}"
SRC_URI[aarch64_rust-zerotrie+dense-devel.sha256sum] = "301958830a5e7e3997bb7e45981640bc73a65f286c764c26128feb3de49fb187"

URI_aarch64_rust-zerotrie+litemap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+litemap-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+litemap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+litemap-devel}"
SRC_URI[aarch64_rust-zerotrie+litemap-devel.sha256sum] = "5c05eb9063d175204a8602f19fca8a362373cb8880d25166a9512abd1958a246"

URI_aarch64_rust-zerotrie+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+serde-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+serde-devel}"
SRC_URI[aarch64_rust-zerotrie+serde-devel.sha256sum] = "455ad169ec3a85edbfd6397a94e20714cc7f9f0633c09d240732af48ac9a7727"

URI_aarch64_rust-zerotrie+yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+yoke-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+yoke-devel}"
SRC_URI[aarch64_rust-zerotrie+yoke-devel.sha256sum] = "6502837e9cf8121f96f7eb947a891e4d0b2441d2a07a716e2639b0a3f15a3358"

URI_aarch64_rust-zerotrie+zerofrom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+zerofrom-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+zerofrom-devel}"
SRC_URI[aarch64_rust-zerotrie+zerofrom-devel.sha256sum] = "c8d3ce89e7a1c19a78e43d15441ec68d97c2065e9b05e0dff6b50bbe16c531e9"

URI_aarch64_rust-zerotrie+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+zerovec-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+zerovec-devel}"
SRC_URI[aarch64_rust-zerotrie+zerovec-devel.sha256sum] = "ec0a7f2bbe9279d48200440fbc5dfd858183dc1a809068d5f9df906fe549e758"

URI_aarch64_rust-zerotrie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie-devel}"
SRC_URI[aarch64_rust-zerotrie-devel.sha256sum] = "3c56df247dac42fc0ece7c19e258d7b5d5a70d4090487694658275ab0fb0d41b"

RDEPENDS:rust-zerotrie+alloc-devel = " \
 cargo \
 rust-zerotrie-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-zerotrie-devel \
 rust-zerovec+databake-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie+default-devel = " \
 cargo \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+dense-devel = " \
 cargo \
 rust-zerotrie-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie+litemap-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 rust-zerotrie+alloc-devel \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+serde-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap+serde-devel \
 rust-litemap-devel \
 rust-serde_core-devel \
 rust-zerotrie+alloc-devel \
 rust-zerotrie-devel \
 rust-zerovec+serde-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie+yoke-devel = " \
 cargo \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+zerofrom-devel = " \
 cargo \
 rust-zerofrom-devel \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+zerovec-devel = " \
 cargo \
 rust-zerotrie-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 "
