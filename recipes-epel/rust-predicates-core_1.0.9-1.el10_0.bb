# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-predicates-core"
PV = "1.0.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-predicates-core+default-devel \
 rust-predicates-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-predicates-core-1.0.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a28dff282a9db0aa15b632a49e37e36f8e9b64022883d762d07663db2f61da40"

URI_x86_64_v2_rust-predicates-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-core+default-devel-1.0.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-core+default-devel}"
SRC_URI[x86_64_v2_rust-predicates-core+default-devel.sha256sum] = "91fa99a1a2f5b3c020643d96046f45174264d3c84c39abbbca83ef809e25b55d"

URI_x86_64_v2_rust-predicates-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-core-devel-1.0.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-core-devel}"
SRC_URI[x86_64_v2_rust-predicates-core-devel.sha256sum] = "4a28fad92002660e142209399a428d140419b1cd4d1b2b27eaafe8cd17ecfd4e"

URI_aarch64_rust-predicates-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-core+default-devel-1.0.9-1.el10_0.noarch.rpm;name=aarch64_rust-predicates-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-core+default-devel}"
SRC_URI[aarch64_rust-predicates-core+default-devel.sha256sum] = "2892aabdf90b4e447aeadea94bb473af32ccef97a4178e1998f89136972cc40e"

URI_aarch64_rust-predicates-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-core-devel-1.0.9-1.el10_0.noarch.rpm;name=aarch64_rust-predicates-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-core-devel}"
SRC_URI[aarch64_rust-predicates-core-devel.sha256sum] = "0a5285c6299f91715e2bfa039535a0048d937918ec78e70473fa48ce050463e5"

RDEPENDS:rust-predicates-core+default-devel = " \
 cargo \
 rust-predicates-core-devel \
 "
RDEPENDS:rust-predicates-core-devel = " \
 cargo \
 rust \
 "
