# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spamass-milter"
PV = "0.4.0"
PR = "30.el10_0"
PACKAGES = " \
 spamass-milter \
 spamass-milter-postfix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spamass-milter-0.4.0-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb6ec7e2f9fd095b8d9ae432bdb0c2f8a5acb7e9b199be1fb3dda855232828e4"

URI_x86_64_v2_spamass-milter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spamass-milter-0.4.0-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spamass-milter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spamass-milter}"
SRC_URI[x86_64_v2_spamass-milter.sha256sum] = "9eddc08f70efcd3013444d345787eb003f6af076abf18e9c1c2a27383bb1e030"

URI_x86_64_v2_spamass-milter-postfix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spamass-milter-postfix-0.4.0-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_spamass-milter-postfix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spamass-milter-postfix}"
SRC_URI[x86_64_v2_spamass-milter-postfix.sha256sum] = "933b7f46830803b03e867f48aa549fba3cd09270bdb4197084c8b11c84687ae1"

URI_aarch64_spamass-milter = "${EPEL_MIRROR}/aarch64/Packages/s/spamass-milter-0.4.0-30.el10_0.aarch64.rpm;name=aarch64_spamass-milter;unpack=0"
SRC_URI:append = " ${URI_aarch64_spamass-milter}"
SRC_URI[aarch64_spamass-milter.sha256sum] = "38bb78e231a54a5f95f04b3bdf16f55166f82ab47d608266714857676748528e"

URI_aarch64_spamass-milter-postfix = "${EPEL_MIRROR}/aarch64/Packages/s/spamass-milter-postfix-0.4.0-30.el10_0.noarch.rpm;name=aarch64_spamass-milter-postfix;unpack=0"
SRC_URI:append = " ${URI_aarch64_spamass-milter-postfix}"
SRC_URI[aarch64_spamass-milter-postfix.sha256sum] = "64606f0e6e2ee2f1b9be3f99011aa2bdc880a66074dd07c702d54da33f8a1c50"

RDEPENDS:spamass-milter = " \
 bash \
 glibc \
 glibc-common \
 libgcc \
 libstdc++ \
 sendmail-milter \
 shadow-utils \
 spamassassin \
 systemd \
 virtual//usr/sbin/sendmail \
 virtual/coreutils \
 "
RDEPENDS:spamass-milter-postfix = " \
 bash \
 postfix \
 shadow-utils \
 spamass-milter \
 "
