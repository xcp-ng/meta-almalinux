# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-zstd"
PV = "0.17.0"
PR = "1.el10_2"
PACKAGES = " \
 php-zstd \
 php-zstd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-zstd-0.17.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51a8c05a39c5cef2ee25eecbce75f8d22d5f5f5426366a463de7bee0f49a8d2c"

URI_x86_64_v2_php-zstd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-zstd-0.17.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-zstd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-zstd}"
SRC_URI[x86_64_v2_php-zstd.sha256sum] = "a057770b39b5875afe4f7b374e931b3239d1a039fa5070f3a78cfe94af31e87a"

URI_x86_64_v2_php-zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-zstd-devel-0.17.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-zstd-devel}"
SRC_URI[x86_64_v2_php-zstd-devel.sha256sum] = "3edfb38ce4a6db6ab497cf5245a60de77aa827e7c22cadc5a5904743828db0c9"

URI_aarch64_php-zstd = "${EPEL_MIRROR}/aarch64/Packages/p/php-zstd-0.17.0-1.el10_2.aarch64.rpm;name=aarch64_php-zstd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-zstd}"
SRC_URI[aarch64_php-zstd.sha256sum] = "e491fc25140ae976e1d4a991cde86bccaf79a29142f0145db12195c4ef631c4d"

URI_aarch64_php-zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-zstd-devel-0.17.0-1.el10_2.aarch64.rpm;name=aarch64_php-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-zstd-devel}"
SRC_URI[aarch64_php-zstd-devel.sha256sum] = "c18ffdc848fb123213fdfb99740bbdab5734548b21768545dc958f02efad2681"

RDEPENDS:php-zstd = " \
 glibc \
 libzstd \
 php-common \
 "
RDEPENDS:php-zstd-devel:x86_64_v2 = " \
 php-zstd \
 virtual/php-devel_x86-64_ \
"
RDEPENDS:php-zstd-devel:aarch64 = " \
 php-zstd \
 virtual/php-devel_aarch-64_ \
"
