# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bird"
PV = "3.2.1"
PR = "1.el10_1"
PACKAGES = " \
 bird \
 bird-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bird-3.2.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c906ebaa6895570d1f9445247c26fbfc2aa88fa42589288a0aba500d5edafac"

URI_x86_64_v2_bird = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bird-3.2.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bird;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bird}"
SRC_URI[x86_64_v2_bird.sha256sum] = "27207ccb6f46740b22e7b39985033a91c3e59eba614294bc219c9aa47253b265"

URI_x86_64_v2_bird-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bird-doc-3.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_bird-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bird-doc}"
SRC_URI[x86_64_v2_bird-doc.sha256sum] = "ab3af6696b15486aa76061f04918adb9db8fa81bd455ebab67154c464b7620f2"

URI_aarch64_bird = "${EPEL_MIRROR}/aarch64/Packages/b/bird-3.2.1-1.el10_1.aarch64.rpm;name=aarch64_bird;unpack=0"
SRC_URI:append = " ${URI_aarch64_bird}"
SRC_URI[aarch64_bird.sha256sum] = "d5ce414adece09352310a037d1a53f2247218dbf794a49e6b42f0801a7d50d83"

URI_aarch64_bird-doc = "${EPEL_MIRROR}/aarch64/Packages/b/bird-doc-3.2.1-1.el10_1.noarch.rpm;name=aarch64_bird-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bird-doc}"
SRC_URI[aarch64_bird-doc.sha256sum] = "035491976966865a41c3efd4b9dfee060a8c43d9924326350ae2176b28734086"

RDEPENDS:bird = " \
 bash \
 glibc \
 libgcc \
 libssh \
 ncurses-libs \
 readline \
 shadow-utils \
 systemd \
 "
RDEPENDS:bird-doc = " \
 "
