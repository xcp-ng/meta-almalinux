# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Package-Stash"
PV = "0.40"
PR = "4.el10_0"
PACKAGES = " \
 perl-Package-Stash \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Package-Stash-0.40-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c958c930443e8d7bdb2c035b76f2a16e929509cac03329433b21a3b89e53b02"

URI_x86_64_v2_perl-Package-Stash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Package-Stash-0.40-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Package-Stash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Package-Stash}"
SRC_URI[x86_64_v2_perl-Package-Stash.sha256sum] = "dc0b19e59022cf2ead2b369058350bdabaaacc328f81462da96bd4a37d1ef47a"

URI_aarch64_perl-Package-Stash = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Package-Stash-0.40-4.el10_0.noarch.rpm;name=aarch64_perl-Package-Stash;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Package-Stash}"
SRC_URI[aarch64_perl-Package-Stash.sha256sum] = "1693ef4d9399a77be284cada1825605000debd49f3cc575cf5d1b0c542a67c90"

RDEPENDS:perl-Package-Stash = " \
 perl-B \
 perl-Carp \
 perl-Dist-CheckConflicts \
 perl-Getopt-Long \
 perl-Module-Implementation \
 perl-Package-Stash \
 perl-Package-Stash-XS \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
