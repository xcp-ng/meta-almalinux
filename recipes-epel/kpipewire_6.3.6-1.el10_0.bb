# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpipewire"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kpipewire \
 kpipewire-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpipewire-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d25c060bca9719296d6493a587bec7706a385fc7b4978ccfbd65a97817a34256"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - kpipewire: libavcodec.so.61()(64bit)
# - kpipewire: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - kpipewire: libavfilter.so.10()(64bit)
# - kpipewire: libavfilter.so.10(LIBAVFILTER_10)(64bit)
# - kpipewire: libavformat.so.61()(64bit)
# - kpipewire: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - kpipewire: libavutil.so.59()(64bit)
# - kpipewire: libavutil.so.59(LIBAVUTIL_59)(64bit)

URI_x86_64_v2_kpipewire = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpipewire-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpipewire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpipewire}"
SRC_URI[x86_64_v2_kpipewire.sha256sum] = "66d530fbc5269c3593b42170d588a687cce662c101a5c162ef9915201aced10b"

URI_x86_64_v2_kpipewire-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpipewire-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpipewire-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpipewire-devel}"
SRC_URI[x86_64_v2_kpipewire-devel.sha256sum] = "1112bc51c850b349e8dbe72e6d58f2e36907ed27d1460fc0535cf90354d4520b"

URI_aarch64_kpipewire = "${EPEL_MIRROR}/aarch64/Packages/k/kpipewire-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kpipewire;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpipewire}"
SRC_URI[aarch64_kpipewire.sha256sum] = "d51cb8e1b4b1ba37d6ba86d832d52f5833d8261ebc1b04533a70c8cf4f5e02fe"

URI_aarch64_kpipewire-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpipewire-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kpipewire-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpipewire-devel}"
SRC_URI[aarch64_kpipewire-devel.sha256sum] = "cc75e50c2704c770c0b6399f8d83632fd55c0228913ebd807dda0ccce36fe803"

RDEPENDS:kpipewire:x86_64_v2 = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 libdrm \
 libepoxy \
 libstdc++ \
 libva \
 mesa-libgbm \
 pipewire-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
"
RDEPENDS:kpipewire:aarch64 = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libdrm \
 libepoxy \
 libstdc++ \
 libva \
 mesa-libgbm \
 pipewire-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
"
RDEPENDS:kpipewire-devel = " \
 cmake-filesystem \
 kpipewire \
 pipewire-devel \
 "
