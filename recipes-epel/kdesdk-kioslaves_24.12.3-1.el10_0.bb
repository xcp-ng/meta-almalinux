# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdesdk-kioslaves"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kdesdk-kioslaves \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdesdk-kioslaves-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "846ec4dfafda2582106089b97b8d23dc826366e2fc32307e1a4419ecb93ab847"

URI_x86_64_v2_kdesdk-kioslaves = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdesdk-kioslaves-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdesdk-kioslaves;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdesdk-kioslaves}"
SRC_URI[x86_64_v2_kdesdk-kioslaves.sha256sum] = "2fb66ccc2dc9868c6df5a4967f4bed565c8be4d482dcbf8f0dd0e086702332de"

URI_aarch64_kdesdk-kioslaves = "${EPEL_MIRROR}/aarch64/Packages/k/kdesdk-kioslaves-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdesdk-kioslaves;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdesdk-kioslaves}"
SRC_URI[aarch64_kdesdk-kioslaves.sha256sum] = "eee6ceb4efcc049a0b08881ab08c19ee838cc9778fdff76ba9d13114850c0c03"

RDEPENDS:kdesdk-kioslaves = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 perl-Carp \
 perl-English \
 perl-Pod-Parser \
 perl-base \
 perl-interpreter \
 perl-libs \
 qt6-qtbase \
 "
