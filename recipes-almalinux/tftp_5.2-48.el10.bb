# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tftp"
PV = "5.2"
PR = "48.el10"
PACKAGES = " \
 tftp \
 tftp-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tftp-5.2-48.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7df5846a64510caa84c2eebb34c162a86f0072dc1ca93839ea4ce097f2a2097f"

URI_x86_64_v2_tftp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tftp-5.2-48.el10.x86_64_v2.rpm;name=x86_64_v2_tftp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tftp}"
SRC_URI[x86_64_v2_tftp.sha256sum] = "ebe2935ea411c063057fa7253bdceefbd3a99676b81b9a2b3a75a15c81a1571b"

URI_x86_64_v2_tftp-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tftp-server-5.2-48.el10.x86_64_v2.rpm;name=x86_64_v2_tftp-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tftp-server}"
SRC_URI[x86_64_v2_tftp-server.sha256sum] = "459c2a48079349dd054695b6e57b8ea9de7107c203ea0d4a97f54b33a0f47bcf"

URI_aarch64_tftp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tftp-5.2-48.el10.aarch64.rpm;name=aarch64_tftp;unpack=0"
SRC_URI:append = " ${URI_aarch64_tftp}"
SRC_URI[aarch64_tftp.sha256sum] = "8f6c5676099ddbb56c10bb5405af21687a86c5ae77f5482336c9486dbd44bcb5"

URI_aarch64_tftp-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tftp-server-5.2-48.el10.aarch64.rpm;name=aarch64_tftp-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_tftp-server}"
SRC_URI[aarch64_tftp-server.sha256sum] = "c9adec0041a8b8395bbfa533f8b0ec854620f8b2e65e5aba4152b3fcda27fc5e"

RDEPENDS:tftp = " \
 glibc \
 readline \
 "
RDEPENDS:tftp-server = " \
 bash \
 glibc \
 systemd \
 "
