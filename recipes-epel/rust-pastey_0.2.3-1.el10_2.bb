# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pastey"
PV = "0.2.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-pastey+default-devel \
 rust-pastey-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pastey-0.2.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef677d169ff308f27889b180053375fe3f034ff68709aeee323f4de96d6f983d"

URI_x86_64_v2_rust-pastey+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pastey+default-devel-0.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pastey+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pastey+default-devel}"
SRC_URI[x86_64_v2_rust-pastey+default-devel.sha256sum] = "2ca9589240716c735f6058981ed6a5674d3ae4cb611a0bb27cd16fb22a470c5d"

URI_x86_64_v2_rust-pastey-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pastey-devel-0.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pastey-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pastey-devel}"
SRC_URI[x86_64_v2_rust-pastey-devel.sha256sum] = "b4af59d17813d7f66ebb06353d2a7448797a0cebe74c1bad36c70785b87fd813"

URI_aarch64_rust-pastey+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pastey+default-devel-0.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-pastey+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pastey+default-devel}"
SRC_URI[aarch64_rust-pastey+default-devel.sha256sum] = "7e4446926bcaaeea4d12cec18120d49dfc44f7fe3c06dc6d1d861701cf96473d"

URI_aarch64_rust-pastey-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pastey-devel-0.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-pastey-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pastey-devel}"
SRC_URI[aarch64_rust-pastey-devel.sha256sum] = "77c552ceb7b62eda1bf8b85ab6245c12edd37015fd4e6f8b358b26a70a8a0b2a"

RDEPENDS:rust-pastey+default-devel = " \
 cargo \
 rust-pastey-devel \
 "
RDEPENDS:rust-pastey-devel = " \
 cargo \
 rust \
 "
