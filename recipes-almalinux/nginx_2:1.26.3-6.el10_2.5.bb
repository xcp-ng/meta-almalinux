# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx"
PE = "2"
PV = "1.26.3"
PR = "6.el10_2.5"
PACKAGES = " \
 nginx \
 nginx-all-modules \
 nginx-core \
 nginx-filesystem \
 nginx-mod-devel \
 nginx-mod-http-image-filter \
 nginx-mod-http-perl \
 nginx-mod-http-xslt-filter \
 nginx-mod-mail \
 nginx-mod-stream \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nginx-1.26.3-6.el10_2.5.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be806bc97951c97d548e202854f3a5fc16705e5729170cd35d960c4c4d1f180d"

URI_x86_64_v2_nginx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-1.26.3-6.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx}"
SRC_URI[x86_64_v2_nginx.sha256sum] = "a9c2539f65028262d9e4ad27dd2f1a6ce598671c4c8dd1a74bb703954478dfc9"
RPROVIDES:nginx:x86_64_v2 = "virtual/httpd_or_nginx virtual/webserver"

URI_x86_64_v2_nginx-all-modules = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-all-modules-1.26.3-6.el10_2.5.noarch.rpm;name=x86_64_v2_nginx-all-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-all-modules}"
SRC_URI[x86_64_v2_nginx-all-modules.sha256sum] = "63783f2757ef9f4c14eb7739660124c6c7d8094475d4b3333f54aa552c72f0fd"

URI_x86_64_v2_nginx-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-core-1.26.3-6.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_nginx-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-core}"
SRC_URI[x86_64_v2_nginx-core.sha256sum] = "cf064e1321fe46ea4e6d92a1ea56b58c2940ebb2a688669ded0345d9bd5d43cb"

URI_x86_64_v2_nginx-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-filesystem-1.26.3-6.el10_2.5.noarch.rpm;name=x86_64_v2_nginx-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-filesystem}"
SRC_URI[x86_64_v2_nginx-filesystem.sha256sum] = "e33cd1bd4272896159c0e7c1cd3fb48f85a85d98e7641fd3ac67aa121ff5fae5"

URI_x86_64_v2_nginx-mod-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nginx-mod-devel-1.26.3-6.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-devel}"
SRC_URI[x86_64_v2_nginx-mod-devel.sha256sum] = "161f22935088cb43637f310a75597562d68ad58fbbbb4bd3bd21ab18a6fa1586"

URI_x86_64_v2_nginx-mod-http-image-filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-image-filter-1.26.3-6.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-image-filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-http-image-filter}"
SRC_URI[x86_64_v2_nginx-mod-http-image-filter.sha256sum] = "ca70abc675dc4e28cf491f87231f03e3dfb3fdf59de5b5210a8013d6572f2956"

URI_x86_64_v2_nginx-mod-http-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-perl-1.26.3-6.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-http-perl}"
SRC_URI[x86_64_v2_nginx-mod-http-perl.sha256sum] = "79f5464576f3e429b4d727bc825fbbec31128892f242e932f0236d871e833c54"

URI_x86_64_v2_nginx-mod-http-xslt-filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-xslt-filter-1.26.3-6.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-xslt-filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-http-xslt-filter}"
SRC_URI[x86_64_v2_nginx-mod-http-xslt-filter.sha256sum] = "74d33d79a2624cac0988e7b6b9b5c3b824637e7fd57aa0a540cd09919387708e"

URI_x86_64_v2_nginx-mod-mail = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-mail-1.26.3-6.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-mail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-mail}"
SRC_URI[x86_64_v2_nginx-mod-mail.sha256sum] = "bba519b65a069f3044bfba3642cf0abb84d35f4d6060f68cc4ed648fa6675e5f"

URI_x86_64_v2_nginx-mod-stream = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-stream-1.26.3-6.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-stream;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-stream}"
SRC_URI[x86_64_v2_nginx-mod-stream.sha256sum] = "1a799b5777ccb396f446d6fc3ce679b7e71442c079a057f2f92c1bf66db6d035"

URI_aarch64_nginx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-1.26.3-6.el10_2.5.aarch64.rpm;name=aarch64_nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx}"
SRC_URI[aarch64_nginx.sha256sum] = "77819453304f4c4b7ae7ce34c3f702463cb69768f62ac94a59be4bc21a9d1867"
RPROVIDES:nginx:aarch64 = "virtual/httpd_or_nginx virtual/webserver"

URI_aarch64_nginx-all-modules = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-all-modules-1.26.3-6.el10_2.5.noarch.rpm;name=aarch64_nginx-all-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-all-modules}"
SRC_URI[aarch64_nginx-all-modules.sha256sum] = "63783f2757ef9f4c14eb7739660124c6c7d8094475d4b3333f54aa552c72f0fd"

URI_aarch64_nginx-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-core-1.26.3-6.el10_2.5.aarch64.rpm;name=aarch64_nginx-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-core}"
SRC_URI[aarch64_nginx-core.sha256sum] = "8ef714150f45dbe07d1bd4e9948a1e7c1cadc51335471a973c21532a8624ab3b"

URI_aarch64_nginx-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-filesystem-1.26.3-6.el10_2.5.noarch.rpm;name=aarch64_nginx-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-filesystem}"
SRC_URI[aarch64_nginx-filesystem.sha256sum] = "e33cd1bd4272896159c0e7c1cd3fb48f85a85d98e7641fd3ac67aa121ff5fae5"

URI_aarch64_nginx-mod-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nginx-mod-devel-1.26.3-6.el10_2.5.aarch64.rpm;name=aarch64_nginx-mod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-devel}"
SRC_URI[aarch64_nginx-mod-devel.sha256sum] = "32746e1138507248f4938da549e2b793cab7104214e07419a50dd2b6513deb47"

URI_aarch64_nginx-mod-http-image-filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-image-filter-1.26.3-6.el10_2.5.aarch64.rpm;name=aarch64_nginx-mod-http-image-filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-http-image-filter}"
SRC_URI[aarch64_nginx-mod-http-image-filter.sha256sum] = "0b50f46f5d190e97026aa20f8f4a3dc70918508e66d438102771bd077683aa24"

URI_aarch64_nginx-mod-http-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-perl-1.26.3-6.el10_2.5.aarch64.rpm;name=aarch64_nginx-mod-http-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-http-perl}"
SRC_URI[aarch64_nginx-mod-http-perl.sha256sum] = "c66805b07378c6cefbc92412557e1f113532557eccb3ecec1ea87d3bd2ee74c8"

URI_aarch64_nginx-mod-http-xslt-filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-xslt-filter-1.26.3-6.el10_2.5.aarch64.rpm;name=aarch64_nginx-mod-http-xslt-filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-http-xslt-filter}"
SRC_URI[aarch64_nginx-mod-http-xslt-filter.sha256sum] = "5f647d048b359ea2a611ca49cba7ee755b6bd3efaf6ab613ca140e220a8e6a5f"

URI_aarch64_nginx-mod-mail = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-mail-1.26.3-6.el10_2.5.aarch64.rpm;name=aarch64_nginx-mod-mail;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-mail}"
SRC_URI[aarch64_nginx-mod-mail.sha256sum] = "c2448d3c059dd2cd2daa41c5dca3362b966a232521d6b755cc404a7870606179"

URI_aarch64_nginx-mod-stream = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-stream-1.26.3-6.el10_2.5.aarch64.rpm;name=aarch64_nginx-mod-stream;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-stream}"
SRC_URI[aarch64_nginx-mod-stream.sha256sum] = "a89c9b85eb8bf053151152ffbb8d4d1f4afd2d0dc3a36d9fb40e12d53ca0ac21"

RDEPENDS:nginx = " \
 almalinux-logos-httpd \
 bash \
 nginx-core \
 nginx-filesystem \
 systemd \
 "
RDEPENDS:nginx-all-modules = " \
 nginx-mod-http-image-filter \
 nginx-mod-http-perl \
 nginx-mod-http-xslt-filter \
 nginx-mod-mail \
 nginx-mod-stream \
 "
RDEPENDS:nginx-core = " \
 glibc \
 libxcrypt \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:nginx-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:nginx-mod-devel = " \
 bash \
 gcc \
 gd-devel \
 libxslt-devel \
 make \
 nginx \
 openssl-devel \
 pcre2-devel \
 perl-Exporter \
 perl-ExtUtils-Embed \
 perl-constant \
 perl-devel \
 perl-interpreter \
 perl-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:nginx-mod-http-image-filter = " \
 bash \
 gd \
 glibc \
 nginx \
 "
RDEPENDS:nginx-mod-http-perl = " \
 bash \
 glibc \
 nginx \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
RDEPENDS:nginx-mod-http-xslt-filter = " \
 bash \
 glibc \
 libxml2 \
 libxslt \
 nginx \
 "
RDEPENDS:nginx-mod-mail = " \
 bash \
 glibc \
 nginx \
 "
RDEPENDS:nginx-mod-stream = " \
 bash \
 glibc \
 nginx \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/httpd_or_nginx rpm/virtual/webserver"

PROVIDES:append:aarch64 = " rpm/virtual/httpd_or_nginx rpm/virtual/webserver"
