# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-PerlIO-utf8_strict"
PV = "0.010"
PR = "10.el10"
PACKAGES = " \
 perl-PerlIO-utf8_strict \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-PerlIO-utf8_strict-0.010-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae40f34ad1641bef92769c9113d95517cec1a2d8f9c013c194c8d9952feaed7c"

URI_x86_64_v2_perl-PerlIO-utf8_strict = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-PerlIO-utf8_strict-0.010-10.el10.x86_64_v2.rpm;name=x86_64_v2_perl-PerlIO-utf8_strict;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PerlIO-utf8_strict}"
SRC_URI[x86_64_v2_perl-PerlIO-utf8_strict.sha256sum] = "e20bfcc5f1b14bb1b51dd6760063cd3eaeabf283d76390dc2241744a4c15f04d"

URI_aarch64_perl-PerlIO-utf8_strict = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-PerlIO-utf8_strict-0.010-10.el10.aarch64.rpm;name=aarch64_perl-PerlIO-utf8_strict;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PerlIO-utf8_strict}"
SRC_URI[aarch64_perl-PerlIO-utf8_strict.sha256sum] = "a6728f94e90d64859f49b5e54b46de6b3994f9706f549bec8f34fe8e1f664792"

RDEPENDS:perl-PerlIO-utf8_strict = " \
 glibc \
 perl-libs \
 "
