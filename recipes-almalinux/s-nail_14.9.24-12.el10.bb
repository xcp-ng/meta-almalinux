# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "s-nail"
PV = "14.9.24"
PR = "12.el10"
PACKAGES = " \
 s-nail \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/s-nail-14.9.24-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63a66a5bc227868ad50505bfbbd194626be3603fcb4618f06e6d54af1ec5579e"

URI_x86_64_v2_s-nail = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/s-nail-14.9.24-12.el10.x86_64_v2.rpm;name=x86_64_v2_s-nail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s-nail}"
SRC_URI[x86_64_v2_s-nail.sha256sum] = "13985f0993b1e3f4f096ab2f576dd59a44884ad41fe81ca4d6a3e17b54e8329a"

URI_aarch64_s-nail = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/s-nail-14.9.24-12.el10.aarch64.rpm;name=aarch64_s-nail;unpack=0"
SRC_URI:append = " ${URI_aarch64_s-nail}"
SRC_URI[aarch64_s-nail.sha256sum] = "b6419715aeb8853f00acd1cbf7626a3d14dffc2b07c3f159b4b12ca11e962c70"

RDEPENDS:s-nail = " \
 alternatives \
 bash \
 glibc \
 krb5-libs \
 libidn2 \
 ncurses-libs \
 openssl-libs \
 "
