# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dtoa"
PV = "1.0.11"
PR = "2.el10_3"
PACKAGES = " \
 rust-dtoa+default-devel \
 rust-dtoa+no-panic-devel \
 rust-dtoa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dtoa-1.0.11-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ded61643ebc4a3a9d10dedccc7031129418bbcb02e43c6f1004f4170fe8e371"

URI_x86_64_v2_rust-dtoa+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dtoa+default-devel-1.0.11-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dtoa+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dtoa+default-devel}"
SRC_URI[x86_64_v2_rust-dtoa+default-devel.sha256sum] = "e84e5325c26d8733cab533ce10332e04fa8703d7e13c3d3aff20dfb236f667e6"

URI_x86_64_v2_rust-dtoa+no-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dtoa+no-panic-devel-1.0.11-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dtoa+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dtoa+no-panic-devel}"
SRC_URI[x86_64_v2_rust-dtoa+no-panic-devel.sha256sum] = "47ccdba04272333ba55f07382d565750962724a10ffd6423ed4bf0eb0111077a"

URI_x86_64_v2_rust-dtoa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dtoa-devel-1.0.11-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dtoa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dtoa-devel}"
SRC_URI[x86_64_v2_rust-dtoa-devel.sha256sum] = "1358149ad737160360744027897259d8a77b98365dfff37de9bcaa129f4a536f"

URI_aarch64_rust-dtoa+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dtoa+default-devel-1.0.11-2.el10_3.noarch.rpm;name=aarch64_rust-dtoa+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dtoa+default-devel}"
SRC_URI[aarch64_rust-dtoa+default-devel.sha256sum] = "68c605f641c55b030f7b923359c04b17948d74f01ed2d7adecba800e9811aeb8"

URI_aarch64_rust-dtoa+no-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dtoa+no-panic-devel-1.0.11-2.el10_3.noarch.rpm;name=aarch64_rust-dtoa+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dtoa+no-panic-devel}"
SRC_URI[aarch64_rust-dtoa+no-panic-devel.sha256sum] = "6bf8c2d13d233550d74971270d54b657619051830ae6e123c0d50a102752010c"

URI_aarch64_rust-dtoa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dtoa-devel-1.0.11-2.el10_3.noarch.rpm;name=aarch64_rust-dtoa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dtoa-devel}"
SRC_URI[aarch64_rust-dtoa-devel.sha256sum] = "5a0a0c3c505f6cae839d984f695cc21649af1ab2bcde657e822cb3686b0ae75f"

RDEPENDS:rust-dtoa+default-devel = " \
 cargo \
 rust-dtoa-devel \
 "
RDEPENDS:rust-dtoa+no-panic-devel = " \
 cargo \
 rust-dtoa-devel \
 rust-no-panic+default-devel \
 "
RDEPENDS:rust-dtoa-devel = " \
 cargo \
 rust \
 "
