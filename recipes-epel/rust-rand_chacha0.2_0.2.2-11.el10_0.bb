# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_chacha0.2"
PV = "0.2.2"
PR = "11.el10_0"
PACKAGES = " \
 rust-rand_chacha0.2+default-devel \
 rust-rand_chacha0.2+simd-devel \
 rust-rand_chacha0.2+std-devel \
 rust-rand_chacha0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_chacha0.2-0.2.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2ba022ba98f5c34d0ebecf255a1c717ca2b95f695a9428608222fbb07ad0d09"

URI_x86_64_v2_rust-rand_chacha0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.2+default-devel-0.2.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.2+default-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.2+default-devel.sha256sum] = "09f5837e493f4311f337f5a16ad28e4600fb011435d11df7c4fcb9902931ec64"

URI_x86_64_v2_rust-rand_chacha0.2+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.2+simd-devel-0.2.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.2+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.2+simd-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.2+simd-devel.sha256sum] = "53e87a220b1a79848ddc7d39af45331729b02ec737d7144d5f3b2b67e5af0f25"

URI_x86_64_v2_rust-rand_chacha0.2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.2+std-devel-0.2.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.2+std-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.2+std-devel.sha256sum] = "17d0f249ce798b374c3864566e8dfd2a31545ff2b639fd20ffabe21d067bd758"

URI_x86_64_v2_rust-rand_chacha0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.2-devel-0.2.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.2-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.2-devel.sha256sum] = "90a423ca3a8a1d2f2056c3c25cc9c7db551b0eeb26ab6ab74800f261a57317e2"

URI_aarch64_rust-rand_chacha0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.2+default-devel-0.2.2-11.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.2+default-devel}"
SRC_URI[aarch64_rust-rand_chacha0.2+default-devel.sha256sum] = "2c055123b9fafa0c7bc7359a220804fe7f29252d648afee9eec3a5b7d90d96c0"

URI_aarch64_rust-rand_chacha0.2+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.2+simd-devel-0.2.2-11.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha0.2+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.2+simd-devel}"
SRC_URI[aarch64_rust-rand_chacha0.2+simd-devel.sha256sum] = "ea853c6359a4632f7a46475bb43e0ae76ead168539c17636c1f89ed94287c6ec"

URI_aarch64_rust-rand_chacha0.2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.2+std-devel-0.2.2-11.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha0.2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.2+std-devel}"
SRC_URI[aarch64_rust-rand_chacha0.2+std-devel.sha256sum] = "f852cebf3201502dbdbfa3043559c791aeb4d00be9622676ac43d99940d5af0b"

URI_aarch64_rust-rand_chacha0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.2-devel-0.2.2-11.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.2-devel}"
SRC_URI[aarch64_rust-rand_chacha0.2-devel.sha256sum] = "47b788cd7dafa961e3125fc4895731cfe1da960770790f7735c7ffe10d0195f3"

RDEPENDS:rust-rand_chacha0.2+default-devel = " \
 cargo \
 rust-rand_chacha0.2+simd-devel \
 rust-rand_chacha0.2+std-devel \
 rust-rand_chacha0.2-devel \
 "
RDEPENDS:rust-rand_chacha0.2+simd-devel = " \
 cargo \
 rust-rand_chacha0.2-devel \
 "
RDEPENDS:rust-rand_chacha0.2+std-devel = " \
 cargo \
 rust-ppv-lite86+std-devel \
 rust-rand_chacha0.2-devel \
 "
RDEPENDS:rust-rand_chacha0.2-devel = " \
 cargo \
 rust-ppv-lite86+simd-devel \
 rust-ppv-lite86-devel \
 rust-rand_core0.5+default-devel \
 "
