# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audiofile"
PE = "1"
PV = "0.3.6"
PR = "44.el10_2"
PACKAGES = " \
 audiofile \
 audiofile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/audiofile-0.3.6-44.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ed0875e36f76d3f4cd544d2a3139ab58ad5ff90ee85335be39200f35e5597c4"

URI_x86_64_v2_audiofile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiofile-0.3.6-44.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audiofile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audiofile}"
SRC_URI[x86_64_v2_audiofile.sha256sum] = "563eb12691f4653b7dfeeb05c015942f92cbc9e0f4a90f2e5df5a1dfd2c8cb47"

URI_x86_64_v2_audiofile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiofile-devel-0.3.6-44.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audiofile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audiofile-devel}"
SRC_URI[x86_64_v2_audiofile-devel.sha256sum] = "dc26860db0cb7db277c36ac0ef3b41f47cda6001e4d28523261e1f2174cc5b28"

URI_aarch64_audiofile = "${EPEL_MIRROR}/aarch64/Packages/a/audiofile-0.3.6-44.el10_2.aarch64.rpm;name=aarch64_audiofile;unpack=0"
SRC_URI:append = " ${URI_aarch64_audiofile}"
SRC_URI[aarch64_audiofile.sha256sum] = "4c1de855ad25749e1b6d642aafa310407e50c14eff44f1ed56451c3218ab7fef"

URI_aarch64_audiofile-devel = "${EPEL_MIRROR}/aarch64/Packages/a/audiofile-devel-0.3.6-44.el10_2.aarch64.rpm;name=aarch64_audiofile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_audiofile-devel}"
SRC_URI[aarch64_audiofile-devel.sha256sum] = "f26bc859e4e17a49c14f5c52125ad2932cd8a81031ace0454b3f2d527a6866ec"

RDEPENDS:audiofile = " \
 flac-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:audiofile-devel = " \
 audiofile \
 pkgconf-pkg-config \
 "
