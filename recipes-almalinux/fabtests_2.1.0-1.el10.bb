# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fabtests"
PV = "2.1.0"
PR = "1.el10"
PACKAGES = " \
 fabtests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/fabtests-2.1.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b2c19a5c6631e0407a2b08ad443e7bf53a799d0c5202debf2a9aab2afeeb9af"

URI_x86_64_v2_fabtests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fabtests-2.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_fabtests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fabtests}"
SRC_URI[x86_64_v2_fabtests.sha256sum] = "3220f89aa95f73616749565cd6f323f60a6ea98bed7f18e59ae25aeb86caae6f"

URI_aarch64_fabtests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fabtests-2.1.0-1.el10.aarch64.rpm;name=aarch64_fabtests;unpack=0"
SRC_URI:append = " ${URI_aarch64_fabtests}"
SRC_URI[aarch64_fabtests.sha256sum] = "0081d864a02c26a882c2f821b307a4242a12a4ef3ca55b0e17731ef3e6221e19"

RDEPENDS:fabtests = " \
 bash \
 glibc \
 libfabric \
 python3 \
 python3-pytest \
 ruby \
 "
