# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-oxipng"
PV = "9.1.5"
PR = "6.el10_3"
PACKAGES = " \
 oxipng \
 rust-oxipng+binary-devel \
 rust-oxipng+default-devel \
 rust-oxipng+filetime-devel \
 rust-oxipng+freestanding-devel \
 rust-oxipng+parallel-devel \
 rust-oxipng+sanity-checks-devel \
 rust-oxipng+system-libdeflate-devel \
 rust-oxipng+zopfli-devel \
 rust-oxipng-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-oxipng-9.1.5-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c9dab5b86e6216dbfbc7f40599a72c7537b8eae57c19a8856ee5fd55b556d4c"

URI_x86_64_v2_oxipng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxipng-9.1.5-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oxipng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oxipng}"
SRC_URI[x86_64_v2_oxipng.sha256sum] = "bf4a5abc438556554073b84285cc642cdcfcc5c5c0ebcd2fe2c757fab1730e53"

URI_x86_64_v2_rust-oxipng+binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+binary-devel-9.1.5-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+binary-devel}"
SRC_URI[x86_64_v2_rust-oxipng+binary-devel.sha256sum] = "5cc0f6dbcaca8664524ebdf70bd595b6f91af9316ce36331e5b247479fb783f4"

URI_x86_64_v2_rust-oxipng+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+default-devel-9.1.5-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+default-devel}"
SRC_URI[x86_64_v2_rust-oxipng+default-devel.sha256sum] = "93b2f1f03ed4394c1160d633f6897a90ca71aa2d6b2ccd1658d030497f8a637b"

URI_x86_64_v2_rust-oxipng+filetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+filetime-devel-9.1.5-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+filetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+filetime-devel}"
SRC_URI[x86_64_v2_rust-oxipng+filetime-devel.sha256sum] = "7552fe844b9b43635efa1c0c529932f018bbe05c215c9a45641d69fb68bfacc6"

URI_x86_64_v2_rust-oxipng+freestanding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+freestanding-devel-9.1.5-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+freestanding-devel}"
SRC_URI[x86_64_v2_rust-oxipng+freestanding-devel.sha256sum] = "4f456d1d20584ef5b4f268e3533ece93df2d95a080e54a9f97725638447906c2"

URI_x86_64_v2_rust-oxipng+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+parallel-devel-9.1.5-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+parallel-devel}"
SRC_URI[x86_64_v2_rust-oxipng+parallel-devel.sha256sum] = "e3aa31dae43d40effb476d3326fae3252f9c4dc64fecd923fd9ce85be63a7b35"

URI_x86_64_v2_rust-oxipng+sanity-checks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+sanity-checks-devel-9.1.5-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+sanity-checks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+sanity-checks-devel}"
SRC_URI[x86_64_v2_rust-oxipng+sanity-checks-devel.sha256sum] = "7d1675d5060621ebbed185b5eebf046314d3555f425ac25194981f5f177fe825"

URI_x86_64_v2_rust-oxipng+system-libdeflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+system-libdeflate-devel-9.1.5-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+system-libdeflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+system-libdeflate-devel}"
SRC_URI[x86_64_v2_rust-oxipng+system-libdeflate-devel.sha256sum] = "6a2f23a0fcddae33312b015c509513873e6b9a19270c08a1115ff2da2e756761"

URI_x86_64_v2_rust-oxipng+zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+zopfli-devel-9.1.5-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+zopfli-devel}"
SRC_URI[x86_64_v2_rust-oxipng+zopfli-devel.sha256sum] = "a9d8f79e4226bf7fa2aecfb64f286ea98914aa352844df6a0a9d1c35c14888e4"

URI_x86_64_v2_rust-oxipng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng-devel-9.1.5-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng-devel}"
SRC_URI[x86_64_v2_rust-oxipng-devel.sha256sum] = "4c72c87d79f778aab2e8ad2b3ab4db5da20764ea895738b5dd6a735a9074d0f9"

URI_aarch64_oxipng = "${EPEL_MIRROR}/aarch64/Packages/o/oxipng-9.1.5-6.el10_3.aarch64.rpm;name=aarch64_oxipng;unpack=0"
SRC_URI:append = " ${URI_aarch64_oxipng}"
SRC_URI[aarch64_oxipng.sha256sum] = "6d72910c6829d015f0c1424dffe5254ac831db5b6fce4d81b3aa5ced0d9057ad"

URI_aarch64_rust-oxipng+binary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+binary-devel-9.1.5-6.el10_3.noarch.rpm;name=aarch64_rust-oxipng+binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+binary-devel}"
SRC_URI[aarch64_rust-oxipng+binary-devel.sha256sum] = "39fda06f11ccf326ee222be69e80887d034be361ad8aebc29ee699d4a900e12b"

URI_aarch64_rust-oxipng+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+default-devel-9.1.5-6.el10_3.noarch.rpm;name=aarch64_rust-oxipng+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+default-devel}"
SRC_URI[aarch64_rust-oxipng+default-devel.sha256sum] = "6540c64196b2744619e1b19420e63b7242d86d0f83e599ba4c1d0f094002e102"

URI_aarch64_rust-oxipng+filetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+filetime-devel-9.1.5-6.el10_3.noarch.rpm;name=aarch64_rust-oxipng+filetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+filetime-devel}"
SRC_URI[aarch64_rust-oxipng+filetime-devel.sha256sum] = "0519af5b219f7271606796061ed6c96c8691c6d2603428ce4a3e0d58bcbba9e0"

URI_aarch64_rust-oxipng+freestanding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+freestanding-devel-9.1.5-6.el10_3.noarch.rpm;name=aarch64_rust-oxipng+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+freestanding-devel}"
SRC_URI[aarch64_rust-oxipng+freestanding-devel.sha256sum] = "01dcd4aa6b33529e8be0a398c896cd90c02626ea2ebd49a7e965ae9e979a38d8"

URI_aarch64_rust-oxipng+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+parallel-devel-9.1.5-6.el10_3.noarch.rpm;name=aarch64_rust-oxipng+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+parallel-devel}"
SRC_URI[aarch64_rust-oxipng+parallel-devel.sha256sum] = "4d3ad6c9a53e1903fa05e7ffe1a45611f16dc0330bc8d5758f27933fa5bc5d29"

URI_aarch64_rust-oxipng+sanity-checks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+sanity-checks-devel-9.1.5-6.el10_3.noarch.rpm;name=aarch64_rust-oxipng+sanity-checks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+sanity-checks-devel}"
SRC_URI[aarch64_rust-oxipng+sanity-checks-devel.sha256sum] = "36bc8ff6340ca7bab9c690138f15d053b8e912d72e365dd3b3f5e6025881c3c7"

URI_aarch64_rust-oxipng+system-libdeflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+system-libdeflate-devel-9.1.5-6.el10_3.noarch.rpm;name=aarch64_rust-oxipng+system-libdeflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+system-libdeflate-devel}"
SRC_URI[aarch64_rust-oxipng+system-libdeflate-devel.sha256sum] = "d475802f7df781fff25f93fec8bc840d0453d577782d6e1f6cb8a3fb91e43f13"

URI_aarch64_rust-oxipng+zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+zopfli-devel-9.1.5-6.el10_3.noarch.rpm;name=aarch64_rust-oxipng+zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+zopfli-devel}"
SRC_URI[aarch64_rust-oxipng+zopfli-devel.sha256sum] = "3dfacd5fac8c4139941bfe8e3d31d1ca384184834e152c1453389bf46a1798ea"

URI_aarch64_rust-oxipng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng-devel-9.1.5-6.el10_3.noarch.rpm;name=aarch64_rust-oxipng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng-devel}"
SRC_URI[aarch64_rust-oxipng-devel.sha256sum] = "595c876bc8b96b35940dbafe33c5c293d48b17238e4ca745cbf4b55781c33b99"

RDEPENDS:oxipng = " \
 glibc \
 libdeflate \
 libgcc \
 "
RDEPENDS:rust-oxipng+binary-devel = " \
 cargo \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-env_logger+auto-color-devel \
 rust-env_logger-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+default-devel = " \
 cargo \
 rust-oxipng+binary-devel \
 rust-oxipng+filetime-devel \
 rust-oxipng+parallel-devel \
 rust-oxipng+zopfli-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+filetime-devel = " \
 cargo \
 rust-filetime+default-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+freestanding-devel = " \
 cargo \
 rust-libdeflater+freestanding-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+parallel-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-indexmap+rayon-devel \
 rust-oxipng-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-oxipng+sanity-checks-devel = " \
 cargo \
 rust-image+png-devel \
 rust-image-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+system-libdeflate-devel = " \
 cargo \
 rust-libdeflater+dynamic-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+zopfli-devel = " \
 cargo \
 rust-oxipng-devel \
 rust-zopfli+std-devel \
 rust-zopfli+zlib-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-oxipng-devel = " \
 cargo \
 rust \
 rust-bitvec+default-devel \
 rust-indexmap+default-devel \
 rust-libdeflater+default-devel \
 rust-log+default-devel \
 rust-rgb+default-devel \
 rust-rustc-hash+default-devel \
 "
