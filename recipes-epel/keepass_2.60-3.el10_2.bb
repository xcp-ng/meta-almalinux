# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keepass"
PV = "2.60"
PR = "3.el10_2"
PACKAGES = " \
 keepass \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keepass-2.60-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db99722c7bfe8dd840c893282776af99b1b84ffb9fecb9982b23b1df5c2bfd6d"

URI_x86_64_v2_keepass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keepass-2.60-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keepass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keepass}"
SRC_URI[x86_64_v2_keepass.sha256sum] = "f12ed9b2a1bd5a540f9e34b8a14ea09bc8987bcbc14a0e72575042b975dd0b33"

URI_aarch64_keepass = "${EPEL_MIRROR}/aarch64/Packages/k/keepass-2.60-3.el10_2.aarch64.rpm;name=aarch64_keepass;unpack=0"
SRC_URI:append = " ${URI_aarch64_keepass}"
SRC_URI[aarch64_keepass.sha256sum] = "71bfe9c31483c961a438825977bab5e0fe30228165e6e6044d145946ca8b76b2"

RDEPENDS:keepass = " \
 bash \
 hicolor-icon-theme \
 mono-core \
 mono-winforms \
 xsel \
 "
