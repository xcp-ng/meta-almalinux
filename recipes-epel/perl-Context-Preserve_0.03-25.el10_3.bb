# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Context-Preserve"
PV = "0.03"
PR = "25.el10_3"
PACKAGES = " \
 perl-Context-Preserve \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Context-Preserve-0.03-25.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "148494449a776c99e895a1b9af37aeeb1709b21df76260acc62b240b7cb15e51"

URI_x86_64_v2_perl-Context-Preserve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Context-Preserve-0.03-25.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Context-Preserve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Context-Preserve}"
SRC_URI[x86_64_v2_perl-Context-Preserve.sha256sum] = "af58f194880ba9087161aa69de346ba016596c4a78bc39780259039a22dc4559"

URI_aarch64_perl-Context-Preserve = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Context-Preserve-0.03-25.el10_3.noarch.rpm;name=aarch64_perl-Context-Preserve;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Context-Preserve}"
SRC_URI[aarch64_perl-Context-Preserve.sha256sum] = "0e8452b16457d0637ed51eb69737d044acb3488ac1d4f9162246d80618ea4dd9"

RDEPENDS:perl-Context-Preserve = " \
 perl-Carp \
 perl-Exporter \
 perl-base \
 perl-libs \
 "
