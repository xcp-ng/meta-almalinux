# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libssh"
PV = "0.12.0"
PR = "2.el10"
PACKAGES = " \
 libssh \
 libssh-config \
 libssh-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libssh-0.12.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86015bce8d539be35b4d8227cd7dd08cfba4b7c869ff81da2829fdf052b73240"

URI_x86_64_v2_libssh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libssh-0.12.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh}"
SRC_URI[x86_64_v2_libssh.sha256sum] = "c96367464b677f983781b11df03e041beb29e2931362281b97643e8c668b972d"

URI_x86_64_v2_libssh-config = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libssh-config-0.12.0-2.el10.noarch.rpm;name=x86_64_v2_libssh-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh-config}"
SRC_URI[x86_64_v2_libssh-config.sha256sum] = "c135864c89e79627744281f8c685d0a001a881683e217ae1e018d595ac7a2ed6"

URI_x86_64_v2_libssh-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libssh-devel-0.12.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh-devel}"
SRC_URI[x86_64_v2_libssh-devel.sha256sum] = "9a924029044043e06690f1cd3c2851532acdab730fc6bd2e98a91c0687a774be"

URI_aarch64_libssh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libssh-0.12.0-2.el10.aarch64.rpm;name=aarch64_libssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh}"
SRC_URI[aarch64_libssh.sha256sum] = "047c4f1539fbef35fcdef2cacd407e9afcc8a439ac36b5d1b2a7587b606e3f2d"

URI_aarch64_libssh-config = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libssh-config-0.12.0-2.el10.noarch.rpm;name=aarch64_libssh-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh-config}"
SRC_URI[aarch64_libssh-config.sha256sum] = "c135864c89e79627744281f8c685d0a001a881683e217ae1e018d595ac7a2ed6"

URI_aarch64_libssh-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libssh-devel-0.12.0-2.el10.aarch64.rpm;name=aarch64_libssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh-devel}"
SRC_URI[aarch64_libssh-devel.sha256sum] = "bee69410179120b2d2baf974a4433d2c54693a639d7f4cad2f251e02b4b62910"

RDEPENDS:libssh = " \
 crypto-policies \
 glibc \
 krb5-libs \
 libfido2 \
 libssh-config \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libssh-config = " \
 "
RDEPENDS:libssh-devel = " \
 cmake-filesystem \
 krb5-devel \
 libssh \
 pkgconf-pkg-config \
 "
