# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lskat"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 lskat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lskat-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8ebb279ee607792d8af2c81d10d11df1497982552a2ca229b6e27dd2675f8a0"

URI_x86_64_v2_lskat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lskat-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lskat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lskat}"
SRC_URI[x86_64_v2_lskat.sha256sum] = "d351c8c6d99438d09b9b5c5e0005699f62f374c83a5bc89df905b6977f83eb1b"

URI_aarch64_lskat = "${EPEL_MIRROR}/aarch64/Packages/l/lskat-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_lskat;unpack=0"
SRC_URI:append = " ${URI_aarch64_lskat}"
SRC_URI[aarch64_lskat.sha256sum] = "b2df20055f62b8a964526ed0224ece650ac0c65ab380192a67add03ea4082cd9"

RDEPENDS:lskat = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
