# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksane"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 libksane \
 libksane-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libksane-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76f0c3195e3051968b09de4c72564f16df0fad76b13b10a6f69fb0017d2b997c"

URI_x86_64_v2_libksane = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksane-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksane;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksane}"
SRC_URI[x86_64_v2_libksane.sha256sum] = "8441315b09bc926021ee0a349ca183917881217aeb4e9a9a5ab1351d0342a5a1"

URI_x86_64_v2_libksane-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksane-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksane-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksane-devel}"
SRC_URI[x86_64_v2_libksane-devel.sha256sum] = "90913bfebef8471e0af5f1c28810ddf03d2161ae579ca4f9b566274f517bb1b4"

URI_aarch64_libksane = "${EPEL_MIRROR}/aarch64/Packages/l/libksane-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libksane;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksane}"
SRC_URI[aarch64_libksane.sha256sum] = "741a10d188002e84af64726969d693dee902159532ee823323727efc22d5b6c8"

URI_aarch64_libksane-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libksane-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libksane-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksane-devel}"
SRC_URI[aarch64_libksane-devel.sha256sum] = "be05e5076176a6868cf0cf307c7754b0d3a05ec5f02bd1eb772cbe7a7c1579f8"

RDEPENDS:libksane = " \
 glibc \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 ksanecore \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libksane-devel = " \
 cmake-filesystem \
 libksane \
 qt6-qtbase-devel \
 "
