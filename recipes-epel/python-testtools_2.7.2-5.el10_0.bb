# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-testtools"
PV = "2.7.2"
PR = "5.el10_0"
PACKAGES = " \
 python-testtools-doc \
 python3-testtools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-testtools-2.7.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31fabb4a6479766ad952b3d4d83c46b09940d999832df170ec0d74bc579222a2"

URI_x86_64_v2_python-testtools-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-testtools-doc-2.7.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-testtools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-testtools-doc}"
SRC_URI[x86_64_v2_python-testtools-doc.sha256sum] = "baf828d7d6acd98e66db35951a2596140b6ab8ff2137952e74e2bbf7aa95bba0"

URI_x86_64_v2_python3-testtools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-testtools-2.7.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-testtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-testtools}"
SRC_URI[x86_64_v2_python3-testtools.sha256sum] = "bc64731c25ad7afa07c0c5e76a73fd13a73c508a8c712a5a4ac6cf43af62f214"

URI_aarch64_python-testtools-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-testtools-doc-2.7.2-5.el10_0.noarch.rpm;name=aarch64_python-testtools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-testtools-doc}"
SRC_URI[aarch64_python-testtools-doc.sha256sum] = "ce1e93f72ca1fb90313b55f8ed7a01a00f1faad427cf02eef763336819af6efd"

URI_aarch64_python3-testtools = "${EPEL_MIRROR}/aarch64/Packages/p/python3-testtools-2.7.2-5.el10_0.noarch.rpm;name=aarch64_python3-testtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-testtools}"
SRC_URI[aarch64_python3-testtools.sha256sum] = "e3e7b70d4719731fdc5dadab5530c23de2d1f7a86ec302e820c0d1e2050f34a4"

RDEPENDS:python-testtools-doc = " \
 "
RDEPENDS:python3-testtools = " \
 python3 \
 python3-setuptools \
 "
