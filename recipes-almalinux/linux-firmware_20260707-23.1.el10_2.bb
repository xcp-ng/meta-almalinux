# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linux-firmware"
PV = "20260707"
PR = "23.1.el10_2"
PACKAGES = " \
 amd-gpu-firmware \
 amd-ucode-firmware \
 atheros-firmware \
 brcmfmac-firmware \
 cirrus-audio-firmware \
 dvb-firmware \
 intel-audio-firmware \
 intel-gpu-firmware \
 intel-vsc-firmware \
 iwlegacy-firmware \
 iwlwifi-dvm-firmware \
 iwlwifi-mvm-firmware \
 libertas-firmware \
 linux-firmware \
 linux-firmware-whence \
 mlxsw_spectrum-firmware \
 mrvlprestera-firmware \
 mt7xxx-firmware \
 netronome-firmware \
 nvidia-gpu-firmware \
 nxpwireless-firmware \
 qcom-firmware \
 realtek-firmware \
 tiwilink-firmware \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/linux-firmware-20260707-23.1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb6105f24a0b0ca9ef42653a18b494798f7508d500c322ae39fc7e29cffec023"

URI_x86_64_v2_amd-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/amd-gpu-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_amd-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amd-gpu-firmware}"
SRC_URI[x86_64_v2_amd-gpu-firmware.sha256sum] = "5f07db0e170be2d458c8a4a370f95782b8a97b7fdc9820ff5a8f0178ca061f40"

URI_x86_64_v2_amd-ucode-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/amd-ucode-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_amd-ucode-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amd-ucode-firmware}"
SRC_URI[x86_64_v2_amd-ucode-firmware.sha256sum] = "445ba3bbe23ed73b1ab97de1943746593efe58c93fad50c6bb9f7f0e4c851167"

URI_x86_64_v2_atheros-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/atheros-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_atheros-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atheros-firmware}"
SRC_URI[x86_64_v2_atheros-firmware.sha256sum] = "7e3170a97efe2df1780ba32e0c7db202ce2ca7181dab8664e920ebb2d7224402"

URI_x86_64_v2_brcmfmac-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/brcmfmac-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_brcmfmac-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brcmfmac-firmware}"
SRC_URI[x86_64_v2_brcmfmac-firmware.sha256sum] = "38525f586f3159c34f483eb430dae4e68019d0d9bad5b7bc23c884216e3305aa"

URI_x86_64_v2_cirrus-audio-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cirrus-audio-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_cirrus-audio-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cirrus-audio-firmware}"
SRC_URI[x86_64_v2_cirrus-audio-firmware.sha256sum] = "2b8ac8faf775d75fc8b8eeff921c7b1bb5e7093c565379acf5d7aa7884d4b366"

URI_x86_64_v2_dvb-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dvb-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_dvb-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dvb-firmware}"
SRC_URI[x86_64_v2_dvb-firmware.sha256sum] = "0e804148ce43208be8783907c23997d89bd86e905d153574640a6bbb849d76aa"

URI_x86_64_v2_intel-audio-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-audio-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_intel-audio-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-audio-firmware}"
SRC_URI[x86_64_v2_intel-audio-firmware.sha256sum] = "b885fd5cb572cc2cb4d2a71728a5190a23ef03770dd0b38bfc7db93866cd9bc5"

URI_x86_64_v2_intel-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/intel-gpu-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_intel-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-gpu-firmware}"
SRC_URI[x86_64_v2_intel-gpu-firmware.sha256sum] = "13e68fbbbe4abbb0a7499e457d8c0d1bb4ed72c633bb5bcac0986a6469370961"

URI_x86_64_v2_intel-vsc-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-vsc-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_intel-vsc-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-vsc-firmware}"
SRC_URI[x86_64_v2_intel-vsc-firmware.sha256sum] = "a31a83b835d093b6f90ee78c0a56c97e80b5f95f273a783b84b99d5f0a0d8bd8"

URI_x86_64_v2_iwlegacy-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlegacy-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_iwlegacy-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iwlegacy-firmware}"
SRC_URI[x86_64_v2_iwlegacy-firmware.sha256sum] = "475c6e3225c5b03db69d92dcc79d994274dc103f138c55a03de1312c95724508"

URI_x86_64_v2_iwlwifi-dvm-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlwifi-dvm-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_iwlwifi-dvm-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iwlwifi-dvm-firmware}"
SRC_URI[x86_64_v2_iwlwifi-dvm-firmware.sha256sum] = "ee6789839eef9119c1964b74ac1528dbfab15e2ca182fdfdd2e44b4cc191d748"

URI_x86_64_v2_iwlwifi-mvm-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlwifi-mvm-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_iwlwifi-mvm-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iwlwifi-mvm-firmware}"
SRC_URI[x86_64_v2_iwlwifi-mvm-firmware.sha256sum] = "7f58bf1f7ef91daa3f845ee8060bcbe6aedf72aa862d6cbe5b96bf524b2c2050"

URI_x86_64_v2_libertas-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libertas-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_libertas-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libertas-firmware}"
SRC_URI[x86_64_v2_libertas-firmware.sha256sum] = "6377967d34796f8865ed975858b5bfe1ba8733df500b1afb2b2cbb27a228a219"

URI_x86_64_v2_linux-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/linux-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_linux-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linux-firmware}"
SRC_URI[x86_64_v2_linux-firmware.sha256sum] = "3337d08154579867f584ef97cc701db45a4623102a6dcf0e34ddda0db81da777"

URI_x86_64_v2_linux-firmware-whence = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/linux-firmware-whence-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_linux-firmware-whence;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linux-firmware-whence}"
SRC_URI[x86_64_v2_linux-firmware-whence.sha256sum] = "8bf930c878035a4e38e0a2923696474ebfa1998c71848632eb38bc047b5ece14"

URI_x86_64_v2_mlxsw_spectrum-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mlxsw_spectrum-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_mlxsw_spectrum-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mlxsw_spectrum-firmware}"
SRC_URI[x86_64_v2_mlxsw_spectrum-firmware.sha256sum] = "e1834e6d3e46e1a302c46ccfb51995b1a5dd5063ca52eb12250bc45397d2b9ef"

URI_x86_64_v2_mrvlprestera-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mrvlprestera-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_mrvlprestera-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrvlprestera-firmware}"
SRC_URI[x86_64_v2_mrvlprestera-firmware.sha256sum] = "224adbe251a1c435de0f4c92865cf6ea6d4e17a83cb074a402aa90b311103a20"

URI_x86_64_v2_mt7xxx-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mt7xxx-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_mt7xxx-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mt7xxx-firmware}"
SRC_URI[x86_64_v2_mt7xxx-firmware.sha256sum] = "22a3ebeb76bacd803db12ca3d79b0ddf5d1017182848832316bdbbabd9b58c1b"

URI_x86_64_v2_netronome-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/netronome-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_netronome-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netronome-firmware}"
SRC_URI[x86_64_v2_netronome-firmware.sha256sum] = "517ff6108d9e35fd175f24b6e7f9f72474611eaf3e7307eb8eabd15c2c6878d2"

URI_x86_64_v2_nvidia-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nvidia-gpu-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_nvidia-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nvidia-gpu-firmware}"
SRC_URI[x86_64_v2_nvidia-gpu-firmware.sha256sum] = "e3775c9229a35bee154ac14dd7413302843a8437ad4a31350a636f23d2d9e060"

URI_x86_64_v2_nxpwireless-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nxpwireless-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_nxpwireless-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nxpwireless-firmware}"
SRC_URI[x86_64_v2_nxpwireless-firmware.sha256sum] = "29b2e89301212df1d67994965d96343a5a72273093a2586693ac0ad880b659ac"

URI_x86_64_v2_qcom-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/qcom-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_qcom-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcom-firmware}"
SRC_URI[x86_64_v2_qcom-firmware.sha256sum] = "a90e62d55efcaec0236096b5bd0132899b7d1729b29aa657200c9e05fe504604"

URI_x86_64_v2_realtek-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/realtek-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_realtek-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_realtek-firmware}"
SRC_URI[x86_64_v2_realtek-firmware.sha256sum] = "ba06331c00e84cc8a8e232e02f347409565db3fd4a1f516bf55f8fe03150a35e"

URI_x86_64_v2_tiwilink-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tiwilink-firmware-20260707-23.1.el10_2.noarch.rpm;name=x86_64_v2_tiwilink-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tiwilink-firmware}"
SRC_URI[x86_64_v2_tiwilink-firmware.sha256sum] = "5660a5b52c841f4297a18f40608fd74ac208a6264c18e5429c8383231ef451b8"

URI_aarch64_amd-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/amd-gpu-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_amd-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_amd-gpu-firmware}"
SRC_URI[aarch64_amd-gpu-firmware.sha256sum] = "5f07db0e170be2d458c8a4a370f95782b8a97b7fdc9820ff5a8f0178ca061f40"

URI_aarch64_amd-ucode-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/amd-ucode-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_amd-ucode-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_amd-ucode-firmware}"
SRC_URI[aarch64_amd-ucode-firmware.sha256sum] = "445ba3bbe23ed73b1ab97de1943746593efe58c93fad50c6bb9f7f0e4c851167"

URI_aarch64_atheros-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/atheros-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_atheros-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_atheros-firmware}"
SRC_URI[aarch64_atheros-firmware.sha256sum] = "7e3170a97efe2df1780ba32e0c7db202ce2ca7181dab8664e920ebb2d7224402"

URI_aarch64_brcmfmac-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/brcmfmac-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_brcmfmac-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_brcmfmac-firmware}"
SRC_URI[aarch64_brcmfmac-firmware.sha256sum] = "38525f586f3159c34f483eb430dae4e68019d0d9bad5b7bc23c884216e3305aa"

URI_aarch64_cirrus-audio-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cirrus-audio-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_cirrus-audio-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_cirrus-audio-firmware}"
SRC_URI[aarch64_cirrus-audio-firmware.sha256sum] = "2b8ac8faf775d75fc8b8eeff921c7b1bb5e7093c565379acf5d7aa7884d4b366"

URI_aarch64_dvb-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dvb-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_dvb-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_dvb-firmware}"
SRC_URI[aarch64_dvb-firmware.sha256sum] = "0e804148ce43208be8783907c23997d89bd86e905d153574640a6bbb849d76aa"

URI_aarch64_intel-audio-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/intel-audio-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_intel-audio-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-audio-firmware}"
SRC_URI[aarch64_intel-audio-firmware.sha256sum] = "b885fd5cb572cc2cb4d2a71728a5190a23ef03770dd0b38bfc7db93866cd9bc5"

URI_aarch64_intel-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/intel-gpu-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_intel-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-gpu-firmware}"
SRC_URI[aarch64_intel-gpu-firmware.sha256sum] = "13e68fbbbe4abbb0a7499e457d8c0d1bb4ed72c633bb5bcac0986a6469370961"

URI_aarch64_intel-vsc-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/intel-vsc-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_intel-vsc-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-vsc-firmware}"
SRC_URI[aarch64_intel-vsc-firmware.sha256sum] = "a31a83b835d093b6f90ee78c0a56c97e80b5f95f273a783b84b99d5f0a0d8bd8"

URI_aarch64_iwlegacy-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlegacy-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_iwlegacy-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_iwlegacy-firmware}"
SRC_URI[aarch64_iwlegacy-firmware.sha256sum] = "475c6e3225c5b03db69d92dcc79d994274dc103f138c55a03de1312c95724508"

URI_aarch64_iwlwifi-dvm-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlwifi-dvm-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_iwlwifi-dvm-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_iwlwifi-dvm-firmware}"
SRC_URI[aarch64_iwlwifi-dvm-firmware.sha256sum] = "ee6789839eef9119c1964b74ac1528dbfab15e2ca182fdfdd2e44b4cc191d748"

URI_aarch64_iwlwifi-mvm-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlwifi-mvm-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_iwlwifi-mvm-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_iwlwifi-mvm-firmware}"
SRC_URI[aarch64_iwlwifi-mvm-firmware.sha256sum] = "7f58bf1f7ef91daa3f845ee8060bcbe6aedf72aa862d6cbe5b96bf524b2c2050"

URI_aarch64_libertas-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libertas-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_libertas-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_libertas-firmware}"
SRC_URI[aarch64_libertas-firmware.sha256sum] = "6377967d34796f8865ed975858b5bfe1ba8733df500b1afb2b2cbb27a228a219"

URI_aarch64_linux-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/linux-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_linux-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_linux-firmware}"
SRC_URI[aarch64_linux-firmware.sha256sum] = "3337d08154579867f584ef97cc701db45a4623102a6dcf0e34ddda0db81da777"

URI_aarch64_linux-firmware-whence = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/linux-firmware-whence-20260707-23.1.el10_2.noarch.rpm;name=aarch64_linux-firmware-whence;unpack=0"
SRC_URI:append = " ${URI_aarch64_linux-firmware-whence}"
SRC_URI[aarch64_linux-firmware-whence.sha256sum] = "8bf930c878035a4e38e0a2923696474ebfa1998c71848632eb38bc047b5ece14"

URI_aarch64_mlxsw_spectrum-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mlxsw_spectrum-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_mlxsw_spectrum-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_mlxsw_spectrum-firmware}"
SRC_URI[aarch64_mlxsw_spectrum-firmware.sha256sum] = "e1834e6d3e46e1a302c46ccfb51995b1a5dd5063ca52eb12250bc45397d2b9ef"

URI_aarch64_mrvlprestera-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mrvlprestera-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_mrvlprestera-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrvlprestera-firmware}"
SRC_URI[aarch64_mrvlprestera-firmware.sha256sum] = "224adbe251a1c435de0f4c92865cf6ea6d4e17a83cb074a402aa90b311103a20"

URI_aarch64_mt7xxx-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mt7xxx-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_mt7xxx-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_mt7xxx-firmware}"
SRC_URI[aarch64_mt7xxx-firmware.sha256sum] = "22a3ebeb76bacd803db12ca3d79b0ddf5d1017182848832316bdbbabd9b58c1b"

URI_aarch64_netronome-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/netronome-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_netronome-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_netronome-firmware}"
SRC_URI[aarch64_netronome-firmware.sha256sum] = "517ff6108d9e35fd175f24b6e7f9f72474611eaf3e7307eb8eabd15c2c6878d2"

URI_aarch64_nvidia-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nvidia-gpu-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_nvidia-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_nvidia-gpu-firmware}"
SRC_URI[aarch64_nvidia-gpu-firmware.sha256sum] = "e3775c9229a35bee154ac14dd7413302843a8437ad4a31350a636f23d2d9e060"

URI_aarch64_nxpwireless-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nxpwireless-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_nxpwireless-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_nxpwireless-firmware}"
SRC_URI[aarch64_nxpwireless-firmware.sha256sum] = "29b2e89301212df1d67994965d96343a5a72273093a2586693ac0ad880b659ac"

URI_aarch64_qcom-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/qcom-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_qcom-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcom-firmware}"
SRC_URI[aarch64_qcom-firmware.sha256sum] = "a90e62d55efcaec0236096b5bd0132899b7d1729b29aa657200c9e05fe504604"

URI_aarch64_realtek-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/realtek-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_realtek-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_realtek-firmware}"
SRC_URI[aarch64_realtek-firmware.sha256sum] = "ba06331c00e84cc8a8e232e02f347409565db3fd4a1f516bf55f8fe03150a35e"

URI_aarch64_tiwilink-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tiwilink-firmware-20260707-23.1.el10_2.noarch.rpm;name=aarch64_tiwilink-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_tiwilink-firmware}"
SRC_URI[aarch64_tiwilink-firmware.sha256sum] = "5660a5b52c841f4297a18f40608fd74ac208a6264c18e5429c8383231ef451b8"

RDEPENDS:amd-gpu-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:amd-ucode-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:atheros-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:brcmfmac-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:cirrus-audio-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:dvb-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-audio-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-gpu-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-vsc-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlegacy-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlwifi-dvm-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlwifi-mvm-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:libertas-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:linux-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:linux-firmware-whence = " \
 "
RDEPENDS:mlxsw_spectrum-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:mrvlprestera-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:mt7xxx-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:netronome-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:nvidia-gpu-firmware = " \
 linux-firmware \
 linux-firmware-whence \
 "
RDEPENDS:nxpwireless-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:qcom-firmware = " \
 atheros-firmware \
 linux-firmware-whence \
 "
RDEPENDS:realtek-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:tiwilink-firmware = " \
 linux-firmware-whence \
 "
