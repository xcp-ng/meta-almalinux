# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-blur-my-shell"
PV = "67"
PR = "1.el10_0"
PACKAGES = " \
 gnome-shell-extension-blur-my-shell \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-shell-extension-blur-my-shell-67-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c36a02f7c86f95318250e19dd95bd96261cef9f7658a2043510c484c88bd0cd"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - gnome-shell-extension-blur-my-shell: gnome-shell >= 46

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - gnome-shell-extension-blur-my-shell: gnome-shell >= 46

URI_x86_64_v2_gnome-shell-extension-blur-my-shell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-shell-extension-blur-my-shell-67-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-shell-extension-blur-my-shell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-blur-my-shell}"
SRC_URI[x86_64_v2_gnome-shell-extension-blur-my-shell.sha256sum] = "62be31e4261ed79fc96be265b0ff1af07a057ad55efdead178f11829627c16b5"

URI_aarch64_gnome-shell-extension-blur-my-shell = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-shell-extension-blur-my-shell-67-1.el10_0.noarch.rpm;name=aarch64_gnome-shell-extension-blur-my-shell;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-blur-my-shell}"
SRC_URI[aarch64_gnome-shell-extension-blur-my-shell.sha256sum] = "3f947aa2bf0dbe77bd7535db0f01422cd8a92581ba7f96f2b0e69fb6aecd7a6b"

RDEPENDS:gnome-shell-extension-blur-my-shell = " \
 "
