# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-specfile"
PV = "0.41.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-specfile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-specfile-0.41.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36ceb3c6ed7632d6a559fea4b76008ea2f5ea3e37b73a87afc4672f49121df0a"

URI_x86_64_v2_python3-specfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-specfile-0.41.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-specfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-specfile}"
SRC_URI[x86_64_v2_python3-specfile.sha256sum] = "6b71d627f40b1e0bc590c3bca4dde718a25d99614f578cd716b0cff9e6628e91"

URI_aarch64_python3-specfile = "${EPEL_MIRROR}/aarch64/Packages/p/python3-specfile-0.41.1-1.el10_2.noarch.rpm;name=aarch64_python3-specfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-specfile}"
SRC_URI[aarch64_python3-specfile.sha256sum] = "76bdccfe4fc7ac72bfa432b13f908988a1b89ac73b17ed1a1db3baab81c4a74a"

RDEPENDS:python3-specfile = " \
 python3 \
 python3-rpm \
 "
