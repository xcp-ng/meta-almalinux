# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "binutils"
PV = "2.41"
PR = "63.el10.alma.1"
PACKAGES = " \
 binutils \
 binutils-devel \
 binutils-gold \
 binutils-gprofng \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/binutils-2.41-63.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2abe515286449e508e9fc303bf18085e8f4cba18ff0bbc3b6b0e593244fb07e"

URI_x86_64_v2_binutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/binutils-2.41-63.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils}"
SRC_URI[x86_64_v2_binutils.sha256sum] = "8ebe266002df27ea80291732b2225bbb8588f86f623eddda1d5ababa85b6b99f"
RPROVIDES:binutils:x86_64_v2 = "virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_ virtual/libgprofng.so.0___64bit_ virtual/libsframe.so.1___64bit_"

URI_x86_64_v2_binutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/binutils-devel-2.41-63.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-devel}"
SRC_URI[x86_64_v2_binutils-devel.sha256sum] = "e3345c3c2e147da064805809b636e7e76449a9871355245da12f484c3d096cfc"

URI_x86_64_v2_binutils-gold = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/binutils-gold-2.41-63.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils-gold;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-gold}"
SRC_URI[x86_64_v2_binutils-gold.sha256sum] = "245c97ee29d663cd6ac0d7f51b2180665cdd15cb05ba701a4deb9f7b0ee8aeb8"

URI_x86_64_v2_binutils-gprofng = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/binutils-gprofng-2.41-63.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils-gprofng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-gprofng}"
SRC_URI[x86_64_v2_binutils-gprofng.sha256sum] = "dc56389b5953b5002f134b1c71df8f58797aeff4bab67bd487307ba2158f8638"

URI_aarch64_binutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/binutils-2.41-63.el10.alma.1.aarch64.rpm;name=aarch64_binutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils}"
SRC_URI[aarch64_binutils.sha256sum] = "1c7aa4c8faad6e38c3269c6da60597fcc4b07700cab3cc2acab48f86e99a67e6"
RPROVIDES:binutils:aarch64 = "virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_ virtual/libgprofng.so.0___64bit_ virtual/libsframe.so.1___64bit_"

URI_aarch64_binutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/binutils-devel-2.41-63.el10.alma.1.aarch64.rpm;name=aarch64_binutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-devel}"
SRC_URI[aarch64_binutils-devel.sha256sum] = "5cb9d7dba8d360e2beaf59af681766d2731230aedc39d3b84e29ff4a93d20ac8"

URI_aarch64_binutils-gold = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/binutils-gold-2.41-63.el10.alma.1.aarch64.rpm;name=aarch64_binutils-gold;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-gold}"
SRC_URI[aarch64_binutils-gold.sha256sum] = "56cfcdd867608f732383fff2775e61bbd0890b7c5cac96efea84ded0af266c0f"

URI_aarch64_binutils-gprofng = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/binutils-gprofng-2.41-63.el10.alma.1.aarch64.rpm;name=aarch64_binutils-gprofng;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-gprofng}"
SRC_URI[aarch64_binutils-gprofng.sha256sum] = "d798bedce9be05196d888d89782ddf09010eb5fd6ef33f8dc5276f11e3ea1e45"

RDEPENDS:binutils = " \
 alternatives \
 bash \
 binutils-gold \
 elfutils-debuginfod-client \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:binutils-devel = " \
 binutils \
 virtual/coreutils \
 zlib-ng-compat-devel \
 "
RDEPENDS:binutils-gold = " \
 bash \
 binutils \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:binutils-gprofng = " \
 binutils \
 glibc \
 libgcc \
 libstdc++ \
 perl-interpreter \
 virtual/libgprofng.so.0___64bit_ \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libctf.so.0_LIBCTF_1.0__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.1__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.2__64bit_ rpm/virtual/libctf.so.0___64bit_ rpm/virtual/libgprofng.so.0___64bit_ rpm/virtual/libsframe.so.1___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libctf.so.0_LIBCTF_1.0__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.1__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.2__64bit_ rpm/virtual/libctf.so.0___64bit_ rpm/virtual/libgprofng.so.0___64bit_ rpm/virtual/libsframe.so.1___64bit_"
