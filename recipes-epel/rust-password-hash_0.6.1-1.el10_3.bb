# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-password-hash"
PV = "0.6.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-password-hash+alloc-devel \
 rust-password-hash+default-devel \
 rust-password-hash+getrandom-devel \
 rust-password-hash+phc-devel \
 rust-password-hash+rand_core-devel \
 rust-password-hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-password-hash-0.6.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1af38f5f806cda22f5866e15f9d5024712816a081d9b6164c705752157c23adb"

URI_x86_64_v2_rust-password-hash+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash+alloc-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash+alloc-devel}"
SRC_URI[x86_64_v2_rust-password-hash+alloc-devel.sha256sum] = "8b6b63d57d6d0070b2a3ad9f5c41d085ea574a66972ea41001e4172d3e3457e4"

URI_x86_64_v2_rust-password-hash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash+default-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash+default-devel}"
SRC_URI[x86_64_v2_rust-password-hash+default-devel.sha256sum] = "8edce4907c2dc63a62a72e548bccd1a43ccd4ab935310316183e0a734eeb8367"

URI_x86_64_v2_rust-password-hash+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash+getrandom-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash+getrandom-devel}"
SRC_URI[x86_64_v2_rust-password-hash+getrandom-devel.sha256sum] = "466aa5972243b6346c7a0bb4aa35003fa504839ead4e9056d38929a788b12155"

URI_x86_64_v2_rust-password-hash+phc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash+phc-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash+phc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash+phc-devel}"
SRC_URI[x86_64_v2_rust-password-hash+phc-devel.sha256sum] = "2fb6eee104595a4f61611f36b04a968db00205efe00641df94a0f894cf4ae6aa"

URI_x86_64_v2_rust-password-hash+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash+rand_core-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash+rand_core-devel}"
SRC_URI[x86_64_v2_rust-password-hash+rand_core-devel.sha256sum] = "749a3b934ab216c7f56167fbaed3f5f0e089052fdc95a7e3f17c1e037ed552ec"

URI_x86_64_v2_rust-password-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash-devel}"
SRC_URI[x86_64_v2_rust-password-hash-devel.sha256sum] = "4754282f63fde9514e89de063d9e2f8a2e3107008c90b279d9344dd3e01e886c"

URI_aarch64_rust-password-hash+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash+alloc-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-password-hash+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash+alloc-devel}"
SRC_URI[aarch64_rust-password-hash+alloc-devel.sha256sum] = "6415a2b4861dffa82e7c77be01b187424270a3311f3f24c010df1d5318c9546e"

URI_aarch64_rust-password-hash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash+default-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-password-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash+default-devel}"
SRC_URI[aarch64_rust-password-hash+default-devel.sha256sum] = "5140156b1c812b295a6b05eb6fd933cb61767502e87e9745383734f2db2212e3"

URI_aarch64_rust-password-hash+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash+getrandom-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-password-hash+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash+getrandom-devel}"
SRC_URI[aarch64_rust-password-hash+getrandom-devel.sha256sum] = "cc8f143e78783fb62dcc098ccf44cfb864238fe62bb0d63ee663c1f00e91b75f"

URI_aarch64_rust-password-hash+phc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash+phc-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-password-hash+phc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash+phc-devel}"
SRC_URI[aarch64_rust-password-hash+phc-devel.sha256sum] = "9bafccb883067c4dfc008dfffeaf9b739dbc9dd8f3c027718af5d2816f603734"

URI_aarch64_rust-password-hash+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash+rand_core-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-password-hash+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash+rand_core-devel}"
SRC_URI[aarch64_rust-password-hash+rand_core-devel.sha256sum] = "ee1b53a2926ca50718df64005ca7f3c32c6880781fc6318a4b0b268de9724f94"

URI_aarch64_rust-password-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash-devel}"
SRC_URI[aarch64_rust-password-hash-devel.sha256sum] = "100bc89ee38da2fce9705b2513e6ea8afdade146db5e0524e43c363b57bd472f"

RDEPENDS:rust-password-hash+alloc-devel = " \
 cargo \
 rust-password-hash-devel \
 rust-phc+alloc-devel \
 rust-phc-devel \
 "
RDEPENDS:rust-password-hash+default-devel = " \
 cargo \
 rust-password-hash-devel \
 "
RDEPENDS:rust-password-hash+getrandom-devel = " \
 cargo \
 rust-getrandom-devel \
 rust-password-hash-devel \
 rust-phc+getrandom-devel \
 rust-phc-devel \
 "
RDEPENDS:rust-password-hash+phc-devel = " \
 cargo \
 rust-password-hash-devel \
 rust-phc-devel \
 "
RDEPENDS:rust-password-hash+rand_core-devel = " \
 cargo \
 rust-password-hash-devel \
 rust-phc+rand_core-devel \
 rust-phc-devel \
 rust-rand_core-devel \
 "
RDEPENDS:rust-password-hash-devel = " \
 cargo \
 rust \
 "
