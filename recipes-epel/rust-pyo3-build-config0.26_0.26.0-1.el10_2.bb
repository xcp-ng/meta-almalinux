# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-build-config0.26"
PV = "0.26.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-pyo3-build-config0.26+abi3-devel \
 rust-pyo3-build-config0.26+abi3-py310-devel \
 rust-pyo3-build-config0.26+abi3-py311-devel \
 rust-pyo3-build-config0.26+abi3-py312-devel \
 rust-pyo3-build-config0.26+abi3-py313-devel \
 rust-pyo3-build-config0.26+abi3-py314-devel \
 rust-pyo3-build-config0.26+abi3-py37-devel \
 rust-pyo3-build-config0.26+abi3-py38-devel \
 rust-pyo3-build-config0.26+abi3-py39-devel \
 rust-pyo3-build-config0.26+default-devel \
 rust-pyo3-build-config0.26+extension-module-devel \
 rust-pyo3-build-config0.26+resolve-config-devel \
 rust-pyo3-build-config0.26-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-build-config0.26-0.26.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8148fbb32e547341e1a7b34b45c2f7517154753d4f72076da4ad7e8e8010bf9a"

URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.26+abi3-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.26+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.26+abi3-devel.sha256sum] = "00a5c9f0dbc72ee183e69cfab83a96cffea01bc0934662f82375ecbf615f2e1d"

URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.26+abi3-py310-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.26+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.26+abi3-py310-devel.sha256sum] = "4f1f982e0911760b1474b7c05f9048db7751e5a64e5c4eff5321e0c17694d4af"

URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.26+abi3-py311-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.26+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.26+abi3-py311-devel.sha256sum] = "3d4afc6a0f2f77d762be2362967ec270c95f1a6d4113266cb59442a7a84ee241"

URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.26+abi3-py312-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.26+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.26+abi3-py312-devel.sha256sum] = "fa34d2fc284bcff618bb107bd8a15967b9443b5210f17152cd774ceac19ceafc"

URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.26+abi3-py313-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.26+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.26+abi3-py313-devel.sha256sum] = "db3da5277137339a281b7c7ce65333eb32e16660e06cc199b53a2f6ac3a426ca"

URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.26+abi3-py314-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.26+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.26+abi3-py314-devel.sha256sum] = "ce378291ae1f09387462b0c8315ae49128588321d4136b14fbe5b68e2e0da04a"

URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.26+abi3-py37-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.26+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.26+abi3-py37-devel.sha256sum] = "21a875c9eb070a5da03e0d548976b0beca559c2f8aae732cb54a12a65a03c706"

URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.26+abi3-py38-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.26+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.26+abi3-py38-devel.sha256sum] = "6a94e71d72c1a941600e0e897dbba09e5fed6e4f047b5471908eb758e949f538"

URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.26+abi3-py39-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.26+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.26+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.26+abi3-py39-devel.sha256sum] = "b76c604fc3e3facb4254c38f3cec1c5736acb55d6e009c45f7ee7bedde2e46f7"

URI_x86_64_v2_rust-pyo3-build-config0.26+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.26+default-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.26+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.26+default-devel.sha256sum] = "1bb2b220ee65d98b80ea2e4d2d5bc8404b702e9347212f6897ce4352ee7ef4ec"

URI_x86_64_v2_rust-pyo3-build-config0.26+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.26+extension-module-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.26+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.26+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.26+extension-module-devel.sha256sum] = "97de892016623e244a7ebbeb634b472441af54a521936065965c1f2d5f2a0e8a"

URI_x86_64_v2_rust-pyo3-build-config0.26+resolve-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.26+resolve-config-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.26+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.26+resolve-config-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.26+resolve-config-devel.sha256sum] = "c7194139ab038269ae458d1d1e9d4e7373746b86ab7deac3cd7e813e5d57a7b6"

URI_x86_64_v2_rust-pyo3-build-config0.26-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.26-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.26-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.26-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.26-devel.sha256sum] = "d78f2c4c684edd18832373d4cad303c788a8a9d177b76391641580c04d1c0044"

URI_aarch64_rust-pyo3-build-config0.26+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.26+abi3-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.26+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.26+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.26+abi3-devel.sha256sum] = "9fb7b7536e1642e2c80fd6c1dc40e7071edca588d3cce91d0099d446a4973212"

URI_aarch64_rust-pyo3-build-config0.26+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.26+abi3-py310-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.26+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.26+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.26+abi3-py310-devel.sha256sum] = "449b9cd2563566f02b43f94e559ce4b02c9aaa4a7136d7f4443eb6dec250d9cc"

URI_aarch64_rust-pyo3-build-config0.26+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.26+abi3-py311-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.26+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.26+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.26+abi3-py311-devel.sha256sum] = "90ac1090413e9edb67bb788ac39d13d85838d10047fdcdc9778257764dec9ec3"

URI_aarch64_rust-pyo3-build-config0.26+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.26+abi3-py312-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.26+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.26+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.26+abi3-py312-devel.sha256sum] = "07e73b9bf65e4f5431ace4de1bd9bb9875b7dc1353aedc2231fec8b2098adc26"

URI_aarch64_rust-pyo3-build-config0.26+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.26+abi3-py313-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.26+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.26+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.26+abi3-py313-devel.sha256sum] = "01678cbc4827e6c9f080343533e6998b7d390f6b2b0b142a6acc925cb9a9be88"

URI_aarch64_rust-pyo3-build-config0.26+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.26+abi3-py314-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.26+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.26+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.26+abi3-py314-devel.sha256sum] = "0e481c28f4028125d6affd76c90eb8cc48f1a4e1a428df530c01d11145114f59"

URI_aarch64_rust-pyo3-build-config0.26+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.26+abi3-py37-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.26+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.26+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.26+abi3-py37-devel.sha256sum] = "636219bd140268d4c420d2df793e1b0b1823181c14de13fc7ebce5c86d580249"

URI_aarch64_rust-pyo3-build-config0.26+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.26+abi3-py38-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.26+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.26+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.26+abi3-py38-devel.sha256sum] = "40a9ce7a58a0c63d27ac83516b310cb0b34056fa33b65733988bc57461611f7f"

URI_aarch64_rust-pyo3-build-config0.26+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.26+abi3-py39-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.26+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.26+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.26+abi3-py39-devel.sha256sum] = "3e68aec8f3ff52cf93425be4adebefc3fa5c846704427d83c75bed8d795e21e1"

URI_aarch64_rust-pyo3-build-config0.26+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.26+default-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.26+default-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.26+default-devel.sha256sum] = "47a3c2929a5be72777d1f46ba2e7471fffb65cdc77a8c81da15b91ef6442454e"

URI_aarch64_rust-pyo3-build-config0.26+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.26+extension-module-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.26+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.26+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.26+extension-module-devel.sha256sum] = "4d87853d3f7b9b07cb0b44040ac481987a5642d58f26c29b5bec99ff6f0101de"

URI_aarch64_rust-pyo3-build-config0.26+resolve-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.26+resolve-config-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.26+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.26+resolve-config-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.26+resolve-config-devel.sha256sum] = "523c3a0827bb59bedf89fb9b593bc2847a9400b722bc7c185fdc3d78b28b49bb"

URI_aarch64_rust-pyo3-build-config0.26-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.26-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.26-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.26-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.26-devel.sha256sum] = "2dd83cf18715d6eff6bbe9c7444d2dd955bb623ce498f05c53015cc793685bff"

RDEPENDS:rust-pyo3-build-config0.26+abi3-devel = " \
 cargo \
 rust-pyo3-build-config0.26-devel \
 "
RDEPENDS:rust-pyo3-build-config0.26+abi3-py310-devel = " \
 cargo \
 rust-pyo3-build-config0.26+abi3-py311-devel \
 rust-pyo3-build-config0.26-devel \
 "
RDEPENDS:rust-pyo3-build-config0.26+abi3-py311-devel = " \
 cargo \
 rust-pyo3-build-config0.26+abi3-py312-devel \
 rust-pyo3-build-config0.26-devel \
 "
RDEPENDS:rust-pyo3-build-config0.26+abi3-py312-devel = " \
 cargo \
 rust-pyo3-build-config0.26+abi3-py313-devel \
 rust-pyo3-build-config0.26-devel \
 "
RDEPENDS:rust-pyo3-build-config0.26+abi3-py313-devel = " \
 cargo \
 rust-pyo3-build-config0.26+abi3-py314-devel \
 rust-pyo3-build-config0.26-devel \
 "
RDEPENDS:rust-pyo3-build-config0.26+abi3-py314-devel = " \
 cargo \
 rust-pyo3-build-config0.26+abi3-devel \
 rust-pyo3-build-config0.26-devel \
 "
RDEPENDS:rust-pyo3-build-config0.26+abi3-py37-devel = " \
 cargo \
 rust-pyo3-build-config0.26+abi3-py38-devel \
 rust-pyo3-build-config0.26-devel \
 "
RDEPENDS:rust-pyo3-build-config0.26+abi3-py38-devel = " \
 cargo \
 rust-pyo3-build-config0.26+abi3-py39-devel \
 rust-pyo3-build-config0.26-devel \
 "
RDEPENDS:rust-pyo3-build-config0.26+abi3-py39-devel = " \
 cargo \
 rust-pyo3-build-config0.26+abi3-py310-devel \
 rust-pyo3-build-config0.26-devel \
 "
RDEPENDS:rust-pyo3-build-config0.26+default-devel = " \
 cargo \
 rust-pyo3-build-config0.26-devel \
 "
RDEPENDS:rust-pyo3-build-config0.26+extension-module-devel = " \
 cargo \
 rust-pyo3-build-config0.26-devel \
 "
RDEPENDS:rust-pyo3-build-config0.26+resolve-config-devel = " \
 cargo \
 rust-pyo3-build-config0.26-devel \
 "
RDEPENDS:rust-pyo3-build-config0.26-devel = " \
 cargo \
 python3 \
 rust \
 rust-target-lexicon+default-devel \
 "
