# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Find"
PV = "0.16"
PR = "3.el10_0"
PACKAGES = " \
 perl-Module-Find \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Find-0.16-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f54ef15f313463630237520642c62a50e3f9a6d590205cc04dbd39cbad55617"

URI_x86_64_v2_perl-Module-Find = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Find-0.16-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Find;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Find}"
SRC_URI[x86_64_v2_perl-Module-Find.sha256sum] = "10b6b286880963218acc160098c110e89a400b5f248a84d678284937fbb32c93"

URI_aarch64_perl-Module-Find = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Find-0.16-3.el10_0.noarch.rpm;name=aarch64_perl-Module-Find;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Find}"
SRC_URI[aarch64_perl-Module-Find.sha256sum] = "9aa80963645f8ca07d0d3ff057c49a52feda707e306297c23a53561a836bc342"

RDEPENDS:perl-Module-Find = " \
 perl-Exporter \
 perl-File-Find \
 perl-PathTools \
 perl-libs \
 "
