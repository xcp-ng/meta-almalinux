# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-base-compat-batteries"
PV = "0.13.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-base-compat-batteries \
 ghc-base-compat-batteries-devel \
 ghc-base-compat-batteries-doc \
 ghc-base-compat-batteries-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-base-compat-batteries-0.13.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dedd59b9ed748d94fd3af64137fb06c5af55983abdb5fda81f91c647df0868bf"

URI_x86_64_v2_ghc-base-compat-batteries = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-compat-batteries-0.13.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base-compat-batteries;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-compat-batteries}"
SRC_URI[x86_64_v2_ghc-base-compat-batteries.sha256sum] = "fc18a69fed500b4930729c65e08f46f419f14bc52a538b9cbdbc353c6c995ccc"

URI_x86_64_v2_ghc-base-compat-batteries-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-compat-batteries-devel-0.13.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base-compat-batteries-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-compat-batteries-devel}"
SRC_URI[x86_64_v2_ghc-base-compat-batteries-devel.sha256sum] = "38686798fbb330218524abf2f7fc33fcd55d73f7cd5c1027044335ce46134728"

URI_x86_64_v2_ghc-base-compat-batteries-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-compat-batteries-doc-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-base-compat-batteries-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-compat-batteries-doc}"
SRC_URI[x86_64_v2_ghc-base-compat-batteries-doc.sha256sum] = "38a56426f4bf5b22491a8dcb58e3a576877559e8a433f5e2d8c7301215e6ec3f"

URI_x86_64_v2_ghc-base-compat-batteries-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-compat-batteries-prof-0.13.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base-compat-batteries-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-compat-batteries-prof}"
SRC_URI[x86_64_v2_ghc-base-compat-batteries-prof.sha256sum] = "10c83a52abc30cb399aae210480b6b324e4ca76f87e0acae3b36c236d9d8d1a7"

URI_aarch64_ghc-base-compat-batteries = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-compat-batteries-0.13.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-base-compat-batteries;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-compat-batteries}"
SRC_URI[aarch64_ghc-base-compat-batteries.sha256sum] = "31a74c28c7a95fb0fde114c194cc6df84f6899424940a2cf161ef0d1f32dac75"

URI_aarch64_ghc-base-compat-batteries-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-compat-batteries-devel-0.13.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-base-compat-batteries-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-compat-batteries-devel}"
SRC_URI[aarch64_ghc-base-compat-batteries-devel.sha256sum] = "b78945d829f3c8a1ea22b31bc40d9dba55837ce949f43ffccf67689a5c0a5850"

URI_aarch64_ghc-base-compat-batteries-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-compat-batteries-doc-0.13.1-1.el10_0.noarch.rpm;name=aarch64_ghc-base-compat-batteries-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-compat-batteries-doc}"
SRC_URI[aarch64_ghc-base-compat-batteries-doc.sha256sum] = "b03c575d8c816bb878ad92849a6a00314b2920aae3abafa3a4972e9384b990d1"

URI_aarch64_ghc-base-compat-batteries-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-compat-batteries-prof-0.13.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-base-compat-batteries-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-compat-batteries-prof}"
SRC_URI[aarch64_ghc-base-compat-batteries-prof.sha256sum] = "81c34d489052ae0f569e227684be8f9875f46e92c66a542a4302efb0c02a267a"

RDEPENDS:ghc-base-compat-batteries = " \
 ghc-array \
 ghc-base \
 ghc-base-compat \
 ghc-bytestring \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-base-compat-batteries-devel = " \
 ghc-base-compat-batteries \
 ghc-base-compat-devel \
 ghc-base-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-base-compat-batteries-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-base-compat-batteries-prof = " \
 ghc-base-compat-batteries-devel \
 ghc-base-compat-prof \
 ghc-base-prof \
 "
