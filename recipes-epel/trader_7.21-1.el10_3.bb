# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "trader"
PV = "7.21"
PR = "1.el10_3"
PACKAGES = " \
 trader \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/trader-7.21-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc0f97be7d83b420db012e6ced7d389c3ce28adb004f51d4ae7b85c9aa30b417"

URI_x86_64_v2_trader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trader-7.21-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_trader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trader}"
SRC_URI[x86_64_v2_trader.sha256sum] = "f68ee74a58e3777d297210a619764392aedb8bf536caac96fe34f427f19e2c20"

URI_aarch64_trader = "${EPEL_MIRROR}/aarch64/Packages/t/trader-7.21-1.el10_3.aarch64.rpm;name=aarch64_trader;unpack=0"
SRC_URI:append = " ${URI_aarch64_trader}"
SRC_URI[aarch64_trader.sha256sum] = "d3d184935da8267b92be17595497dafe15bd99c4c47a772fcb094e03d09c9bf9"

RDEPENDS:trader = " \
 glibc \
 ncurses-libs \
 "
