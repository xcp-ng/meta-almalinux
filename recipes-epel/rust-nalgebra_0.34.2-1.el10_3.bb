# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nalgebra"
PV = "0.34.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-nalgebra+alloc-devel \
 rust-nalgebra+arbitrary-devel \
 rust-nalgebra+bytemuck-devel \
 rust-nalgebra+compare-devel \
 rust-nalgebra+convert-bytemuck-devel \
 rust-nalgebra+convert-mint-devel \
 rust-nalgebra+debug-devel \
 rust-nalgebra+default-devel \
 rust-nalgebra+io-devel \
 rust-nalgebra+libm-devel \
 rust-nalgebra+libm-force-devel \
 rust-nalgebra+macros-devel \
 rust-nalgebra+matrixcompare-core-devel \
 rust-nalgebra+matrixmultiply-devel \
 rust-nalgebra+mint-devel \
 rust-nalgebra+nalgebra-macros-devel \
 rust-nalgebra+pest-devel \
 rust-nalgebra+pest_derive-devel \
 rust-nalgebra+proptest-devel \
 rust-nalgebra+proptest-support-devel \
 rust-nalgebra+quickcheck-devel \
 rust-nalgebra+rand-devel \
 rust-nalgebra+rand-no-std-devel \
 rust-nalgebra+rand-package-devel \
 rust-nalgebra+rand_distr-devel \
 rust-nalgebra+rayon-devel \
 rust-nalgebra+serde-devel \
 rust-nalgebra+serde-serialize-devel \
 rust-nalgebra+serde-serialize-no-std-devel \
 rust-nalgebra+slow-tests-devel \
 rust-nalgebra+sparse-devel \
 rust-nalgebra+std-devel \
 rust-nalgebra-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nalgebra-0.34.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eebbb11bd0e7091ce042f1c9d8f8c27ddb82943ae2cd42a00f6048bfab39742d"

URI_x86_64_v2_rust-nalgebra+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+alloc-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+alloc-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+alloc-devel.sha256sum] = "db853ec7969b696675f6c71513c2405a3937751fc4cd4eefdaae30ea6680ec32"

URI_x86_64_v2_rust-nalgebra+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+arbitrary-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+arbitrary-devel.sha256sum] = "6f2d58f72bfa4864db39506f950fca2669c9a844159568d0d5528b6dbb25dae7"

URI_x86_64_v2_rust-nalgebra+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+bytemuck-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+bytemuck-devel.sha256sum] = "7e29cd7da0026f68bc138915bea853074be93f9a0e978d514b98eaccf6e54e50"

URI_x86_64_v2_rust-nalgebra+compare-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+compare-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+compare-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+compare-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+compare-devel.sha256sum] = "cb059ded7b260d512b4c5330c0739bd34610d2cf2aeabbdcb642a7afae82afe1"

URI_x86_64_v2_rust-nalgebra+convert-bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+convert-bytemuck-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+convert-bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+convert-bytemuck-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+convert-bytemuck-devel.sha256sum] = "92d83f6199d336c871abe085e7fe9fb7f3798573c60ec67f217d8ae5c6e96ae2"

URI_x86_64_v2_rust-nalgebra+convert-mint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+convert-mint-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+convert-mint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+convert-mint-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+convert-mint-devel.sha256sum] = "63c23b65c3f993a3ba20a4fdf7d0f28727881d3cc8d0f2d6f148034c0528ad85"

URI_x86_64_v2_rust-nalgebra+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+debug-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+debug-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+debug-devel.sha256sum] = "10dfc3bd203e33e9d93d79e70072075b02043c0842638eaf4169b50b18af5849"

URI_x86_64_v2_rust-nalgebra+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+default-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+default-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+default-devel.sha256sum] = "b06c28840750c69dd4aa5ded157fb6441448f3c51dcbaa1dd633243285be1d0a"

URI_x86_64_v2_rust-nalgebra+io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+io-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+io-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+io-devel.sha256sum] = "e4c1708b4e69b8c26e7125dd7b133066764173b513fbe536ad624d2a2f39918c"

URI_x86_64_v2_rust-nalgebra+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+libm-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+libm-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+libm-devel.sha256sum] = "f708ca2b7e89202233fd1e2d868d42cb4e05a68538a9c064d38b19f6d9cfdc79"

URI_x86_64_v2_rust-nalgebra+libm-force-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+libm-force-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+libm-force-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+libm-force-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+libm-force-devel.sha256sum] = "4402e0f58477746eb1bc99f2eb62feab8c61c511bbbeddd0fff04e6607391ff9"

URI_x86_64_v2_rust-nalgebra+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+macros-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+macros-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+macros-devel.sha256sum] = "63231d25dd90a68eecca9a764f45347c2055fb028fbf818e6a53808f90c48a94"

URI_x86_64_v2_rust-nalgebra+matrixcompare-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+matrixcompare-core-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+matrixcompare-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+matrixcompare-core-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+matrixcompare-core-devel.sha256sum] = "546cc50623de5290704aca9042fa572cb2b5e04b6c3de308b387e5d51e4542f7"

URI_x86_64_v2_rust-nalgebra+matrixmultiply-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+matrixmultiply-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+matrixmultiply-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+matrixmultiply-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+matrixmultiply-devel.sha256sum] = "fc2b4099a2bdeae2662bce926cf25d60fc1f2ed2cf62b9921e9d46edbb541a77"

URI_x86_64_v2_rust-nalgebra+mint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+mint-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+mint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+mint-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+mint-devel.sha256sum] = "e98c6a9224cc5daaa60951d46f927686508049682499a6cf10a206b6377b034f"

URI_x86_64_v2_rust-nalgebra+nalgebra-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+nalgebra-macros-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+nalgebra-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+nalgebra-macros-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+nalgebra-macros-devel.sha256sum] = "cdaa5998c3fea821f541455c6aea5952c41c8b1fc9748e941ed616f682776af8"

URI_x86_64_v2_rust-nalgebra+pest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+pest-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+pest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+pest-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+pest-devel.sha256sum] = "eb7339c28be711186458da3077f39f4cdd66bc807c628606aa1319b58a214438"

URI_x86_64_v2_rust-nalgebra+pest_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+pest_derive-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+pest_derive-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+pest_derive-devel.sha256sum] = "5e6740a9d41a709eb57262b7b38ddc40805225053ea772530d10d78dafd37a27"

URI_x86_64_v2_rust-nalgebra+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+proptest-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+proptest-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+proptest-devel.sha256sum] = "59cef9f28838f0070d3a61e058fa4f2ba5ca14ffb4546de14a4273fe615428bf"

URI_x86_64_v2_rust-nalgebra+proptest-support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+proptest-support-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+proptest-support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+proptest-support-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+proptest-support-devel.sha256sum] = "0f4bee178a22188cad8613f53f52685f925b583adbbbeaf421e94ecd555d2659"

URI_x86_64_v2_rust-nalgebra+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+quickcheck-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+quickcheck-devel.sha256sum] = "45fb4e06ad0b9e62a1a12c3589da95320235422632c09aef47c8dfe176e65422"

URI_x86_64_v2_rust-nalgebra+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+rand-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+rand-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+rand-devel.sha256sum] = "4a9629cbb8eb6b56a9c357a3e4cfe32f4ad01ab6171b92032b863b2d422ee7b3"

URI_x86_64_v2_rust-nalgebra+rand-no-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+rand-no-std-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+rand-no-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+rand-no-std-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+rand-no-std-devel.sha256sum] = "9313972cc68b24c1ca6db42ffe2b7ce79edb553ed4d7ed04d894d184d98b47af"

URI_x86_64_v2_rust-nalgebra+rand-package-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+rand-package-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+rand-package-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+rand-package-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+rand-package-devel.sha256sum] = "bc7ffe1aa17e0f859f5f33dfe55bb61a116e2dc210aa3e088c5d27923f7a42b7"

URI_x86_64_v2_rust-nalgebra+rand_distr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+rand_distr-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+rand_distr-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+rand_distr-devel.sha256sum] = "b6120a068472619da85687cca5dc3b1b39d14b86712146e9c5f27e2a37459cc2"

URI_x86_64_v2_rust-nalgebra+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+rayon-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+rayon-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+rayon-devel.sha256sum] = "b07685d5ae8c712bfa6f311140d9885f31f77f057e0fc7539612289a267f3622"

URI_x86_64_v2_rust-nalgebra+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+serde-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+serde-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+serde-devel.sha256sum] = "c8bd381c63c17e6eef7cc0e6f7452e764a0ec5a41fd3f823c5aa9891a264e66d"

URI_x86_64_v2_rust-nalgebra+serde-serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+serde-serialize-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+serde-serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+serde-serialize-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+serde-serialize-devel.sha256sum] = "92812b23446a84046f97152b688ffe823c9bf7652183692b5ffb2746adce92d8"

URI_x86_64_v2_rust-nalgebra+serde-serialize-no-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+serde-serialize-no-std-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+serde-serialize-no-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+serde-serialize-no-std-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+serde-serialize-no-std-devel.sha256sum] = "cb98a0ab921bb360de0c223ed040417fc7b09be3f74690690b2f7e7683b3aec4"

URI_x86_64_v2_rust-nalgebra+slow-tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+slow-tests-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+slow-tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+slow-tests-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+slow-tests-devel.sha256sum] = "b43ff45c6fdf619f49947b4867c060b29382e1db017a53084585343b78787346"

URI_x86_64_v2_rust-nalgebra+sparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+sparse-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+sparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+sparse-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+sparse-devel.sha256sum] = "8c4e019a760968f40c5ae87571610d3246fc8853ca8aa359c2baf90a932a69dc"

URI_x86_64_v2_rust-nalgebra+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra+std-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra+std-devel}"
SRC_URI[x86_64_v2_rust-nalgebra+std-devel.sha256sum] = "9d9eee6ed4da0a1e57cb6850d86f16b6767cf187789bceafcf0943c5b57d781a"

URI_x86_64_v2_rust-nalgebra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra-devel-0.34.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra-devel}"
SRC_URI[x86_64_v2_rust-nalgebra-devel.sha256sum] = "5124ddcf40e8488fae3c9cbfcbf4ac175de7fca3025f52114212d0e5296edcfe"

URI_aarch64_rust-nalgebra+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+alloc-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+alloc-devel}"
SRC_URI[aarch64_rust-nalgebra+alloc-devel.sha256sum] = "c54deda6e38799d58eac5679e04b061c3ba3b74bec2a3b4545068e6c697e26ae"

URI_aarch64_rust-nalgebra+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+arbitrary-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+arbitrary-devel}"
SRC_URI[aarch64_rust-nalgebra+arbitrary-devel.sha256sum] = "a798f55067c16846b329cfc3cefc3a6f89106135d8c486f400871c2201f303b8"

URI_aarch64_rust-nalgebra+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+bytemuck-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+bytemuck-devel}"
SRC_URI[aarch64_rust-nalgebra+bytemuck-devel.sha256sum] = "2185ca71e049d157217891dbc6acfc8e8f4a5efb09e6c2c19ca868f2591a9f0c"

URI_aarch64_rust-nalgebra+compare-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+compare-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+compare-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+compare-devel}"
SRC_URI[aarch64_rust-nalgebra+compare-devel.sha256sum] = "51416b536b35e8d6102754c712bddcddc3a8d9cdfb28b260819f464b9df7c39e"

URI_aarch64_rust-nalgebra+convert-bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+convert-bytemuck-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+convert-bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+convert-bytemuck-devel}"
SRC_URI[aarch64_rust-nalgebra+convert-bytemuck-devel.sha256sum] = "a0abac51ef3e29f6a441c5ac8027add2af93c4c40e46d13a6acf0f43769d6cc6"

URI_aarch64_rust-nalgebra+convert-mint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+convert-mint-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+convert-mint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+convert-mint-devel}"
SRC_URI[aarch64_rust-nalgebra+convert-mint-devel.sha256sum] = "90ba04e047491bc6ce24e7120b45617b81305c59d4e62446eeaeb08c0c982840"

URI_aarch64_rust-nalgebra+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+debug-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+debug-devel}"
SRC_URI[aarch64_rust-nalgebra+debug-devel.sha256sum] = "aabb631daa95d3e2f68426e3d86b9d9e1d277426f25a031d5c3fad785bcc1153"

URI_aarch64_rust-nalgebra+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+default-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+default-devel}"
SRC_URI[aarch64_rust-nalgebra+default-devel.sha256sum] = "36f7af74846f30ba583bce10e9e8e7ff1624fa2c30edfd6b9c459648e43cd16d"

URI_aarch64_rust-nalgebra+io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+io-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+io-devel}"
SRC_URI[aarch64_rust-nalgebra+io-devel.sha256sum] = "a819c9630b02241b447222a1381384913949709e9b3732dbdff61134b4d2575d"

URI_aarch64_rust-nalgebra+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+libm-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+libm-devel}"
SRC_URI[aarch64_rust-nalgebra+libm-devel.sha256sum] = "0a700fee9eaa0ea74546887261f8807a9aeb443f97c437b5422e1955df70c695"

URI_aarch64_rust-nalgebra+libm-force-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+libm-force-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+libm-force-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+libm-force-devel}"
SRC_URI[aarch64_rust-nalgebra+libm-force-devel.sha256sum] = "ddb45dfe7bb6484b33e1de23732250b9a657c0051d86b166ea62317bb43de0ca"

URI_aarch64_rust-nalgebra+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+macros-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+macros-devel}"
SRC_URI[aarch64_rust-nalgebra+macros-devel.sha256sum] = "6a952bc4dd7dbee5eb3b4ceb855a0e37021bf584589010f833318f23adfd321e"

URI_aarch64_rust-nalgebra+matrixcompare-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+matrixcompare-core-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+matrixcompare-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+matrixcompare-core-devel}"
SRC_URI[aarch64_rust-nalgebra+matrixcompare-core-devel.sha256sum] = "a9fc46a241395b328347f9567b3e963a912b5c1f13aa758436f496c485e4a7df"

URI_aarch64_rust-nalgebra+matrixmultiply-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+matrixmultiply-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+matrixmultiply-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+matrixmultiply-devel}"
SRC_URI[aarch64_rust-nalgebra+matrixmultiply-devel.sha256sum] = "1095488961e6ea879a9dce8d122be6e4bdf1994788ef17217d8be8ee9a97c97f"

URI_aarch64_rust-nalgebra+mint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+mint-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+mint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+mint-devel}"
SRC_URI[aarch64_rust-nalgebra+mint-devel.sha256sum] = "a0ea251fc883236d7800f0d79880cb41ba8d35268e92fb1f5a7f578d90171436"

URI_aarch64_rust-nalgebra+nalgebra-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+nalgebra-macros-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+nalgebra-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+nalgebra-macros-devel}"
SRC_URI[aarch64_rust-nalgebra+nalgebra-macros-devel.sha256sum] = "9d3c81a73db26dd0f2118d1222d5b4fa70d267e0ff0afc547aff17c0bd199b7f"

URI_aarch64_rust-nalgebra+pest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+pest-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+pest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+pest-devel}"
SRC_URI[aarch64_rust-nalgebra+pest-devel.sha256sum] = "a3ef512cafb5c64ad32ab3add0f49db4472f775f243ebacf6ecbc239526cb043"

URI_aarch64_rust-nalgebra+pest_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+pest_derive-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+pest_derive-devel}"
SRC_URI[aarch64_rust-nalgebra+pest_derive-devel.sha256sum] = "b8733f1a9f52b4733d25a0e921140435aea4f4a619d7034b51da673246ca51c5"

URI_aarch64_rust-nalgebra+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+proptest-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+proptest-devel}"
SRC_URI[aarch64_rust-nalgebra+proptest-devel.sha256sum] = "81984c6c14db86e61f6b180186dedf352692b19273299971df72056cb2653e14"

URI_aarch64_rust-nalgebra+proptest-support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+proptest-support-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+proptest-support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+proptest-support-devel}"
SRC_URI[aarch64_rust-nalgebra+proptest-support-devel.sha256sum] = "1df71307276d2e326238a1bdda827932d396a1a29b10fbca094f1e074cbccd48"

URI_aarch64_rust-nalgebra+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+quickcheck-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+quickcheck-devel}"
SRC_URI[aarch64_rust-nalgebra+quickcheck-devel.sha256sum] = "9f1e9539698016a9122e6127ae047c781eeb83b44c39004618914df4980f7c56"

URI_aarch64_rust-nalgebra+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+rand-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+rand-devel}"
SRC_URI[aarch64_rust-nalgebra+rand-devel.sha256sum] = "f21cab044df5ffb471c8c99bf7319c25dd2ec62aa3a56e55f776304ca85bdd4a"

URI_aarch64_rust-nalgebra+rand-no-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+rand-no-std-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+rand-no-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+rand-no-std-devel}"
SRC_URI[aarch64_rust-nalgebra+rand-no-std-devel.sha256sum] = "542e89264ab89acef887dbdb05f9196e9a85857221d3d2bf3e1d36164bc1045f"

URI_aarch64_rust-nalgebra+rand-package-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+rand-package-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+rand-package-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+rand-package-devel}"
SRC_URI[aarch64_rust-nalgebra+rand-package-devel.sha256sum] = "6acddf23178246cb484f57fcd1aa116b42a8638b231362f6eaa5541e0ae43738"

URI_aarch64_rust-nalgebra+rand_distr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+rand_distr-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+rand_distr-devel}"
SRC_URI[aarch64_rust-nalgebra+rand_distr-devel.sha256sum] = "5e5101abd6ef2a3450389a87bc7afaa1fedaafb960cc59b12e6370dac85dadac"

URI_aarch64_rust-nalgebra+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+rayon-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+rayon-devel}"
SRC_URI[aarch64_rust-nalgebra+rayon-devel.sha256sum] = "64e7f915b2af60e57e247e63c281a27c99245888ad5f99ed6f60bded98986fba"

URI_aarch64_rust-nalgebra+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+serde-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+serde-devel}"
SRC_URI[aarch64_rust-nalgebra+serde-devel.sha256sum] = "8c119d477fd178a4af79616c3a35260c20e49a41863fc0acad5dbaed74bda560"

URI_aarch64_rust-nalgebra+serde-serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+serde-serialize-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+serde-serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+serde-serialize-devel}"
SRC_URI[aarch64_rust-nalgebra+serde-serialize-devel.sha256sum] = "f7aecd3073e4784f2beb1265b1f169b553e43cf0842fd834e83eb504cdf10e3b"

URI_aarch64_rust-nalgebra+serde-serialize-no-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+serde-serialize-no-std-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+serde-serialize-no-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+serde-serialize-no-std-devel}"
SRC_URI[aarch64_rust-nalgebra+serde-serialize-no-std-devel.sha256sum] = "dfd206c697a376e208916ae090bd8a3940ac7d4cc9876998ab3c4c76089b03d8"

URI_aarch64_rust-nalgebra+slow-tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+slow-tests-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+slow-tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+slow-tests-devel}"
SRC_URI[aarch64_rust-nalgebra+slow-tests-devel.sha256sum] = "1f1e901ce38c3e6f422a923ca37125f61aa5e7167815ff6dcb4d4a070f773515"

URI_aarch64_rust-nalgebra+sparse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+sparse-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+sparse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+sparse-devel}"
SRC_URI[aarch64_rust-nalgebra+sparse-devel.sha256sum] = "7e5369335215fefdf030644022aba033a9fc18acde23c7d93308b4051b4c97a2"

URI_aarch64_rust-nalgebra+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra+std-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra+std-devel}"
SRC_URI[aarch64_rust-nalgebra+std-devel.sha256sum] = "d28babc06512ff7080e5c16f8e659d33fc415b1c5737806685c70ec4cf2750f3"

URI_aarch64_rust-nalgebra-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra-devel-0.34.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra-devel}"
SRC_URI[aarch64_rust-nalgebra-devel.sha256sum] = "16ea23f063406099ca754d4ec608de12d0d5edd85f99f74f97e8449826c275d2"

RDEPENDS:rust-nalgebra+alloc-devel = " \
 cargo \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+arbitrary-devel = " \
 cargo \
 rust-nalgebra+quickcheck-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+compare-devel = " \
 cargo \
 rust-nalgebra+matrixcompare-core-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+convert-bytemuck-devel = " \
 cargo \
 rust-nalgebra+bytemuck-devel \
 rust-nalgebra-devel \
 rust-num-complex+bytemuck-devel \
 "
RDEPENDS:rust-nalgebra+convert-mint-devel = " \
 cargo \
 rust-nalgebra+mint-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+debug-devel = " \
 cargo \
 rust-approx+num-complex-devel \
 rust-nalgebra+rand-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+default-devel = " \
 cargo \
 rust-nalgebra+macros-devel \
 rust-nalgebra+std-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+io-devel = " \
 cargo \
 rust-nalgebra+pest-devel \
 rust-nalgebra+pest_derive-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+libm-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-simba+libm-devel \
 "
RDEPENDS:rust-nalgebra+libm-force-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-simba+libm_force-devel \
 "
RDEPENDS:rust-nalgebra+macros-devel = " \
 cargo \
 rust-nalgebra+nalgebra-macros-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+matrixcompare-core-devel = " \
 cargo \
 rust-matrixcompare-core+default-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+matrixmultiply-devel = " \
 cargo \
 rust-matrixmultiply+default-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+mint-devel = " \
 cargo \
 rust-mint+default-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+nalgebra-macros-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-nalgebra-macros+default-devel \
 "
RDEPENDS:rust-nalgebra+pest-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-pest+default-devel \
 "
RDEPENDS:rust-nalgebra+pest_derive-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-pest_derive+default-devel \
 "
RDEPENDS:rust-nalgebra+proptest-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-nalgebra+proptest-support-devel = " \
 cargo \
 rust-nalgebra+proptest-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+quickcheck-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-quickcheck+default-devel \
 "
RDEPENDS:rust-nalgebra+rand-devel = " \
 cargo \
 rust-nalgebra+rand-no-std-devel \
 rust-nalgebra+rand_distr-devel \
 rust-nalgebra-devel \
 rust-rand0.9+std-devel \
 rust-rand0.9+std_rng-devel \
 rust-rand0.9+thread_rng-devel \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-nalgebra+rand-no-std-devel = " \
 cargo \
 rust-nalgebra+rand-package-devel \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+rand-package-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-nalgebra+rand_distr-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-rand_distr0.5-devel \
 "
RDEPENDS:rust-nalgebra+rayon-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-nalgebra+serde-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-nalgebra+serde-serialize-devel = " \
 cargo \
 rust-nalgebra+serde-serialize-no-std-devel \
 rust-nalgebra-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-nalgebra+serde-serialize-no-std-devel = " \
 cargo \
 rust-nalgebra+serde-devel \
 rust-nalgebra-devel \
 rust-num-complex+serde-devel \
 "
RDEPENDS:rust-nalgebra+slow-tests-devel = " \
 cargo \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+sparse-devel = " \
 cargo \
 rust-nalgebra-devel \
 "
RDEPENDS:rust-nalgebra+std-devel = " \
 cargo \
 rust-approx+std-devel \
 rust-nalgebra+matrixmultiply-devel \
 rust-nalgebra-devel \
 rust-num-complex+std-devel \
 rust-num-rational+std-devel \
 rust-num-traits+std-devel \
 rust-simba+std-devel \
 "
RDEPENDS:rust-nalgebra-devel = " \
 cargo \
 rust \
 rust-approx-devel \
 rust-num-complex-devel \
 rust-num-rational-devel \
 rust-num-traits-devel \
 rust-simba-devel \
 rust-typenum+default-devel \
 "
