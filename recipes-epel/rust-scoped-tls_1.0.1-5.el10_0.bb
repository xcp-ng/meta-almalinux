# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scoped-tls"
PV = "1.0.1"
PR = "5.el10_0"
PACKAGES = " \
 rust-scoped-tls+default-devel \
 rust-scoped-tls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scoped-tls-1.0.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5412758ed4920d5f0ad3bc8075703022e4af6bf8837e3b1b96e8385b7dcdd2e"

URI_x86_64_v2_rust-scoped-tls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scoped-tls+default-devel-1.0.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scoped-tls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scoped-tls+default-devel}"
SRC_URI[x86_64_v2_rust-scoped-tls+default-devel.sha256sum] = "361f8776a94fc78ed0fd5666fd490a82137d3d133ff823aa43ebf594c883e690"

URI_x86_64_v2_rust-scoped-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scoped-tls-devel-1.0.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scoped-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scoped-tls-devel}"
SRC_URI[x86_64_v2_rust-scoped-tls-devel.sha256sum] = "dbdb60277dd69ed9c02b3c76ddb7e05681a50294fa10371d00fd96c24eeb326b"

URI_aarch64_rust-scoped-tls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scoped-tls+default-devel-1.0.1-5.el10_0.noarch.rpm;name=aarch64_rust-scoped-tls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scoped-tls+default-devel}"
SRC_URI[aarch64_rust-scoped-tls+default-devel.sha256sum] = "dfd7feffc7fd553f06cb176f0659b6c9b328ce816acb3a23667a726513e02ec9"

URI_aarch64_rust-scoped-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scoped-tls-devel-1.0.1-5.el10_0.noarch.rpm;name=aarch64_rust-scoped-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scoped-tls-devel}"
SRC_URI[aarch64_rust-scoped-tls-devel.sha256sum] = "e75deac128b49cae457a9ebf865a108703d2ecb08f8d96e09950f42ae9a5aa72"

RDEPENDS:rust-scoped-tls+default-devel = " \
 cargo \
 rust-scoped-tls-devel \
 "
RDEPENDS:rust-scoped-tls-devel = " \
 cargo \
 rust \
 "
