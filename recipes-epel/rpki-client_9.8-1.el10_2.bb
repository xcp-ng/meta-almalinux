# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpki-client"
PV = "9.8"
PR = "1.el10_2"
PACKAGES = " \
 rpki-client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rpki-client-9.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0497d260f8b752c37aec3cd7518797be9ca696e62d4c2d5988abf26e4ec72636"

URI_x86_64_v2_rpki-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpki-client-9.8-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rpki-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpki-client}"
SRC_URI[x86_64_v2_rpki-client.sha256sum] = "526e2f1c09732efc128279c749a1760edc02be6bbcf8e79d57bdbcb1341ba565"

URI_aarch64_rpki-client = "${EPEL_MIRROR}/aarch64/Packages/r/rpki-client-9.8-1.el10_2.aarch64.rpm;name=aarch64_rpki-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpki-client}"
SRC_URI[aarch64_rpki-client.sha256sum] = "f9e27416d2a38f610b973df187473ced5e939843704dd2d7946506c9be54629d"

RDEPENDS:rpki-client = " \
 bash \
 expat \
 glibc \
 libretls \
 openssl-libs \
 rsync \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
