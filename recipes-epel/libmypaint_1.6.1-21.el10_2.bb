# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmypaint"
PV = "1.6.1"
PR = "21.el10_2"
PACKAGES = " \
 libmypaint \
 libmypaint-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmypaint-1.6.1-21.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e2371d5c41c43ac78d4a773379fbaf455973b5f0248b87891bb864916752093"

URI_x86_64_v2_libmypaint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmypaint-1.6.1-21.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmypaint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmypaint}"
SRC_URI[x86_64_v2_libmypaint.sha256sum] = "8856b41603586818a1b4486974885ffc8f192f237f390cb111ed6aec2ed1c63e"

URI_x86_64_v2_libmypaint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmypaint-devel-1.6.1-21.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmypaint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmypaint-devel}"
SRC_URI[x86_64_v2_libmypaint-devel.sha256sum] = "f8d393b5b613f00aecd1bf714d3e30296a0910ff8b2cf89e71799825c104a225"

URI_aarch64_libmypaint = "${EPEL_MIRROR}/aarch64/Packages/l/libmypaint-1.6.1-21.el10_2.aarch64.rpm;name=aarch64_libmypaint;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmypaint}"
SRC_URI[aarch64_libmypaint.sha256sum] = "487772c8290eb9a3599032c9dc497fe0026266fe315033b80b15d8d300f76fae"

URI_aarch64_libmypaint-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmypaint-devel-1.6.1-21.el10_2.aarch64.rpm;name=aarch64_libmypaint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmypaint-devel}"
SRC_URI[aarch64_libmypaint-devel.sha256sum] = "604254c45be40ff8fd0178810223070087daea9eeecbea6065c386eebdb53ac0"

RDEPENDS:libmypaint = " \
 glib2 \
 glibc \
 json-c \
 "
RDEPENDS:libmypaint-devel = " \
 glib2-devel \
 json-c-devel \
 libmypaint \
 pkgconf-pkg-config \
 "
