# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mesa"
PV = "25.2.7"
PR = "4.el10.alma.5"
PACKAGES = " \
 mesa-dri-drivers \
 mesa-filesystem \
 mesa-libEGL \
 mesa-libEGL-devel \
 mesa-libGL \
 mesa-libGL-devel \
 mesa-libgbm \
 mesa-libgbm-devel \
 mesa-vulkan-drivers \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mesa-25.2.7-4.el10.alma.5.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "660d85bbe661b36615f9e8992173920a280f30dbff2678aec46abd6935384b39"

URI_x86_64_v2_mesa-dri-drivers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-dri-drivers-25.2.7-4.el10.alma.5.x86_64_v2.rpm;name=x86_64_v2_mesa-dri-drivers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-dri-drivers}"
SRC_URI[x86_64_v2_mesa-dri-drivers.sha256sum] = "7611443fe3d5657b6c3b13ae8ad0e73872d0c713e806845dabc4a99a6f0628c3"

URI_x86_64_v2_mesa-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-filesystem-25.2.7-4.el10.alma.5.x86_64_v2.rpm;name=x86_64_v2_mesa-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-filesystem}"
SRC_URI[x86_64_v2_mesa-filesystem.sha256sum] = "3ae623721d8232886f4f414f60c38a00427f7bdd829b9bc53ce478548e883119"

URI_x86_64_v2_mesa-libEGL = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libEGL-25.2.7-4.el10.alma.5.x86_64_v2.rpm;name=x86_64_v2_mesa-libEGL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libEGL}"
SRC_URI[x86_64_v2_mesa-libEGL.sha256sum] = "836c45df10e40ca2c957ad0066bcd7d35e426a14549133b13201e6c2dcf64c86"

URI_x86_64_v2_mesa-libEGL-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libEGL-devel-25.2.7-4.el10.alma.5.x86_64_v2.rpm;name=x86_64_v2_mesa-libEGL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libEGL-devel}"
SRC_URI[x86_64_v2_mesa-libEGL-devel.sha256sum] = "1a24221d57fe615715b9f7027882b6f504da7bb5023f5853a17e193811ab2537"

URI_x86_64_v2_mesa-libGL = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libGL-25.2.7-4.el10.alma.5.x86_64_v2.rpm;name=x86_64_v2_mesa-libGL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libGL}"
SRC_URI[x86_64_v2_mesa-libGL.sha256sum] = "1f60fd3e177101ceeeda84343a578774904fcfcdf32bc8366e5b8ef7cda6bc43"

URI_x86_64_v2_mesa-libGL-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libGL-devel-25.2.7-4.el10.alma.5.x86_64_v2.rpm;name=x86_64_v2_mesa-libGL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libGL-devel}"
SRC_URI[x86_64_v2_mesa-libGL-devel.sha256sum] = "143e248dafb006f8f366538119131427ae5b884c65107a22f8184fca8e2c9d5f"

URI_x86_64_v2_mesa-libgbm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libgbm-25.2.7-4.el10.alma.5.x86_64_v2.rpm;name=x86_64_v2_mesa-libgbm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libgbm}"
SRC_URI[x86_64_v2_mesa-libgbm.sha256sum] = "21a2effb17353987a33651fa124de5f9f13a6c3df31e6066b6e3bc43a4a40cd4"

URI_x86_64_v2_mesa-libgbm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libgbm-devel-25.2.7-4.el10.alma.5.x86_64_v2.rpm;name=x86_64_v2_mesa-libgbm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libgbm-devel}"
SRC_URI[x86_64_v2_mesa-libgbm-devel.sha256sum] = "705d887ad8a65faad1d2a4570cd4d9f8bd7cc7ae15865fe47f43563f4d59efbe"

URI_x86_64_v2_mesa-vulkan-drivers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-vulkan-drivers-25.2.7-4.el10.alma.5.x86_64_v2.rpm;name=x86_64_v2_mesa-vulkan-drivers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-vulkan-drivers}"
SRC_URI[x86_64_v2_mesa-vulkan-drivers.sha256sum] = "93dbc4fda868c4d47819afd8d6c60f241d4bc993864bebabc6ef4c3495887369"

URI_aarch64_mesa-dri-drivers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-dri-drivers-25.2.7-4.el10.alma.5.aarch64.rpm;name=aarch64_mesa-dri-drivers;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-dri-drivers}"
SRC_URI[aarch64_mesa-dri-drivers.sha256sum] = "471dd61623af5bb83f68d2c1af1c37ff52f340a1547aaabc4e891e8312f1d58c"

URI_aarch64_mesa-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-filesystem-25.2.7-4.el10.alma.5.aarch64.rpm;name=aarch64_mesa-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-filesystem}"
SRC_URI[aarch64_mesa-filesystem.sha256sum] = "cbb1e62dacc86c79b1ffec85f5717b6b478f41985ef3f0cc552d28c945cec9dd"

URI_aarch64_mesa-libEGL = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libEGL-25.2.7-4.el10.alma.5.aarch64.rpm;name=aarch64_mesa-libEGL;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libEGL}"
SRC_URI[aarch64_mesa-libEGL.sha256sum] = "8e976e507a8828633023e0031ec24dd41c5bb3d4554a36071d3057313a2ccb72"

URI_aarch64_mesa-libEGL-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libEGL-devel-25.2.7-4.el10.alma.5.aarch64.rpm;name=aarch64_mesa-libEGL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libEGL-devel}"
SRC_URI[aarch64_mesa-libEGL-devel.sha256sum] = "76346d937ca0ef613b3c6edad079460c6f337d4702f38b367472e8f561c1eaed"

URI_aarch64_mesa-libGL = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libGL-25.2.7-4.el10.alma.5.aarch64.rpm;name=aarch64_mesa-libGL;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libGL}"
SRC_URI[aarch64_mesa-libGL.sha256sum] = "5afefee8db2ee6469dd9a93c9636d41b5d7073ae45f8e20ff15938ec228edbeb"

URI_aarch64_mesa-libGL-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libGL-devel-25.2.7-4.el10.alma.5.aarch64.rpm;name=aarch64_mesa-libGL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libGL-devel}"
SRC_URI[aarch64_mesa-libGL-devel.sha256sum] = "5b8673b9081aaf32d1d3d8610419d2a76a35ccf9d81f821a27d230c4a3f83b65"

URI_aarch64_mesa-libgbm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libgbm-25.2.7-4.el10.alma.5.aarch64.rpm;name=aarch64_mesa-libgbm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libgbm}"
SRC_URI[aarch64_mesa-libgbm.sha256sum] = "b88c5d9f6eb1a4ef7741b50e7fa8e8cb59ca14215da7f4dda7dcd76cde71c368"

URI_aarch64_mesa-libgbm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libgbm-devel-25.2.7-4.el10.alma.5.aarch64.rpm;name=aarch64_mesa-libgbm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libgbm-devel}"
SRC_URI[aarch64_mesa-libgbm-devel.sha256sum] = "31015db2ab191b4be15506d54231fd161cfe85ca2ea18c2f0e7fd5862799d54e"

URI_aarch64_mesa-vulkan-drivers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-vulkan-drivers-25.2.7-4.el10.alma.5.aarch64.rpm;name=aarch64_mesa-vulkan-drivers;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-vulkan-drivers}"
SRC_URI[aarch64_mesa-vulkan-drivers.sha256sum] = "993f75e8e8cdddfe7cffe8f1191cc05214c622465db05e4438a06b41062e0fbc"

RDEPENDS:mesa-dri-drivers = " \
 elfutils-libelf \
 expat \
 glibc \
 libX11-xcb \
 libdrm \
 libgcc \
 libstdc++ \
 libxcb \
 libxshmfence \
 libzstd \
 llvm-libs \
 mesa-filesystem \
 mesa-libgbm \
 spirv-tools-libs \
 zlib-ng-compat \
 "
RDEPENDS:mesa-filesystem = " \
 "
RDEPENDS:mesa-libEGL = " \
 expat \
 glibc \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libwayland-client \
 libxcb \
 mesa-dri-drivers \
 mesa-libgbm \
 "
RDEPENDS:mesa-libEGL-devel = " \
 libglvnd-devel \
 mesa-libEGL \
 "
RDEPENDS:mesa-libGL = " \
 expat \
 glibc \
 libX11 \
 libX11-xcb \
 libXext \
 libXxf86vm \
 libdrm \
 libglvnd-glx \
 libxcb \
 mesa-dri-drivers \
 "
RDEPENDS:mesa-libGL-devel = " \
 libdrm-devel \
 libglvnd-devel \
 mesa-libGL \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-libgbm = " \
 expat \
 glibc \
 libdrm \
 mesa-dri-drivers \
 "
RDEPENDS:mesa-libgbm-devel = " \
 mesa-libgbm \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-vulkan-drivers = " \
 elfutils-libelf \
 expat \
 glibc \
 libX11-xcb \
 libdrm \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 libxshmfence \
 libzstd \
 llvm-libs \
 mesa-filesystem \
 spirv-tools-libs \
 systemd-libs \
 vulkan-loader \
 zlib-ng-compat \
 "
