# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-cloud-google-spanner"
PV = "1.63.0"
PR = "3.el10_0~bootstrap"
PACKAGES = " \
 golang-cloud-google-spanner-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-cloud-google-spanner-1.63.0-3.el10_0~bootstrap.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edab5db8fa6e7c30e3d22c45e211701026a48ac76972c565a774eb130c7e0f57"

URI_x86_64_v2_golang-cloud-google-spanner-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-cloud-google-spanner-devel-1.63.0-3.el10_0~bootstrap.alma_altarch.noarch.rpm;name=x86_64_v2_golang-cloud-google-spanner-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-cloud-google-spanner-devel}"
SRC_URI[x86_64_v2_golang-cloud-google-spanner-devel.sha256sum] = "248fdf7f4f451e5a82cd5edce96c52b5bdc3fec3154a60a4f34a98ca84b13941"

URI_aarch64_golang-cloud-google-spanner-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-cloud-google-spanner-devel-1.63.0-3.el10_0~bootstrap.noarch.rpm;name=aarch64_golang-cloud-google-spanner-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-cloud-google-spanner-devel}"
SRC_URI[aarch64_golang-cloud-google-spanner-devel.sha256sum] = "a4d0cdb5bebecced9a27d64ac8d26749d6f74318ef519e7e19d9b54ffc45e7a1"

RDEPENDS:golang-cloud-google-spanner-devel = " \
 go-filesystem \
 "
