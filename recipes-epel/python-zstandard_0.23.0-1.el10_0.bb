# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-zstandard"
PV = "0.23.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-zstandard \
 python3-zstandard+cffi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-zstandard-0.23.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fc3b69c5c0b1875624c337ef7a8877fd9cde53efa1905d7508dda1f30e3b2ad"

URI_x86_64_v2_python3-zstandard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zstandard-0.23.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-zstandard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zstandard}"
SRC_URI[x86_64_v2_python3-zstandard.sha256sum] = "cca3aa73e593659381be7180e1eeeb43dc6a7b2031938c5fc1dcb816a9b05b1b"

URI_x86_64_v2_python3-zstandard+cffi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zstandard+cffi-0.23.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-zstandard+cffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zstandard+cffi}"
SRC_URI[x86_64_v2_python3-zstandard+cffi.sha256sum] = "dae87ab843d8558b0678b53360b23cff237b5337b759ef7f3b881bb71bb227c0"

URI_aarch64_python3-zstandard = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zstandard-0.23.0-1.el10_0.aarch64.rpm;name=aarch64_python3-zstandard;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zstandard}"
SRC_URI[aarch64_python3-zstandard.sha256sum] = "a323842e8f053a318dd2b87d9e272724420a468cbd59102d6e12b29373b751fb"

URI_aarch64_python3-zstandard+cffi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zstandard+cffi-0.23.0-1.el10_0.aarch64.rpm;name=aarch64_python3-zstandard+cffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zstandard+cffi}"
SRC_URI[aarch64_python3-zstandard+cffi.sha256sum] = "8f379a036bb2c3b4cfa16297fb44a203414b0e9a582f9ca3e2abe9821f44e573"

RDEPENDS:python3-zstandard = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-zstandard+cffi = " \
 python3 \
 python3-cffi \
 python3-zstandard \
 "
