# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indoc"
PV = "2.0.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-indoc+default-devel \
 rust-indoc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indoc-2.0.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea655f0e870e0612882b7ea3e607a719d4cbf692431822276221372bda4bcaa3"

URI_x86_64_v2_rust-indoc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indoc+default-devel-2.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indoc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indoc+default-devel}"
SRC_URI[x86_64_v2_rust-indoc+default-devel.sha256sum] = "9219613d01d5658a4546d92c141c3930319ca6a345a63f9345b9d018732f11c1"

URI_x86_64_v2_rust-indoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indoc-devel-2.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indoc-devel}"
SRC_URI[x86_64_v2_rust-indoc-devel.sha256sum] = "c8988f1f876247fa7e646c91169092a0563026f2ad0e83fa33abd7d5360be3d1"

URI_aarch64_rust-indoc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indoc+default-devel-2.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-indoc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indoc+default-devel}"
SRC_URI[aarch64_rust-indoc+default-devel.sha256sum] = "d1f0bf35e8a98f5ec609ad68f4fcb927d648be8be536e1ff490669808277cf9c"

URI_aarch64_rust-indoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indoc-devel-2.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-indoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indoc-devel}"
SRC_URI[aarch64_rust-indoc-devel.sha256sum] = "5709be7b52063394b5135774ecff91d9e98a74799a2626172abde2e7095c4462"

RDEPENDS:rust-indoc+default-devel = " \
 cargo \
 rust-indoc-devel \
 "
RDEPENDS:rust-indoc-devel = " \
 cargo \
 rust \
 "
