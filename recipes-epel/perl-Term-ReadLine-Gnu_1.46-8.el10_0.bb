# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Term-ReadLine-Gnu"
PV = "1.46"
PR = "8.el10_0"
PACKAGES = " \
 perl-Term-ReadLine-Gnu \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Term-ReadLine-Gnu-1.46-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec0c18d8f14b18d1eacccfc20d0a48566aa479f0fbd10e4f54b34442267f6c2e"

URI_x86_64_v2_perl-Term-ReadLine-Gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Term-ReadLine-Gnu-1.46-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Term-ReadLine-Gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Term-ReadLine-Gnu}"
SRC_URI[x86_64_v2_perl-Term-ReadLine-Gnu.sha256sum] = "d16edd50a90a54e1e24c62ae1c37e1e067a8e7fbac570a0210e87f6257d7537f"

URI_aarch64_perl-Term-ReadLine-Gnu = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Term-ReadLine-Gnu-1.46-8.el10_0.aarch64.rpm;name=aarch64_perl-Term-ReadLine-Gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Term-ReadLine-Gnu}"
SRC_URI[aarch64_perl-Term-ReadLine-Gnu.sha256sum] = "f13f1438c28be1c536e76787947005bdb2f86dc3c4e55c554ce3414e6dd159fd"

RDEPENDS:perl-Term-ReadLine-Gnu = " \
 glibc \
 ncurses-libs \
 perl-AutoLoader \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-POSIX \
 perl-Term-ReadLine \
 perl-Term-ReadLine-Gnu \
 perl-interpreter \
 perl-libs \
 perl-vars \
 readline \
 "
