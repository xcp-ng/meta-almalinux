# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tldr"
PV = "3.3.0"
PR = "3.el10_0"
PACKAGES = " \
 tldr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tldr-3.3.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0a3bd675709206f4250ba47db3d075cf5212333cf8b9ec1663fe342b5c1876f"

URI_x86_64_v2_tldr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tldr-3.3.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_tldr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tldr}"
SRC_URI[x86_64_v2_tldr.sha256sum] = "6f63d62208fd807643fb4897340524ae812f79db396f63cc586a0cfb8452fc60"

URI_aarch64_tldr = "${EPEL_MIRROR}/aarch64/Packages/t/tldr-3.3.0-3.el10_0.noarch.rpm;name=aarch64_tldr;unpack=0"
SRC_URI:append = " ${URI_aarch64_tldr}"
SRC_URI[aarch64_tldr.sha256sum] = "ca96f6e1bfc2ad435c4cd2627e0fa986663bc8812ab03515c45ef1ec36f6ddfb"

RDEPENDS:tldr = " \
 python3 \
 python3-colorama \
 python3-shtab \
 python3-termcolor \
 "
