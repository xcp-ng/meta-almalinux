# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "papers"
PV = "48.7"
PR = "3.el10"
PACKAGES = " \
 papers \
 papers-devel \
 papers-libs \
 papers-nautilus \
 papers-previewer \
 papers-thumbnailer \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/papers-48.7-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f34ab47169fad5a9f944a8328c56abaa4f8843b247320cee839656e46dc34205"

URI_x86_64_v2_papers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-48.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_papers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers}"
SRC_URI[x86_64_v2_papers.sha256sum] = "3c5e3b34ca5e0cf252dbcdd7b04736ab5bf4eb1985ea0daafcc9d6358f3a3a5a"

URI_x86_64_v2_papers-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/papers-devel-48.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_papers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-devel}"
SRC_URI[x86_64_v2_papers-devel.sha256sum] = "bc87348efae4fb52fddfe65a0de10bd8c7b0b1d54f80d13cc0af3cf95c4a73d4"

URI_x86_64_v2_papers-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-libs-48.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_papers-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-libs}"
SRC_URI[x86_64_v2_papers-libs.sha256sum] = "d333f4a30554f6c1b5b5852ff05271c11abeb07dcae60edb5afb90896114649c"

URI_x86_64_v2_papers-nautilus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-nautilus-48.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_papers-nautilus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-nautilus}"
SRC_URI[x86_64_v2_papers-nautilus.sha256sum] = "a9db4711b6046e9e45bb81749b162108b712a541ee0713ef7df42973758abe9b"

URI_x86_64_v2_papers-previewer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-previewer-48.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_papers-previewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-previewer}"
SRC_URI[x86_64_v2_papers-previewer.sha256sum] = "741ebaa6ce93102eccffadac382204a46f7cf7cb098b301562e908270ffbbeff"

URI_x86_64_v2_papers-thumbnailer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-thumbnailer-48.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_papers-thumbnailer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-thumbnailer}"
SRC_URI[x86_64_v2_papers-thumbnailer.sha256sum] = "0d89ee085dc1a4c35f69990d9abff839ac6dd57b492a2d153de83876501a2c88"

URI_aarch64_papers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-48.7-3.el10.aarch64.rpm;name=aarch64_papers;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers}"
SRC_URI[aarch64_papers.sha256sum] = "dd31db90374d56b08211fb03de4b997400ff9cf2430e4380a8be9d548b6a6c91"

URI_aarch64_papers-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/papers-devel-48.7-3.el10.aarch64.rpm;name=aarch64_papers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-devel}"
SRC_URI[aarch64_papers-devel.sha256sum] = "fa9f375475cd47dbbc3952d2f16ba71d42985b63bb7d3650a81e25a0dd100784"

URI_aarch64_papers-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-libs-48.7-3.el10.aarch64.rpm;name=aarch64_papers-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-libs}"
SRC_URI[aarch64_papers-libs.sha256sum] = "63121c60e34a45b452b9c6ebb0295d546fc8f7f2959e4447dabcaf84714fe0f4"

URI_aarch64_papers-nautilus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-nautilus-48.7-3.el10.aarch64.rpm;name=aarch64_papers-nautilus;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-nautilus}"
SRC_URI[aarch64_papers-nautilus.sha256sum] = "fa54492dce29c6fa8fd3919c4f39a7514159976a619eec04672f741b46e72254"

URI_aarch64_papers-previewer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-previewer-48.7-3.el10.aarch64.rpm;name=aarch64_papers-previewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-previewer}"
SRC_URI[aarch64_papers-previewer.sha256sum] = "25fc1c771599e1d06c933e7c5e920d25082cfe9c90af6bb98e93ef2225dec2c9"

URI_aarch64_papers-thumbnailer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-thumbnailer-48.7-3.el10.aarch64.rpm;name=aarch64_papers-thumbnailer;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-thumbnailer}"
SRC_URI[aarch64_papers-thumbnailer.sha256sum] = "856f0d090fe884c76d6cd2708f2f5a6258b81429f3ba9e72033ee1ab2b294d7b"

RDEPENDS:papers = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 hicolor-icon-theme \
 libadwaita \
 libgcc \
 pango \
 papers-libs \
 papers-previewer \
 papers-thumbnailer \
 "
RDEPENDS:papers-devel = " \
 glib2-devel \
 gtk4-devel \
 libadwaita-devel \
 papers-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:papers-libs = " \
 cairo \
 exempi \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 gtksourceview5 \
 libadwaita \
 libarchive \
 libgcc \
 libspelling \
 libtiff \
 pango \
 poppler-glib \
 "
RDEPENDS:papers-nautilus = " \
 glib2 \
 glibc \
 libgcc \
 nautilus \
 nautilus-extensions \
 papers-libs \
 "
RDEPENDS:papers-previewer = " \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
 libgcc \
 papers-libs \
 "
RDEPENDS:papers-thumbnailer = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libgcc \
 papers-libs \
 "
