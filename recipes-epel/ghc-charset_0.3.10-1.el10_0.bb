# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-charset"
PV = "0.3.10"
PR = "1.el10_0"
PACKAGES = " \
 ghc-charset \
 ghc-charset-devel \
 ghc-charset-doc \
 ghc-charset-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-charset-0.3.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "099ca059b0aa60b678e37621f203be8fa05ddd4037efe0755500447a7fcb7e93"

URI_x86_64_v2_ghc-charset = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-charset-0.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-charset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-charset}"
SRC_URI[x86_64_v2_ghc-charset.sha256sum] = "ca19e367e47427ba683737289ed43cdd64b2f7756b9a3c030a97452cbc0a4e31"

URI_x86_64_v2_ghc-charset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-charset-devel-0.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-charset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-charset-devel}"
SRC_URI[x86_64_v2_ghc-charset-devel.sha256sum] = "cd9924f3c26a28555e2949bb45a0cbe47daecbbd07fae6daf75862fafcaf1be7"

URI_x86_64_v2_ghc-charset-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-charset-doc-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-charset-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-charset-doc}"
SRC_URI[x86_64_v2_ghc-charset-doc.sha256sum] = "15f67e1d3d8ccfe43f768d05c61ea3cb7c040d551fb32e0f51a180a237f3a0d2"

URI_x86_64_v2_ghc-charset-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-charset-prof-0.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-charset-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-charset-prof}"
SRC_URI[x86_64_v2_ghc-charset-prof.sha256sum] = "abf97f9b229f2419f83dd5716ab6fa35fa4316184c12331c705682c2072082a8"

URI_aarch64_ghc-charset = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-charset-0.3.10-1.el10_0.aarch64.rpm;name=aarch64_ghc-charset;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-charset}"
SRC_URI[aarch64_ghc-charset.sha256sum] = "dc21cfc5f8aa5a96e6321e75bc5e2b06a600227a2a28fde7dca523e7a45fa609"

URI_aarch64_ghc-charset-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-charset-devel-0.3.10-1.el10_0.aarch64.rpm;name=aarch64_ghc-charset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-charset-devel}"
SRC_URI[aarch64_ghc-charset-devel.sha256sum] = "dbd792de73213d56414b312b53261309bcfce5c35ab9d7fc671e9aba1619b2b4"

URI_aarch64_ghc-charset-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-charset-doc-0.3.10-1.el10_0.noarch.rpm;name=aarch64_ghc-charset-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-charset-doc}"
SRC_URI[aarch64_ghc-charset-doc.sha256sum] = "3ec59a9ec343560cb0a7b2889d8b28fa578601078afa22745c0c2cd35afff296"

URI_aarch64_ghc-charset-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-charset-prof-0.3.10-1.el10_0.aarch64.rpm;name=aarch64_ghc-charset-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-charset-prof}"
SRC_URI[aarch64_ghc-charset-prof.sha256sum] = "180bfc9952487958dc7064f3b9405af8fca3632da4ffd2f1769fa82061d1d3a8"

RDEPENDS:ghc-charset = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-unordered-containers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-charset-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-charset \
 ghc-compiler \
 ghc-containers-devel \
 ghc-unordered-containers-devel \
 "
RDEPENDS:ghc-charset-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-charset-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-charset-devel \
 ghc-containers-prof \
 ghc-unordered-containers-prof \
 "
