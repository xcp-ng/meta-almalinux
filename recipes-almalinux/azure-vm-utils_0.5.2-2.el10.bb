# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "azure-vm-utils"
PV = "0.5.2"
PR = "2.el10"
PACKAGES = " \
 azure-vm-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/azure-vm-utils-0.5.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d79eeb27dc36253961e17cf62d47bf28338dcf458332a34274dc2c98eabcde6"

URI_x86_64_v2_azure-vm-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/azure-vm-utils-0.5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_azure-vm-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_azure-vm-utils}"
SRC_URI[x86_64_v2_azure-vm-utils.sha256sum] = "4eae19e81365f10286673b77b7484d9c022bf62aaac69f4a589ade231c005e3a"

URI_aarch64_azure-vm-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/azure-vm-utils-0.5.2-2.el10.aarch64.rpm;name=aarch64_azure-vm-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_azure-vm-utils}"
SRC_URI[aarch64_azure-vm-utils.sha256sum] = "d51fc24b55d2decb4a0b39d468f46074285f7f9450b5681086e2fa842b3c68dd"

RDEPENDS:azure-vm-utils = " \
 bash \
 glibc \
 json-c \
 "
