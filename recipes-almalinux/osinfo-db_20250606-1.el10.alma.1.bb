# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osinfo-db"
PV = "20250606"
PR = "1.el10.alma.1"
PACKAGES = " \
 osinfo-db \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/osinfo-db-20250606-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d258875d0194e9e33dc314e6b4912c72c442853a8bea3a92c5ae461dff1b4917"

URI_x86_64_v2_osinfo-db = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osinfo-db-20250606-1.el10.alma.1.noarch.rpm;name=x86_64_v2_osinfo-db;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osinfo-db}"
SRC_URI[x86_64_v2_osinfo-db.sha256sum] = "8927328507233939c9fc5d1d2d719e026b1aa2c4bcb355d63964feb36d232f39"

URI_aarch64_osinfo-db = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osinfo-db-20250606-1.el10.alma.1.noarch.rpm;name=aarch64_osinfo-db;unpack=0"
SRC_URI:append = " ${URI_aarch64_osinfo-db}"
SRC_URI[aarch64_osinfo-db.sha256sum] = "8927328507233939c9fc5d1d2d719e026b1aa2c4bcb355d63964feb36d232f39"

RDEPENDS:osinfo-db = " \
 hwdata \
 "
