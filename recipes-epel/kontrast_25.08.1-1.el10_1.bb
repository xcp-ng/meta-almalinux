# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kontrast"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kontrast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kontrast-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bf987ebd23ae8c1450a4ba33993ece8b4aa20cd8a0126104f42b2b0dee7f5ba"

URI_x86_64_v2_kontrast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontrast-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontrast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontrast}"
SRC_URI[x86_64_v2_kontrast.sha256sum] = "a8b5675b16de703ae7d62ea812fe5c71ba87fafa4ec601a8e9716aa6c1a1b01a"

URI_aarch64_kontrast = "${EPEL_MIRROR}/aarch64/Packages/k/kontrast-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kontrast;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontrast}"
SRC_URI[aarch64_kontrast.sha256sum] = "984bdfe6b06836a8e2dbde58837098b92c19012976d5ebdcdda9de721404d3cf"

RDEPENDS:kontrast = " \
 futuresql-qt6 \
 glibc \
 hicolor-icon-theme \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
