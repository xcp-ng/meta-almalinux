# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-All"
PV = "0.87"
PR = "26.el10"
PACKAGES = " \
 perl-IO-All \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-IO-All-0.87-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6db17b8667e9868b4b9e76bf5953ddc2701fef5952538637a61944fc6f58b43c"

URI_x86_64_v2_perl-IO-All = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-IO-All-0.87-26.el10.noarch.rpm;name=x86_64_v2_perl-IO-All;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-All}"
SRC_URI[x86_64_v2_perl-IO-All.sha256sum] = "d2069fc8ecb6cefcc7d473c8adaad1f5954913ca7093c06f4e2188f98bdc6168"

URI_aarch64_perl-IO-All = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-IO-All-0.87-26.el10.noarch.rpm;name=aarch64_perl-IO-All;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-All}"
SRC_URI[aarch64_perl-IO-All.sha256sum] = "d2069fc8ecb6cefcc7d473c8adaad1f5954913ca7093c06f4e2188f98bdc6168"

RDEPENDS:perl-IO-All = " \
 perl-Carp \
 perl-Fcntl \
 perl-File-Copy \
 perl-File-MimeInfo \
 perl-File-Path \
 perl-File-ReadBackwards \
 perl-IO \
 perl-IO-All \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-Tie-File \
 perl-libs \
 perl-overload \
 "
