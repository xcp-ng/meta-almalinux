# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dragon"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 dragon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dragon-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e3625fc38a34e9e5dbf520c9215a1aabea2441ef064b0e4e89c8cbd1f53de4a"

URI_x86_64_v2_dragon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dragon-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dragon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dragon}"
SRC_URI[x86_64_v2_dragon.sha256sum] = "51c0ff270c2535a3a80f3298d796fd935bf47adfc35f325f3f1524e97dc581a1"

URI_aarch64_dragon = "${EPEL_MIRROR}/aarch64/Packages/d/dragon-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_dragon;unpack=0"
SRC_URI:append = " ${URI_aarch64_dragon}"
SRC_URI[aarch64_dragon.sha256sum] = "c71ca9e9f908d05aa6a8c183498b4ce64ce60da648e68b6f9d5b758690812f62"

RDEPENDS:dragon = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kwindowsystem \
 libavcodec-free \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
