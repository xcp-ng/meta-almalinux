# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enum-iterator"
PV = "2.3.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-enum-iterator+default-devel \
 rust-enum-iterator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enum-iterator-2.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "165a858949c59688ba13a733205176a126d3370307d7b8ae8c3cc538675beee0"

URI_x86_64_v2_rust-enum-iterator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-iterator+default-devel-2.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-iterator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-iterator+default-devel}"
SRC_URI[x86_64_v2_rust-enum-iterator+default-devel.sha256sum] = "b11d847d6d0a1772563e44c204975006271df373e2ba4b6fff6bb55796565b9a"

URI_x86_64_v2_rust-enum-iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-iterator-devel-2.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-iterator-devel}"
SRC_URI[x86_64_v2_rust-enum-iterator-devel.sha256sum] = "9feb2f0b52eadf7c3dba4701a8db23648908c0696d51490a370f762a609750ec"

URI_aarch64_rust-enum-iterator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-iterator+default-devel-2.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-enum-iterator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-iterator+default-devel}"
SRC_URI[aarch64_rust-enum-iterator+default-devel.sha256sum] = "94c1ce10908515509677f0b793a0b370dad556b566fd4ba796b548b9974fedd4"

URI_aarch64_rust-enum-iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-iterator-devel-2.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-enum-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-iterator-devel}"
SRC_URI[aarch64_rust-enum-iterator-devel.sha256sum] = "5fccf4cccf0488b6a043c7e55633625907224382f02369444711306fc3409157"

RDEPENDS:rust-enum-iterator+default-devel = " \
 cargo \
 rust-enum-iterator-devel \
 "
RDEPENDS:rust-enum-iterator-devel = " \
 cargo \
 rust-enum-iterator-derive+default-devel \
 "
