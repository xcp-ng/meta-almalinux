# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-versions"
PV = "6.0.7"
PR = "2.el10_0"
PACKAGES = " \
 ghc-versions \
 ghc-versions-devel \
 ghc-versions-doc \
 ghc-versions-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-versions-6.0.7-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18bc81b20eaff4b1102851ff731e9339af282a0eb32afb5c995aedf320ea579f"

URI_x86_64_v2_ghc-versions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-versions-6.0.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-versions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-versions}"
SRC_URI[x86_64_v2_ghc-versions.sha256sum] = "2ca5f1cb11915c65c06668515f92a31ee6264fb2da5881d9e40d4af4e93dd8d1"

URI_x86_64_v2_ghc-versions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-versions-devel-6.0.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-versions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-versions-devel}"
SRC_URI[x86_64_v2_ghc-versions-devel.sha256sum] = "6674706958df93a1f6128fe0b242b7e23a2bc73fec6f2ca7a806049749946219"

URI_x86_64_v2_ghc-versions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-versions-doc-6.0.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-versions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-versions-doc}"
SRC_URI[x86_64_v2_ghc-versions-doc.sha256sum] = "158ce1bd473d9b5b4a47602e8e76ade39beca01cd6eb314f55d1edc5dbdecaed"

URI_x86_64_v2_ghc-versions-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-versions-prof-6.0.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-versions-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-versions-prof}"
SRC_URI[x86_64_v2_ghc-versions-prof.sha256sum] = "c99ec91a4e9ddd58d92d3bcea13900714844bfb49a8561b0151a7428d8c08b65"

URI_aarch64_ghc-versions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-versions-6.0.7-2.el10_0.aarch64.rpm;name=aarch64_ghc-versions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-versions}"
SRC_URI[aarch64_ghc-versions.sha256sum] = "b33028c25a775acef0148ba3b58cf512deefe63ae9e7e4cc40b59811f4724c7d"

URI_aarch64_ghc-versions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-versions-devel-6.0.7-2.el10_0.aarch64.rpm;name=aarch64_ghc-versions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-versions-devel}"
SRC_URI[aarch64_ghc-versions-devel.sha256sum] = "2e86e15a2a8b49140624f769afbf929673893510802fbb076195215ec6161ade"

URI_aarch64_ghc-versions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-versions-doc-6.0.7-2.el10_0.noarch.rpm;name=aarch64_ghc-versions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-versions-doc}"
SRC_URI[aarch64_ghc-versions-doc.sha256sum] = "b90ef48944bf568240cab7dda657a16feb88d538c7902d69523d21dbc9e487a6"

URI_aarch64_ghc-versions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-versions-prof-6.0.7-2.el10_0.aarch64.rpm;name=aarch64_ghc-versions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-versions-prof}"
SRC_URI[aarch64_ghc-versions-prof.sha256sum] = "5845aa8835c85571b37e81258b7a87c40566f05f0c7f80bdbb00d0cf9a3653a1"

RDEPENDS:ghc-versions = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-megaparsec \
 ghc-mtl \
 ghc-os-string \
 ghc-parser-combinators \
 ghc-pretty \
 ghc-primitive \
 ghc-scientific \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-versions-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-hashable-devel \
 ghc-megaparsec-devel \
 ghc-parser-combinators-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-versions \
 "
RDEPENDS:ghc-versions-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-versions-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-hashable-prof \
 ghc-megaparsec-prof \
 ghc-parser-combinators-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-versions-devel \
 "
