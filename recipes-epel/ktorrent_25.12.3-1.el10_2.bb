# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktorrent"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ktorrent \
 ktorrent-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktorrent-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c6d73a311476f84ef59d6180a9f108795a04f67a1f522289348ede302105474"

URI_x86_64_v2_ktorrent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktorrent-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktorrent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktorrent}"
SRC_URI[x86_64_v2_ktorrent.sha256sum] = "691238842ba7cf9ad0579b674729bc4e6b67ed6b9c630fd72dab49aa8f00357d"

URI_x86_64_v2_ktorrent-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktorrent-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktorrent-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktorrent-libs}"
SRC_URI[x86_64_v2_ktorrent-libs.sha256sum] = "3f9419a1521f9eb315a03d900ee799ecf3b4c6d56505028ec99de6e457e2f31d"

URI_aarch64_ktorrent = "${EPEL_MIRROR}/aarch64/Packages/k/ktorrent-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ktorrent;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktorrent}"
SRC_URI[aarch64_ktorrent.sha256sum] = "cfd52dde4fab0f3bb71bbacb47fd20fb6b867bc205898f3f7eac0b78e3d0064e"

URI_aarch64_ktorrent-libs = "${EPEL_MIRROR}/aarch64/Packages/k/ktorrent-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ktorrent-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktorrent-libs}"
SRC_URI[aarch64_ktorrent-libs.sha256sum] = "c75e6cbcc727d96a124448b4005007f85a22a4a37cd3d19e0ad84f6d6280cfa2"

RDEPENDS:ktorrent = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kplotting \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-syndication \
 ktorrent-libs \
 libgcc \
 libktorrent \
 libmaxminddb \
 libstdc++ \
 phonon-qt6 \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 taglib \
 "
RDEPENDS:ktorrent-libs = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 ktorrent \
 libgcc \
 libktorrent \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
