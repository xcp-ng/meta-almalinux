# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mbedtls"
PV = "3.6.6"
PR = "1.el10_1"
PACKAGES = " \
 mbedtls \
 mbedtls-devel \
 mbedtls-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mbedtls-3.6.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83eafaa29b0c863d25c3c73c8535b8bce247ef1d5a0d034432128980bc8c8e0b"

URI_x86_64_v2_mbedtls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbedtls-3.6.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbedtls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbedtls}"
SRC_URI[x86_64_v2_mbedtls.sha256sum] = "a4078759330134d3b615d6c8b48298b3dbaceed8a773d09f71350ec48ac4d479"

URI_x86_64_v2_mbedtls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbedtls-devel-3.6.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbedtls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbedtls-devel}"
SRC_URI[x86_64_v2_mbedtls-devel.sha256sum] = "d2d9ce989008b1a9bb359d145de65071b7d639812679e0b9b09c8603b17a3088"

URI_x86_64_v2_mbedtls-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbedtls-doc-3.6.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mbedtls-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbedtls-doc}"
SRC_URI[x86_64_v2_mbedtls-doc.sha256sum] = "b5adfb216a671c91a51e0453b5aa64f16d85730e2cab9d6f32be86a3b721cb70"

URI_aarch64_mbedtls = "${EPEL_MIRROR}/aarch64/Packages/m/mbedtls-3.6.6-1.el10_1.aarch64.rpm;name=aarch64_mbedtls;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbedtls}"
SRC_URI[aarch64_mbedtls.sha256sum] = "9bde8dc718e611c98f207c30c7feb39ed1722e69327ed079179500ea3d7c4bec"

URI_aarch64_mbedtls-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mbedtls-devel-3.6.6-1.el10_1.aarch64.rpm;name=aarch64_mbedtls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbedtls-devel}"
SRC_URI[aarch64_mbedtls-devel.sha256sum] = "5492f238d6fd1247f735c265546eb8ff14951cbd6e77cc58858c717571909c5e"

URI_aarch64_mbedtls-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mbedtls-doc-3.6.6-1.el10_1.noarch.rpm;name=aarch64_mbedtls-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbedtls-doc}"
SRC_URI[aarch64_mbedtls-doc.sha256sum] = "0b2e77e955415a78cb0a403777aa4e4de152e2708a05c31562aed740962cb772"

RDEPENDS:mbedtls = " \
 glibc \
 "
RDEPENDS:mbedtls-devel = " \
 cmake-filesystem \
 glibc \
 mbedtls \
 mbedtls-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:mbedtls-doc = " \
 "
