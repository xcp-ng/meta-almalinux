# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lv2"
PV = "1.18.10"
PR = "1.el10_0"
PACKAGES = " \
 lv2 \
 lv2-devel \
 lv2-doc \
 lv2-example-plugins \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lv2-1.18.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c30125200dad188b8155f4e74596b49b8812c7c3286ec160df96525e0027a948"

URI_x86_64_v2_lv2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lv2-1.18.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lv2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lv2}"
SRC_URI[x86_64_v2_lv2.sha256sum] = "de22dd67440b0518d89abb77dc3e28f18cf7eb8330227d013080a73457d7bb49"

URI_x86_64_v2_lv2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lv2-devel-1.18.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lv2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lv2-devel}"
SRC_URI[x86_64_v2_lv2-devel.sha256sum] = "186d3aed90b3ff645edf17ff2f66954588973587ac8a5437cb2238c7b8decaad"

URI_x86_64_v2_lv2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lv2-doc-1.18.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lv2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lv2-doc}"
SRC_URI[x86_64_v2_lv2-doc.sha256sum] = "97b7e6e910e83b394cfefb37e95493a3ec3817c99f5be589d3fcb0d7fd070f85"

URI_x86_64_v2_lv2-example-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lv2-example-plugins-1.18.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lv2-example-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lv2-example-plugins}"
SRC_URI[x86_64_v2_lv2-example-plugins.sha256sum] = "baf052b98fce9da5e368a9b937532fda0ed5d08ce425056b5aa04d87f5748a6e"

URI_aarch64_lv2 = "${EPEL_MIRROR}/aarch64/Packages/l/lv2-1.18.10-1.el10_0.aarch64.rpm;name=aarch64_lv2;unpack=0"
SRC_URI:append = " ${URI_aarch64_lv2}"
SRC_URI[aarch64_lv2.sha256sum] = "8f97dc6e0a9e30dd30a1335ebe30e78c3d47deb4d9e0f9bf989e4f48229d5b03"

URI_aarch64_lv2-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lv2-devel-1.18.10-1.el10_0.aarch64.rpm;name=aarch64_lv2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lv2-devel}"
SRC_URI[aarch64_lv2-devel.sha256sum] = "0f0780e42f10a0dfb33a190a4457847cd69911ac7affabf11fd15c73f9535852"

URI_aarch64_lv2-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lv2-doc-1.18.10-1.el10_0.noarch.rpm;name=aarch64_lv2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lv2-doc}"
SRC_URI[aarch64_lv2-doc.sha256sum] = "8f13b243bd26afe9920b2401a573c960cbffc53f32d32577dee0c54e07f59ee8"

URI_aarch64_lv2-example-plugins = "${EPEL_MIRROR}/aarch64/Packages/l/lv2-example-plugins-1.18.10-1.el10_0.aarch64.rpm;name=aarch64_lv2-example-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_lv2-example-plugins}"
SRC_URI[aarch64_lv2-example-plugins.sha256sum] = "4dc11d60371e0928b92b16ace6122aa9650535f1a4d41e2da37a9b74776ff96c"

RDEPENDS:lv2 = " \
 "
RDEPENDS:lv2-devel = " \
 bash \
 lv2 \
 pkgconf-pkg-config \
 python3 \
 python3-markdown \
 python3-rdflib \
 "
RDEPENDS:lv2-doc = " \
 "
RDEPENDS:lv2-example-plugins = " \
 glibc \
 lv2 \
 "
