# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-backtrace"
PV = "0.3.75"
PR = "1.el10_0"
PACKAGES = " \
 rust-backtrace+cpp_demangle-devel \
 rust-backtrace+default-devel \
 rust-backtrace+dl_iterate_phdr-devel \
 rust-backtrace+ruzstd-devel \
 rust-backtrace+serde-devel \
 rust-backtrace+serialize-serde-devel \
 rust-backtrace+std-devel \
 rust-backtrace-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-backtrace-0.3.75-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c496ebf6257bf6d948c3cf6ff9aaff845941852b4f2e77707b40aef6d1731f7b"

URI_x86_64_v2_rust-backtrace+cpp_demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+cpp_demangle-devel-0.3.75-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+cpp_demangle-devel}"
SRC_URI[x86_64_v2_rust-backtrace+cpp_demangle-devel.sha256sum] = "0d1b66bde725547f1ddc2ed834cf98451224638ad34de38a78b5456146f6f0c1"

URI_x86_64_v2_rust-backtrace+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+default-devel-0.3.75-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+default-devel}"
SRC_URI[x86_64_v2_rust-backtrace+default-devel.sha256sum] = "df024bdeb4719e4579e6908b5b3470dd4ac1cee7b0f6b0c6000f0535fc09f6aa"

URI_x86_64_v2_rust-backtrace+dl_iterate_phdr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+dl_iterate_phdr-devel-0.3.75-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+dl_iterate_phdr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+dl_iterate_phdr-devel}"
SRC_URI[x86_64_v2_rust-backtrace+dl_iterate_phdr-devel.sha256sum] = "7b4dcd2c5ef9bc41a103990d6ec721bf0dd40ce302a7cf9aef02d27be9242ff0"

URI_x86_64_v2_rust-backtrace+ruzstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+ruzstd-devel-0.3.75-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+ruzstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+ruzstd-devel}"
SRC_URI[x86_64_v2_rust-backtrace+ruzstd-devel.sha256sum] = "829f1c6676026ff8e0ff78afcc4ab054ad36241bf145127b73080030a03281c0"

URI_x86_64_v2_rust-backtrace+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+serde-devel-0.3.75-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+serde-devel}"
SRC_URI[x86_64_v2_rust-backtrace+serde-devel.sha256sum] = "08b3201f696b8c4597bcce05d817310df2256cf625193eb5d7056071bf992013"

URI_x86_64_v2_rust-backtrace+serialize-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+serialize-serde-devel-0.3.75-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+serialize-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+serialize-serde-devel}"
SRC_URI[x86_64_v2_rust-backtrace+serialize-serde-devel.sha256sum] = "8ef4c532e4787526d965052e1b1ecd215d13c51ca27e9b1c3cddaf8e30b4ddfd"

URI_x86_64_v2_rust-backtrace+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+std-devel-0.3.75-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+std-devel}"
SRC_URI[x86_64_v2_rust-backtrace+std-devel.sha256sum] = "1e12223a6d5b6e436987b03b16d789968e13c42327f0e3a716097044466a2124"

URI_x86_64_v2_rust-backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace-devel-0.3.75-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace-devel}"
SRC_URI[x86_64_v2_rust-backtrace-devel.sha256sum] = "0a978607cb2ba38b238c957be218b9d5cc3b1b848315f37b36a9391694ccc0e7"

URI_aarch64_rust-backtrace+cpp_demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+cpp_demangle-devel-0.3.75-1.el10_0.noarch.rpm;name=aarch64_rust-backtrace+cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+cpp_demangle-devel}"
SRC_URI[aarch64_rust-backtrace+cpp_demangle-devel.sha256sum] = "60f335ccc8cbacd6752ccb4fa6bfa5354d68f3371ff8d10a40844c24fbc5500a"

URI_aarch64_rust-backtrace+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+default-devel-0.3.75-1.el10_0.noarch.rpm;name=aarch64_rust-backtrace+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+default-devel}"
SRC_URI[aarch64_rust-backtrace+default-devel.sha256sum] = "d86b6d05d909932675b047dfbf59a93992fbb1fa31210e09d418d532755aa22e"

URI_aarch64_rust-backtrace+dl_iterate_phdr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+dl_iterate_phdr-devel-0.3.75-1.el10_0.noarch.rpm;name=aarch64_rust-backtrace+dl_iterate_phdr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+dl_iterate_phdr-devel}"
SRC_URI[aarch64_rust-backtrace+dl_iterate_phdr-devel.sha256sum] = "74cb21e2cb9f24a155641dd932ee518bc662348833a6a38675659d00f473f15a"

URI_aarch64_rust-backtrace+ruzstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+ruzstd-devel-0.3.75-1.el10_0.noarch.rpm;name=aarch64_rust-backtrace+ruzstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+ruzstd-devel}"
SRC_URI[aarch64_rust-backtrace+ruzstd-devel.sha256sum] = "e40376e55bc66ba7e0567eda7e16da2c7e21ee60765ec373b307b810a9f17e5f"

URI_aarch64_rust-backtrace+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+serde-devel-0.3.75-1.el10_0.noarch.rpm;name=aarch64_rust-backtrace+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+serde-devel}"
SRC_URI[aarch64_rust-backtrace+serde-devel.sha256sum] = "8020ff8b060ac24359ec0b33ec5ccaffdd218ccefb5b92c1df47b451f3931640"

URI_aarch64_rust-backtrace+serialize-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+serialize-serde-devel-0.3.75-1.el10_0.noarch.rpm;name=aarch64_rust-backtrace+serialize-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+serialize-serde-devel}"
SRC_URI[aarch64_rust-backtrace+serialize-serde-devel.sha256sum] = "58b0928e5373254b542d1e4a9516f17e1311752bdeea7e2f0997abc5c871d84b"

URI_aarch64_rust-backtrace+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+std-devel-0.3.75-1.el10_0.noarch.rpm;name=aarch64_rust-backtrace+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+std-devel}"
SRC_URI[aarch64_rust-backtrace+std-devel.sha256sum] = "43788a91e48717963f3d0850df20f473ca09afa4b079ffb3063f20e332d88285"

URI_aarch64_rust-backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace-devel-0.3.75-1.el10_0.noarch.rpm;name=aarch64_rust-backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace-devel}"
SRC_URI[aarch64_rust-backtrace-devel.sha256sum] = "5d3ec688f1ec061f95d07e3faf8f353aef94e168b351dc26dba8202a826e6ff2"

RDEPENDS:rust-backtrace+cpp_demangle-devel = " \
 cargo \
 rust-backtrace-devel \
 rust-cpp_demangle+alloc-devel \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-backtrace+default-devel = " \
 cargo \
 rust-backtrace+std-devel \
 rust-backtrace-devel \
 "
RDEPENDS:rust-backtrace+dl_iterate_phdr-devel = " \
 cargo \
 rust-backtrace-devel \
 "
RDEPENDS:rust-backtrace+ruzstd-devel = " \
 cargo \
 rust-backtrace-devel \
 rust-ruzstd-devel \
 "
RDEPENDS:rust-backtrace+serde-devel = " \
 cargo \
 rust-backtrace-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-backtrace+serialize-serde-devel = " \
 cargo \
 rust-backtrace+serde-devel \
 rust-backtrace-devel \
 "
RDEPENDS:rust-backtrace+std-devel = " \
 cargo \
 rust-backtrace-devel \
 "
RDEPENDS:rust-backtrace-devel = " \
 cargo \
 rust \
 rust-addr2line-devel \
 rust-cfg-if+default-devel \
 rust-libc-devel \
 rust-miniz_oxide-devel \
 rust-object+archive-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+read_core-devel \
 rust-object+unaligned-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 rust-rustc-demangle+default-devel \
 "
