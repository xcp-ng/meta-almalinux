# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "e3"
PV = "2.82"
PR = "20.el10_0"
PACKAGES:x86_64_v2 = " \
 e3 \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/e/e3-2.82-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca45bc73b7d3cb56368feeccbab2003f8870d6a2a52ef6b105c037ea0254c70c"

URI_x86_64_v2_e3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/e3-2.82-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_e3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_e3}"
SRC_URI[x86_64_v2_e3.sha256sum] = "f912b2d8257f3aabb67fef21f72f4281f4289e42b0e19d833b65944ce244f729"

RDEPENDS:e3 = " \
 "
