# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-auth"
PV = "0.1.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-http-auth+base64-devel \
 rust-http-auth+basic-scheme-devel \
 rust-http-auth+default-devel \
 rust-http-auth+digest-devel \
 rust-http-auth+digest-scheme-devel \
 rust-http-auth+hex-devel \
 rust-http-auth+http10-devel \
 rust-http-auth+log-devel \
 rust-http-auth+md-5-devel \
 rust-http-auth+rand-devel \
 rust-http-auth+sha2-devel \
 rust-http-auth+trace-devel \
 rust-http-auth-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-auth-0.1.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a31b2fbdd87528d903a1d0fa4cb0f7c6e9829c5e3eed40631ce236b09094039f"

URI_x86_64_v2_rust-http-auth+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-auth+base64-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-auth+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-auth+base64-devel}"
SRC_URI[x86_64_v2_rust-http-auth+base64-devel.sha256sum] = "b8b5b1b06caf7102860a815a99aa3829cdc446294c9189e5d7a6f261dad22d50"

URI_x86_64_v2_rust-http-auth+basic-scheme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-auth+basic-scheme-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-auth+basic-scheme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-auth+basic-scheme-devel}"
SRC_URI[x86_64_v2_rust-http-auth+basic-scheme-devel.sha256sum] = "12907a97ca0ba4c83209b2c70cd9a8df117a6d9c53b1c8d38a87439224157082"

URI_x86_64_v2_rust-http-auth+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-auth+default-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-auth+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-auth+default-devel}"
SRC_URI[x86_64_v2_rust-http-auth+default-devel.sha256sum] = "7857975af53f7c971b551927caa5a96c612c941dc85c971495f374ab3d4d27df"

URI_x86_64_v2_rust-http-auth+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-auth+digest-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-auth+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-auth+digest-devel}"
SRC_URI[x86_64_v2_rust-http-auth+digest-devel.sha256sum] = "259db792e3c30a7b30af01a631aeae0f157ab924402cab711a73bc450fe1a45f"

URI_x86_64_v2_rust-http-auth+digest-scheme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-auth+digest-scheme-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-auth+digest-scheme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-auth+digest-scheme-devel}"
SRC_URI[x86_64_v2_rust-http-auth+digest-scheme-devel.sha256sum] = "fbc189ecb5c1b64121a6fb17b9acfde918c83413d960386d29aa95ed542707b5"

URI_x86_64_v2_rust-http-auth+hex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-auth+hex-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-auth+hex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-auth+hex-devel}"
SRC_URI[x86_64_v2_rust-http-auth+hex-devel.sha256sum] = "10892072e361ec300a213133f6897541f1b1f0a023f1c1cf650c6185d5cb7bc2"

URI_x86_64_v2_rust-http-auth+http10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-auth+http10-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-auth+http10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-auth+http10-devel}"
SRC_URI[x86_64_v2_rust-http-auth+http10-devel.sha256sum] = "2d1e97cab4042ebecc58a689311ea7189c3893a86471a27fa94e6a9f4a1ac267"

URI_x86_64_v2_rust-http-auth+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-auth+log-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-auth+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-auth+log-devel}"
SRC_URI[x86_64_v2_rust-http-auth+log-devel.sha256sum] = "c32e9d011b9efb3664c723b2c94343146037b6a728fe9393cab152a2a6846849"

URI_x86_64_v2_rust-http-auth+md-5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-auth+md-5-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-auth+md-5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-auth+md-5-devel}"
SRC_URI[x86_64_v2_rust-http-auth+md-5-devel.sha256sum] = "ffee9b69099fc3b755d2a1475721ec98762406c233c7efe25d6308984fa56aff"

URI_x86_64_v2_rust-http-auth+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-auth+rand-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-auth+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-auth+rand-devel}"
SRC_URI[x86_64_v2_rust-http-auth+rand-devel.sha256sum] = "f1701e15badecbb5a0d45d4213301e9b0850cd5a47d14ab6678e26bd7bd262e9"

URI_x86_64_v2_rust-http-auth+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-auth+sha2-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-auth+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-auth+sha2-devel}"
SRC_URI[x86_64_v2_rust-http-auth+sha2-devel.sha256sum] = "0af07755984a2ffb44d3648da1b82840f11341911f0650a085ab0f59143123be"

URI_x86_64_v2_rust-http-auth+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-auth+trace-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-auth+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-auth+trace-devel}"
SRC_URI[x86_64_v2_rust-http-auth+trace-devel.sha256sum] = "a7449e81e44341b52cd03b48ed2fd0dc12a454f0b1f1341f279c22cff18d81ae"

URI_x86_64_v2_rust-http-auth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-auth-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-auth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-auth-devel}"
SRC_URI[x86_64_v2_rust-http-auth-devel.sha256sum] = "abf02a41fdcfef2bf64d8052abd7e7ff56bdeca5f500a17308dcf77bc895fedf"

URI_aarch64_rust-http-auth+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-auth+base64-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-http-auth+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-auth+base64-devel}"
SRC_URI[aarch64_rust-http-auth+base64-devel.sha256sum] = "7b31965276937a55f07c26bd5a342c7a2c43f9f0470741e83f2701b7dea3e3ef"

URI_aarch64_rust-http-auth+basic-scheme-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-auth+basic-scheme-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-http-auth+basic-scheme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-auth+basic-scheme-devel}"
SRC_URI[aarch64_rust-http-auth+basic-scheme-devel.sha256sum] = "066376fb61852a31c0c90f28e8a9897026e8ca7a79a012193556a84f935dcc8e"

URI_aarch64_rust-http-auth+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-auth+default-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-http-auth+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-auth+default-devel}"
SRC_URI[aarch64_rust-http-auth+default-devel.sha256sum] = "8d4873e49903a6acf4c7650a686e6d68427e8525be9283953fb3e19a43147e13"

URI_aarch64_rust-http-auth+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-auth+digest-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-http-auth+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-auth+digest-devel}"
SRC_URI[aarch64_rust-http-auth+digest-devel.sha256sum] = "fb210c80cda59b7fd8ae2cd19803df23006219455634e57ae6d5375feb47865a"

URI_aarch64_rust-http-auth+digest-scheme-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-auth+digest-scheme-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-http-auth+digest-scheme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-auth+digest-scheme-devel}"
SRC_URI[aarch64_rust-http-auth+digest-scheme-devel.sha256sum] = "8e7d040e5f49cc26b969a19635430b365de305ac9da750d59b6106bfd6e6f6b6"

URI_aarch64_rust-http-auth+hex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-auth+hex-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-http-auth+hex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-auth+hex-devel}"
SRC_URI[aarch64_rust-http-auth+hex-devel.sha256sum] = "dbfc0c460cbe817ab42c4c8766add74a6a1d60010f8b454555eff4541191be94"

URI_aarch64_rust-http-auth+http10-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-auth+http10-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-http-auth+http10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-auth+http10-devel}"
SRC_URI[aarch64_rust-http-auth+http10-devel.sha256sum] = "ef97aff0f6314cf0eca60cf2cd83d976c026638acd42c6fbaac657fd25e56c8d"

URI_aarch64_rust-http-auth+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-auth+log-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-http-auth+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-auth+log-devel}"
SRC_URI[aarch64_rust-http-auth+log-devel.sha256sum] = "12bc098443ed0373d5ad90c0a3491128febc75c7b1f441df53cbd0df9159ed17"

URI_aarch64_rust-http-auth+md-5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-auth+md-5-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-http-auth+md-5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-auth+md-5-devel}"
SRC_URI[aarch64_rust-http-auth+md-5-devel.sha256sum] = "ba2a0e5bb3c56b13d370e27c8d28dac60f5df3d6a3e338214fc9af3ac81031b3"

URI_aarch64_rust-http-auth+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-auth+rand-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-http-auth+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-auth+rand-devel}"
SRC_URI[aarch64_rust-http-auth+rand-devel.sha256sum] = "57b9c551bd1099fdb0d4cddf38ef73abdcf06c5d5d80d831e86759c1307afb5a"

URI_aarch64_rust-http-auth+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-auth+sha2-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-http-auth+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-auth+sha2-devel}"
SRC_URI[aarch64_rust-http-auth+sha2-devel.sha256sum] = "1afc733b3ff18c65663732f80cf1ae6e89064a14d946decaaee73bbbdc0c6fcf"

URI_aarch64_rust-http-auth+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-auth+trace-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-http-auth+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-auth+trace-devel}"
SRC_URI[aarch64_rust-http-auth+trace-devel.sha256sum] = "b63b9cee7062199766feac85ee3e8c0e1e92b39a6d62b9b8112638da536261c9"

URI_aarch64_rust-http-auth-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-auth-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-http-auth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-auth-devel}"
SRC_URI[aarch64_rust-http-auth-devel.sha256sum] = "9001ed72b7604be58f7eeeb45ed0e9625ae9e4e52191181291c515d58250a24c"

RDEPENDS:rust-http-auth+base64-devel = " \
 cargo \
 rust-base64_0.22+default-devel \
 rust-http-auth-devel \
 "
RDEPENDS:rust-http-auth+basic-scheme-devel = " \
 cargo \
 rust-http-auth+base64-devel \
 rust-http-auth-devel \
 "
RDEPENDS:rust-http-auth+default-devel = " \
 cargo \
 rust-http-auth+basic-scheme-devel \
 rust-http-auth+digest-scheme-devel \
 rust-http-auth-devel \
 "
RDEPENDS:rust-http-auth+digest-devel = " \
 cargo \
 rust-digest0.10+default-devel \
 rust-http-auth-devel \
 "
RDEPENDS:rust-http-auth+digest-scheme-devel = " \
 cargo \
 rust-http-auth+digest-devel \
 rust-http-auth+hex-devel \
 rust-http-auth+md-5-devel \
 rust-http-auth+rand-devel \
 rust-http-auth+sha2-devel \
 rust-http-auth-devel \
 "
RDEPENDS:rust-http-auth+hex-devel = " \
 cargo \
 rust-hex+default-devel \
 rust-http-auth-devel \
 "
RDEPENDS:rust-http-auth+http10-devel = " \
 cargo \
 rust-http+default-devel \
 rust-http-auth-devel \
 "
RDEPENDS:rust-http-auth+log-devel = " \
 cargo \
 rust-http-auth-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-http-auth+md-5-devel = " \
 cargo \
 rust-http-auth-devel \
 rust-md-5_0.10+default-devel \
 "
RDEPENDS:rust-http-auth+rand-devel = " \
 cargo \
 rust-http-auth-devel \
 rust-rand0.8+default-devel \
 "
RDEPENDS:rust-http-auth+sha2-devel = " \
 cargo \
 rust-http-auth-devel \
 rust-sha2_0.10+default-devel \
 "
RDEPENDS:rust-http-auth+trace-devel = " \
 cargo \
 rust-http-auth+log-devel \
 rust-http-auth-devel \
 "
RDEPENDS:rust-http-auth-devel = " \
 cargo \
 rust \
 rust-memchr+default-devel \
 "
