# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bolt"
PV = "0.9.8"
PR = "3.el10"
PACKAGES = " \
 bolt \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/bolt-0.9.8-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9690ebf5fb577e76b642a410c2d6ff296c1e3f1c0791450e905a17e81a6f6159"

URI_x86_64_v2_bolt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/bolt-0.9.8-3.el10.x86_64_v2.rpm;name=x86_64_v2_bolt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bolt}"
SRC_URI[x86_64_v2_bolt.sha256sum] = "cc14a90a4d752dc42b81f8b2f30b0c52f35b9079f232f30921e087d22600dfd7"

URI_aarch64_bolt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/bolt-0.9.8-3.el10.aarch64.rpm;name=aarch64_bolt;unpack=0"
SRC_URI:append = " ${URI_aarch64_bolt}"
SRC_URI[aarch64_bolt.sha256sum] = "7600b5619cdf05f8279b390e697bfefb3f93b82d21f0238a763c3593cbc89958"

RDEPENDS:bolt = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 polkit-libs \
 systemd \
 systemd-libs \
 "
