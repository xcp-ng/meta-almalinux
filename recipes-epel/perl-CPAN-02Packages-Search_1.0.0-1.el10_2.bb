# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CPAN-02Packages-Search"
PV = "1.0.0"
PR = "1.el10_2"
PACKAGES = " \
 perl-CPAN-02Packages-Search \
 perl-CPAN-02Packages-Search-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-CPAN-02Packages-Search-1.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f34949b007fe99d98859a6c4691396c781a8e1989b5cb979bdd6cf55d71c33a"

URI_x86_64_v2_perl-CPAN-02Packages-Search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CPAN-02Packages-Search-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CPAN-02Packages-Search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CPAN-02Packages-Search}"
SRC_URI[x86_64_v2_perl-CPAN-02Packages-Search.sha256sum] = "3c26f9640dd30fd32a7242bac423d59c5474b81f916f02ed4a4c9c9466b6eda7"

URI_x86_64_v2_perl-CPAN-02Packages-Search-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CPAN-02Packages-Search-tests-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CPAN-02Packages-Search-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CPAN-02Packages-Search-tests}"
SRC_URI[x86_64_v2_perl-CPAN-02Packages-Search-tests.sha256sum] = "a75064c9971968138a75f59ab4fb8cc51e95c16bf23fd4e1e7a7ff1c8741078c"

URI_aarch64_perl-CPAN-02Packages-Search = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CPAN-02Packages-Search-1.0.0-1.el10_2.noarch.rpm;name=aarch64_perl-CPAN-02Packages-Search;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CPAN-02Packages-Search}"
SRC_URI[aarch64_perl-CPAN-02Packages-Search.sha256sum] = "f492d43e6e8475a1735f75084a4441cf333da9646b18ad423da2f7ac6b6a3fc9"

URI_aarch64_perl-CPAN-02Packages-Search-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CPAN-02Packages-Search-tests-1.0.0-1.el10_2.noarch.rpm;name=aarch64_perl-CPAN-02Packages-Search-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CPAN-02Packages-Search-tests}"
SRC_URI[aarch64_perl-CPAN-02Packages-Search-tests.sha256sum] = "1ac48975b58dac1dab31db7d9f74edf3d6d107ea0eca365e8fd5804e6ce02c44"

RDEPENDS:perl-CPAN-02Packages-Search = " \
 perl-Search-Dict \
 perl-Symbol \
 perl-Tie-Handle-Offset \
 perl-experimental \
 perl-libs \
 "
RDEPENDS:perl-CPAN-02Packages-Search-tests = " \
 bash \
 perl-CPAN-02Packages-Search \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-experimental \
 perl-interpreter \
 perl-libs \
 "
