# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_normalizer"
PV = "2.1.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-icu_normalizer+compiled_data-devel \
 rust-icu_normalizer+datagen-devel \
 rust-icu_normalizer+default-devel \
 rust-icu_normalizer+experimental-devel \
 rust-icu_normalizer+icu_properties-devel \
 rust-icu_normalizer+serde-devel \
 rust-icu_normalizer+utf16_iter-devel \
 rust-icu_normalizer+utf8_iter-devel \
 rust-icu_normalizer+write16-devel \
 rust-icu_normalizer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_normalizer-2.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "035022d5cd7639a0be32347bc0858a8a84e29d15c7a8596e635e8e39a55fe615"

URI_x86_64_v2_rust-icu_normalizer+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+compiled_data-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+compiled_data-devel.sha256sum] = "542f06207e6362017b92898fc9f29bc123bb41c7a3fb14886d46fec59215ddd3"

URI_x86_64_v2_rust-icu_normalizer+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+datagen-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+datagen-devel.sha256sum] = "ca48f236b4ad1826f418b944465b695d37c1a9db9142ac6010211018948610b7"

URI_x86_64_v2_rust-icu_normalizer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+default-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+default-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+default-devel.sha256sum] = "93c9aa9a0406f4ab0f425980a5f596d00a0491e0a3e315f125b9a66fcb909a6f"

URI_x86_64_v2_rust-icu_normalizer+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+experimental-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+experimental-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+experimental-devel.sha256sum] = "7935afe890b8469991d2529b2679d1309bd587259fd36efd4e8e77b4e01f02d5"

URI_x86_64_v2_rust-icu_normalizer+icu_properties-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+icu_properties-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+icu_properties-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+icu_properties-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+icu_properties-devel.sha256sum] = "294cfa6c2c84bd1cb1c0b52e3334ceda500ca1fb7559c822a864159ab2c95bf7"

URI_x86_64_v2_rust-icu_normalizer+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+serde-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+serde-devel.sha256sum] = "505f00ff28cf4a428069730bd91c79b4889e7dacffad26c9f552f0ed9ffbaec0"

URI_x86_64_v2_rust-icu_normalizer+utf16_iter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+utf16_iter-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+utf16_iter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+utf16_iter-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+utf16_iter-devel.sha256sum] = "6b2cb7264a6d23aabdc277d9c1ffa52adc3c818345b13343ccc09389bccb3a7e"

URI_x86_64_v2_rust-icu_normalizer+utf8_iter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+utf8_iter-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+utf8_iter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+utf8_iter-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+utf8_iter-devel.sha256sum] = "1490bace2f95b9bdb9fbb1e7bda1e8f3bfba26bce0f7cda9f707eb5da7610a04"

URI_x86_64_v2_rust-icu_normalizer+write16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+write16-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+write16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+write16-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+write16-devel.sha256sum] = "e78200128adf52103e820f3acf6359bccec5c7b296f999ef01e68fc585f418e1"

URI_x86_64_v2_rust-icu_normalizer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer-devel.sha256sum] = "85d179b512334aaeec8b0a1f2dc892c2341889f7ad9c386a1a5baffe7c3961d1"

URI_aarch64_rust-icu_normalizer+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+compiled_data-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_normalizer+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_normalizer+compiled_data-devel.sha256sum] = "d2c7c5f1f424ad5dcb6215c6cda0a841487d9d7780b4a2c15d93bba71c0a8f36"

URI_aarch64_rust-icu_normalizer+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+datagen-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_normalizer+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+datagen-devel}"
SRC_URI[aarch64_rust-icu_normalizer+datagen-devel.sha256sum] = "a9036eaa8929e0161686833e6ba9a0d6d607ebbb21ff0da828b723f7b0be5118"

URI_aarch64_rust-icu_normalizer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+default-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_normalizer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+default-devel}"
SRC_URI[aarch64_rust-icu_normalizer+default-devel.sha256sum] = "5a6ce16c6be3468fce8ee82bc82aa1bb4508ac4b0ba75b5f56cbfd0244c126bf"

URI_aarch64_rust-icu_normalizer+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+experimental-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_normalizer+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+experimental-devel}"
SRC_URI[aarch64_rust-icu_normalizer+experimental-devel.sha256sum] = "288ec6b97fc17c11bf900acfb8eb00d54b4047a3f6f42f3fc4bb715868d23df3"

URI_aarch64_rust-icu_normalizer+icu_properties-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+icu_properties-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_normalizer+icu_properties-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+icu_properties-devel}"
SRC_URI[aarch64_rust-icu_normalizer+icu_properties-devel.sha256sum] = "3fee7d125b5901d9572f0f230c2c7430f13a645342e201915d3fc7459ef7e1cb"

URI_aarch64_rust-icu_normalizer+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+serde-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_normalizer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+serde-devel}"
SRC_URI[aarch64_rust-icu_normalizer+serde-devel.sha256sum] = "22dcff4c1981903aa6d09279c9af867bcb295c2ea50a77715edd83cb1625e2a3"

URI_aarch64_rust-icu_normalizer+utf16_iter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+utf16_iter-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_normalizer+utf16_iter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+utf16_iter-devel}"
SRC_URI[aarch64_rust-icu_normalizer+utf16_iter-devel.sha256sum] = "463407706d7eca3a0723a7cc58e39f4a5856a840df7795a8b99f32c74b385ed4"

URI_aarch64_rust-icu_normalizer+utf8_iter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+utf8_iter-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_normalizer+utf8_iter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+utf8_iter-devel}"
SRC_URI[aarch64_rust-icu_normalizer+utf8_iter-devel.sha256sum] = "3e7e11b2d522196c1fdfed14e27375ffa5ee8b2c4ccb72ac04bc9b7bbac4d2bb"

URI_aarch64_rust-icu_normalizer+write16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+write16-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_normalizer+write16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+write16-devel}"
SRC_URI[aarch64_rust-icu_normalizer+write16-devel.sha256sum] = "0be461b8246895ce1f60adcca513b43f0099de3e4713242b5016cf9c738157ee"

URI_aarch64_rust-icu_normalizer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_normalizer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer-devel}"
SRC_URI[aarch64_rust-icu_normalizer-devel.sha256sum] = "86fe4567577bde4b403a6a9d428cd6e9729a1085fa11e2472bd51e6002f246ea"

RDEPENDS:rust-icu_normalizer+compiled_data-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 rust-icu_normalizer_data-devel \
 rust-icu_properties+compiled_data-devel \
 rust-icu_properties-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_normalizer+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collections+databake-devel \
 rust-icu_normalizer+icu_properties-devel \
 rust-icu_normalizer+serde-devel \
 rust-icu_normalizer-devel \
 rust-icu_properties+datagen-devel \
 rust-icu_properties-devel \
 rust-icu_provider+export-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_normalizer+default-devel = " \
 cargo \
 rust-icu_normalizer+compiled_data-devel \
 rust-icu_normalizer+utf16_iter-devel \
 rust-icu_normalizer+utf8_iter-devel \
 rust-icu_normalizer-devel \
 "
RDEPENDS:rust-icu_normalizer+experimental-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 "
RDEPENDS:rust-icu_normalizer+icu_properties-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 rust-icu_properties-devel \
 "
RDEPENDS:rust-icu_normalizer+serde-devel = " \
 cargo \
 rust-icu_collections+serde-devel \
 rust-icu_normalizer-devel \
 rust-icu_properties+serde-devel \
 rust-icu_properties-devel \
 rust-icu_provider+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_normalizer+utf16_iter-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 rust-utf16_iter-devel \
 rust-write16+alloc-devel \
 rust-write16-devel \
 "
RDEPENDS:rust-icu_normalizer+utf8_iter-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 rust-utf8_iter-devel \
 "
RDEPENDS:rust-icu_normalizer+write16-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 "
RDEPENDS:rust-icu_normalizer-devel = " \
 cargo \
 rust \
 rust-icu_collections-devel \
 rust-icu_provider-devel \
 rust-smallvec-devel \
 rust-zerovec-devel \
 "
