# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "argon2"
PV = "20190702"
PR = "6.el10_0"
PACKAGES = " \
 argon2 \
 libargon2 \
 libargon2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/argon2-20190702-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d51963bbd2fa8a9eb375a4b9ee927f868551b087d6c26e9097dc4618db5a656e"

URI_x86_64_v2_argon2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/argon2-20190702-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_argon2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_argon2}"
SRC_URI[x86_64_v2_argon2.sha256sum] = "2daaabc39c520a4e43439afdcbc5626b56f1bfcb1dc9d0b90cd636fe8fca0312"

URI_x86_64_v2_libargon2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libargon2-20190702-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libargon2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libargon2}"
SRC_URI[x86_64_v2_libargon2.sha256sum] = "61223649977d492e7b8727257f2f9ed92a70d6c109da0c6306902ca1021ee364"

URI_x86_64_v2_libargon2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libargon2-devel-20190702-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libargon2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libargon2-devel}"
SRC_URI[x86_64_v2_libargon2-devel.sha256sum] = "948c0cc06fa22c62c9da5bd13c83aaa886a9d573c68f89612aa5910988705690"

URI_aarch64_argon2 = "${EPEL_MIRROR}/aarch64/Packages/a/argon2-20190702-6.el10_0.aarch64.rpm;name=aarch64_argon2;unpack=0"
SRC_URI:append = " ${URI_aarch64_argon2}"
SRC_URI[aarch64_argon2.sha256sum] = "217e23731ab62195c2ad2f5bbf62116b18c295d0b81aa472c8d8eafde8e2e695"

URI_aarch64_libargon2 = "${EPEL_MIRROR}/aarch64/Packages/l/libargon2-20190702-6.el10_0.aarch64.rpm;name=aarch64_libargon2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libargon2}"
SRC_URI[aarch64_libargon2.sha256sum] = "4449da295350419c93d51458db9ce8b2a13efe01c23fdf67ad3f983ec291fcae"

URI_aarch64_libargon2-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libargon2-devel-20190702-6.el10_0.aarch64.rpm;name=aarch64_libargon2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libargon2-devel}"
SRC_URI[aarch64_libargon2-devel.sha256sum] = "2432173dc6d49a551abd8282a4b69f8e69ac76f8982abf9955c9187ff8de03cf"

RDEPENDS:argon2 = " \
 glibc \
 libargon2 \
 "
RDEPENDS:libargon2 = " \
 glibc \
 "
RDEPENDS:libargon2-devel = " \
 libargon2 \
 pkgconf-pkg-config \
 "
