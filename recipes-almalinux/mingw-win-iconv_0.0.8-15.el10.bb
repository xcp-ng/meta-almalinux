# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-win-iconv"
PV = "0.0.8"
PR = "15.el10"
PACKAGES = " \
 mingw32-win-iconv \
 mingw32-win-iconv-static \
 mingw64-win-iconv \
 mingw64-win-iconv-static \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-win-iconv-0.0.8-15.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f995198afe9143666a4afe726b4320039cff0d3762f2b20558a780f476739575"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-win-iconv-0.0.8-15.el10.noarch.rpm;name=x86_64_v2_mingw32-win-iconv;unpack=0"
SRC_URI[x86_64_v2_mingw32-win-iconv.sha256sum] = "da9a306c7183b3b79d2e954e144b5d4108804e2d32be423ac7bd812fb353ba85"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-win-iconv-static-0.0.8-15.el10.noarch.rpm;name=x86_64_v2_mingw32-win-iconv-static;unpack=0"
SRC_URI[x86_64_v2_mingw32-win-iconv-static.sha256sum] = "e39b159fbe7b6b65afcdd3f2c0447c2c3cb085b23132ae15cdbdb2a051092d9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-win-iconv-0.0.8-15.el10.noarch.rpm;name=x86_64_v2_mingw64-win-iconv;unpack=0"
SRC_URI[x86_64_v2_mingw64-win-iconv.sha256sum] = "c4ee8122bfab7310adbd3109506e16e95189c5810244ceb39dde284ced91735d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-win-iconv-static-0.0.8-15.el10.noarch.rpm;name=x86_64_v2_mingw64-win-iconv-static;unpack=0"
SRC_URI[x86_64_v2_mingw64-win-iconv-static.sha256sum] = "55117739a3a9f9cee6e9cb4493def05d5a3e859e7fc126b517a88a55a1b04102"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-win-iconv-0.0.8-15.el10.noarch.rpm;name=aarch64_mingw32-win-iconv;unpack=0"
SRC_URI[aarch64_mingw32-win-iconv.sha256sum] = "da9a306c7183b3b79d2e954e144b5d4108804e2d32be423ac7bd812fb353ba85"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-win-iconv-static-0.0.8-15.el10.noarch.rpm;name=aarch64_mingw32-win-iconv-static;unpack=0"
SRC_URI[aarch64_mingw32-win-iconv-static.sha256sum] = "e39b159fbe7b6b65afcdd3f2c0447c2c3cb085b23132ae15cdbdb2a051092d9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-win-iconv-0.0.8-15.el10.noarch.rpm;name=aarch64_mingw64-win-iconv;unpack=0"
SRC_URI[aarch64_mingw64-win-iconv.sha256sum] = "c4ee8122bfab7310adbd3109506e16e95189c5810244ceb39dde284ced91735d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-win-iconv-static-0.0.8-15.el10.noarch.rpm;name=aarch64_mingw64-win-iconv-static;unpack=0"
SRC_URI[aarch64_mingw64-win-iconv-static.sha256sum] = "55117739a3a9f9cee6e9cb4493def05d5a3e859e7fc126b517a88a55a1b04102"

RDEPENDS:mingw32-win-iconv = " \
 mingw32-crt \
 mingw32-filesystem \
 "
RDEPENDS:mingw32-win-iconv-static = " \
 mingw32-win-iconv \
 "
RDEPENDS:mingw64-win-iconv = " \
 mingw64-crt \
 mingw64-filesystem \
 "
RDEPENDS:mingw64-win-iconv-static = " \
 mingw64-win-iconv \
 "
