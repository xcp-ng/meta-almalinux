# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "splix"
PV = "2.0.1"
PR = "0.53.20130902svn.el10"
PACKAGES = " \
 splix \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/splix-2.0.1-0.53.20130902svn.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e2d85f1804b8f9ec27e9f829d06e0ca7ef20c91f8366f411cf02d46f07622ca"

URI_x86_64_v2_splix = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/splix-2.0.1-0.53.20130902svn.el10.x86_64_v2.rpm;name=x86_64_v2_splix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_splix}"
SRC_URI[x86_64_v2_splix.sha256sum] = "33f1ae092684dd14e9c632c96460d03d77db7fe49a7bb368dd521b7277be5075"

URI_aarch64_splix = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/splix-2.0.1-0.53.20130902svn.el10.aarch64.rpm;name=aarch64_splix;unpack=0"
SRC_URI:append = " ${URI_aarch64_splix}"
SRC_URI[aarch64_splix.sha256sum] = "537c6b9d2fddd5f1092fd2c9270d70604130ea9512f311e9e7d0c3acd8a05272"

RDEPENDS:splix = " \
 cups \
 cups-libs \
 glibc \
 jbigkit-libs \
 libgcc \
 libstdc++ \
 "
