# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvirt"
PV = "12.5.0"
PR = "1.el10.alma.1"
PACKAGES = " \
 libvirt \
 libvirt-client \
 libvirt-client-qemu \
 libvirt-daemon \
 libvirt-daemon-common \
 libvirt-daemon-config-network \
 libvirt-daemon-config-nwfilter \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-daemon-driver-storage-core \
 libvirt-daemon-driver-storage-disk \
 libvirt-daemon-driver-storage-iscsi \
 libvirt-daemon-driver-storage-logical \
 libvirt-daemon-driver-storage-mpath \
 libvirt-daemon-driver-storage-rbd \
 libvirt-daemon-driver-storage-scsi \
 libvirt-daemon-kvm \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-plugin-sanlock \
 libvirt-daemon-proxy \
 libvirt-devel \
 libvirt-docs \
 libvirt-libs \
 libvirt-nss \
 libvirt-ssh-proxy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvirt-12.5.0-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da4fc9803d2b9dc2e7003a9daf2c4dd21997076c03aad08b9d2d735e531ca4f8"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - libvirt-daemon-plugin-sanlock: augeas

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - libvirt-daemon-plugin-sanlock: augeas

URI_x86_64_v2_libvirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt}"
SRC_URI[x86_64_v2_libvirt.sha256sum] = "8c9258b9f49d2e7b179e1c0bcb2c687c91603c9093df3a4a1801a9a76c5b07ba"

URI_x86_64_v2_libvirt-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-client-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-client}"
SRC_URI[x86_64_v2_libvirt-client.sha256sum] = "09df311e21aff6df26869b5b089c2ed73907d9cf668f90158e09233b5d9fee8e"

URI_x86_64_v2_libvirt-client-qemu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-client-qemu-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-client-qemu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-client-qemu}"
SRC_URI[x86_64_v2_libvirt-client-qemu.sha256sum] = "77afd7caeaf406edf1fa794b37e479f9a64a97cc704422f10680398fcb299fac"

URI_x86_64_v2_libvirt-daemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon}"
SRC_URI[x86_64_v2_libvirt-daemon.sha256sum] = "c967b44d74863114e4af7a436efad5b56caacc60e23d4db9d7d75b4454bb86f2"

URI_x86_64_v2_libvirt-daemon-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-common-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-common}"
SRC_URI[x86_64_v2_libvirt-daemon-common.sha256sum] = "4cd9a25c2a5d07321407c2f61288399568bddb7c3d5a6bbbf2c9d3835568e29e"

URI_x86_64_v2_libvirt-daemon-config-network = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-config-network-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-config-network;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-config-network}"
SRC_URI[x86_64_v2_libvirt-daemon-config-network.sha256sum] = "c2c1c3d9bec910c6bafcc35132ff1ab3feefc304d8feb3ef293fcf8295c7d147"

URI_x86_64_v2_libvirt-daemon-config-nwfilter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-config-nwfilter-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-config-nwfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-config-nwfilter}"
SRC_URI[x86_64_v2_libvirt-daemon-config-nwfilter.sha256sum] = "7ad4a8bbe4121287e4d661efcd35b14913a0b5809b4e3535ae67034552ad89b5"

URI_x86_64_v2_libvirt-daemon-driver-interface = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-interface-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-interface;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-interface}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-interface.sha256sum] = "9ff9f45d8e60aa4646f528e768a27ba0bf2aae4f04dac1af1a2e237fb5aa51ce"

URI_x86_64_v2_libvirt-daemon-driver-network = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-network-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-network;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-network}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-network.sha256sum] = "1fb39075ef786ff011cfe3c5b1bcee7051b82dc5a3ccd8675e657cb39c02542c"

URI_x86_64_v2_libvirt-daemon-driver-nodedev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-nodedev-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-nodedev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-nodedev}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-nodedev.sha256sum] = "0049b016b44a0ed90d874add427e5b45023753c23f201cbeeb7223bda702756b"

URI_x86_64_v2_libvirt-daemon-driver-nwfilter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-nwfilter-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-nwfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-nwfilter}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-nwfilter.sha256sum] = "95b429a237d8e927e8e4c68afdc9fafa5c458a5fe9ed159920c15350c3b0ac9c"

URI_x86_64_v2_libvirt-daemon-driver-qemu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-qemu-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-qemu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-qemu}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-qemu.sha256sum] = "0f03a5800a7ab197910deab8c49e8b454acbdb360dc89287dd87cff75ef2704c"

URI_x86_64_v2_libvirt-daemon-driver-secret = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-secret-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-secret;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-secret}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-secret.sha256sum] = "99655111a79cf34123de331d9e819ed3133adaa9711b5a072468bb58d797f02b"

URI_x86_64_v2_libvirt-daemon-driver-storage = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage.sha256sum] = "2afdf25bff8676636dad2f0fec972a28d02ed79d4a4e3929ef515eb044024d89"

URI_x86_64_v2_libvirt-daemon-driver-storage-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-core-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-core}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-core.sha256sum] = "96651c5dcf5bf647d3a39ef6602fa3c5265cc5b5d605fc90a8a249b688bcbb32"

URI_x86_64_v2_libvirt-daemon-driver-storage-disk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-disk-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-disk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-disk}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-disk.sha256sum] = "ceca65d0aeef63aa613ac7c842d54ff8bfd99823817d9dedc022056ae7dd0c5a"

URI_x86_64_v2_libvirt-daemon-driver-storage-iscsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-iscsi-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-iscsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-iscsi}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-iscsi.sha256sum] = "c23a2e36f7d5da01560f84afd84b80f8421903b1c44d7abac0117a1b942fb5c3"

URI_x86_64_v2_libvirt-daemon-driver-storage-logical = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-logical-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-logical;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-logical}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-logical.sha256sum] = "1acfbfdb0ddd54cd458a01f7c3754973574aed7e1f2659bda0ba3ee2a06c72a8"

URI_x86_64_v2_libvirt-daemon-driver-storage-mpath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-mpath-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-mpath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-mpath}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-mpath.sha256sum] = "039b472ee08578c915acaf5153d78cf2acd28d29cfea5b6cbf8195e23df1a57a"

URI_x86_64_v2_libvirt-daemon-driver-storage-rbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-rbd-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-rbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-rbd}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-rbd.sha256sum] = "17bba397ac748c3c2f8cb93a51c36919ec9675ee410ed7d59af02da5678accaa"

URI_x86_64_v2_libvirt-daemon-driver-storage-scsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-scsi-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-scsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-scsi}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-scsi.sha256sum] = "ac21659900458852cb0cc7092b7c1c08d1adb05049b5b864cb7d36464ea28a59"

URI_x86_64_v2_libvirt-daemon-kvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-kvm-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-kvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-kvm}"
SRC_URI[x86_64_v2_libvirt-daemon-kvm.sha256sum] = "aaa27f88c8dfe4b0730d573ca848ff1fd68789e126a25473f1392a96e9b74b3e"

URI_x86_64_v2_libvirt-daemon-lock = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-lock-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-lock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-lock}"
SRC_URI[x86_64_v2_libvirt-daemon-lock.sha256sum] = "3e3282a695bb2d5ae539bc3d71970f6d804f7707cba1d9945c330328f6b5828c"

URI_x86_64_v2_libvirt-daemon-log = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-log-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-log}"
SRC_URI[x86_64_v2_libvirt-daemon-log.sha256sum] = "74236c97fee3bef7f5bc66b04a6b6b1bc7376e68ae47aac28ebd11bac9ce09dd"

URI_x86_64_v2_libvirt-daemon-plugin-lockd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-plugin-lockd-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-plugin-lockd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-plugin-lockd}"
SRC_URI[x86_64_v2_libvirt-daemon-plugin-lockd.sha256sum] = "8e85cbe664bdd2099379f2d4fccc9f311cbc5b1425742fd76f0b729c4e924833"

URI_x86_64_v2_libvirt-daemon-plugin-sanlock = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-daemon-plugin-sanlock-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-plugin-sanlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-plugin-sanlock}"
SRC_URI[x86_64_v2_libvirt-daemon-plugin-sanlock.sha256sum] = "f7d4e9e03f0bf8e9095cd0db5768ef79ee14f275194e1c1467530b9d1f4b4bdc"

URI_x86_64_v2_libvirt-daemon-proxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-proxy-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-proxy}"
SRC_URI[x86_64_v2_libvirt-daemon-proxy.sha256sum] = "eef7136975b2da59fadc797f0c2616f7975f8a4e01045ea3ce383b9e03d1a3a2"

URI_x86_64_v2_libvirt-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-devel-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-devel}"
SRC_URI[x86_64_v2_libvirt-devel.sha256sum] = "7f08503fbcebff5e48c3658880fe97234a36eaa9c84e2ad026a5d174df4efdeb"

URI_x86_64_v2_libvirt-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-docs-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-docs}"
SRC_URI[x86_64_v2_libvirt-docs.sha256sum] = "91c213ffef494f82470f33ee3bbef1589ffcdd98c82cce96cc29eda7706da318"

URI_x86_64_v2_libvirt-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-libs-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-libs}"
SRC_URI[x86_64_v2_libvirt-libs.sha256sum] = "dfc936605f80d025a5c2190abc58b04c02aa54c36514f77dc77fdd34d1124978"

URI_x86_64_v2_libvirt-nss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-nss-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-nss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-nss}"
SRC_URI[x86_64_v2_libvirt-nss.sha256sum] = "6cf8d4e0ede0bbb2424b4cee8463cb4ed0ca74c44daa5b629f43b83c7527bb6f"

URI_x86_64_v2_libvirt-ssh-proxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-ssh-proxy-12.5.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-ssh-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-ssh-proxy}"
SRC_URI[x86_64_v2_libvirt-ssh-proxy.sha256sum] = "aa1ab305afcbdd69087d1518d36b969ec4b6e356d5f3419b379d47a1158b2a3c"

URI_aarch64_libvirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt}"
SRC_URI[aarch64_libvirt.sha256sum] = "59324246d60432c9cfbcd3b8f65406ceceb733b5c8c0d5bb0659c936f1b18006"

URI_aarch64_libvirt-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-client-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-client}"
SRC_URI[aarch64_libvirt-client.sha256sum] = "c3d04d6b7e9b060277124337ea7871c6b19c61e9ee31af2e350fa2b090e3dab3"

URI_aarch64_libvirt-client-qemu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-client-qemu-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-client-qemu;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-client-qemu}"
SRC_URI[aarch64_libvirt-client-qemu.sha256sum] = "e96fa3a5cedd44da2e37f6aa65f7e38fbf1a7a926a0658cfcc5fa4ac5b8b7aac"

URI_aarch64_libvirt-daemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon}"
SRC_URI[aarch64_libvirt-daemon.sha256sum] = "da15752c8dbdcde765e1957208c1baaeaf8a6b4247617c9537b60fdd60550dbd"

URI_aarch64_libvirt-daemon-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-common-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-common}"
SRC_URI[aarch64_libvirt-daemon-common.sha256sum] = "4e745438503d3699e095a198ddf204898feb481e7c21ec35d17d9ba5b939c26b"

URI_aarch64_libvirt-daemon-config-network = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-config-network-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-config-network;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-config-network}"
SRC_URI[aarch64_libvirt-daemon-config-network.sha256sum] = "fb63b105e21798f867bf62c62f8b9c192bfaae591c0eac3c5897bff4e59dcaca"

URI_aarch64_libvirt-daemon-config-nwfilter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-config-nwfilter-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-config-nwfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-config-nwfilter}"
SRC_URI[aarch64_libvirt-daemon-config-nwfilter.sha256sum] = "67a34df2f8c40f159f35d8651de602e4f998761327d2a23687815ca4ef95ae6f"

URI_aarch64_libvirt-daemon-driver-interface = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-interface-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-interface;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-interface}"
SRC_URI[aarch64_libvirt-daemon-driver-interface.sha256sum] = "dde7d7b70a1089548e4e4a539f07aa9bd4b76d8afb8bbe8d1572f241d138653d"

URI_aarch64_libvirt-daemon-driver-network = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-network-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-network;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-network}"
SRC_URI[aarch64_libvirt-daemon-driver-network.sha256sum] = "fd0cb48df58f6ed47866834b1a161318d98a4c27e128844f4907f16ed9fd23f9"

URI_aarch64_libvirt-daemon-driver-nodedev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-nodedev-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-nodedev;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-nodedev}"
SRC_URI[aarch64_libvirt-daemon-driver-nodedev.sha256sum] = "cc340ea037e8c0b9f5aa32ca82bf26fd21e12b32dc2fb1dd1bab59079b72956c"

URI_aarch64_libvirt-daemon-driver-nwfilter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-nwfilter-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-nwfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-nwfilter}"
SRC_URI[aarch64_libvirt-daemon-driver-nwfilter.sha256sum] = "78e2c4e85413f79e07a8504f95ac2a872a4f25ab77b3761ad66863aca9d7421f"

URI_aarch64_libvirt-daemon-driver-qemu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-qemu-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-qemu;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-qemu}"
SRC_URI[aarch64_libvirt-daemon-driver-qemu.sha256sum] = "fbc552d84e6aeda83c71aeccc30e192f8316082250b7d3a3dd9144ed5e2f0934"

URI_aarch64_libvirt-daemon-driver-secret = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-secret-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-secret;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-secret}"
SRC_URI[aarch64_libvirt-daemon-driver-secret.sha256sum] = "67c43b302cea5f50ff0ed2c6716ec5393a96f74ed5108324b6f01324dd8f8503"

URI_aarch64_libvirt-daemon-driver-storage = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage}"
SRC_URI[aarch64_libvirt-daemon-driver-storage.sha256sum] = "898f2fc0b94130ec40b2762cabcc500b0553e86994df6b131466ce8143592507"

URI_aarch64_libvirt-daemon-driver-storage-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-core-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-core}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-core.sha256sum] = "3cdbae28036a50a8637d8f0063820f29af2919ff41b8a238df320112bc9d147a"

URI_aarch64_libvirt-daemon-driver-storage-disk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-disk-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-disk;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-disk}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-disk.sha256sum] = "2483614064c38de1cae7dc3f3f0f9fb2499856232e36f2b8658eb089a43d3023"

URI_aarch64_libvirt-daemon-driver-storage-iscsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-iscsi-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-iscsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-iscsi}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-iscsi.sha256sum] = "ea9945ad17336c5d354f0cb8dd275067cf34e5f220b8723b713acfe81dd81950"

URI_aarch64_libvirt-daemon-driver-storage-logical = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-logical-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-logical;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-logical}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-logical.sha256sum] = "31b2ae5cb92c3e0f21149203fe1b1d592bce55a51117da4909cfc704c6e5eb40"

URI_aarch64_libvirt-daemon-driver-storage-mpath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-mpath-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-mpath;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-mpath}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-mpath.sha256sum] = "30528b113fe2e3565338e2041f845fb3a088c849f23d539f17305415c9728ca7"

URI_aarch64_libvirt-daemon-driver-storage-rbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-rbd-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-rbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-rbd}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-rbd.sha256sum] = "7a4053cac76fb741cbd5dafbc0734b776c8d52bad0bb57133fd490088ff5062d"

URI_aarch64_libvirt-daemon-driver-storage-scsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-scsi-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-scsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-scsi}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-scsi.sha256sum] = "832c5d533e122ee2b66ce23a76b9d2449511c57c1759677ea105ad65a1e894ef"

URI_aarch64_libvirt-daemon-kvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-kvm-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-kvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-kvm}"
SRC_URI[aarch64_libvirt-daemon-kvm.sha256sum] = "467b1fe36fa4a12d96d960e17eac196b915566ca1b0db2a4fd952683c2814990"

URI_aarch64_libvirt-daemon-lock = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-lock-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-lock;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-lock}"
SRC_URI[aarch64_libvirt-daemon-lock.sha256sum] = "b252641ec942a6630f964c6a729de62a81a6718403f2d906ababfdd7d507bd01"

URI_aarch64_libvirt-daemon-log = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-log-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-log;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-log}"
SRC_URI[aarch64_libvirt-daemon-log.sha256sum] = "fbc5ea5daad215d940661f89c9aaa4c8a2226fb15ff0870448560c08a576828d"

URI_aarch64_libvirt-daemon-plugin-lockd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-plugin-lockd-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-plugin-lockd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-plugin-lockd}"
SRC_URI[aarch64_libvirt-daemon-plugin-lockd.sha256sum] = "44a65829a1e54125006f6d225e14282fb8219f5f112df164b055988d723776e1"

URI_aarch64_libvirt-daemon-plugin-sanlock = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-daemon-plugin-sanlock-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-plugin-sanlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-plugin-sanlock}"
SRC_URI[aarch64_libvirt-daemon-plugin-sanlock.sha256sum] = "7f5997f2c6364633b63c30d88be71c9621a51bf27f2a87733b1743869a4a63ad"

URI_aarch64_libvirt-daemon-proxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-proxy-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-proxy}"
SRC_URI[aarch64_libvirt-daemon-proxy.sha256sum] = "230d15a09f139e9bb81a85aca3ac5f2f139c626cbe68a382aef8eeecdfb3350e"

URI_aarch64_libvirt-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-devel-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-devel}"
SRC_URI[aarch64_libvirt-devel.sha256sum] = "b31f5c108b093b1f59b339e4aec88efbf4d4f1cf2da9b349be57a908cf8baec4"

URI_aarch64_libvirt-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-docs-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-docs}"
SRC_URI[aarch64_libvirt-docs.sha256sum] = "4a9373b26d758e333a560adcf03198907ed609ec07fa3f527361f9bbfe9109aa"

URI_aarch64_libvirt-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-libs-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-libs}"
SRC_URI[aarch64_libvirt-libs.sha256sum] = "c2eec6343a56199b9ee911ab3cc98d4f3d53a9ac187b8546c58cd794de17929f"

URI_aarch64_libvirt-nss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-nss-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-nss;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-nss}"
SRC_URI[aarch64_libvirt-nss.sha256sum] = "31bda6a1e110732d1d380713709d00a9e4345663fbbb1c03d3acd5d59c249dc5"

URI_aarch64_libvirt-ssh-proxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-ssh-proxy-12.5.0-1.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-ssh-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-ssh-proxy}"
SRC_URI[aarch64_libvirt-ssh-proxy.sha256sum] = "6ebab52e7eae281f59a8d5e2707b52a292b87a7b65a6fce4c37ef8ccc91efa6a"

RDEPENDS:libvirt = " \
 libvirt-client \
 libvirt-client-qemu \
 libvirt-daemon \
 libvirt-daemon-config-network \
 libvirt-daemon-config-nwfilter \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-libs \
 "
RDEPENDS:libvirt-client = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 libvirt-libs \
 libxml2 \
 readline \
 "
RDEPENDS:libvirt-client-qemu = " \
 libvirt-libs \
 python3 \
 python3-cryptography \
 python3-libvirt \
 python3-lxml \
 "
RDEPENDS:libvirt-daemon = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-proxy \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-common = " \
 bash \
 dbus \
 dmidecode \
 gettext \
 glib2 \
 glibc \
 iproute \
 iproute-tc \
 kmod \
 libacl \
 libgcc \
 libvirt-libs \
 polkit \
 readline \
 shadow-utils \
 systemd \
 "
RDEPENDS:libvirt-daemon-config-network = " \
 bash \
 libvirt-daemon-driver-network \
 "
RDEPENDS:libvirt-daemon-config-nwfilter = " \
 bash \
 libvirt-daemon-driver-nwfilter \
 "
RDEPENDS:libvirt-daemon-driver-interface = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 systemd-libs \
 "
RDEPENDS:libvirt-daemon-driver-network = " \
 bash \
 dnsmasq \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 nftables \
 "
RDEPENDS:libvirt-daemon-driver-nodedev = " \
 bash \
 glib2 \
 glibc \
 kmod \
 libgcc \
 libpciaccess \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 mdevctl \
 systemd \
 systemd-libs \
 "
RDEPENDS:libvirt-daemon-driver-nwfilter = " \
 bash \
 glib2 \
 glibc \
 iptables-nft \
 libgcc \
 libpcap \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-qemu = " \
 bash \
 bzip2 \
 glib2 \
 glibc \
 gnutls \
 gzip \
 libgcc \
 libnbd \
 libselinux \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-log \
 libvirt-libs \
 libxml2 \
 lzop \
 numad \
 qemu-img \
 swtpm-tools \
 systemd-container \
 xz \
 zstd \
 "
RDEPENDS:libvirt-daemon-driver-secret = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage = " \
 libvirt-daemon-driver-storage-core \
 libvirt-daemon-driver-storage-disk \
 libvirt-daemon-driver-storage-iscsi \
 libvirt-daemon-driver-storage-logical \
 libvirt-daemon-driver-storage-mpath \
 libvirt-daemon-driver-storage-rbd \
 libvirt-daemon-driver-storage-scsi \
 "
RDEPENDS:libvirt-daemon-driver-storage-core = " \
 bash \
 glib2 \
 glibc \
 libblkid \
 libgcc \
 libselinux \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 libxml2 \
 parted \
 qemu-img \
 scrub \
 util-linux \
 "
RDEPENDS:libvirt-daemon-driver-storage-disk = " \
 device-mapper \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 parted \
 "
RDEPENDS:libvirt-daemon-driver-storage-iscsi = " \
 glib2 \
 glibc \
 iscsi-initiator-utils \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-logical = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 lvm2 \
 "
RDEPENDS:libvirt-daemon-driver-storage-mpath = " \
 device-mapper \
 device-mapper-libs \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-rbd = " \
 glib2 \
 glibc \
 libgcc \
 librados2 \
 librbd1 \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-scsi = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-kvm = " \
 libvirt-daemon-common \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-proxy \
 libvirt-ssh-proxy \
 qemu-kvm \
 "
RDEPENDS:libvirt-daemon-lock = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-log = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-plugin-lockd = " \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-lock \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-plugin-sanlock = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-common \
 libvirt-libs \
 sanlock \
 sanlock-lib \
 "
RDEPENDS:libvirt-daemon-proxy = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-devel = " \
 libvirt-devel \
 libvirt-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:libvirt-docs = " \
 "
RDEPENDS:libvirt-libs = " \
 audit-libs \
 cyrus-sasl-gssapi \
 cyrus-sasl-lib \
 glib2 \
 glibc \
 gnutls \
 json-c \
 libacl \
 libcap-ng \
 libgcc \
 libnl3 \
 libselinux \
 libssh \
 libtirpc \
 libwsman1 \
 libxml2 \
 numactl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libvirt-nss = " \
 glibc \
 json-c \
 libgcc \
 libvirt-daemon-driver-network \
 "
RDEPENDS:libvirt-ssh-proxy = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-libs \
 libxml2 \
 "
