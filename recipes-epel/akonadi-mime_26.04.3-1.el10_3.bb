# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-mime"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 akonadi-mime \
 akonadi-mime-devel \
 akonadi-mime-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-mime-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7781cc4020d1ed85fccf6138be005695bfc9029edf3946ddb741cefb44ea39da"

URI_x86_64_v2_akonadi-mime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-mime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-mime}"
SRC_URI[x86_64_v2_akonadi-mime.sha256sum] = "d3f4040b50d501262ceca03c3b3a259ec09c749c6442a50f196756828bd30f42"

URI_x86_64_v2_akonadi-mime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-mime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-mime-devel}"
SRC_URI[x86_64_v2_akonadi-mime-devel.sha256sum] = "4e69a2f742a1d34f2d11993da14f7b9f4ffceeb0aefbd73901816a697e5452a9"

URI_x86_64_v2_akonadi-mime-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-mime-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-mime-doc}"
SRC_URI[x86_64_v2_akonadi-mime-doc.sha256sum] = "1f9b47f0267aeb0fdfe780ffe40bacb9b8f40b602b624c79b7cf12f0430dde02"

URI_aarch64_akonadi-mime = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_akonadi-mime;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-mime}"
SRC_URI[aarch64_akonadi-mime.sha256sum] = "369eb2844d5624288175df3739b019849ac815412215c20d56f180eb8ab5fa21"

URI_aarch64_akonadi-mime-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_akonadi-mime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-mime-devel}"
SRC_URI[aarch64_akonadi-mime-devel.sha256sum] = "c693010b290d72a65151193691693809a67bff248e517b2dcb051fe180c23b97"

URI_aarch64_akonadi-mime-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_akonadi-mime-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-mime-doc}"
SRC_URI[aarch64_akonadi-mime-doc.sha256sum] = "49088d20ac35a06544da3cd3cbcbec2d906d46e07d9f746273ae9c5c59ce9a12"

RDEPENDS:akonadi-mime = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:akonadi-mime-devel = " \
 akonadi-mime \
 akonadi-server-devel \
 cmake-filesystem \
 "
RDEPENDS:akonadi-mime-doc = " \
 "
