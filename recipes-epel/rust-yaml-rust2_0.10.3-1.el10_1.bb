# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yaml-rust2"
PV = "0.10.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-yaml-rust2+debug_prints-devel \
 rust-yaml-rust2+default-devel \
 rust-yaml-rust2+encoding-devel \
 rust-yaml-rust2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-yaml-rust2-0.10.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4103acf60d5fe6f1e89c182703a016e2c24c1cda5d35ca7581f62a9f0cd48987"

URI_x86_64_v2_rust-yaml-rust2+debug_prints-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yaml-rust2+debug_prints-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yaml-rust2+debug_prints-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yaml-rust2+debug_prints-devel}"
SRC_URI[x86_64_v2_rust-yaml-rust2+debug_prints-devel.sha256sum] = "2d20d23c37c82661a402094b36df22c962075239cc542ea7608f5bb0662fe679"

URI_x86_64_v2_rust-yaml-rust2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yaml-rust2+default-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yaml-rust2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yaml-rust2+default-devel}"
SRC_URI[x86_64_v2_rust-yaml-rust2+default-devel.sha256sum] = "ade15162e314aede88a4144f637f1a0a83c9a50c429c33fc4164215a174debd1"

URI_x86_64_v2_rust-yaml-rust2+encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yaml-rust2+encoding-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yaml-rust2+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yaml-rust2+encoding-devel}"
SRC_URI[x86_64_v2_rust-yaml-rust2+encoding-devel.sha256sum] = "2be094a4706417ddf3ef94075440ac821ba0aecc4cbe95fe4942155c0fb5cb88"

URI_x86_64_v2_rust-yaml-rust2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yaml-rust2-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yaml-rust2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yaml-rust2-devel}"
SRC_URI[x86_64_v2_rust-yaml-rust2-devel.sha256sum] = "b18290e0296bd873a59fc4b1a939a971786ad9d633f2fe89f9086915c1a2b33a"

URI_aarch64_rust-yaml-rust2+debug_prints-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yaml-rust2+debug_prints-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-yaml-rust2+debug_prints-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yaml-rust2+debug_prints-devel}"
SRC_URI[aarch64_rust-yaml-rust2+debug_prints-devel.sha256sum] = "a10b105bbc453c27cf147de77b1f8fe6751dad3f5fe09241c5e949fe66e72c4b"

URI_aarch64_rust-yaml-rust2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yaml-rust2+default-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-yaml-rust2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yaml-rust2+default-devel}"
SRC_URI[aarch64_rust-yaml-rust2+default-devel.sha256sum] = "fb298b32596ba0a9de7f4b7b2568028646500e8afaca4f5c4bba143dabde6c68"

URI_aarch64_rust-yaml-rust2+encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yaml-rust2+encoding-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-yaml-rust2+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yaml-rust2+encoding-devel}"
SRC_URI[aarch64_rust-yaml-rust2+encoding-devel.sha256sum] = "9781f56098968904045e5f0c7ac5eaef9fc7391aef24a9f59cfe736e17bebbea"

URI_aarch64_rust-yaml-rust2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yaml-rust2-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-yaml-rust2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yaml-rust2-devel}"
SRC_URI[aarch64_rust-yaml-rust2-devel.sha256sum] = "dc6ab6bba8c69fb9796b25f7e4bb0a14d33bf9e538297012bbc3ac2458c1bfe1"

RDEPENDS:rust-yaml-rust2+debug_prints-devel = " \
 cargo \
 rust-yaml-rust2-devel \
 "
RDEPENDS:rust-yaml-rust2+default-devel = " \
 cargo \
 rust-yaml-rust2+encoding-devel \
 rust-yaml-rust2-devel \
 "
RDEPENDS:rust-yaml-rust2+encoding-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-yaml-rust2-devel \
 "
RDEPENDS:rust-yaml-rust2-devel = " \
 cargo \
 rust \
 rust-arraydeque+default-devel \
 rust-hashlink+default-devel \
 "
