# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libwebp"
PV = "1.3.2"
PR = "8.el10"
PACKAGES = " \
 libwebp \
 libwebp-devel \
 libwebp-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libwebp-1.3.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82e7b54269ae5f52de75aec768d431e48928e16f48b648bc850ae6ee9af2987d"

URI_x86_64_v2_libwebp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwebp-1.3.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_libwebp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwebp}"
SRC_URI[x86_64_v2_libwebp.sha256sum] = "137c8c9a4b0b8d0285622b4a530383ace32346a36f5f7caaf454d7c4ab774300"

URI_x86_64_v2_libwebp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwebp-devel-1.3.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_libwebp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwebp-devel}"
SRC_URI[x86_64_v2_libwebp-devel.sha256sum] = "6c0b6d6b06f6a75b4ccf2df3c2f8759e5ae72557e99a1d97e7731a511736b4db"

URI_x86_64_v2_libwebp-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwebp-tools-1.3.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_libwebp-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwebp-tools}"
SRC_URI[x86_64_v2_libwebp-tools.sha256sum] = "f8224318ac017d08a0066c90f6adc8a89cc5b4b0308e4035749fbfe8e3a620ee"

URI_aarch64_libwebp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwebp-1.3.2-8.el10.aarch64.rpm;name=aarch64_libwebp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwebp}"
SRC_URI[aarch64_libwebp.sha256sum] = "863392527228a8e6b8f71bc07afd30bf827f6005c1730051855953c91261c702"

URI_aarch64_libwebp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwebp-devel-1.3.2-8.el10.aarch64.rpm;name=aarch64_libwebp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwebp-devel}"
SRC_URI[aarch64_libwebp-devel.sha256sum] = "4232ed41005909cff5c51fea4015b6ddb2d4c7f06463c3a8add640835e4eabea"

URI_aarch64_libwebp-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwebp-tools-1.3.2-8.el10.aarch64.rpm;name=aarch64_libwebp-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwebp-tools}"
SRC_URI[aarch64_libwebp-tools.sha256sum] = "86ea5488664a19f39b15fab68471e0a5cc358d26b8e4620eb04fa77be76c1543"

RDEPENDS:libwebp = " \
 glibc \
 "
RDEPENDS:libwebp-devel = " \
 cmake-filesystem \
 libwebp \
 libwebp-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libwebp-tools = " \
 freeglut \
 giflib \
 glibc \
 libglvnd-glx \
 libglvnd-opengl \
 libjpeg-turbo \
 libpng \
 libtiff \
 libwebp \
 "
