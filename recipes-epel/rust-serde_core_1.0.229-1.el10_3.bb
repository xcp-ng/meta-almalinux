# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_core"
PV = "1.0.229"
PR = "1.el10_3"
PACKAGES = " \
 rust-serde_core+alloc-devel \
 rust-serde_core+default-devel \
 rust-serde_core+rc-devel \
 rust-serde_core+result-devel \
 rust-serde_core+std-devel \
 rust-serde_core+unstable-devel \
 rust-serde_core-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-serde_core-1.0.229-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2de3d844f1aa76d87154cb5a98c5f1b9577d964961f3239ed5cc2add08f900ee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+alloc-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_core+alloc-devel.sha256sum] = "378e577c99c25a877f7d4b8475e4d477763610fd7e1c7e9531b1a840f091a316"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+default-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_core+default-devel.sha256sum] = "36c7435864df453c3ba436e547d6fbd36e403c96727e97d70d814d2df2c60849"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+rc-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+rc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_core+rc-devel.sha256sum] = "cd6538c2b0884429522b1eb9ee065fc82fe650147edaf7bfb89d920dbef8a83b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+result-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+result-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_core+result-devel.sha256sum] = "9e6f883c4b817eca7dc9ad0c942466d9d79d289412ee75fe7feb784467955df7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+std-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_core+std-devel.sha256sum] = "53d580c7c700b01b9b9924f3ec9142ed9f31cc57359dfdd41e84ef5502bf28d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+unstable-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+unstable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_core+unstable-devel.sha256sum] = "2b7b7379bb858ce000024bb17464bd32f48b4759f871ae9fec1f6fb8ec47922f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_core-devel.sha256sum] = "c79ea711424da524530fde513c1a259f8e2e1f54ef466c011c21ac2769942dc9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+alloc-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde_core+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-serde_core+alloc-devel.sha256sum] = "adc184c043c13b1650261b537df8424e7f56e801d87ae9d70c83e0ce1e6b1ee6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+default-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde_core+default-devel;unpack=0"
SRC_URI[aarch64_rust-serde_core+default-devel.sha256sum] = "78838fa365d8002be2d31b4da98dbb0cfe577d04f0f66923c41405942ee46318"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+rc-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde_core+rc-devel;unpack=0"
SRC_URI[aarch64_rust-serde_core+rc-devel.sha256sum] = "6a76c59fcbc07c0c49130fac053b6f286f8704f0a1cba3436b4a3a720cecd28a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+result-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde_core+result-devel;unpack=0"
SRC_URI[aarch64_rust-serde_core+result-devel.sha256sum] = "ea2f4c7a3a9922162d28eb5e5e1b7c4ff524fd2b4ce0cdfefc082c6ff0e61900"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+std-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde_core+std-devel;unpack=0"
SRC_URI[aarch64_rust-serde_core+std-devel.sha256sum] = "85505d38d003628508d40afd2b290bd533bdad00151e09e030a3b51296b692ac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+unstable-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde_core+unstable-devel;unpack=0"
SRC_URI[aarch64_rust-serde_core+unstable-devel.sha256sum] = "a271b794c2b7f39ff718f2ffb78723c2df8ba9bf9ed54da6e2aef22f3aa517a2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde_core-devel;unpack=0"
SRC_URI[aarch64_rust-serde_core-devel.sha256sum] = "dc8d77eee60e4de3449b7ed8d7215a08d6b81a2d2428927dd4901afe5633b2fb"

RDEPENDS:rust-serde_core+alloc-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+default-devel = " \
 cargo \
 rust-serde_core+result-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+rc-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+result-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+std-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+unstable-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core-devel = " \
 cargo \
 rust \
 rust-serde_derive+default-devel \
 "
