# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdepim-addons"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdepim-addons \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdepim-addons-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "48a45cceea8a769a5d63cf075da3250eebee40795cd740e54ba7c9398c44c024"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdepim-addons-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdepim-addons;unpack=0"
SRC_URI[x86_64_v2_kdepim-addons.sha256sum] = "bea1afcca7c5f9efe8c604bf04da694ac66bf74e345dcec6547c70761b3d15e0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdepim-addons-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdepim-addons;unpack=0"
SRC_URI[aarch64_kdepim-addons.sha256sum] = "933c5169e3182022d5f1042a23e416b67ef7610761d3449b54411439851bc831"

RDEPENDS:kdepim-addons = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-import-wizard \
 akonadi-mime \
 akonadi-server \
 bash \
 calendarsupport \
 glibc \
 gpgme2pp \
 grantleetheme \
 incidenceeditor \
 kaddressbook-libs \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kdeclarative \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kmime \
 kf6-kservice \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-prison \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kimap \
 kitinerary \
 kldap \
 kmailtransport \
 kpimtextedit \
 kpkpass \
 ktextaddons-qt6 \
 ktnef \
 libgcc \
 libgravatar \
 libkleo \
 libksieve \
 libmarkdown \
 libstdc++ \
 mailcommon \
 mailimporter \
 messagelib \
 pimcommon \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 "
