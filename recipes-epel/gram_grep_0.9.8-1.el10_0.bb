# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gram_grep"
PV = "0.9.8"
PR = "1.el10_0"
PACKAGES = " \
 gram_grep \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gram_grep-0.9.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80176a5e0ecef59feb5ca593213ad629ea4e5fed31c96b12b4c88c7ed3d9ab06"

URI_x86_64_v2_gram_grep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gram_grep-0.9.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gram_grep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gram_grep}"
SRC_URI[x86_64_v2_gram_grep.sha256sum] = "3f12353ffc6a71a6bce3f46282301ee6c0bb2c36514c5bef76cc5d60ec155b63"

URI_aarch64_gram_grep = "${EPEL_MIRROR}/aarch64/Packages/g/gram_grep-0.9.8-1.el10_0.aarch64.rpm;name=aarch64_gram_grep;unpack=0"
SRC_URI:append = " ${URI_aarch64_gram_grep}"
SRC_URI[aarch64_gram_grep.sha256sum] = "6e8907c3756ae3f3e955efc354df0855e71b80a8ed1f06d873d5822f7b323fa9"

RDEPENDS:gram_grep = " \
 glibc \
 libgcc \
 libstdc++ \
 "
