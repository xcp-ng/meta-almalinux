# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mysql-selinux"
PV = "1.0.15"
PR = "1.el10"
PACKAGES = " \
 mysql-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mysql-selinux-1.0.15-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d0b501c62503b45047f887d05e1d5539677e8e748108f428e5901d6d8af3174"

URI_x86_64_v2_mysql-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql-selinux-1.0.15-1.el10.noarch.rpm;name=x86_64_v2_mysql-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql-selinux}"
SRC_URI[x86_64_v2_mysql-selinux.sha256sum] = "f08269d9bbfeeb60ef40a61373cb832f0681d698c37c6fd0c4f52dac173b0b1e"

URI_aarch64_mysql-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql-selinux-1.0.15-1.el10.noarch.rpm;name=aarch64_mysql-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql-selinux}"
SRC_URI[aarch64_mysql-selinux.sha256sum] = "f08269d9bbfeeb60ef40a61373cb832f0681d698c37c6fd0c4f52dac173b0b1e"

RDEPENDS:mysql-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
