# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libayatana-indicator"
PV = "0.9.5"
PR = "1.el10_2"
PACKAGES = " \
 libayatana-indicator-gtk3 \
 libayatana-indicator-gtk3-devel \
 libayatana-indicator-tools-gtk3 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libayatana-indicator-0.9.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6b9a7a9612d8b15759dbaf32dcfda7afafa475fce7fcf30706c49b26baae3888"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-indicator-gtk3-0.9.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-indicator-gtk3;unpack=0"
SRC_URI[x86_64_v2_libayatana-indicator-gtk3.sha256sum] = "d58bf143281c47ed9b7095959e7a16a12298203c112bae66f35fee68966de6aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-indicator-gtk3-devel-0.9.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-indicator-gtk3-devel;unpack=0"
SRC_URI[x86_64_v2_libayatana-indicator-gtk3-devel.sha256sum] = "ab86a37174b0cbf1891e9fbb755407846b3d80e1951ae1640513f2a5649f1844"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-indicator-tools-gtk3-0.9.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-indicator-tools-gtk3;unpack=0"
SRC_URI[x86_64_v2_libayatana-indicator-tools-gtk3.sha256sum] = "f401a6c63d5c808915ae971948a889f770524364a57c2f82a6b1a4bcb10682df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libayatana-indicator-gtk3-0.9.5-1.el10_2.aarch64.rpm;name=aarch64_libayatana-indicator-gtk3;unpack=0"
SRC_URI[aarch64_libayatana-indicator-gtk3.sha256sum] = "c48b4473b9eef24a77b531ca28e157c5dd2fbd476a681954b794210b8f3bb44b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libayatana-indicator-gtk3-devel-0.9.5-1.el10_2.aarch64.rpm;name=aarch64_libayatana-indicator-gtk3-devel;unpack=0"
SRC_URI[aarch64_libayatana-indicator-gtk3-devel.sha256sum] = "3aa2cd7c27ad7eab7040dc3c21f7ece006f0ae05a4ab68909e47818a41527488"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libayatana-indicator-tools-gtk3-0.9.5-1.el10_2.aarch64.rpm;name=aarch64_libayatana-indicator-tools-gtk3;unpack=0"
SRC_URI[aarch64_libayatana-indicator-tools-gtk3.sha256sum] = "7bfec644a2d770d4588556b748e885c6daf98be4d8b259266e82933bbe7b5285"

RDEPENDS:libayatana-indicator-gtk3 = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libayatana-ido-gtk3 \
 "
RDEPENDS:libayatana-indicator-gtk3-devel = " \
 gtk3-devel \
 libayatana-ido-gtk3-devel \
 libayatana-indicator-gtk3 \
 pkgconf-pkg-config \
 "
RDEPENDS:libayatana-indicator-tools-gtk3 = " \
 libayatana-indicator-gtk3 \
 "
