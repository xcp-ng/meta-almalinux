# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-lexicon"
PV = "2.0.1"
PR = "12.el10_0"
PACKAGES = " \
 python3-lexicon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-lexicon-2.0.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78de97cb33c202a5f94f446e393190e772abad4b64242bd83160ce3ab5f35c26"

URI_x86_64_v2_python3-lexicon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lexicon-2.0.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-lexicon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lexicon}"
SRC_URI[x86_64_v2_python3-lexicon.sha256sum] = "b096d1fe82ee1a59f60ac84355191650b386a25282969ca36d777ac130aadb59"

URI_aarch64_python3-lexicon = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lexicon-2.0.1-12.el10_0.noarch.rpm;name=aarch64_python3-lexicon;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lexicon}"
SRC_URI[aarch64_python3-lexicon.sha256sum] = "689ecb735a91a70cf058032ddc35196352df473fd0d1d9ca98c859fba54353ce"

RDEPENDS:python3-lexicon = " \
 python3 \
 "
