# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdbm"
PE = "1"
PV = "1.23"
PR = "12.el10_0"
PACKAGES = " \
 gdbm \
 gdbm-devel \
 gdbm-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gdbm-1.23-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9afddc4b0b1e29c311d5bb8b96b82b3824a27f62c2d5a42a466bfd3208d8739c"

URI_x86_64_v2_gdbm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gdbm-1.23-12.el10_0.x86_64_v2.rpm;name=x86_64_v2_gdbm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdbm}"
SRC_URI[x86_64_v2_gdbm.sha256sum] = "04c2ffdc96a621e37fb0c7e87d1d7f98844d996b6382293195217c8f862d473c"

URI_x86_64_v2_gdbm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdbm-devel-1.23-12.el10_0.x86_64_v2.rpm;name=x86_64_v2_gdbm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdbm-devel}"
SRC_URI[x86_64_v2_gdbm-devel.sha256sum] = "3be5895ac4fb15168bfd2f85b68151891c2a12a13f988feb96cd90f315068300"

URI_x86_64_v2_gdbm-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gdbm-libs-1.23-12.el10_0.x86_64_v2.rpm;name=x86_64_v2_gdbm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdbm-libs}"
SRC_URI[x86_64_v2_gdbm-libs.sha256sum] = "7765df2bf2c2ddda06205e8e7ffd8b55f5dc090426b740daf5b32b9bcb09a6bf"

URI_aarch64_gdbm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gdbm-1.23-12.el10_0.aarch64.rpm;name=aarch64_gdbm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdbm}"
SRC_URI[aarch64_gdbm.sha256sum] = "e8474b0244a9b453e86a1c65159310e9cc22091feef93701c789af3e3f6c39dc"

URI_aarch64_gdbm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdbm-devel-1.23-12.el10_0.aarch64.rpm;name=aarch64_gdbm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdbm-devel}"
SRC_URI[aarch64_gdbm-devel.sha256sum] = "14f7cb04a2a675c8eeab287166d85fd22f7812a0bffdf5b4442e4c9654e5d103"

URI_aarch64_gdbm-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gdbm-libs-1.23-12.el10_0.aarch64.rpm;name=aarch64_gdbm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdbm-libs}"
SRC_URI[aarch64_gdbm-libs.sha256sum] = "ce675d7c4e47ed0fe8447e3793c10701a789a4bace5c96de65333e991616c146"

RDEPENDS:gdbm = " \
 gdbm-libs \
 glibc \
 readline \
 "
RDEPENDS:gdbm-devel = " \
 gdbm \
 gdbm-libs \
 info \
 "
RDEPENDS:gdbm-libs = " \
 glibc \
 "
