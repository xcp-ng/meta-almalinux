# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nodeenv"
PV = "1.9.1"
PR = "3.el10_0"
PACKAGES = " \
 python3-nodeenv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-nodeenv-1.9.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "944d5df40f38b6d09deeab2a665a172ed51bf64d663cec1bd70c27dc9d5523c0"

URI_x86_64_v2_python3-nodeenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nodeenv-1.9.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-nodeenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nodeenv}"
SRC_URI[x86_64_v2_python3-nodeenv.sha256sum] = "9cd534bbd30e9b3d4e1f3e2af6eed8f98fe885b78a24b480de3ddabc3171f24e"

URI_aarch64_python3-nodeenv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nodeenv-1.9.1-3.el10_0.noarch.rpm;name=aarch64_python3-nodeenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nodeenv}"
SRC_URI[aarch64_python3-nodeenv.sha256sum] = "2b6c8a774f41ca3c1945d35558f74f9ade05dce96b79b9e5fd0cf3bf70d82b7a"

RDEPENDS:python3-nodeenv = " \
 python3 \
 "
