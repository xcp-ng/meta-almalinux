# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futf"
PV = "0.1.5"
PR = "7.el10_0"
PACKAGES = " \
 rust-futf+default-devel \
 rust-futf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futf-0.1.5-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "619a5d5eaa2e5e458a4688e8ce65139f235c99007edb84efd4571ef111315344"

URI_x86_64_v2_rust-futf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futf+default-devel-0.1.5-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futf+default-devel}"
SRC_URI[x86_64_v2_rust-futf+default-devel.sha256sum] = "7ef72b43196a1d85cf81c7dd086dcfa081b6956dd9599c629241041fc6791ce8"

URI_x86_64_v2_rust-futf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futf-devel-0.1.5-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futf-devel}"
SRC_URI[x86_64_v2_rust-futf-devel.sha256sum] = "494d704f4b20f50f8afae5a1166c6352fb423a6c9dca9eae85dbe82e541604c4"

URI_aarch64_rust-futf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futf+default-devel-0.1.5-7.el10_0.noarch.rpm;name=aarch64_rust-futf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futf+default-devel}"
SRC_URI[aarch64_rust-futf+default-devel.sha256sum] = "0742359fb62830692c8905810fb61265008f0e6474fe04778889c6b9e4a7e92f"

URI_aarch64_rust-futf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futf-devel-0.1.5-7.el10_0.noarch.rpm;name=aarch64_rust-futf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futf-devel}"
SRC_URI[aarch64_rust-futf-devel.sha256sum] = "9126ad5cd481e02df5b4a237bf283505c00b08e626c7c54760576d9eb19fd46d"

RDEPENDS:rust-futf+default-devel = " \
 cargo \
 rust-futf-devel \
 "
RDEPENDS:rust-futf-devel = " \
 cargo \
 rust-mac+default-devel \
 rust-new_debug_unreachable+default-devel \
 "
