# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-terminfo"
PV = "0.9.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-terminfo+default-devel \
 rust-terminfo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-terminfo-0.9.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aeb93db7139c3b43a8603af915c4ae15700eb31603bded1c2f8e2313676eb3a6"

URI_x86_64_v2_rust-terminfo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminfo+default-devel-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminfo+default-devel}"
SRC_URI[x86_64_v2_rust-terminfo+default-devel.sha256sum] = "90f8fde20539a42fe200b1d22c87a7a8a379aff808c769750c168621df780c6e"

URI_x86_64_v2_rust-terminfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminfo-devel-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminfo-devel}"
SRC_URI[x86_64_v2_rust-terminfo-devel.sha256sum] = "c8ed19527cd3ad3646a68e76c087ed57bbd31f8eb3a8002160d4065d0f1ff0d4"

URI_aarch64_rust-terminfo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminfo+default-devel-0.9.0-2.el10_0.noarch.rpm;name=aarch64_rust-terminfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminfo+default-devel}"
SRC_URI[aarch64_rust-terminfo+default-devel.sha256sum] = "a194ad7494006a76e371bba51efab608d7e3fb7402412ec671cdda344d22ebb6"

URI_aarch64_rust-terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminfo-devel-0.9.0-2.el10_0.noarch.rpm;name=aarch64_rust-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminfo-devel}"
SRC_URI[aarch64_rust-terminfo-devel.sha256sum] = "413430d770a31ceeabf94f3233f988949c83a49fe64ea755369c4d0a8e331ef8"

RDEPENDS:rust-terminfo+default-devel = " \
 cargo \
 rust-terminfo-devel \
 "
RDEPENDS:rust-terminfo-devel = " \
 cargo \
 rust-fnv+default-devel \
 rust-nom+std-devel \
 rust-nom-devel \
 rust-phf+default-devel \
 rust-phf_codegen+default-devel \
 "
