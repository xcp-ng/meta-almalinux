# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest_generator"
PV = "2.8.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-pest_generator+default-devel \
 rust-pest_generator+export-internal-devel \
 rust-pest_generator+grammar-extras-devel \
 rust-pest_generator+std-devel \
 rust-pest_generator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest_generator-2.8.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "baaff3d919f4ab89c4240af2ee87dd51a8b9b694c72cac8c2af2516be9a7adf4"

URI_x86_64_v2_rust-pest_generator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+default-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+default-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+default-devel.sha256sum] = "42d6e9dd8f25aae41a0ade7237eee79b8bdddbaa60a4df6b01102a34b3741291"

URI_x86_64_v2_rust-pest_generator+export-internal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+export-internal-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+export-internal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+export-internal-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+export-internal-devel.sha256sum] = "1f49a05331ae6d82420d6d41204421b6db72c6e28b8da1cf3f38e8d52494b499"

URI_x86_64_v2_rust-pest_generator+grammar-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+grammar-extras-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+grammar-extras-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+grammar-extras-devel.sha256sum] = "71b675a5bea0bc47af976680341f7280faa1129b021f376b5636c42261a2f962"

URI_x86_64_v2_rust-pest_generator+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+std-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+std-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+std-devel.sha256sum] = "75eea774934e11188b6991742f58d8b6ce050f23e1b4c1f9ee51b9ff192e35c2"

URI_x86_64_v2_rust-pest_generator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator-devel}"
SRC_URI[x86_64_v2_rust-pest_generator-devel.sha256sum] = "351683fc99f69b090fe434fa3087be5af957d360018cf9f148a4ae1e2ea58d31"

URI_aarch64_rust-pest_generator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+default-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+default-devel}"
SRC_URI[aarch64_rust-pest_generator+default-devel.sha256sum] = "62d18952fcd8a0e675cc0a738ef7fad95ba0e2c772d14515e165286a1ec563e1"

URI_aarch64_rust-pest_generator+export-internal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+export-internal-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest_generator+export-internal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+export-internal-devel}"
SRC_URI[aarch64_rust-pest_generator+export-internal-devel.sha256sum] = "ad1e209ae35ebd63ebe0b5e74b56da71af6079a6588f557bddc183184a68755e"

URI_aarch64_rust-pest_generator+grammar-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+grammar-extras-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest_generator+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+grammar-extras-devel}"
SRC_URI[aarch64_rust-pest_generator+grammar-extras-devel.sha256sum] = "94b67037e8bd06ac5df0ef8a71627c9565136ed9b28826aa9fd4ae9069c23384"

URI_aarch64_rust-pest_generator+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+std-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest_generator+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+std-devel}"
SRC_URI[aarch64_rust-pest_generator+std-devel.sha256sum] = "78a6772dcd3577d935418d7704c82c56d037ad648692aa94f85b8e22bdb8c32b"

URI_aarch64_rust-pest_generator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest_generator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator-devel}"
SRC_URI[aarch64_rust-pest_generator-devel.sha256sum] = "5eb97d70e6ec37a46527a45ddf0a72dbc28800f23933811d3ba85200e541fcb4"

RDEPENDS:rust-pest_generator+default-devel = " \
 cargo \
 rust-pest_generator+std-devel \
 rust-pest_generator-devel \
 "
RDEPENDS:rust-pest_generator+export-internal-devel = " \
 cargo \
 rust-pest_generator-devel \
 "
RDEPENDS:rust-pest_generator+grammar-extras-devel = " \
 cargo \
 rust-pest_generator-devel \
 rust-pest_meta+grammar-extras-devel \
 "
RDEPENDS:rust-pest_generator+std-devel = " \
 cargo \
 rust-pest+std-devel \
 rust-pest_generator-devel \
 "
RDEPENDS:rust-pest_generator-devel = " \
 cargo \
 rust \
 rust-pest-devel \
 rust-pest_meta+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
