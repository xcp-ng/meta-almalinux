# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-gi-glib"
PV = "2.0.30"
PR = "1.el10_0"
PACKAGES = " \
 ghc-gi-glib \
 ghc-gi-glib-devel \
 ghc-gi-glib-doc \
 ghc-gi-glib-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-gi-glib-2.0.30-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db4859057c77d83c0f18e49a841b49ba6d9f6e6ce2a04fd5a76b968b4443b339"

URI_x86_64_v2_ghc-gi-glib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-glib-2.0.30-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gi-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-glib}"
SRC_URI[x86_64_v2_ghc-gi-glib.sha256sum] = "7a1c1b9b03067cde786e34f270e10b518dddafb9ef051690a50577aa73dc37f8"

URI_x86_64_v2_ghc-gi-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-glib-devel-2.0.30-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gi-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-glib-devel}"
SRC_URI[x86_64_v2_ghc-gi-glib-devel.sha256sum] = "052a11e20b7f8a87288b6f6d94256ce86c0a83c52349c3c35e105147e3daebd9"

URI_x86_64_v2_ghc-gi-glib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-glib-doc-2.0.30-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-gi-glib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-glib-doc}"
SRC_URI[x86_64_v2_ghc-gi-glib-doc.sha256sum] = "23a966bbb4881088cb020a181db06a9393797e90fe2054c739ca3f2b47b81f04"

URI_x86_64_v2_ghc-gi-glib-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-glib-prof-2.0.30-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gi-glib-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-glib-prof}"
SRC_URI[x86_64_v2_ghc-gi-glib-prof.sha256sum] = "4ac16406306dd88f1d9feb97ed7693b67628be22d844d05f17e2eea83a42f60d"

URI_aarch64_ghc-gi-glib = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-glib-2.0.30-1.el10_0.aarch64.rpm;name=aarch64_ghc-gi-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-glib}"
SRC_URI[aarch64_ghc-gi-glib.sha256sum] = "bcd19bfc6721c2e66a30df483ec7fef2da9a07e734ecab94315bfa03743b3070"

URI_aarch64_ghc-gi-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-glib-devel-2.0.30-1.el10_0.aarch64.rpm;name=aarch64_ghc-gi-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-glib-devel}"
SRC_URI[aarch64_ghc-gi-glib-devel.sha256sum] = "df70bd3061338c000cdcc984546233a9924406a3883940e0a7c45c7b342f5890"

URI_aarch64_ghc-gi-glib-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-glib-doc-2.0.30-1.el10_0.noarch.rpm;name=aarch64_ghc-gi-glib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-glib-doc}"
SRC_URI[aarch64_ghc-gi-glib-doc.sha256sum] = "45ca559616954123b08e2b9dccdffd1952e8dc36248c85094eefa8a5e2f6ef13"

URI_aarch64_ghc-gi-glib-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-glib-prof-2.0.30-1.el10_0.aarch64.rpm;name=aarch64_ghc-gi-glib-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-glib-prof}"
SRC_URI[aarch64_ghc-gi-glib-prof.sha256sum] = "234f83a218cfd780cd831ec8752159f75f50288d112b0f8ffe3f495608f8a418"

RDEPENDS:ghc-gi-glib = " \
 ghc-Cabal \
 ghc-Cabal-syntax \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-colour \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-haskell-gi \
 ghc-haskell-gi-base \
 ghc-haskell-lexer \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-pretty-show \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-regex-base \
 ghc-regex-tdfa \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-xdg-basedir \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glib2 \
 glibc \
 gmp \
 gobject-introspection \
 zlib-ng-compat \
 "
RDEPENDS:ghc-gi-glib-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-gi-glib \
 ghc-haskell-gi-base-devel \
 ghc-haskell-gi-devel \
 ghc-haskell-gi-overloading-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 glib2-devel \
 "
RDEPENDS:ghc-gi-glib-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-gi-glib-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-gi-glib-devel \
 ghc-haskell-gi-base-prof \
 ghc-haskell-gi-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 "
