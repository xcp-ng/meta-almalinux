# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "s3fs-fuse"
PV = "1.95"
PR = "2.el10_1"
PACKAGES = " \
 s3fs-fuse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/s3fs-fuse-1.95-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01eb43abf46e5221cc6e8cce691b3726c22ef9c9ec9ce5bab852aa9d8bb851ee"

URI_x86_64_v2_s3fs-fuse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/s3fs-fuse-1.95-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_s3fs-fuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s3fs-fuse}"
SRC_URI[x86_64_v2_s3fs-fuse.sha256sum] = "3ec2b871d17ec18bbe8f37485c11b0efa26a2a6c7ab2a7485d8314576e026e9d"

URI_aarch64_s3fs-fuse = "${EPEL_MIRROR}/aarch64/Packages/s/s3fs-fuse-1.95-2.el10_1.aarch64.rpm;name=aarch64_s3fs-fuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_s3fs-fuse}"
SRC_URI[aarch64_s3fs-fuse.sha256sum] = "53a3767791e7e606e6b128259c271f2f22f26d8f9baadbd4b04a9d54c6a19574"

RDEPENDS:s3fs-fuse = " \
 fuse \
 fuse-libs \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 mailcap \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
