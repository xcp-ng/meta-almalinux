# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knights"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 knights \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/knights-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "df1cc22676f28519da8e7155dbcd8dc2d58489076ca6a49f088e89118a5f34a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knights-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knights;unpack=0"
SRC_URI[x86_64_v2_knights.sha256sum] = "c0a5c2f80acee937f16b0e32355fe4cc1886b32d1f79da56c551e9c0fd796e78"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/knights-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_knights;unpack=0"
SRC_URI[aarch64_knights.sha256sum] = "36d1caf8bc8b70607e4e50d9d4d6f7b2c9f61e2352741be1930dd82f0c58b19f"

RDEPENDS:knights = " \
 glibc \
 gnuchess \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kplotting \
 kf6-ksvg \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
