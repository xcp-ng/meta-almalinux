# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtscxml"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtscxml \
 qt5-qtscxml-devel \
 qt5-qtscxml-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtscxml-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ded2f890d0ef3e212b2c2ad2da4cd9cc4c984d07d80d74c37df75de554267bab"

URI_x86_64_v2_qt5-qtscxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscxml-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscxml}"
SRC_URI[x86_64_v2_qt5-qtscxml.sha256sum] = "1569dc56d7e555c0deabc32e0ee3ce5648eb0f87e60516d8ba2d39550f5366bb"

URI_x86_64_v2_qt5-qtscxml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscxml-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscxml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscxml-devel}"
SRC_URI[x86_64_v2_qt5-qtscxml-devel.sha256sum] = "5ba84ec698023f9959221c351e45e753b5624aacd70a8ad9a043e499e7de7113"

URI_x86_64_v2_qt5-qtscxml-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscxml-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscxml-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscxml-examples}"
SRC_URI[x86_64_v2_qt5-qtscxml-examples.sha256sum] = "a4dab43b668043f3156866e3cd0701de56e7206d8866f2a15d7a36e744065ad6"

URI_aarch64_qt5-qtscxml = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscxml-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtscxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscxml}"
SRC_URI[aarch64_qt5-qtscxml.sha256sum] = "410236bcf8eef9cde45bc1bace9298fee6133877c051d0fd485f7367a89edda6"

URI_aarch64_qt5-qtscxml-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscxml-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtscxml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscxml-devel}"
SRC_URI[aarch64_qt5-qtscxml-devel.sha256sum] = "450dc85c73fa81d65067acf8b71382cfb0f679dfbadf214ff706029d68f18df0"

URI_aarch64_qt5-qtscxml-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscxml-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtscxml-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscxml-examples}"
SRC_URI[aarch64_qt5-qtscxml-examples.sha256sum] = "f7da5d5d4ed8201ed6d099f7a3fb60ce3561e8e84f335b26bf411bb7aac9b0bc"

RDEPENDS:qt5-qtscxml = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtscxml-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtscxml \
 "
RDEPENDS:qt5-qtscxml-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtscxml \
 "
