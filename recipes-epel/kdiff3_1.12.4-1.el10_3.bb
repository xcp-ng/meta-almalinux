# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdiff3"
PV = "1.12.4"
PR = "1.el10_3"
PACKAGES = " \
 kdiff3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdiff3-1.12.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79bab2359092f6877a648b2ee6b7f8b6605cf4dc16c4d10415435f50217cf7b7"

URI_x86_64_v2_kdiff3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdiff3-1.12.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdiff3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdiff3}"
SRC_URI[x86_64_v2_kdiff3.sha256sum] = "a68683055d2c0b6fb85f5e3bdd9dd99e1cea9e3237d44a081d1818ce8ea6c7cd"

URI_aarch64_kdiff3 = "${EPEL_MIRROR}/aarch64/Packages/k/kdiff3-1.12.4-1.el10_3.aarch64.rpm;name=aarch64_kdiff3;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdiff3}"
SRC_URI[aarch64_kdiff3.sha256sum] = "82f058d2cf7be6789fe81c4c5e67f6a895254d80c3d87faf111b272747c17677"

RDEPENDS:kdiff3 = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libicu \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
