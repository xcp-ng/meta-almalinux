# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pkg-config"
PV = "0.3.32"
PR = "1.el10_0"
PACKAGES = " \
 rust-pkg-config+default-devel \
 rust-pkg-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pkg-config-0.3.32-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70dc2e5a3f50497fec92d56b4428888cb5475730ac56894fc1711c667016950d"

URI_x86_64_v2_rust-pkg-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkg-config+default-devel-0.3.32-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkg-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkg-config+default-devel}"
SRC_URI[x86_64_v2_rust-pkg-config+default-devel.sha256sum] = "856e82e60eaea2dbb5d93970a4482a0b77f7be0bf6f67194e7d68822176596f0"

URI_x86_64_v2_rust-pkg-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkg-config-devel-0.3.32-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkg-config-devel}"
SRC_URI[x86_64_v2_rust-pkg-config-devel.sha256sum] = "eb7ab1ecfd76138ef8cc03df4c220c4eee4646e9ad28baea1bcff661c996f549"

URI_aarch64_rust-pkg-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkg-config+default-devel-0.3.32-1.el10_0.noarch.rpm;name=aarch64_rust-pkg-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkg-config+default-devel}"
SRC_URI[aarch64_rust-pkg-config+default-devel.sha256sum] = "9d94ab661a9a9cdee1b8592885e6ad954d5cf663e8f9e6101c40dd697a84c658"

URI_aarch64_rust-pkg-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkg-config-devel-0.3.32-1.el10_0.noarch.rpm;name=aarch64_rust-pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkg-config-devel}"
SRC_URI[aarch64_rust-pkg-config-devel.sha256sum] = "86798c3c34d6e57fccd2df17983b744985f52ce4f1006d6a70b55f9aeae78c0a"

RDEPENDS:rust-pkg-config+default-devel = " \
 cargo \
 rust-pkg-config-devel \
 "
RDEPENDS:rust-pkg-config-devel = " \
 cargo \
 pkgconf-pkg-config \
 rust \
 "
