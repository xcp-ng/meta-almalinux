# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-plain"
PV = "0.2.3"
PR = "19.el10_0"
PACKAGES = " \
 rust-plain+default-devel \
 rust-plain-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-plain-0.2.3-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e1c8180c65d0caa65a0972d6cd48cbe1a434434dc1e3e187e50ba88157aeb4e5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plain+default-devel-0.2.3-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plain+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-plain+default-devel.sha256sum] = "6b036e203808fc8d53a02b92eeb000bc269d7210ea26f58cdb76d6fbf6045aaf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plain-devel-0.2.3-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plain-devel;unpack=0"
SRC_URI[x86_64_v2_rust-plain-devel.sha256sum] = "9af279475277c188d284b87ad477d03f163bd1c06c47c0b0b3a0952f11faf36f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-plain+default-devel-0.2.3-19.el10_0.noarch.rpm;name=aarch64_rust-plain+default-devel;unpack=0"
SRC_URI[aarch64_rust-plain+default-devel.sha256sum] = "27214d1075a566c38e0c3c45278a7c14c30c67bc48b632fd421553f861179a41"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-plain-devel-0.2.3-19.el10_0.noarch.rpm;name=aarch64_rust-plain-devel;unpack=0"
SRC_URI[aarch64_rust-plain-devel.sha256sum] = "3476c6140f4650a02c78774956df28c47f4bbb14d5e4ecdaa1461446f6cf4e50"

RDEPENDS:rust-plain+default-devel = " \
 cargo \
 rust-plain-devel \
 "
RDEPENDS:rust-plain-devel = " \
 cargo \
 "
