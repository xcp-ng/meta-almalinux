# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "beaker"
PV = "29.2"
PR = "5.el10_1"
PACKAGES = " \
 beaker-client \
 beaker-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/beaker-29.2-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c7930ce1c021744ec724339dcb1507af01f5ef43b06e1a1e85b334a06e82714"

URI_x86_64_v2_beaker-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/beaker-client-29.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_beaker-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_beaker-client}"
SRC_URI[x86_64_v2_beaker-client.sha256sum] = "ca44c2758ccb948c2dbfceb2432942fb1add41302ac58dfaacf98c5af2a5e757"

URI_x86_64_v2_beaker-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/beaker-common-29.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_beaker-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_beaker-common}"
SRC_URI[x86_64_v2_beaker-common.sha256sum] = "c18ceef00b76e2d482c88c7c645338eb6a6f8700119e21b6d8bbaf56bdcd1cd6"

URI_aarch64_beaker-client = "${EPEL_MIRROR}/aarch64/Packages/b/beaker-client-29.2-5.el10_1.noarch.rpm;name=aarch64_beaker-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_beaker-client}"
SRC_URI[aarch64_beaker-client.sha256sum] = "0c988934b472370284aff46d8d5a0e3edbb0a12bad50703813ff7089d9800e0c"

URI_aarch64_beaker-common = "${EPEL_MIRROR}/aarch64/Packages/b/beaker-common-29.2-5.el10_1.noarch.rpm;name=aarch64_beaker-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_beaker-common}"
SRC_URI[aarch64_beaker-common.sha256sum] = "e4f8f2b26a12cc412d533c39f843b57ca530a480a5e3766e5d0826b231d2dac4"

RDEPENDS:beaker-client = " \
 beaker-common \
 python3 \
 python3-gssapi \
 python3-jinja2 \
 python3-libxml2 \
 python3-lxml \
 python3-prettytable \
 python3-requests \
 python3-setuptools \
 python3-six \
 "
RDEPENDS:beaker-common = " \
 python3 \
 "
