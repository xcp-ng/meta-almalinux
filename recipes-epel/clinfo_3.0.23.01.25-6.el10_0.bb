# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clinfo"
PV = "3.0.23.01.25"
PR = "6.el10_0"
PACKAGES = " \
 clinfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clinfo-3.0.23.01.25-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec16de061c29af2144ff0139fa6590b1da3f8b303281d8d06c5e1541ba723341"

URI_x86_64_v2_clinfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clinfo-3.0.23.01.25-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clinfo}"
SRC_URI[x86_64_v2_clinfo.sha256sum] = "1810c333397a19fe646ade3eaf898080c2cd731c8fbc146251950bac42f3e307"

URI_aarch64_clinfo = "${EPEL_MIRROR}/aarch64/Packages/c/clinfo-3.0.23.01.25-6.el10_0.aarch64.rpm;name=aarch64_clinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_clinfo}"
SRC_URI[aarch64_clinfo.sha256sum] = "016228164e0ebfddd1cc2fe9d9bb47f310580ec1daaa0e115636bf7bc9222ed9"

RDEPENDS:clinfo = " \
 glibc \
 ocl-icd \
 "
