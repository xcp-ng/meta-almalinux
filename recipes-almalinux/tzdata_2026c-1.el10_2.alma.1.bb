# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tzdata"
PV = "2026c"
PR = "1.el10_2.alma.1"
PACKAGES = " \
 tzdata \
 tzdata-java \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tzdata-2026c-1.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "47a9b5d8acf70e7da54cc4af442bf4cd7a6ff4325adc3aefd6108f3f0afbc248"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tzdata-2026c-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tzdata;unpack=0"
SRC_URI[x86_64_v2_tzdata.sha256sum] = "dc75c299b84e237e7adb3f20bdc65b3d2c5447d496d8641a00c69d9a5df85f93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tzdata-java-2026c-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tzdata-java;unpack=0"
SRC_URI[x86_64_v2_tzdata-java.sha256sum] = "93c25eca875a1023ae448219939e4eaafb58357b84955d02e1cd80b3e27d7657"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tzdata-2026c-1.el10_2.alma.1.noarch.rpm;name=aarch64_tzdata;unpack=0"
SRC_URI[aarch64_tzdata.sha256sum] = "dc75c299b84e237e7adb3f20bdc65b3d2c5447d496d8641a00c69d9a5df85f93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tzdata-java-2026c-1.el10_2.alma.1.noarch.rpm;name=aarch64_tzdata-java;unpack=0"
SRC_URI[aarch64_tzdata-java.sha256sum] = "93c25eca875a1023ae448219939e4eaafb58357b84955d02e1cd80b3e27d7657"

RDEPENDS:tzdata = " \
 "
RDEPENDS:tzdata-java = " \
 "
