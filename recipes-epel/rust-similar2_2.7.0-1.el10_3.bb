# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-similar2"
PV = "2.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-similar2+bstr-devel \
 rust-similar2+bytes-devel \
 rust-similar2+default-devel \
 rust-similar2+inline-devel \
 rust-similar2+serde-devel \
 rust-similar2+text-devel \
 rust-similar2+unicode-devel \
 rust-similar2+unicode-segmentation-devel \
 rust-similar2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-similar2-2.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39ba9ac13114620ae6e0e0acf4955dee52ed415d0ea99298673e69f7d198c3e5"

URI_x86_64_v2_rust-similar2+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar2+bstr-devel-2.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar2+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar2+bstr-devel}"
SRC_URI[x86_64_v2_rust-similar2+bstr-devel.sha256sum] = "d4a08198a4098f2d22a720793ff4d62b2a2be9128215d94cdf907951a21e1a22"

URI_x86_64_v2_rust-similar2+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar2+bytes-devel-2.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar2+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar2+bytes-devel}"
SRC_URI[x86_64_v2_rust-similar2+bytes-devel.sha256sum] = "70f8f9a732286ac3679338dde9c45681a057133d3d163ff832b349af48931049"

URI_x86_64_v2_rust-similar2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar2+default-devel-2.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar2+default-devel}"
SRC_URI[x86_64_v2_rust-similar2+default-devel.sha256sum] = "0faefb076a401f2737585f88e8da860f2d7ae1bd2049fe926efb803c34d7c577"

URI_x86_64_v2_rust-similar2+inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar2+inline-devel-2.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar2+inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar2+inline-devel}"
SRC_URI[x86_64_v2_rust-similar2+inline-devel.sha256sum] = "abcb7504d17f55b417241968718148feb0d51426cd468c1a829f6d71c6b53975"

URI_x86_64_v2_rust-similar2+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar2+serde-devel-2.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar2+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar2+serde-devel}"
SRC_URI[x86_64_v2_rust-similar2+serde-devel.sha256sum] = "17fbc80389acef7596e461c1ca251cee3f2758081e82bd2cfbd74f5efaa2161b"

URI_x86_64_v2_rust-similar2+text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar2+text-devel-2.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar2+text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar2+text-devel}"
SRC_URI[x86_64_v2_rust-similar2+text-devel.sha256sum] = "8d5fda330a9b031ae7d693f79896bde90d53afab9e8417e6dffd93022ca3695e"

URI_x86_64_v2_rust-similar2+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar2+unicode-devel-2.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar2+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar2+unicode-devel}"
SRC_URI[x86_64_v2_rust-similar2+unicode-devel.sha256sum] = "397e2f8cceb56b1427c698d07383172b0ea099c1e13855fac38c731e2fd3f8af"

URI_x86_64_v2_rust-similar2+unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar2+unicode-segmentation-devel-2.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar2+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar2+unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-similar2+unicode-segmentation-devel.sha256sum] = "8b81e5dc1698ac2fc35713519fdeb7fdf83a1e4c21fd3d196acef3d4cf4077cb"

URI_x86_64_v2_rust-similar2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar2-devel-2.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar2-devel}"
SRC_URI[x86_64_v2_rust-similar2-devel.sha256sum] = "285868595b97ab6c6155a4e1f1a41c3f1b7463a535f2ffac581c5aafb027a409"

URI_aarch64_rust-similar2+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar2+bstr-devel-2.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-similar2+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar2+bstr-devel}"
SRC_URI[aarch64_rust-similar2+bstr-devel.sha256sum] = "c1fa6a8ee51facc6c291b6b553e3f2d376a189f78a667deafcf3f39273271f07"

URI_aarch64_rust-similar2+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar2+bytes-devel-2.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-similar2+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar2+bytes-devel}"
SRC_URI[aarch64_rust-similar2+bytes-devel.sha256sum] = "7a475a8ffd1913af36a97561425aa6faacc7ed25d627ca6e73a410b572e5dd57"

URI_aarch64_rust-similar2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar2+default-devel-2.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-similar2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar2+default-devel}"
SRC_URI[aarch64_rust-similar2+default-devel.sha256sum] = "4b01989287c3607e8fe7ab2a9408c95a3468b49f653514bbad7d5775b1dcdad4"

URI_aarch64_rust-similar2+inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar2+inline-devel-2.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-similar2+inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar2+inline-devel}"
SRC_URI[aarch64_rust-similar2+inline-devel.sha256sum] = "4fc46dff8b9099316a2b8a93f8890930ba08dd879691beecdf54b62d92ec9ce6"

URI_aarch64_rust-similar2+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar2+serde-devel-2.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-similar2+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar2+serde-devel}"
SRC_URI[aarch64_rust-similar2+serde-devel.sha256sum] = "37beab9faa7b1bf3577a5fc259fa21ada5c6848a26f3d0cc73d38644a3ee3eb0"

URI_aarch64_rust-similar2+text-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar2+text-devel-2.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-similar2+text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar2+text-devel}"
SRC_URI[aarch64_rust-similar2+text-devel.sha256sum] = "dbfb540387e3dc2a137acc8f33a66d3cc693850de31041d8c2326b9fce58a9c5"

URI_aarch64_rust-similar2+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar2+unicode-devel-2.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-similar2+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar2+unicode-devel}"
SRC_URI[aarch64_rust-similar2+unicode-devel.sha256sum] = "94b81008d484103e5231cf0dc6a2a8c1d73223ced9ce6aa51c2c9d80185992aa"

URI_aarch64_rust-similar2+unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar2+unicode-segmentation-devel-2.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-similar2+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar2+unicode-segmentation-devel}"
SRC_URI[aarch64_rust-similar2+unicode-segmentation-devel.sha256sum] = "52d2e2f4da1183a4929e03fa5128847b14e6de3b2112db63e5b472c890319f6d"

URI_aarch64_rust-similar2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar2-devel-2.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-similar2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar2-devel}"
SRC_URI[aarch64_rust-similar2-devel.sha256sum] = "62cc22003bc8ff439b00187ec6dba99a5d0a67dd21376685ca3239e308b975e1"

RDEPENDS:rust-similar2+bstr-devel = " \
 cargo \
 rust-bstr-devel \
 rust-similar2-devel \
 "
RDEPENDS:rust-similar2+bytes-devel = " \
 cargo \
 rust-similar2+bstr-devel \
 rust-similar2+text-devel \
 rust-similar2-devel \
 "
RDEPENDS:rust-similar2+default-devel = " \
 cargo \
 rust-similar2+text-devel \
 rust-similar2-devel \
 "
RDEPENDS:rust-similar2+inline-devel = " \
 cargo \
 rust-similar2+text-devel \
 rust-similar2-devel \
 "
RDEPENDS:rust-similar2+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-similar2-devel \
 "
RDEPENDS:rust-similar2+text-devel = " \
 cargo \
 rust-similar2-devel \
 "
RDEPENDS:rust-similar2+unicode-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-similar2+text-devel \
 rust-similar2+unicode-segmentation-devel \
 rust-similar2-devel \
 "
RDEPENDS:rust-similar2+unicode-segmentation-devel = " \
 cargo \
 rust-similar2-devel \
 rust-unicode-segmentation+default-devel \
 "
RDEPENDS:rust-similar2-devel = " \
 bash \
 cargo \
 rust \
 "
