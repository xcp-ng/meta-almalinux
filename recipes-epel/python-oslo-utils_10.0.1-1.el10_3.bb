# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslo-utils"
PV = "10.0.1"
PR = "1.el10_3"
PACKAGES = " \
 python-oslo-utils-doc \
 python-oslo-utils-lang \
 python3-oslo-utils \
 python3-oslo-utils-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-oslo-utils-10.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e417758debfc0f688c45b3ce5f329af688eb91e4f6e862793b99e009a4d7937c"

URI_x86_64_v2_python-oslo-utils-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-utils-doc-10.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-utils-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-utils-doc}"
SRC_URI[x86_64_v2_python-oslo-utils-doc.sha256sum] = "b3741952d6a4b86f18f4c85b459fbbd668be945f543626ec1bda929fd3e1e16a"

URI_x86_64_v2_python-oslo-utils-lang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-utils-lang-10.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-utils-lang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-utils-lang}"
SRC_URI[x86_64_v2_python-oslo-utils-lang.sha256sum] = "dd1a5149af76c9044b828cf2458ccaf21ced9c22cd10663758744a06068c01f4"

URI_x86_64_v2_python3-oslo-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-utils-10.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-utils}"
SRC_URI[x86_64_v2_python3-oslo-utils.sha256sum] = "82752a59e91109e72b94b62ac55e64e9d131259b490c9ca035180f22caf88675"

URI_x86_64_v2_python3-oslo-utils-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-utils-tests-10.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-utils-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-utils-tests}"
SRC_URI[x86_64_v2_python3-oslo-utils-tests.sha256sum] = "a7dd0b525a4f22d13107f59dcf876ec48229d4dfe01b765743c6397d1ca03054"

URI_aarch64_python-oslo-utils-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-utils-doc-10.0.1-1.el10_3.noarch.rpm;name=aarch64_python-oslo-utils-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-utils-doc}"
SRC_URI[aarch64_python-oslo-utils-doc.sha256sum] = "e1a73929458e9ce5938a43153fefc833780e61d5c4bb24fc053b780210af578b"

URI_aarch64_python-oslo-utils-lang = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-utils-lang-10.0.1-1.el10_3.noarch.rpm;name=aarch64_python-oslo-utils-lang;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-utils-lang}"
SRC_URI[aarch64_python-oslo-utils-lang.sha256sum] = "7ad7c50ebde0ea26b4e6ae1585ee5bd5946d1ae6e3f22c0b0a9a6f2424d8d6e7"

URI_aarch64_python3-oslo-utils = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-utils-10.0.1-1.el10_3.noarch.rpm;name=aarch64_python3-oslo-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-utils}"
SRC_URI[aarch64_python3-oslo-utils.sha256sum] = "9e80c39356337e036cacb56ec7de397a7d5387c901524208eb78eb22038252ff"

URI_aarch64_python3-oslo-utils-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-utils-tests-10.0.1-1.el10_3.noarch.rpm;name=aarch64_python3-oslo-utils-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-utils-tests}"
SRC_URI[aarch64_python3-oslo-utils-tests.sha256sum] = "ecf268af0f838d00b9d3352fbdd59df15de191eb870460cad281c3359a4bc8e7"

RDEPENDS:python-oslo-utils-doc = " \
 "
RDEPENDS:python-oslo-utils-lang = " \
 "
RDEPENDS:python3-oslo-utils = " \
 python-oslo-utils-lang \
 python3 \
 python3-debtcollector \
 python3-iso8601 \
 python3-netaddr \
 python3-oslo-i18n \
 python3-packaging \
 python3-pbr \
 python3-psutil \
 python3-pyparsing \
 python3-pyyaml \
 "
RDEPENDS:python3-oslo-utils-tests = " \
 python3 \
 python3-oslo-utils \
 "
