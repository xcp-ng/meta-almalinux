# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "memtester"
PV = "4.7.1"
PR = "1.el10_0"
PACKAGES = " \
 memtester \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/memtester-4.7.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "029ee1b62315ae506e688bb4040840cef484a860f2a50559bfb06876bb64777b"

URI_x86_64_v2_memtester = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/memtester-4.7.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_memtester;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_memtester}"
SRC_URI[x86_64_v2_memtester.sha256sum] = "99d3bace47af2600fd8a2939e010533099d7f62beea1b463f8a89f74443b883e"

URI_aarch64_memtester = "${EPEL_MIRROR}/aarch64/Packages/m/memtester-4.7.1-1.el10_0.aarch64.rpm;name=aarch64_memtester;unpack=0"
SRC_URI:append = " ${URI_aarch64_memtester}"
SRC_URI[aarch64_memtester.sha256sum] = "e873c1f6aefc33916a859e5dca79e39513b6515efbe674da0d84493fee013ef5"

RDEPENDS:memtester = " \
 glibc \
 "
