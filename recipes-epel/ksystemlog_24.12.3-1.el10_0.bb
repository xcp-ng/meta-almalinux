# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksystemlog"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 ksystemlog \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksystemlog-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ff231b1215fcdf937da5b57d436a8b538c732137455321d62a23105776fdd4a"

URI_x86_64_v2_ksystemlog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksystemlog-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksystemlog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksystemlog}"
SRC_URI[x86_64_v2_ksystemlog.sha256sum] = "3c518a90d68d4727252d3b70c9c94d2de3068221bfa349236f14bcd4bb6d2cb0"

URI_aarch64_ksystemlog = "${EPEL_MIRROR}/aarch64/Packages/k/ksystemlog-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ksystemlog;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksystemlog}"
SRC_URI[aarch64_ksystemlog.sha256sum] = "1da748c0dcb973cd9806d48ad487311f0bbab59001be1cb972a1331ac333872c"

RDEPENDS:ksystemlog = " \
 audit-libs \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 systemd-libs \
 "
