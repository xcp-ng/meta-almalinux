# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-SSLeay"
PV = "1.94"
PR = "7.el10"
PACKAGES = " \
 perl-Net-SSLeay \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Net-SSLeay-1.94-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e69f5a047c36d4edb79bb2cc7084ba49a2196202680c7455a5b99a9e441adcab"

URI_x86_64_v2_perl-Net-SSLeay = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Net-SSLeay-1.94-7.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Net-SSLeay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-SSLeay}"
SRC_URI[x86_64_v2_perl-Net-SSLeay.sha256sum] = "9d2a5946943d31e25b8312d60fa1f7c6cd0d467b1c1ace743867d825bdda7079"

URI_aarch64_perl-Net-SSLeay = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Net-SSLeay-1.94-7.el10.aarch64.rpm;name=aarch64_perl-Net-SSLeay;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-SSLeay}"
SRC_URI[aarch64_perl-Net-SSLeay.sha256sum] = "b5e4d712f5220a91be8d93bf734bc6d274c31ce449a9094180b289f3fbe9e141"

RDEPENDS:perl-Net-SSLeay = " \
 glibc \
 openssl-libs \
 perl-AutoLoader \
 perl-Carp \
 perl-Errno \
 perl-Exporter \
 perl-MIME-Base64 \
 perl-Net-SSLeay \
 perl-Socket \
 perl-libs \
 perl-vars \
 "
