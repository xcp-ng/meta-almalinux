# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quick-error1"
PV = "1.2.3"
PR = "11.el10_0"
PACKAGES = " \
 rust-quick-error1+default-devel \
 rust-quick-error1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quick-error1-1.2.3-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e925c085fabf17c0a5915c73ce7f2ef718b8f8a2f733bd7441481bee0f651e99"

URI_x86_64_v2_rust-quick-error1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-error1+default-devel-1.2.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-error1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-error1+default-devel}"
SRC_URI[x86_64_v2_rust-quick-error1+default-devel.sha256sum] = "9860b31a4d97eb60c42b275f57bd6021cdfee3c615666c5e74279bf2274eec2d"

URI_x86_64_v2_rust-quick-error1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-error1-devel-1.2.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-error1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-error1-devel}"
SRC_URI[x86_64_v2_rust-quick-error1-devel.sha256sum] = "28fb3737bafe77cf52aaaadfda8a4218501e10143ef7af8abaeb61f063db5f60"

URI_aarch64_rust-quick-error1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-error1+default-devel-1.2.3-11.el10_0.noarch.rpm;name=aarch64_rust-quick-error1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-error1+default-devel}"
SRC_URI[aarch64_rust-quick-error1+default-devel.sha256sum] = "78b210b03f291412a466c23596dedd01ec65a0af1140f3fe3faaf2be6bca446a"

URI_aarch64_rust-quick-error1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-error1-devel-1.2.3-11.el10_0.noarch.rpm;name=aarch64_rust-quick-error1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-error1-devel}"
SRC_URI[aarch64_rust-quick-error1-devel.sha256sum] = "73c2e7f61078b16ca4cbc5f0ae3276b5306537dc0699e63aa5cc8314e57b310b"

RDEPENDS:rust-quick-error1+default-devel = " \
 cargo \
 rust-quick-error1-devel \
 "
RDEPENDS:rust-quick-error1-devel = " \
 cargo \
 "
