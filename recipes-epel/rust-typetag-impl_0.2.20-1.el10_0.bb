# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typetag-impl"
PV = "0.2.20"
PR = "1.el10_0"
PACKAGES = " \
 rust-typetag-impl+default-devel \
 rust-typetag-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typetag-impl-0.2.20-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f66e2389f931a08032d19519311a4149024ecee59db924122f530084c0f5b094"

URI_x86_64_v2_rust-typetag-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag-impl+default-devel-0.2.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typetag-impl+default-devel}"
SRC_URI[x86_64_v2_rust-typetag-impl+default-devel.sha256sum] = "5d313605b2d4efc6378c1f8e7f9cae565247cb35a02cbab9d796cddf0d9bf645"

URI_x86_64_v2_rust-typetag-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag-impl-devel-0.2.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typetag-impl-devel}"
SRC_URI[x86_64_v2_rust-typetag-impl-devel.sha256sum] = "d6ada8368fcf5eaaeb50f40f155c0962737c3206ce9f1e0f961689d521ff7808"

URI_aarch64_rust-typetag-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag-impl+default-devel-0.2.20-1.el10_0.noarch.rpm;name=aarch64_rust-typetag-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typetag-impl+default-devel}"
SRC_URI[aarch64_rust-typetag-impl+default-devel.sha256sum] = "70767911a0efd514ddbb41da18ecca7a0ca7152846ca358e7848aabf9d6a975a"

URI_aarch64_rust-typetag-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag-impl-devel-0.2.20-1.el10_0.noarch.rpm;name=aarch64_rust-typetag-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typetag-impl-devel}"
SRC_URI[aarch64_rust-typetag-impl-devel.sha256sum] = "5df4b8ba130dc74b4966cabfd6faec1df4917b72ed1cef08f9d8101679086022"

RDEPENDS:rust-typetag-impl+default-devel = " \
 cargo \
 rust-typetag-impl-devel \
 "
RDEPENDS:rust-typetag-impl-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
