# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtiff"
PV = "4.6.0"
PR = "6.el10_0.1"
PACKAGES = " \
 libtiff \
 libtiff-devel \
 libtiff-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libtiff-4.6.0-6.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3eb3fc867f4bce2b38cdbf7d60427af4d635c37dd4638e650484306d0e6eec03"

URI_x86_64_v2_libtiff = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtiff-4.6.0-6.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_libtiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtiff}"
SRC_URI[x86_64_v2_libtiff.sha256sum] = "122de85508347ea88b188867311746788fde26758a6340b4f4d0bf97f3c4432e"
RPROVIDES:libtiff:x86_64_v2 = "virtual/libtiffxx.so.6___64bit_"

URI_x86_64_v2_libtiff-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtiff-devel-4.6.0-6.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_libtiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtiff-devel}"
SRC_URI[x86_64_v2_libtiff-devel.sha256sum] = "67b8506c78ae271159846b2ca2c7bc78aa75aaf63b6c64bf6b62bad98e66e1fe"

URI_x86_64_v2_libtiff-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libtiff-tools-4.6.0-6.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_libtiff-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtiff-tools}"
SRC_URI[x86_64_v2_libtiff-tools.sha256sum] = "fc56e721789c8983a71d619df00b4dfd50e8b237d99add9d25a992d0410da968"

URI_aarch64_libtiff = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtiff-4.6.0-6.el10_0.1.aarch64.rpm;name=aarch64_libtiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtiff}"
SRC_URI[aarch64_libtiff.sha256sum] = "de452d622bebb550dd5af68a4bfb29aa7f3eb99194cd42b630948a86261c66a1"
RPROVIDES:libtiff:aarch64 = "virtual/libtiffxx.so.6___64bit_"

URI_aarch64_libtiff-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtiff-devel-4.6.0-6.el10_0.1.aarch64.rpm;name=aarch64_libtiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtiff-devel}"
SRC_URI[aarch64_libtiff-devel.sha256sum] = "dcfd53d97a8be8ee7053d1d34a4450e5633b38a9cb369bd010bc7ef76e72adf8"

URI_aarch64_libtiff-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libtiff-tools-4.6.0-6.el10_0.1.aarch64.rpm;name=aarch64_libtiff-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtiff-tools}"
SRC_URI[aarch64_libtiff-tools.sha256sum] = "1d22793493659af67dfb2ee5664f4f0b1816727e1243433346fa864a1de382e0"

RDEPENDS:libtiff = " \
 glibc \
 jbigkit-libs \
 libgcc \
 libjpeg-turbo \
 liblerc \
 libstdc++ \
 libwebp \
 libzstd \
 zlib-ng-compat \
 "
RDEPENDS:libtiff-devel = " \
 libjpeg-turbo-devel \
 libtiff \
 libwebp-devel \
 libzstd-devel \
 pkgconf-pkg-config \
 virtual/libtiffxx.so.6___64bit_ \
 zlib-ng-compat-devel \
 "
RDEPENDS:libtiff-tools = " \
 glibc \
 libtiff \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libtiffxx.so.6___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libtiffxx.so.6___64bit_"
