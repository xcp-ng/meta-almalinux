# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unpaper"
PV = "7.0.0"
PR = "13.el10_0"
PACKAGES = " \
 unpaper \
 unpaper-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/unpaper-7.0.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c1c80034f3bd6ee56c1967c9a8af25a70d8dc50a7058651cb7604473715e012"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - unpaper: libavcodec.so.61()(64bit)
# - unpaper: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - unpaper: libavformat.so.61()(64bit)
# - unpaper: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - unpaper: libavutil.so.59()(64bit)
# - unpaper: libavutil.so.59(LIBAVUTIL_59)(64bit)

URI_x86_64_v2_unpaper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unpaper-7.0.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unpaper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unpaper}"
SRC_URI[x86_64_v2_unpaper.sha256sum] = "c97e719abe85615d8003ed40b27c59505ad61337dd13bf9214b053e6b9fb9bd9"

URI_x86_64_v2_unpaper-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unpaper-tests-7.0.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_unpaper-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unpaper-tests}"
SRC_URI[x86_64_v2_unpaper-tests.sha256sum] = "8fddbeb6dd1413db2c54242bb686a3ffbd2e6ae31f01d81ee59f44f91a9e582e"

URI_aarch64_unpaper = "${EPEL_MIRROR}/aarch64/Packages/u/unpaper-7.0.0-13.el10_0.aarch64.rpm;name=aarch64_unpaper;unpack=0"
SRC_URI:append = " ${URI_aarch64_unpaper}"
SRC_URI[aarch64_unpaper.sha256sum] = "d39ab5faadc06e7ae4f4621d9064c5b4943c24d7fda0176f317a7f67005d6c81"

URI_aarch64_unpaper-tests = "${EPEL_MIRROR}/aarch64/Packages/u/unpaper-tests-7.0.0-13.el10_0.noarch.rpm;name=aarch64_unpaper-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_unpaper-tests}"
SRC_URI[aarch64_unpaper-tests.sha256sum] = "ea6013f720a2ce91bd4b013ba2a8e646442e6a81be4eb376458a6d5fe2b23a15"

RDEPENDS:unpaper:x86_64_v2 = " \
 glibc \
"
RDEPENDS:unpaper:aarch64 = " \
 glibc \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
"
RDEPENDS:unpaper-tests = " \
 bash \
 python3-pillow \
 python3-pytest \
 python3-pytest-xdist \
 unpaper \
 "
