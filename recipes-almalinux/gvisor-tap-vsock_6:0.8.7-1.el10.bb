# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gvisor-tap-vsock"
PE = "6"
PV = "0.8.7"
PR = "1.el10"
PACKAGES = " \
 gvisor-tap-vsock \
 gvisor-tap-vsock-gvforwarder \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gvisor-tap-vsock-0.8.7-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f2899c33168948a8602aa162e88b3aa02dff3a33a020e94cebddfca888df09f"

URI_x86_64_v2_gvisor-tap-vsock = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvisor-tap-vsock-0.8.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_gvisor-tap-vsock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvisor-tap-vsock}"
SRC_URI[x86_64_v2_gvisor-tap-vsock.sha256sum] = "c87badb30895e0cd5a68e66a04e6f684f65280d77650813abc39b2466554cd50"

URI_x86_64_v2_gvisor-tap-vsock-gvforwarder = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvisor-tap-vsock-gvforwarder-0.8.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_gvisor-tap-vsock-gvforwarder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvisor-tap-vsock-gvforwarder}"
SRC_URI[x86_64_v2_gvisor-tap-vsock-gvforwarder.sha256sum] = "42d5bc2653c13c1bdfee926ec705bbd2de6c4bc7b969b6d511a574ea9d6fac5e"

URI_aarch64_gvisor-tap-vsock = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvisor-tap-vsock-0.8.7-1.el10.aarch64.rpm;name=aarch64_gvisor-tap-vsock;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvisor-tap-vsock}"
SRC_URI[aarch64_gvisor-tap-vsock.sha256sum] = "93a6a70ed7b0485b1d5cc972f38bb292a96723529e36b224db161f548364974d"

URI_aarch64_gvisor-tap-vsock-gvforwarder = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvisor-tap-vsock-gvforwarder-0.8.7-1.el10.aarch64.rpm;name=aarch64_gvisor-tap-vsock-gvforwarder;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvisor-tap-vsock-gvforwarder}"
SRC_URI[aarch64_gvisor-tap-vsock-gvforwarder.sha256sum] = "ae93092ca607bc0cb4d2367edfbdeb8a7cb3dd7b271deb271814e5bf241408aa"

RDEPENDS:gvisor-tap-vsock = " \
 glibc \
 gvisor-tap-vsock-gvforwarder \
 "
RDEPENDS:gvisor-tap-vsock-gvforwarder = " \
 glibc \
 "
