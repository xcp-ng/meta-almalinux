# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-ds"
PV = "1.6.0"
PR = "1.el10_1"
PACKAGES = " \
 php-pecl-ds \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-ds-1.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de1f0cdb7045da93e4b700d7e7fb84f452da250c781741bd82a0e05bcf5634ab"

URI_x86_64_v2_php-pecl-ds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-ds-1.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-ds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-ds}"
SRC_URI[x86_64_v2_php-pecl-ds.sha256sum] = "3ab94bb2e4ca703c40fefcc14e24576afe331f41557e90cac613e11427cc84e4"

URI_aarch64_php-pecl-ds = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-ds-1.6.0-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-ds;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-ds}"
SRC_URI[aarch64_php-pecl-ds.sha256sum] = "d220f3a97b302a813e97d95e8d049353fc51cad78308817d6b00562acfa4076f"

RDEPENDS:php-pecl-ds = " \
 glibc \
 php-common \
 "
