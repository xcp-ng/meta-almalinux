# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-target"
PV = "2.1.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-target+default-devel \
 rust-target-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-target-2.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af9b818a2b6eb1261394128791e148564e2877f13b3f4a6830c491e6c9eb4fd6"

URI_x86_64_v2_rust-target+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target+default-devel-2.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target+default-devel}"
SRC_URI[x86_64_v2_rust-target+default-devel.sha256sum] = "535b9f12958228c6dfb08bde3d4593a60625752b3013d6296dc4c78cf6da103b"

URI_x86_64_v2_rust-target-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-devel-2.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-devel}"
SRC_URI[x86_64_v2_rust-target-devel.sha256sum] = "7ef86c4d8ee8054e410ead46d00f9ddf31ea62405cd90ce5781edf98871a1fe1"

URI_aarch64_rust-target+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target+default-devel-2.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-target+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target+default-devel}"
SRC_URI[aarch64_rust-target+default-devel.sha256sum] = "e251948efea40b598fc7278bd26dd7e4199be06c577ecbfdf864ced6616d56cd"

URI_aarch64_rust-target-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-devel-2.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-target-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-devel}"
SRC_URI[aarch64_rust-target-devel.sha256sum] = "21e4746e06f5dfcf102d1a631d8b4bcef9ef3d8fea70296557e754dfc6ad8487"

RDEPENDS:rust-target+default-devel = " \
 cargo \
 rust-target-devel \
 "
RDEPENDS:rust-target-devel = " \
 cargo \
 "
