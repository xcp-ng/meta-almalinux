# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdebugsettings"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdebugsettings \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdebugsettings-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d137164171c828da1182412e4e81e00c49347a538b5530264a6cf7df5dc99c5b"

URI_x86_64_v2_kdebugsettings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdebugsettings-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdebugsettings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdebugsettings}"
SRC_URI[x86_64_v2_kdebugsettings.sha256sum] = "fa66b722672b247d7bc79107ca19932f3ab6d6c3730e2daaa8bac9c916cf21fc"

URI_aarch64_kdebugsettings = "${EPEL_MIRROR}/aarch64/Packages/k/kdebugsettings-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdebugsettings;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdebugsettings}"
SRC_URI[aarch64_kdebugsettings.sha256sum] = "096e502c12503304c4909e5a2372230046c31c572a7a6d917c7399882af5014f"

RDEPENDS:kdebugsettings = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
