# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mdadm"
PV = "4.3"
PR = "5.el10"
PACKAGES = " \
 mdadm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mdadm-4.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ece409ada6ca083305fe30ae65f5daf12b89482ca081c45cbb73cf3851915ea2"

URI_x86_64_v2_mdadm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mdadm-4.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_mdadm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mdadm}"
SRC_URI[x86_64_v2_mdadm.sha256sum] = "0c7e8372c94330ac95acae4b52049389fa824e2b4ea172f7ebc0e6f6bfe22d03"

URI_aarch64_mdadm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mdadm-4.3-5.el10.aarch64.rpm;name=aarch64_mdadm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mdadm}"
SRC_URI[aarch64_mdadm.sha256sum] = "f88dabfe84217775ccb4444cfd6d771b1e0807be5ebaa40371cde13ea03d5307"

RDEPENDS:mdadm = " \
 bash \
 glibc \
 systemd \
 systemd-libs \
 virtual/coreutils \
 "
