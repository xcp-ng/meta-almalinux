# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc"
PV = "14.3.1"
PR = "2.1.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 cpp \
 gcc \
 gcc-c++ \
 gcc-gfortran \
 gcc-offload-amdgcn \
 gcc-offload-nvptx \
 gcc-plugin-annobin \
 gcc-plugin-devel \
 libasan \
 libatomic \
 libgcc \
 libgccjit \
 libgccjit-devel \
 libgfortran \
 libgfortran-static \
 libgomp \
 libgomp-offload-amdgcn \
 libgomp-offload-nvptx \
 libhwasan \
 libitm \
 libitm-devel \
 liblsan \
 libquadmath \
 libquadmath-devel \
 libquadmath-static \
 libstdc++ \
 libstdc++-devel \
 libstdc++-docs \
 libstdc++-static \
 libtsan \
 libubsan \
"
PACKAGES:aarch64 = " \
 cpp \
 gcc \
 gcc-c++ \
 gcc-gfortran \
 gcc-plugin-annobin \
 gcc-plugin-devel \
 libasan \
 libatomic \
 libgcc \
 libgccjit \
 libgccjit-devel \
 libgfortran \
 libgfortran-static \
 libgomp \
 libhwasan \
 libitm \
 libitm-devel \
 liblsan \
 libstdc++ \
 libstdc++-devel \
 libstdc++-docs \
 libstdc++-static \
 libtsan \
 libubsan \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gcc-14.3.1-2.1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52bede4dacecb74b1c0593f56f45c85497582f0ca64e5703f12d3bbd8bbc321d"

URI_x86_64_v2_cpp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cpp-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpp}"
SRC_URI[x86_64_v2_cpp.sha256sum] = "7bad0e218e0524346f5352651ace0d59338f307cab11f38d9e92669bb4065575"

URI_x86_64_v2_gcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc}"
SRC_URI[x86_64_v2_gcc.sha256sum] = "745f1b4792be8b0d6f129a1cad298858a38c9324faadaa7afa7ead62b2a1593e"

URI_x86_64_v2_gcc-c++ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-c++-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++}"
SRC_URI[x86_64_v2_gcc-c++.sha256sum] = "73bbc266321deae411f52b601f30b0f18f0e283ca226f647b619dfea3ab2f01f"

URI_x86_64_v2_gcc-gfortran = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-gfortran-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-gfortran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-gfortran}"
SRC_URI[x86_64_v2_gcc-gfortran.sha256sum] = "9b8bb16f6457c43eaa7f689456ed14a9b88b62d2072ea5f3c85c1d0a0eabfb8d"

URI_x86_64_v2_gcc-offload-amdgcn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-offload-amdgcn-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-offload-amdgcn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-offload-amdgcn}"
SRC_URI[x86_64_v2_gcc-offload-amdgcn.sha256sum] = "e02b9caa79abfd30cf270cc8ac13f29c47971f00e17f1bd481709f62eaf487ac"

URI_x86_64_v2_gcc-offload-nvptx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-offload-nvptx-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-offload-nvptx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-offload-nvptx}"
SRC_URI[x86_64_v2_gcc-offload-nvptx.sha256sum] = "ef380c8cb537a425f62c7ad17a5cfb49218cc7ecdb157fbf5b2217f4bade1c1b"

URI_x86_64_v2_gcc-plugin-annobin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-plugin-annobin-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-plugin-annobin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-plugin-annobin}"
SRC_URI[x86_64_v2_gcc-plugin-annobin.sha256sum] = "3b606e9dbc0ee36563e91ef3b7402cfb8da1da3eca98b84051c115d5e98eb9d2"

URI_x86_64_v2_gcc-plugin-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-plugin-devel-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-plugin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-plugin-devel}"
SRC_URI[x86_64_v2_gcc-plugin-devel.sha256sum] = "8005fa34dddc20c5cd4ce1baa6cdd0eaec020d13e903ab2a9537c5fdc8e1faa4"

URI_x86_64_v2_libasan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libasan-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libasan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libasan}"
SRC_URI[x86_64_v2_libasan.sha256sum] = "efcf411966de2531d1b3b630ee8e373b665a6939a605c1c25d023deb7e3baf92"

URI_x86_64_v2_libatomic = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libatomic-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libatomic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libatomic}"
SRC_URI[x86_64_v2_libatomic.sha256sum] = "e5d839a2056ac9922987af55d13990fd3ab422311ee0ce1c6365c6bfff5a9167"

URI_x86_64_v2_libgcc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgcc-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgcc}"
SRC_URI[x86_64_v2_libgcc.sha256sum] = "0dcf3146e09abf5cf46f82584c06c0b5922c1a246bf6b54256f01ae73246c050"

URI_x86_64_v2_libgccjit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgccjit-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgccjit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgccjit}"
SRC_URI[x86_64_v2_libgccjit.sha256sum] = "0731e138f33e9093e91f45c2f2af3d7b5a4db537018dcd3a15d9708605b4cb25"
RPROVIDES:libgccjit:x86_64_v2 = "virtual/libgccjit.so.0___64bit_"

URI_x86_64_v2_libgccjit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgccjit-devel-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgccjit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgccjit-devel}"
SRC_URI[x86_64_v2_libgccjit-devel.sha256sum] = "1dafdc8790039dba3b6d9fd0f5f29edf4a9d2dc8bed9b6cfd17374eb4871d552"

URI_x86_64_v2_libgfortran = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgfortran-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgfortran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgfortran}"
SRC_URI[x86_64_v2_libgfortran.sha256sum] = "b37ce2e7205bbb9a71ccce873d143016e1822377b5fd41dacdbfe8ab890914e6"

URI_x86_64_v2_libgfortran-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgfortran-static-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgfortran-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgfortran-static}"
SRC_URI[x86_64_v2_libgfortran-static.sha256sum] = "dde1606f53cd202260502b566f89a14818a02d2a17d8db12be4f09c823887f55"

URI_x86_64_v2_libgomp = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgomp-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgomp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgomp}"
SRC_URI[x86_64_v2_libgomp.sha256sum] = "5e14762a6494b7e838fcc6432d24db2a60b02c1a98fe9b4bf963b6ed300ca121"

URI_x86_64_v2_libgomp-offload-amdgcn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgomp-offload-amdgcn-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgomp-offload-amdgcn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgomp-offload-amdgcn}"
SRC_URI[x86_64_v2_libgomp-offload-amdgcn.sha256sum] = "3ef13847a165e1293fc24807911c003a2cf84bacffb5e0834e46caab81bc9874"

URI_x86_64_v2_libgomp-offload-nvptx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgomp-offload-nvptx-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgomp-offload-nvptx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgomp-offload-nvptx}"
SRC_URI[x86_64_v2_libgomp-offload-nvptx.sha256sum] = "986de7d3ab0b867210bf9b2bbb810fca6da8565d1e74e992428264c36fc76715"

URI_x86_64_v2_libhwasan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libhwasan-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libhwasan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libhwasan}"
SRC_URI[x86_64_v2_libhwasan.sha256sum] = "ead522cf9d043f5c29e8980a7c13c1b1a1a11b1153dc1f562be60caaa07696e3"

URI_x86_64_v2_libitm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libitm-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libitm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libitm}"
SRC_URI[x86_64_v2_libitm.sha256sum] = "3d599df3a70e6496f6c851013ebf97837e65aa20655c3d3a1cf3acc2ef62fcb2"

URI_x86_64_v2_libitm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libitm-devel-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libitm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libitm-devel}"
SRC_URI[x86_64_v2_libitm-devel.sha256sum] = "ed0a9932c1ae638a5c6f4aa0d44bd2974b2e5a40684716475c45b89a95e2c28c"

URI_x86_64_v2_liblsan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liblsan-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_liblsan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblsan}"
SRC_URI[x86_64_v2_liblsan.sha256sum] = "223f7f900ddf0704c10539a3d2d5409cdbfd7b187fd318320fbcebe05a6e1b43"

URI_x86_64_v2_libquadmath = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libquadmath-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libquadmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquadmath}"
SRC_URI[x86_64_v2_libquadmath.sha256sum] = "8f97e98a12801d165970af1cbd4c151332cf033dce183f7d0ba0c4c72b302b02"

URI_x86_64_v2_libquadmath-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libquadmath-devel-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libquadmath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquadmath-devel}"
SRC_URI[x86_64_v2_libquadmath-devel.sha256sum] = "0b75a40e002c0f23faa343ba274b19fe31f10b3409adbfc8eee3ac8b199232b7"

URI_x86_64_v2_libquadmath-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libquadmath-static-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libquadmath-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquadmath-static}"
SRC_URI[x86_64_v2_libquadmath-static.sha256sum] = "516d75e12654eeaf3e5b063eae48ca7ee8309f4409d4cca272f421db3459abeb"

URI_x86_64_v2_libstdc++ = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libstdc++-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libstdc++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++}"
SRC_URI[x86_64_v2_libstdc++.sha256sum] = "257c18e35a64003f533ac35a79ea7d21944646f1ec9201c95307bd04a370842c"

URI_x86_64_v2_libstdc++-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstdc++-devel-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++-devel}"
SRC_URI[x86_64_v2_libstdc++-devel.sha256sum] = "7e72baeb3116ffe5257b455448dbb3c82241954e2aafe64d3c432d58d6ffcca8"

URI_x86_64_v2_libstdc++-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstdc++-docs-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libstdc++-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++-docs}"
SRC_URI[x86_64_v2_libstdc++-docs.sha256sum] = "a7084371422efcbcc674c86ecdf8ee44cc72aac7e72af4a877a48c1ce97b8e17"

URI_x86_64_v2_libstdc++-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libstdc++-static-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libstdc++-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++-static}"
SRC_URI[x86_64_v2_libstdc++-static.sha256sum] = "3ad279d50ba0c24d0c244f8ca46423afd8af5eab005d36ec7fdd120ca4fc1329"

URI_x86_64_v2_libtsan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtsan-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libtsan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtsan}"
SRC_URI[x86_64_v2_libtsan.sha256sum] = "cf22f58900e93a6ccadc0aea304cc75787572043e1da4bbb0b4ba64811446de9"

URI_x86_64_v2_libubsan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libubsan-14.3.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libubsan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libubsan}"
SRC_URI[x86_64_v2_libubsan.sha256sum] = "a0d6750b2a77f1a7e37d1704b8c891dfb0e568c403c3c18c6d94822184f0d19b"

URI_aarch64_cpp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cpp-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpp}"
SRC_URI[aarch64_cpp.sha256sum] = "dbe57dd6dfbeff292ba49288d94b83463ee096fe7945f7681777b654617f6aac"

URI_aarch64_gcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc}"
SRC_URI[aarch64_gcc.sha256sum] = "18e647ecddf8526fe1332a2f02cec2c22abdaaca3e238b7699ec1dce55d51f35"

URI_aarch64_gcc-c++ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-c++-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_gcc-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++}"
SRC_URI[aarch64_gcc-c++.sha256sum] = "6feb4688822e1944b521e03983889298bbc99c4a5b32004e1163d67bb8c91949"

URI_aarch64_gcc-gfortran = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-gfortran-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_gcc-gfortran;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-gfortran}"
SRC_URI[aarch64_gcc-gfortran.sha256sum] = "97ad96d974850030925f8852570bffa96ea60048733604724d07370c22b62c52"

URI_aarch64_gcc-plugin-annobin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-plugin-annobin-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_gcc-plugin-annobin;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-plugin-annobin}"
SRC_URI[aarch64_gcc-plugin-annobin.sha256sum] = "0374e48ddab4c97a7d605333d2d008287495df429e80acac1c3348716013d68f"

URI_aarch64_gcc-plugin-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-plugin-devel-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_gcc-plugin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-plugin-devel}"
SRC_URI[aarch64_gcc-plugin-devel.sha256sum] = "3de5fc268c7c965ff0dc0578b9f356550f3c5c0b56b7df41f45e3c231579a7d6"

URI_aarch64_libasan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libasan-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libasan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libasan}"
SRC_URI[aarch64_libasan.sha256sum] = "e186914c3efbd00be6e4a257b1263619c2b58dd3a47d96bf9b0f7e38b334c215"

URI_aarch64_libatomic = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libatomic-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libatomic;unpack=0"
SRC_URI:append = " ${URI_aarch64_libatomic}"
SRC_URI[aarch64_libatomic.sha256sum] = "07cf4791e8effd35b58a75d4d377e2756bad4d54a7d9f643f4b44479f13f4790"

URI_aarch64_libgcc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgcc-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libgcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgcc}"
SRC_URI[aarch64_libgcc.sha256sum] = "82b8eab50b30f870b1d43ea658b4cbf55401c15ae6730bba9635ea987a1c7237"

URI_aarch64_libgccjit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgccjit-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libgccjit;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgccjit}"
SRC_URI[aarch64_libgccjit.sha256sum] = "731930cd784d0000108259a835270c061fd70021e62abec5f6712a60bc4f9f7d"
RPROVIDES:libgccjit:aarch64 = "virtual/libgccjit.so.0___64bit_"

URI_aarch64_libgccjit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgccjit-devel-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libgccjit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgccjit-devel}"
SRC_URI[aarch64_libgccjit-devel.sha256sum] = "bab2f88ddb16656307dcf1a01c781d1be4c031f2d6e973b492eb5893ae52765c"

URI_aarch64_libgfortran = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgfortran-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libgfortran;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgfortran}"
SRC_URI[aarch64_libgfortran.sha256sum] = "5df7f8807e313efa1adf216a5edf5e68fb80a4808937950424f857207739e143"

URI_aarch64_libgfortran-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgfortran-static-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libgfortran-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgfortran-static}"
SRC_URI[aarch64_libgfortran-static.sha256sum] = "08d21c1ec3ac7f130ad44c943a87557dd64bd7efb54035eab58ee28f48ce8a6a"

URI_aarch64_libgomp = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgomp-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libgomp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgomp}"
SRC_URI[aarch64_libgomp.sha256sum] = "164cf4c5c2ab1c704826fdce3d4a3f02aee875c8fb70fbf11078e2c403e8b72c"

URI_aarch64_libhwasan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libhwasan-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libhwasan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libhwasan}"
SRC_URI[aarch64_libhwasan.sha256sum] = "7aac0b5295cd0201852c2244b276401b468e04ee2278d54cc049a89e686223be"

URI_aarch64_libitm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libitm-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libitm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libitm}"
SRC_URI[aarch64_libitm.sha256sum] = "57b25dd0bfd285ea7ca4c1978969acef96066850030a727a4b60ff0e58918cc1"

URI_aarch64_libitm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libitm-devel-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libitm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libitm-devel}"
SRC_URI[aarch64_libitm-devel.sha256sum] = "ebddda3c53a8eefd27b1f98f932fcf7d91d0232834c5fbe5c74b1ff4daeb82b0"

URI_aarch64_liblsan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liblsan-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_liblsan;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblsan}"
SRC_URI[aarch64_liblsan.sha256sum] = "401a0810f429a92bd76ed3b17b13b6d3b908a08e8d0f710583aa4d0791b49037"

URI_aarch64_libstdc++ = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libstdc++-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libstdc++;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++}"
SRC_URI[aarch64_libstdc++.sha256sum] = "c28eff74e1a4d8f097fd4a94a2f94bb71a7d763987bd56c248e85317956aa1bc"

URI_aarch64_libstdc++-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstdc++-devel-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++-devel}"
SRC_URI[aarch64_libstdc++-devel.sha256sum] = "3a6d19bf248ad0904f563bd4944e637e694e055c49a52685b95f5cb5994987e6"

URI_aarch64_libstdc++-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstdc++-docs-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libstdc++-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++-docs}"
SRC_URI[aarch64_libstdc++-docs.sha256sum] = "6e86368d0dc551bf9bc6c9654e5ce017b230e4d1b1faf72cebd452fa599550ed"

URI_aarch64_libstdc++-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libstdc++-static-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libstdc++-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++-static}"
SRC_URI[aarch64_libstdc++-static.sha256sum] = "3f9455e3955a6d8768bcd89948f1657136847e35014d42f3004a2fdcb46b1bb6"

URI_aarch64_libtsan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtsan-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libtsan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtsan}"
SRC_URI[aarch64_libtsan.sha256sum] = "ec89ec73c668f0c20a6ba0b47cdf9ef49928a2c0b6678c19b743672fd15a1aa7"

URI_aarch64_libubsan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libubsan-14.3.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_libubsan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libubsan}"
SRC_URI[aarch64_libubsan.sha256sum] = "22f15bc724a1ecafa68826e1350236e5b85447e2d274fc96d3a47d1c896c2f61"

RDEPENDS:cpp = " \
 filesystem \
 glibc \
 gmp \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc:x86_64_v2 = " \
 bash \
 binutils \
 cpp \
 glibc \
 glibc-devel \
 gmp \
 libgcc \
 libgomp \
 libmpc \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc:aarch64 = " \
 bash \
 binutils \
 cpp \
 glibc \
 glibc-devel \
 gmp \
 libasan \
 libatomic \
 libgcc \
 libgomp \
 libmpc \
 libubsan \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-c++ = " \
 gcc \
 glibc \
 gmp \
 libmpc \
 libstdc++ \
 libstdc++-devel \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-gfortran:x86_64_v2 = " \
 gcc \
 glibc \
 gmp \
 libgfortran \
 libmpc \
 libquadmath \
 libquadmath-devel \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-gfortran:aarch64 = " \
 gcc \
 glibc \
 gmp \
 libgfortran \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-offload-amdgcn = " \
 gcc \
 glibc \
 gmp \
 libgcc \
 libgomp-offload-amdgcn \
 libmpc \
 libstdc++ \
 libzstd \
 lld \
 llvm \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-offload-nvptx = " \
 gcc \
 glibc \
 gmp \
 libgcc \
 libgomp-offload-nvptx \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-plugin-annobin = " \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gcc-plugin-devel = " \
 gcc \
 glibc \
 gmp-devel \
 libmpc-devel \
 mpfr-devel \
 "
RDEPENDS:libasan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libatomic = " \
 glibc \
 "
RDEPENDS:libgcc = " \
 "
RDEPENDS:libgccjit = " \
 gcc \
 glibc \
 gmp \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:libgccjit-devel = " \
 libgccjit \
 virtual/libgccjit.so.0___64bit_ \
 "
RDEPENDS:libgfortran = " \
 glibc \
 libgcc \
 "
RDEPENDS:libgfortran-static:x86_64_v2 = " \
 gcc \
 libgfortran \
 libquadmath-static \
"
RDEPENDS:libgfortran-static:aarch64 = " \
 gcc \
 libgfortran \
"
RDEPENDS:libgomp = " \
 glibc \
 "
RDEPENDS:libgomp-offload-amdgcn = " \
 glibc \
 libgomp \
 "
RDEPENDS:libgomp-offload-nvptx = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:libhwasan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libitm = " \
 glibc \
 "
RDEPENDS:libitm-devel = " \
 gcc \
 libitm \
 "
RDEPENDS:liblsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libquadmath = " \
 glibc \
 libgcc \
 "
RDEPENDS:libquadmath-devel = " \
 gcc \
 libquadmath \
 "
RDEPENDS:libquadmath-static = " \
 libquadmath-devel \
 "
RDEPENDS:libstdc++ = " \
 glibc \
 libgcc \
 "
RDEPENDS:libstdc++-devel = " \
 libstdc++ \
 "
RDEPENDS:libstdc++-docs = " \
 "
RDEPENDS:libstdc++-static = " \
 libstdc++-devel \
 "
RDEPENDS:libtsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libubsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libgccjit.so.0___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libgccjit.so.0___64bit_"
