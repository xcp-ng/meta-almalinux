# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-papaya"
PV = "0.2.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-papaya+default-devel \
 rust-papaya+fast-barrier-devel \
 rust-papaya+serde-devel \
 rust-papaya-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-papaya-0.2.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6a52f044219f1c4a38c1f380e0595bcb455b42525a4574f630fd78abbde81fe3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-papaya+default-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-papaya+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-papaya+default-devel.sha256sum] = "d71e8183be864c475b11f815bb2e9c7ae835e3063c8e8f4a85d556a7efa4b1bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-papaya+fast-barrier-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-papaya+fast-barrier-devel;unpack=0"
SRC_URI[x86_64_v2_rust-papaya+fast-barrier-devel.sha256sum] = "c00b3631842e82b68fda30c57cc02e8ed70f2f4a2aa8bd328e62123bf44d0672"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-papaya+serde-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-papaya+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-papaya+serde-devel.sha256sum] = "8ed2884dced09ec575bfbed160e4564bb8a2a8c117f8e8045ebe6b4c71351247"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-papaya-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-papaya-devel;unpack=0"
SRC_URI[x86_64_v2_rust-papaya-devel.sha256sum] = "9ecda7fc7658accd4a6ad92808dc23008b1a069e5b4d98c591fd2bdfb795a740"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-papaya+default-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-papaya+default-devel;unpack=0"
SRC_URI[aarch64_rust-papaya+default-devel.sha256sum] = "719d284f57e10a3a6bfcaa568c08567ccbb6fa28a7e6d10bf559f1135f929938"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-papaya+fast-barrier-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-papaya+fast-barrier-devel;unpack=0"
SRC_URI[aarch64_rust-papaya+fast-barrier-devel.sha256sum] = "637aabd432532bd479ece8a9147c2f6e1a265cc58541b4d874b2ceeb0a756981"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-papaya+serde-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-papaya+serde-devel;unpack=0"
SRC_URI[aarch64_rust-papaya+serde-devel.sha256sum] = "f74c477927056585df82b7788c5ae3dc904ed93d2f4d4935200c6da353057cc9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-papaya-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-papaya-devel;unpack=0"
SRC_URI[aarch64_rust-papaya-devel.sha256sum] = "e4e74559c4cedee8bdb60c92ff542bc02adc968a7c435460770637479305b059"

RDEPENDS:rust-papaya+default-devel = " \
 cargo \
 rust-papaya+fast-barrier-devel \
 rust-papaya-devel \
 "
RDEPENDS:rust-papaya+fast-barrier-devel = " \
 cargo \
 rust-papaya-devel \
 rust-seize+fast-barrier-devel \
 "
RDEPENDS:rust-papaya+serde-devel = " \
 cargo \
 rust-papaya-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-papaya-devel = " \
 cargo \
 rust \
 rust-equivalent+default-devel \
 rust-seize-devel \
 "
