# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xhtml2fo-style-xsl"
PV = "20051222"
PR = "31.el10"
PACKAGES = " \
 xhtml2fo-style-xsl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xhtml2fo-style-xsl-20051222-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "719d749b3a9981ef8c26deea8a95df8a04b6658c33290ffa5695ce2a4888e37e"

URI_x86_64_v2_xhtml2fo-style-xsl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xhtml2fo-style-xsl-20051222-31.el10.noarch.rpm;name=x86_64_v2_xhtml2fo-style-xsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xhtml2fo-style-xsl}"
SRC_URI[x86_64_v2_xhtml2fo-style-xsl.sha256sum] = "1bae8a1732c0ae2a3189e3fe11b2fd1d07f4693f95f3d0802a917102b05349ab"

URI_aarch64_xhtml2fo-style-xsl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xhtml2fo-style-xsl-20051222-31.el10.noarch.rpm;name=aarch64_xhtml2fo-style-xsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_xhtml2fo-style-xsl}"
SRC_URI[aarch64_xhtml2fo-style-xsl.sha256sum] = "1bae8a1732c0ae2a3189e3fe11b2fd1d07f4693f95f3d0802a917102b05349ab"

RDEPENDS:xhtml2fo-style-xsl = " \
 bash \
 xhtml1-dtds \
 xml-common \
 "
