# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3-lxc"
PV = "5.0.0"
PR = "14.el10_2"
PACKAGES = " \
 python3-lxc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3-lxc-5.0.0-14.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1aa33d3e397fdb22916d4c17b23b37da423f391a2611c73d8d27d41cf9f86eb"

URI_x86_64_v2_python3-lxc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lxc-5.0.0-14.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lxc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lxc}"
SRC_URI[x86_64_v2_python3-lxc.sha256sum] = "031247750d0802883edb011289aa1aac03779c3799be64cb5adf871dfe75ea5f"

URI_aarch64_python3-lxc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lxc-5.0.0-14.el10_2.aarch64.rpm;name=aarch64_python3-lxc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lxc}"
SRC_URI[aarch64_python3-lxc.sha256sum] = "9025638081f945da4bd899c6377b39b2f635b656bae55f814f07ccd793ff0a4f"

RDEPENDS:python3-lxc = " \
 glibc \
 lxc-libs \
 python3 \
 "
