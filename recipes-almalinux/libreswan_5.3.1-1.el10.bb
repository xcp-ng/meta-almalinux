# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libreswan"
PV = "5.3.1"
PR = "1.el10"
PACKAGES = " \
 libreswan \
 libreswan-minimal \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libreswan-5.3.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80a1c83816073437111daf54dfa8159e460aa2406e1b8e87ee88e8b072cb78e6"

URI_x86_64_v2_libreswan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libreswan-5.3.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libreswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libreswan}"
SRC_URI[x86_64_v2_libreswan.sha256sum] = "329cd92c5e4db83a85f97eba43f0c821b0452bece8b8aed53d448c7a834b0003"

URI_x86_64_v2_libreswan-minimal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libreswan-minimal-5.3.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libreswan-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libreswan-minimal}"
SRC_URI[x86_64_v2_libreswan-minimal.sha256sum] = "249ee0bbeb71476f11b49b09b4eec4c60aa6e9e9d77f6b061ebb28d00856f608"

URI_aarch64_libreswan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libreswan-5.3.1-1.el10.aarch64.rpm;name=aarch64_libreswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libreswan}"
SRC_URI[aarch64_libreswan.sha256sum] = "c05ffbf6524dfe91a639af04c539ac582510e8d49b3e7dd84a005c70f426708e"

URI_aarch64_libreswan-minimal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libreswan-minimal-5.3.1-1.el10.aarch64.rpm;name=aarch64_libreswan-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_libreswan-minimal}"
SRC_URI[aarch64_libreswan-minimal.sha256sum] = "ccbc8706ebbbc9b9ddeb35df6333f1b12c7caf6a961abff8567f69975291d70d"

RDEPENDS:libreswan = " \
 bash \
 iproute \
 libreswan-minimal \
 logrotate \
 nss \
 nss-softokn \
 procps-ng \
 systemd \
 "
RDEPENDS:libreswan-minimal = " \
 audit-libs \
 bash \
 glibc \
 ldns \
 libcap-ng \
 libevent \
 libgcc \
 libseccomp \
 libselinux \
 libxcrypt \
 nspr \
 nss \
 nss-tools \
 nss-util \
 openldap \
 pam-libs \
 unbound-libs \
 virtual/coreutils \
 virtual/libcurl.so.4___64bit_ \
 "
