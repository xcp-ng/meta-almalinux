# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Ima-DBI"
PV = "0.35"
PR = "52.el10_3"
PACKAGES = " \
 perl-Ima-DBI \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Ima-DBI-0.35-52.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4b916ebceb182c0747c92c14d3deeffa07f43745543953bd88e30512f65599b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Ima-DBI-0.35-52.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Ima-DBI;unpack=0"
SRC_URI[x86_64_v2_perl-Ima-DBI.sha256sum] = "a66db644e4c89a0f5812cf86c4afc3f4cd2d11cafdfbf4888fe7e3a6d6a524a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Ima-DBI-0.35-52.el10_3.noarch.rpm;name=aarch64_perl-Ima-DBI;unpack=0"
SRC_URI[aarch64_perl-Ima-DBI.sha256sum] = "d40d1d42e44581910fa71208a42ef6f194475d69d827f4af98a36e521cb74f14"

RDEPENDS:perl-Ima-DBI = " \
 perl-Carp \
 perl-Class-Data-Inheritable \
 perl-DBI \
 perl-DBIx-ContextualFetch \
 perl-base \
 perl-libs \
 "
