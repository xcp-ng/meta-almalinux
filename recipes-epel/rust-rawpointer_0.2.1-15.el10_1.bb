# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rawpointer"
PV = "0.2.1"
PR = "15.el10_1"
PACKAGES = " \
 rust-rawpointer+default-devel \
 rust-rawpointer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rawpointer-0.2.1-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa90ad0a7995bfe9bc062b8240bd41a1a483b59f164cb684102734da93382c76"

URI_x86_64_v2_rust-rawpointer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rawpointer+default-devel-0.2.1-15.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rawpointer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rawpointer+default-devel}"
SRC_URI[x86_64_v2_rust-rawpointer+default-devel.sha256sum] = "f29c23ddd296e0efea93f59dbbc4f9d93bd394570654a3e400018447a3e648a2"

URI_x86_64_v2_rust-rawpointer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rawpointer-devel-0.2.1-15.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rawpointer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rawpointer-devel}"
SRC_URI[x86_64_v2_rust-rawpointer-devel.sha256sum] = "1d2473156365adfa09467247f650175e89f8abbead538f291a576ba17adf97d0"

URI_aarch64_rust-rawpointer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rawpointer+default-devel-0.2.1-15.el10_1.noarch.rpm;name=aarch64_rust-rawpointer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rawpointer+default-devel}"
SRC_URI[aarch64_rust-rawpointer+default-devel.sha256sum] = "4e18add0023c190d3fad39e50f1ca4d5344dec5e3659d0eb085c0c9ab6a5bd56"

URI_aarch64_rust-rawpointer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rawpointer-devel-0.2.1-15.el10_1.noarch.rpm;name=aarch64_rust-rawpointer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rawpointer-devel}"
SRC_URI[aarch64_rust-rawpointer-devel.sha256sum] = "1d5e587803defcafc61c402b626415af23b8a925c6f36a15c4385de9255b3bee"

RDEPENDS:rust-rawpointer+default-devel = " \
 cargo \
 rust-rawpointer-devel \
 "
RDEPENDS:rust-rawpointer-devel = " \
 cargo \
 "
