# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmbim"
PV = "1.32.0"
PR = "1.el10"
PACKAGES = " \
 libmbim \
 libmbim-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libmbim-1.32.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d98163173660d2499a8e705f825ba8f1cdc0fc5f0e3aa1ce490596656071d0a"

URI_x86_64_v2_libmbim = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libmbim-1.32.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libmbim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmbim}"
SRC_URI[x86_64_v2_libmbim.sha256sum] = "5f8e16019a5e69f5547565a0cc87bc082c4f4596cf9d93bd9a50dc72a71f3d3c"

URI_x86_64_v2_libmbim-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libmbim-utils-1.32.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libmbim-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmbim-utils}"
SRC_URI[x86_64_v2_libmbim-utils.sha256sum] = "6ea0e7a6f2a23dda49fe9e77364a4354b62aa972228ba2da49487c9997698f2b"

URI_aarch64_libmbim = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libmbim-1.32.0-1.el10.aarch64.rpm;name=aarch64_libmbim;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmbim}"
SRC_URI[aarch64_libmbim.sha256sum] = "bba41efbbe731c983a9ff49f9f1942a31de0de7bc0ef48031c273b2c53642319"

URI_aarch64_libmbim-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libmbim-utils-1.32.0-1.el10.aarch64.rpm;name=aarch64_libmbim-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmbim-utils}"
SRC_URI[aarch64_libmbim-utils.sha256sum] = "e1dd6faa5aa24dc4db491b1e4d37b8c3708708c11787412f10bc032e3d0bd10b"

RDEPENDS:libmbim = " \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:libmbim-utils = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libmbim \
 "
