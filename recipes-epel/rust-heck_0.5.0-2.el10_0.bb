# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-heck"
PV = "0.5.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-heck+default-devel \
 rust-heck-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-heck-0.5.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e96b6c2439cbbc977b4175bc071b2a72cca8f398cd83ac5b6e6a0fc124afece"

URI_x86_64_v2_rust-heck+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heck+default-devel-0.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heck+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heck+default-devel}"
SRC_URI[x86_64_v2_rust-heck+default-devel.sha256sum] = "46403b3e91be97e37970b290d0790b967b7b89abf422a0a7beb6710021b02930"

URI_x86_64_v2_rust-heck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heck-devel-0.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heck-devel}"
SRC_URI[x86_64_v2_rust-heck-devel.sha256sum] = "40abaa91ef16af6c28e40a41c2a150131e414d4d17a6aedd146c4614da548209"

URI_aarch64_rust-heck+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heck+default-devel-0.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-heck+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heck+default-devel}"
SRC_URI[aarch64_rust-heck+default-devel.sha256sum] = "c01f16e9aa5c1f0c5f81982ba13d2653ef672f26a610bd83a60ad297e0dc31bf"

URI_aarch64_rust-heck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heck-devel-0.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-heck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heck-devel}"
SRC_URI[aarch64_rust-heck-devel.sha256sum] = "f09b517236caa9786326400fe253a2aae43cdbb8ff5c631bfbe4df5e80b543bf"

RDEPENDS:rust-heck+default-devel = " \
 cargo \
 rust-heck-devel \
 "
RDEPENDS:rust-heck-devel = " \
 cargo \
 rust \
 "
