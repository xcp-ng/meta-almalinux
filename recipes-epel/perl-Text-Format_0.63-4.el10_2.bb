# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-Format"
PV = "0.63"
PR = "4.el10_2"
PACKAGES = " \
 perl-Text-Format \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-Format-0.63-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "373b4fec2a734ab130cf01bf55394a3c25b4ade9e730299891a7d6b33863a956"

URI_x86_64_v2_perl-Text-Format = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-Format-0.63-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-Format;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-Format}"
SRC_URI[x86_64_v2_perl-Text-Format.sha256sum] = "22b07c050b90d8a6b29b1be578f4271fce9f17fb72f4aba8adb4d779a57f4d19"

URI_aarch64_perl-Text-Format = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-Format-0.63-4.el10_2.noarch.rpm;name=aarch64_perl-Text-Format;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-Format}"
SRC_URI[aarch64_perl-Text-Format.sha256sum] = "b54903fb111df4f384d1ff07fe378cde7e021edfd9d7353da517ac844ffb4d45"

RDEPENDS:perl-Text-Format = " \
 perl-Carp \
 perl-libs \
 "
