# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kopeninghours"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kopeninghours \
 kopeninghours-devel \
 kopeninghours-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kopeninghours-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6dc3569385a8811ddc66bd91790f4df2fd7d352f2888cda4137456354aa64a4"

URI_x86_64_v2_kopeninghours = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kopeninghours;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kopeninghours}"
SRC_URI[x86_64_v2_kopeninghours.sha256sum] = "81f931f9290f30e612c4a4da2951bade262124c3bd7386b0e3c5613f9d2c8316"

URI_x86_64_v2_kopeninghours-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kopeninghours-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kopeninghours-devel}"
SRC_URI[x86_64_v2_kopeninghours-devel.sha256sum] = "2e064ca2dc3825ff6ab7cc30f706e48ad2a7ec5ec9bfada413c6735701478042"

URI_x86_64_v2_kopeninghours-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kopeninghours-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kopeninghours-doc}"
SRC_URI[x86_64_v2_kopeninghours-doc.sha256sum] = "0410bce663f176c49961fc009601014b94082a6bc58e1b99291094d5980c57c7"

URI_aarch64_kopeninghours = "${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kopeninghours;unpack=0"
SRC_URI:append = " ${URI_aarch64_kopeninghours}"
SRC_URI[aarch64_kopeninghours.sha256sum] = "549fb94a91f1d38e46031e79c32a5f978820aaa1b1001faa502458457089b200"

URI_aarch64_kopeninghours-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kopeninghours-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kopeninghours-devel}"
SRC_URI[aarch64_kopeninghours-devel.sha256sum] = "62812fdc4df98ff42b06359a512733bc06dabefc1f753923b9fb109b96dacbc6"

URI_aarch64_kopeninghours-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kopeninghours-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kopeninghours-doc}"
SRC_URI[aarch64_kopeninghours-doc.sha256sum] = "78521db2c7c07e9d9b7ed9f58f38c3902d217848a0d4bafce73180bce8ee2204"

RDEPENDS:kopeninghours = " \
 boost-python3 \
 glibc \
 kf6-filesystem \
 kf6-kholidays \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kopeninghours-devel = " \
 cmake-filesystem \
 kopeninghours \
 "
RDEPENDS:kopeninghours-doc = " \
 "
