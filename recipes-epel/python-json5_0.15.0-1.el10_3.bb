# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-json5"
PV = "0.15.0"
PR = "1.el10_3"
PACKAGES = " \
 pyjson5 \
 python3-json5 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-json5-0.15.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fadf42b8288b12940e94fa44680182648808af04e0b3aee801ea1ab57031d228"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pyjson5-0.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pyjson5;unpack=0"
SRC_URI[x86_64_v2_pyjson5.sha256sum] = "f822ee47a81275856f0d8b7a22e098c396ce45d3747bab068bf4dcd530f5e5c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-json5-0.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-json5;unpack=0"
SRC_URI[x86_64_v2_python3-json5.sha256sum] = "fdecca03233429340cf64b699f2f93ff870f0974e4c1319d91840b98a6024106"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pyjson5-0.15.0-1.el10_3.noarch.rpm;name=aarch64_pyjson5;unpack=0"
SRC_URI[aarch64_pyjson5.sha256sum] = "86415f9b6e92cf4f560490ba314c1e36ee4865fe4f36f8d2a1bf673f18c02be8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-json5-0.15.0-1.el10_3.noarch.rpm;name=aarch64_python3-json5;unpack=0"
SRC_URI[aarch64_python3-json5.sha256sum] = "a5d890b1e10e5d69fdd3cd5f4cd89553b078bce9ec1c45b7ef79d4a9b19c82b9"

RDEPENDS:pyjson5 = " \
 python3 \
 python3-json5 \
 "
RDEPENDS:python3-json5 = " \
 python3 \
 "
