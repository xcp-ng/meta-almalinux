# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpkpass"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kpkpass \
 kpkpass-devel \
 kpkpass-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpkpass-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7cb0865f2ff6adf61384d500f3eaa8784ffcd9451ccaa5f829010bed16c37e13"

URI_x86_64_v2_kpkpass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpkpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpkpass}"
SRC_URI[x86_64_v2_kpkpass.sha256sum] = "a55d83cff822c7b82e4bbbf9a01cd662917b8a56c7111f74b3b0794792934f01"

URI_x86_64_v2_kpkpass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpkpass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpkpass-devel}"
SRC_URI[x86_64_v2_kpkpass-devel.sha256sum] = "302ca3b9f53d0917b932db558ab84231f358ee9e87ef3b6e1cf9b6c5db3136d3"

URI_x86_64_v2_kpkpass-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kpkpass-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpkpass-doc}"
SRC_URI[x86_64_v2_kpkpass-doc.sha256sum] = "b5e7b3f88b9c171ccbcdb758bc1aebd56fa8723c852664e54d3b0ea02058ef0f"

URI_aarch64_kpkpass = "${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kpkpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpkpass}"
SRC_URI[aarch64_kpkpass.sha256sum] = "313a82ac71ed6bc25f3ee82d1f2e376db828307387556e7d1c34af9fb2d41c59"

URI_aarch64_kpkpass-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kpkpass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpkpass-devel}"
SRC_URI[aarch64_kpkpass-devel.sha256sum] = "8868772ccf95fa00222ef4c1ba4a6c81325d129d6d3bcbaccf83db2cc2152096"

URI_aarch64_kpkpass-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kpkpass-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpkpass-doc}"
SRC_URI[aarch64_kpkpass-doc.sha256sum] = "cb6599676cacea2da9b20c46eb066eb1a5b6dbc9316206dbea6cffa0826af6b1"

RDEPENDS:kpkpass = " \
 glibc \
 kf6-karchive \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kpkpass-devel = " \
 cmake-filesystem \
 kf6-karchive-devel \
 kpkpass \
 "
RDEPENDS:kpkpass-doc = " \
 "
