# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Daemon"
PV = "6.16"
PR = "7.el10"
PACKAGES = " \
 perl-HTTP-Daemon \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-HTTP-Daemon-6.16-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bc46a62fc6518bc50a77a9feaf59988696a0a804e272b9794ca79534ce70aff8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-HTTP-Daemon-6.16-7.el10.noarch.rpm;name=x86_64_v2_perl-HTTP-Daemon;unpack=0"
SRC_URI[x86_64_v2_perl-HTTP-Daemon.sha256sum] = "28e887f70e0a69a65b3defbc1ba20d6d6a1a56fb760f40eef335da8773eae435"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-HTTP-Daemon-6.16-7.el10.noarch.rpm;name=aarch64_perl-HTTP-Daemon;unpack=0"
SRC_URI[aarch64_perl-HTTP-Daemon.sha256sum] = "28e887f70e0a69a65b3defbc1ba20d6d6a1a56fb760f40eef335da8773eae435"

RDEPENDS:perl-HTTP-Daemon = " \
 perl-Carp \
 perl-HTTP-Date \
 perl-HTTP-Message \
 perl-IO-Socket-IP \
 perl-LWP-MediaTypes \
 perl-Socket \
 perl-libs \
 "
