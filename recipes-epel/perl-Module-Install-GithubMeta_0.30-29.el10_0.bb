# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Install-GithubMeta"
PV = "0.30"
PR = "29.el10_0"
PACKAGES = " \
 perl-Module-Install-GithubMeta \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Install-GithubMeta-0.30-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4fa1b0d1cc62c1c19816d7f8cc07a6189a0b5aa06d31a00ca81c24c064b027d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Install-GithubMeta-0.30-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Install-GithubMeta;unpack=0"
SRC_URI[x86_64_v2_perl-Module-Install-GithubMeta.sha256sum] = "92962103d8723cbf7ce7099f2aa3722cbc299c57142c464545ac944659f7160b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Install-GithubMeta-0.30-29.el10_0.noarch.rpm;name=aarch64_perl-Module-Install-GithubMeta;unpack=0"
SRC_URI[aarch64_perl-Module-Install-GithubMeta.sha256sum] = "72c5e7f1c9b79d42dec96569a5407d1e7a0724c434a6e19ff3f22628ceb28d36"

RDEPENDS:perl-Module-Install-GithubMeta = " \
 perl-Module-Install \
 perl-PathTools \
 perl-base \
 perl-libs \
 perl-vars \
 "
