# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-cmake"
PV = "7.2.0"
PR = "3.el10_3"
PACKAGES = " \
 rocm-cmake \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rocm-cmake-7.2.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "20c1178f484fa4524a079a7105c30423276fb88ebce73192656c46062f61c0c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-cmake-7.2.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rocm-cmake;unpack=0"
SRC_URI[x86_64_v2_rocm-cmake.sha256sum] = "74808c525d7b8dcff253703b92c1c0606c447fe5c83ce2131fdad0dbfaccfd2f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rocm-cmake-7.2.0-3.el10_3.noarch.rpm;name=aarch64_rocm-cmake;unpack=0"
SRC_URI[aarch64_rocm-cmake.sha256sum] = "6756bdbbad0f21ab3fd188b165a31fe5c56111bebd3211abcacc13a1d8d8942c"

RDEPENDS:rocm-cmake = " \
 cmake \
 rocm-filesystem \
 "
