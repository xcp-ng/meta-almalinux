# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tui-react"
PV = "0.24.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tui-react+default-devel \
 rust-tui-react-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tui-react-0.24.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c6cb821fc3a97b2b0a2480565e6c3c05b152ecfabbd2e6ac92ce095f949de98"

URI_x86_64_v2_rust-tui-react+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tui-react+default-devel-0.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tui-react+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tui-react+default-devel}"
SRC_URI[x86_64_v2_rust-tui-react+default-devel.sha256sum] = "96d09bb1bdec3ac314ee9924f88a7e57f6f44169de5f4b2f272d5a5827edc61a"

URI_x86_64_v2_rust-tui-react-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tui-react-devel-0.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tui-react-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tui-react-devel}"
SRC_URI[x86_64_v2_rust-tui-react-devel.sha256sum] = "8fa12ba06a015311719088b91e081b05f2895e61cde2cbcd761a30e61996a34a"

URI_aarch64_rust-tui-react+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tui-react+default-devel-0.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-tui-react+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tui-react+default-devel}"
SRC_URI[aarch64_rust-tui-react+default-devel.sha256sum] = "c9864e0ea359ce74a163d0c69b562f611cc4a4f836d78b4983555de2299302b1"

URI_aarch64_rust-tui-react-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tui-react-devel-0.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-tui-react-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tui-react-devel}"
SRC_URI[aarch64_rust-tui-react-devel.sha256sum] = "7df89a6b1b58f68e37912c07dba86ef3c2d455e23c1c1526d91a68f8a632a2ff"

RDEPENDS:rust-tui-react+default-devel = " \
 cargo \
 rust-tui-react-devel \
 "
RDEPENDS:rust-tui-react-devel = " \
 cargo \
 rust-log+default-devel \
 rust-ratatui-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width+default-devel \
 "
