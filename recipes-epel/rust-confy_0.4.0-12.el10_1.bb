# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-confy"
PV = "0.4.0"
PR = "12.el10_1"
PACKAGES = " \
 rust-confy+default-devel \
 rust-confy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-confy-0.4.0-12.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "535d3bf9b899ec0e8b4e0f4c68994ff325e629c94f68566f58aabc8063996e05"

URI_x86_64_v2_rust-confy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-confy+default-devel-0.4.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-confy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-confy+default-devel}"
SRC_URI[x86_64_v2_rust-confy+default-devel.sha256sum] = "50bb09aadaae59a79179e9940788d35eb13acf78d27251e79e2a1ae7fd7b1ef7"

URI_x86_64_v2_rust-confy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-confy-devel-0.4.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-confy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-confy-devel}"
SRC_URI[x86_64_v2_rust-confy-devel.sha256sum] = "fee1e2ec8bb664692cc6629afb702f32994400c2784837c5455385097c624657"

URI_aarch64_rust-confy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-confy+default-devel-0.4.0-12.el10_1.noarch.rpm;name=aarch64_rust-confy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-confy+default-devel}"
SRC_URI[aarch64_rust-confy+default-devel.sha256sum] = "3ebd1834bbecd9834dbe1dcf6d31a6cbb6e3e0818e48a940dc402b7bf4ead9ef"

URI_aarch64_rust-confy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-confy-devel-0.4.0-12.el10_1.noarch.rpm;name=aarch64_rust-confy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-confy-devel}"
SRC_URI[aarch64_rust-confy-devel.sha256sum] = "11556e8dd333bea3fd7b6a0bcb522f6def7b30e4b2f418667d71716ee2e04e86"

RDEPENDS:rust-confy+default-devel = " \
 cargo \
 rust-confy-devel \
 "
RDEPENDS:rust-confy-devel = " \
 cargo \
 rust-directories+default-devel \
 rust-serde+default-devel \
 rust-toml0.5+default-devel \
 "
