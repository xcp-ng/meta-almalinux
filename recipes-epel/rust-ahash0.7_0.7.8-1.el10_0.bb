# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ahash0.7"
PV = "0.7.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-ahash0.7+atomic-polyfill-devel \
 rust-ahash0.7+compile-time-rng-devel \
 rust-ahash0.7+const-random-devel \
 rust-ahash0.7+default-devel \
 rust-ahash0.7+serde-devel \
 rust-ahash0.7+std-devel \
 rust-ahash0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ahash0.7-0.7.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "950b8719017cac98dfa20783d8340cb6720ac5675c2d3b5a28cde6c4c5d10b2d"

URI_x86_64_v2_rust-ahash0.7+atomic-polyfill-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash0.7+atomic-polyfill-devel-0.7.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash0.7+atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash0.7+atomic-polyfill-devel}"
SRC_URI[x86_64_v2_rust-ahash0.7+atomic-polyfill-devel.sha256sum] = "8d474d801b9d35b914e085d394089ba8676bba17a384c57f8e0bc6a1e3c8bfc0"

URI_x86_64_v2_rust-ahash0.7+compile-time-rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash0.7+compile-time-rng-devel-0.7.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash0.7+compile-time-rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash0.7+compile-time-rng-devel}"
SRC_URI[x86_64_v2_rust-ahash0.7+compile-time-rng-devel.sha256sum] = "0084df300bd83cdc0f5a628fbe23e9f639704edce56205d4e4de8826c47470a8"

URI_x86_64_v2_rust-ahash0.7+const-random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash0.7+const-random-devel-0.7.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash0.7+const-random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash0.7+const-random-devel}"
SRC_URI[x86_64_v2_rust-ahash0.7+const-random-devel.sha256sum] = "97706dcf8f0aa47ceede9395bf3986c4c9d8c132a393f7706ef89b4dd74538c9"

URI_x86_64_v2_rust-ahash0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash0.7+default-devel-0.7.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash0.7+default-devel}"
SRC_URI[x86_64_v2_rust-ahash0.7+default-devel.sha256sum] = "8794ff5138788cdd1f86b422a1452973bb33cd3bb01b0e597393089a5bba137c"

URI_x86_64_v2_rust-ahash0.7+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash0.7+serde-devel-0.7.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash0.7+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash0.7+serde-devel}"
SRC_URI[x86_64_v2_rust-ahash0.7+serde-devel.sha256sum] = "8c952eb8d606fe7c5440ebae96c6068b0c7ecdb51004bed5a409916e1cd5624c"

URI_x86_64_v2_rust-ahash0.7+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash0.7+std-devel-0.7.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash0.7+std-devel}"
SRC_URI[x86_64_v2_rust-ahash0.7+std-devel.sha256sum] = "e295d6be3e299784d99a88c4aa3ee0a7d73c3e52b8ca8901d31992a48ab4fab9"

URI_x86_64_v2_rust-ahash0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash0.7-devel-0.7.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash0.7-devel}"
SRC_URI[x86_64_v2_rust-ahash0.7-devel.sha256sum] = "12a369f050271fa0d9017121502c4aacaf42736fb9fb986b6bcaf70ebdc80608"

URI_aarch64_rust-ahash0.7+atomic-polyfill-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash0.7+atomic-polyfill-devel-0.7.8-1.el10_0.noarch.rpm;name=aarch64_rust-ahash0.7+atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash0.7+atomic-polyfill-devel}"
SRC_URI[aarch64_rust-ahash0.7+atomic-polyfill-devel.sha256sum] = "003f5e36591db8b194a1f38360a2bc43f10d5eae180a8a298776fe66462547c5"

URI_aarch64_rust-ahash0.7+compile-time-rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash0.7+compile-time-rng-devel-0.7.8-1.el10_0.noarch.rpm;name=aarch64_rust-ahash0.7+compile-time-rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash0.7+compile-time-rng-devel}"
SRC_URI[aarch64_rust-ahash0.7+compile-time-rng-devel.sha256sum] = "e7d6145d4402e535e3af706521972905486aac64bb252c8e7c2b11f5542515cb"

URI_aarch64_rust-ahash0.7+const-random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash0.7+const-random-devel-0.7.8-1.el10_0.noarch.rpm;name=aarch64_rust-ahash0.7+const-random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash0.7+const-random-devel}"
SRC_URI[aarch64_rust-ahash0.7+const-random-devel.sha256sum] = "4328b5ddd89042f9d1b5e8c9c65c98a7dab8fa7e833e9294d8b7ab8b55ca0bf9"

URI_aarch64_rust-ahash0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash0.7+default-devel-0.7.8-1.el10_0.noarch.rpm;name=aarch64_rust-ahash0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash0.7+default-devel}"
SRC_URI[aarch64_rust-ahash0.7+default-devel.sha256sum] = "c8f5791046ef41f21a0eec171d2c300915d4688a412ca78f03dcad5eb674d797"

URI_aarch64_rust-ahash0.7+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash0.7+serde-devel-0.7.8-1.el10_0.noarch.rpm;name=aarch64_rust-ahash0.7+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash0.7+serde-devel}"
SRC_URI[aarch64_rust-ahash0.7+serde-devel.sha256sum] = "573a5dfcea9562876d6a6c5a6b1f339e5e7984c430b40d4900b5bbe5bed9459f"

URI_aarch64_rust-ahash0.7+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash0.7+std-devel-0.7.8-1.el10_0.noarch.rpm;name=aarch64_rust-ahash0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash0.7+std-devel}"
SRC_URI[aarch64_rust-ahash0.7+std-devel.sha256sum] = "1d7ecf919835f4eb74d7629e4d4daa963fb914d449eab9e9fad4a6d2a1319f08"

URI_aarch64_rust-ahash0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash0.7-devel-0.7.8-1.el10_0.noarch.rpm;name=aarch64_rust-ahash0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash0.7-devel}"
SRC_URI[aarch64_rust-ahash0.7-devel.sha256sum] = "f2c7543b8495635d5ccd31b2bfda088c67a9defb2889b0d0947674b021064915"

RDEPENDS:rust-ahash0.7+atomic-polyfill-devel = " \
 cargo \
 rust-ahash0.7-devel \
 rust-once_cell+atomic-polyfill-devel \
 "
RDEPENDS:rust-ahash0.7+compile-time-rng-devel = " \
 cargo \
 rust-ahash0.7+const-random-devel \
 rust-ahash0.7-devel \
 "
RDEPENDS:rust-ahash0.7+const-random-devel = " \
 cargo \
 rust-ahash0.7-devel \
 rust-const-random+default-devel \
 "
RDEPENDS:rust-ahash0.7+default-devel = " \
 cargo \
 rust-ahash0.7+std-devel \
 rust-ahash0.7-devel \
 "
RDEPENDS:rust-ahash0.7+serde-devel = " \
 cargo \
 rust-ahash0.7-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-ahash0.7+std-devel = " \
 cargo \
 rust-ahash0.7-devel \
 "
RDEPENDS:rust-ahash0.7-devel = " \
 cargo \
 rust-getrandom0.2+default-devel \
 rust-once_cell+alloc-devel \
 rust-once_cell-devel \
 rust-version_check+default-devel \
 "
