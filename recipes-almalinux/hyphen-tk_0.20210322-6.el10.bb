# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-tk"
PV = "0.20210322"
PR = "6.el10"
PACKAGES = " \
 hyphen-tk \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-tk-0.20210322-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "de6fda5ad0a6dacc136744f37490fd6dfc980fc39f129ebdb5f6a431b57c2b6b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-tk-0.20210322-6.el10.noarch.rpm;name=x86_64_v2_hyphen-tk;unpack=0"
SRC_URI[x86_64_v2_hyphen-tk.sha256sum] = "800bb35cf87014117b84f31af534abc139bb433b54f799f0fcd19ad0e7040bed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-tk-0.20210322-6.el10.noarch.rpm;name=aarch64_hyphen-tk;unpack=0"
SRC_URI[aarch64_hyphen-tk.sha256sum] = "800bb35cf87014117b84f31af534abc139bb433b54f799f0fcd19ad0e7040bed"

RDEPENDS:hyphen-tk = " \
 hyphen \
 "
