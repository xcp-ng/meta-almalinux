# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-strict"
PV = "0.5"
PR = "6.el10_0"
PACKAGES = " \
 ghc-strict \
 ghc-strict-devel \
 ghc-strict-doc \
 ghc-strict-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-strict-0.5-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30d48f4350a9dd5c54ff11d6934f2cb5f1eb28e3152608d5884a64929c54e736"

URI_x86_64_v2_ghc-strict = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-strict-0.5-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-strict;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-strict}"
SRC_URI[x86_64_v2_ghc-strict.sha256sum] = "d5bada35f652dc91d8dfd60e392e55a70db7739c948d41b0e1e848d10558bc5d"

URI_x86_64_v2_ghc-strict-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-strict-devel-0.5-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-strict-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-strict-devel}"
SRC_URI[x86_64_v2_ghc-strict-devel.sha256sum] = "8e47e909a4851d6a2bf000015a28aaee8b60412ed0f2e5cf4a5943334765e1c2"

URI_x86_64_v2_ghc-strict-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-strict-doc-0.5-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-strict-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-strict-doc}"
SRC_URI[x86_64_v2_ghc-strict-doc.sha256sum] = "4be8d71de6729ab439534baa6f14967bd04858da6a19ff37b4fd263a4ec8c406"

URI_x86_64_v2_ghc-strict-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-strict-prof-0.5-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-strict-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-strict-prof}"
SRC_URI[x86_64_v2_ghc-strict-prof.sha256sum] = "de12d9e985dc61a4779d92f8c56824476a469edb73cc92bdc36e8728c58e973a"

URI_aarch64_ghc-strict = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-strict-0.5-6.el10_0.aarch64.rpm;name=aarch64_ghc-strict;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-strict}"
SRC_URI[aarch64_ghc-strict.sha256sum] = "820ea8fc2acd8cd10c019b45a9e8cbb81dd9055f26951364bf17d4191ea57c9a"

URI_aarch64_ghc-strict-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-strict-devel-0.5-6.el10_0.aarch64.rpm;name=aarch64_ghc-strict-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-strict-devel}"
SRC_URI[aarch64_ghc-strict-devel.sha256sum] = "155899ce92ffdf19d7dadeca9685f19b316ce46940fed5af7fc94b6014e2d1c3"

URI_aarch64_ghc-strict-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-strict-doc-0.5-6.el10_0.noarch.rpm;name=aarch64_ghc-strict-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-strict-doc}"
SRC_URI[aarch64_ghc-strict-doc.sha256sum] = "376ba477fa60246bf64ef03dbbd3987264bcd10b94e856e74484c6eeb315f6c6"

URI_aarch64_ghc-strict-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-strict-prof-0.5-6.el10_0.aarch64.rpm;name=aarch64_ghc-strict-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-strict-prof}"
SRC_URI[aarch64_ghc-strict-prof.sha256sum] = "b16108b1483ddb5361633fb06daaafcb60375ba22e8b2cf26a86fad4630078ac"

RDEPENDS:ghc-strict = " \
 ghc-array \
 ghc-assoc \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-these \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-strict-devel = " \
 ghc-assoc-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-hashable-devel \
 ghc-strict \
 ghc-text-devel \
 ghc-these-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-strict-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-strict-prof = " \
 ghc-assoc-prof \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 ghc-hashable-prof \
 ghc-strict-devel \
 ghc-text-prof \
 ghc-these-prof \
 ghc-transformers-prof \
 "
