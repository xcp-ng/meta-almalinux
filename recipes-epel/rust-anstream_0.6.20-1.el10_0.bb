# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstream"
PV = "0.6.20"
PR = "1.el10_0"
PACKAGES = " \
 rust-anstream+auto-devel \
 rust-anstream+default-devel \
 rust-anstream+test-devel \
 rust-anstream+wincon-devel \
 rust-anstream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstream-0.6.20-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "577dd2423b9e45ce20c318e8baeff3f70340175556adce6c346b8905e3c401c9"

URI_x86_64_v2_rust-anstream+auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream+auto-devel-0.6.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream+auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream+auto-devel}"
SRC_URI[x86_64_v2_rust-anstream+auto-devel.sha256sum] = "b6504e352422608e3bb2e7a1d63b981f1b1d43dde39805e800abf44770a6a0cf"

URI_x86_64_v2_rust-anstream+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream+default-devel-0.6.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream+default-devel}"
SRC_URI[x86_64_v2_rust-anstream+default-devel.sha256sum] = "1b1cbd6a78c5319b3b9e0ae279456722db5f19059a12568d2e92b3ba5e7ab2db"

URI_x86_64_v2_rust-anstream+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream+test-devel-0.6.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream+test-devel}"
SRC_URI[x86_64_v2_rust-anstream+test-devel.sha256sum] = "6a06f742b7d61f3e5ac13eb027bda37e82f8ed7f85eab5ec91d14195a4cfe3a0"

URI_x86_64_v2_rust-anstream+wincon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream+wincon-devel-0.6.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream+wincon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream+wincon-devel}"
SRC_URI[x86_64_v2_rust-anstream+wincon-devel.sha256sum] = "38e52e57bdeefb0220c09059f097facd7285c8ef23ff0f2365d336aa4abfb282"

URI_x86_64_v2_rust-anstream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream-devel-0.6.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream-devel}"
SRC_URI[x86_64_v2_rust-anstream-devel.sha256sum] = "b10c6cf6b781439cf3292b431b6c03fb4579af475e9362dd123d40ce51957407"

URI_aarch64_rust-anstream+auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream+auto-devel-0.6.20-1.el10_0.noarch.rpm;name=aarch64_rust-anstream+auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream+auto-devel}"
SRC_URI[aarch64_rust-anstream+auto-devel.sha256sum] = "3bf3f32528ce4e2b8690adc0be060a2a43584c97c2e6a6bdd69a98f2e4edf6e1"

URI_aarch64_rust-anstream+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream+default-devel-0.6.20-1.el10_0.noarch.rpm;name=aarch64_rust-anstream+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream+default-devel}"
SRC_URI[aarch64_rust-anstream+default-devel.sha256sum] = "0a09020f7bd3ba711a7edc1ebc4099262953cbbad8d106c2dbbf5f92125ec508"

URI_aarch64_rust-anstream+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream+test-devel-0.6.20-1.el10_0.noarch.rpm;name=aarch64_rust-anstream+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream+test-devel}"
SRC_URI[aarch64_rust-anstream+test-devel.sha256sum] = "e943d12a079fd3edb3afaf74b2d528c77678eb415d623469fef831a0564ef702"

URI_aarch64_rust-anstream+wincon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream+wincon-devel-0.6.20-1.el10_0.noarch.rpm;name=aarch64_rust-anstream+wincon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream+wincon-devel}"
SRC_URI[aarch64_rust-anstream+wincon-devel.sha256sum] = "43505f21bef99b82413ad1619158b556a277790e7a1f7c9078f1723a6b1c2e1a"

URI_aarch64_rust-anstream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream-devel-0.6.20-1.el10_0.noarch.rpm;name=aarch64_rust-anstream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream-devel}"
SRC_URI[aarch64_rust-anstream-devel.sha256sum] = "663e4278c6cb15a295a2ec414636c3dea666695e114d7197ba39efaafdfbe160"

RDEPENDS:rust-anstream+auto-devel = " \
 cargo \
 rust-anstream-devel \
 rust-anstyle-query+default-devel \
 "
RDEPENDS:rust-anstream+default-devel = " \
 cargo \
 rust-anstream+auto-devel \
 rust-anstream+wincon-devel \
 rust-anstream-devel \
 "
RDEPENDS:rust-anstream+test-devel = " \
 cargo \
 rust-anstream-devel \
 "
RDEPENDS:rust-anstream+wincon-devel = " \
 cargo \
 rust-anstream-devel \
 "
RDEPENDS:rust-anstream-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-anstyle-parse+default-devel \
 rust-colorchoice+default-devel \
 rust-utf8parse+default-devel \
 "
