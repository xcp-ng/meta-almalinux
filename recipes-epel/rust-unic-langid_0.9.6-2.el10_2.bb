# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-langid"
PV = "0.9.6"
PR = "2.el10_2"
PACKAGES = " \
 rust-unic-langid+default-devel \
 rust-unic-langid+likelysubtags-devel \
 rust-unic-langid+macros-devel \
 rust-unic-langid+serde-devel \
 rust-unic-langid+unic-langid-macros-devel \
 rust-unic-langid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-langid-0.9.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a3187b3de7ded1c085110adb2617a214ff92586cfd364dd958b267f1c21df3e"

URI_x86_64_v2_rust-unic-langid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid+default-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid+default-devel}"
SRC_URI[x86_64_v2_rust-unic-langid+default-devel.sha256sum] = "0ec40e969e5decfc2a5bd41911e52542b352d954b1847b8c1d25ab65c78a5f40"

URI_x86_64_v2_rust-unic-langid+likelysubtags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid+likelysubtags-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid+likelysubtags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid+likelysubtags-devel}"
SRC_URI[x86_64_v2_rust-unic-langid+likelysubtags-devel.sha256sum] = "4cbc90ca0181840859de5e8ed34703e80a418b85e5d534383edcf2fb4bbbd357"

URI_x86_64_v2_rust-unic-langid+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid+macros-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid+macros-devel}"
SRC_URI[x86_64_v2_rust-unic-langid+macros-devel.sha256sum] = "5922c59c12757b98541918a9b2a3e832dad83f3005fccca8b10782e68fcb1433"

URI_x86_64_v2_rust-unic-langid+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid+serde-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid+serde-devel}"
SRC_URI[x86_64_v2_rust-unic-langid+serde-devel.sha256sum] = "a93abd433f179d1aabfd9c15f759ab785217c7e93f99772b9c8845e914cdd1ce"

URI_x86_64_v2_rust-unic-langid+unic-langid-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid+unic-langid-macros-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid+unic-langid-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid+unic-langid-macros-devel}"
SRC_URI[x86_64_v2_rust-unic-langid+unic-langid-macros-devel.sha256sum] = "f7baa3245c58872050e45dd1adf5247e5ed94061af150c3bb39f313570c04926"

URI_x86_64_v2_rust-unic-langid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid-devel}"
SRC_URI[x86_64_v2_rust-unic-langid-devel.sha256sum] = "68574b013596202ee541ff9e2ac3cf70da18b00bcb2048961308c0b057dc9aba"

URI_aarch64_rust-unic-langid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid+default-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid+default-devel}"
SRC_URI[aarch64_rust-unic-langid+default-devel.sha256sum] = "bdad55b6245b5a604187432ea73d5c3c8b570019b1004206bbe42998e0041919"

URI_aarch64_rust-unic-langid+likelysubtags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid+likelysubtags-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid+likelysubtags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid+likelysubtags-devel}"
SRC_URI[aarch64_rust-unic-langid+likelysubtags-devel.sha256sum] = "0633071325a792f25cd91938e7fb751cd0edab95e2d9b653de3de6e54dc491c9"

URI_aarch64_rust-unic-langid+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid+macros-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid+macros-devel}"
SRC_URI[aarch64_rust-unic-langid+macros-devel.sha256sum] = "fb98f4e40dd0c73683d94c60d56285d687932b0a5d88efc9e4a7e594f55fc7c1"

URI_aarch64_rust-unic-langid+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid+serde-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid+serde-devel}"
SRC_URI[aarch64_rust-unic-langid+serde-devel.sha256sum] = "3939d797ff5151f268e390ca6d8aed1aaea55dbd72573de381e80fa0b65321c9"

URI_aarch64_rust-unic-langid+unic-langid-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid+unic-langid-macros-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid+unic-langid-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid+unic-langid-macros-devel}"
SRC_URI[aarch64_rust-unic-langid+unic-langid-macros-devel.sha256sum] = "571c4ae8b3e61f1c72d29930910c3535c16abd1c3f792210931d10e9ad52c9ff"

URI_aarch64_rust-unic-langid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid-devel}"
SRC_URI[aarch64_rust-unic-langid-devel.sha256sum] = "f32cbae39dfb5f96da4fc1f23643bca7a05af513926a02b37be1d6f3419a69c5"

RDEPENDS:rust-unic-langid+default-devel = " \
 cargo \
 rust-unic-langid-devel \
 "
RDEPENDS:rust-unic-langid+likelysubtags-devel = " \
 cargo \
 rust-unic-langid-devel \
 rust-unic-langid-impl+likelysubtags-devel \
 "
RDEPENDS:rust-unic-langid+macros-devel = " \
 cargo \
 rust-unic-langid+unic-langid-macros-devel \
 rust-unic-langid-devel \
 "
RDEPENDS:rust-unic-langid+serde-devel = " \
 cargo \
 rust-unic-langid-devel \
 rust-unic-langid-impl+serde-devel \
 "
RDEPENDS:rust-unic-langid+unic-langid-macros-devel = " \
 cargo \
 rust-unic-langid-devel \
 rust-unic-langid-macros+default-devel \
 "
RDEPENDS:rust-unic-langid-devel = " \
 cargo \
 rust-unic-langid-impl+default-devel \
 "
