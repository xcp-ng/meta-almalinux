# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-openat"
PV = "0.1.21"
PR = "11.el10_0"
PACKAGES = " \
 rust-openat+default-devel \
 rust-openat-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-openat-0.1.21-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "412abc3fa25bb745d5b7f9d398947c28b56b79f4b7bd783356923bf4091ed888"

URI_x86_64_v2_rust-openat+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openat+default-devel-0.1.21-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openat+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openat+default-devel}"
SRC_URI[x86_64_v2_rust-openat+default-devel.sha256sum] = "d1916722efcfe30a43a61ce7422f056a274f9e9e33d760c21f24b506253889c8"

URI_x86_64_v2_rust-openat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openat-devel-0.1.21-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openat-devel}"
SRC_URI[x86_64_v2_rust-openat-devel.sha256sum] = "9b8dfbd161d71eb49abb185125ab2fe8569a0db131fc5ac20f9adf861c88d09a"

URI_aarch64_rust-openat+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openat+default-devel-0.1.21-11.el10_0.noarch.rpm;name=aarch64_rust-openat+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openat+default-devel}"
SRC_URI[aarch64_rust-openat+default-devel.sha256sum] = "3f5ca3211849f142ce1899f8ff2044a9d5d7098f07cca34d5473a7319dc77c06"

URI_aarch64_rust-openat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openat-devel-0.1.21-11.el10_0.noarch.rpm;name=aarch64_rust-openat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openat-devel}"
SRC_URI[aarch64_rust-openat-devel.sha256sum] = "274667d75c3690a9a2d25b7219dca8b63cd4013ed1cca14c3afe779ed6fe4aee"

RDEPENDS:rust-openat+default-devel = " \
 cargo \
 rust-openat-devel \
 "
RDEPENDS:rust-openat-devel = " \
 cargo \
 rust-libc+default-devel \
 "
