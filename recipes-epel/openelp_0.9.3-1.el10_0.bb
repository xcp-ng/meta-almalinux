# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openelp"
PV = "0.9.3"
PR = "1.el10_0"
PACKAGES = " \
 openelp \
 openelp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openelp-0.9.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a9be9cc19fa2456160dd268d395d21c0bd839f35276264b01afdb4c87bc64ca"

URI_x86_64_v2_openelp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openelp-0.9.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openelp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openelp}"
SRC_URI[x86_64_v2_openelp.sha256sum] = "71a8420f9e955cc84dda0f9cab93061141d750b892893c64a9d79a4efb208a09"

URI_x86_64_v2_openelp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openelp-devel-0.9.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openelp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openelp-devel}"
SRC_URI[x86_64_v2_openelp-devel.sha256sum] = "5c1bbf2d807a10d7ea644b0896d1e16cc5465d06695675bcc5306ec521f505c6"

URI_aarch64_openelp = "${EPEL_MIRROR}/aarch64/Packages/o/openelp-0.9.3-1.el10_0.aarch64.rpm;name=aarch64_openelp;unpack=0"
SRC_URI:append = " ${URI_aarch64_openelp}"
SRC_URI[aarch64_openelp.sha256sum] = "56dffd837b41e1fc84b42e679a2e1f02aa923cca6818c3cb9611fe6afe1c3d79"

URI_aarch64_openelp-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openelp-devel-0.9.3-1.el10_0.aarch64.rpm;name=aarch64_openelp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openelp-devel}"
SRC_URI[aarch64_openelp-devel.sha256sum] = "b91a47628600dc150089062c6035e7d2c513167ba3c155418fcdcdb3f0c454f7"

RDEPENDS:openelp = " \
 bash \
 firewalld-filesystem \
 glibc \
 openssl-libs \
 pcre2 \
 shadow-utils \
 "
RDEPENDS:openelp-devel = " \
 openelp \
 "
