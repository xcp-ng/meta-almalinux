# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hashicorp-hcl"
PV = "1.0.0"
PR = "17.el10_0"
PACKAGES = " \
 golang-github-hashicorp-hcl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-hashicorp-hcl-1.0.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7cd11bebc943e16931950503e2342ed643b9657818330943163a3aa12c47cc7b"

URI_x86_64_v2_golang-github-hashicorp-hcl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hashicorp-hcl-devel-1.0.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hashicorp-hcl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hashicorp-hcl-devel}"
SRC_URI[x86_64_v2_golang-github-hashicorp-hcl-devel.sha256sum] = "905d1e74b21da13b68032f9887d2559e860ff734b7d80a6b7aab1a9ea7fb91bc"

URI_aarch64_golang-github-hashicorp-hcl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hashicorp-hcl-devel-1.0.0-17.el10_0.noarch.rpm;name=aarch64_golang-github-hashicorp-hcl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hashicorp-hcl-devel}"
SRC_URI[aarch64_golang-github-hashicorp-hcl-devel.sha256sum] = "e003f94bfde125c40529c85edf4212d554e7f39e0094d758e52d5c8d2960320d"

RDEPENDS:golang-github-hashicorp-hcl-devel = " \
 go-filesystem \
 "
