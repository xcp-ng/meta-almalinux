# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ppv-lite86"
PV = "0.2.21"
PR = "1.el10_1"
PACKAGES = " \
 rust-ppv-lite86+default-devel \
 rust-ppv-lite86+no_simd-devel \
 rust-ppv-lite86+simd-devel \
 rust-ppv-lite86+std-devel \
 rust-ppv-lite86-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ppv-lite86-0.2.21-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19d80957252499c584cc9a4ba6bd74ee4c199cdec78d1be499ddde95aa236929"

URI_x86_64_v2_rust-ppv-lite86+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ppv-lite86+default-devel-0.2.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ppv-lite86+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ppv-lite86+default-devel}"
SRC_URI[x86_64_v2_rust-ppv-lite86+default-devel.sha256sum] = "d3ea3b2e401c1416aac53be9a3b3485ec9e589066d347d83a8e35cc38e7d29c3"

URI_x86_64_v2_rust-ppv-lite86+no_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ppv-lite86+no_simd-devel-0.2.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ppv-lite86+no_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ppv-lite86+no_simd-devel}"
SRC_URI[x86_64_v2_rust-ppv-lite86+no_simd-devel.sha256sum] = "a2c77ad50fa0ad44c02b2311a1bef06d5789b03581fff6afcfee270845224829"

URI_x86_64_v2_rust-ppv-lite86+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ppv-lite86+simd-devel-0.2.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ppv-lite86+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ppv-lite86+simd-devel}"
SRC_URI[x86_64_v2_rust-ppv-lite86+simd-devel.sha256sum] = "3dd0a054b2c3beb551f6efcb17d81dcbe5e406b34e0c82f8418de032432c45df"

URI_x86_64_v2_rust-ppv-lite86+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ppv-lite86+std-devel-0.2.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ppv-lite86+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ppv-lite86+std-devel}"
SRC_URI[x86_64_v2_rust-ppv-lite86+std-devel.sha256sum] = "86f2aad55cde7a2740869d88645b10da545a8f30876c47a0c43af7b8228afe78"

URI_x86_64_v2_rust-ppv-lite86-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ppv-lite86-devel-0.2.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ppv-lite86-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ppv-lite86-devel}"
SRC_URI[x86_64_v2_rust-ppv-lite86-devel.sha256sum] = "98ab658a7747aff1a00c0a0decfeae12542b0c32b4567040ad7879512b652e8c"

URI_aarch64_rust-ppv-lite86+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ppv-lite86+default-devel-0.2.21-1.el10_1.noarch.rpm;name=aarch64_rust-ppv-lite86+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ppv-lite86+default-devel}"
SRC_URI[aarch64_rust-ppv-lite86+default-devel.sha256sum] = "73031c2092df46aac75d3fc54ff18b66c3bb2dd810e498737f41cb33780be946"

URI_aarch64_rust-ppv-lite86+no_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ppv-lite86+no_simd-devel-0.2.21-1.el10_1.noarch.rpm;name=aarch64_rust-ppv-lite86+no_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ppv-lite86+no_simd-devel}"
SRC_URI[aarch64_rust-ppv-lite86+no_simd-devel.sha256sum] = "5c8813e0136a9ba94b22197b75384c3bd17b7c62820f62ccd9180bd9efc81b06"

URI_aarch64_rust-ppv-lite86+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ppv-lite86+simd-devel-0.2.21-1.el10_1.noarch.rpm;name=aarch64_rust-ppv-lite86+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ppv-lite86+simd-devel}"
SRC_URI[aarch64_rust-ppv-lite86+simd-devel.sha256sum] = "b89b23606268cdc7a614f0d9d9d4de0bbf71d4cfca3298550f73af025a449657"

URI_aarch64_rust-ppv-lite86+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ppv-lite86+std-devel-0.2.21-1.el10_1.noarch.rpm;name=aarch64_rust-ppv-lite86+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ppv-lite86+std-devel}"
SRC_URI[aarch64_rust-ppv-lite86+std-devel.sha256sum] = "359269388bea964f1201e050b0eec53d2a3024f4fc835a21700ed93f08ce3ca5"

URI_aarch64_rust-ppv-lite86-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ppv-lite86-devel-0.2.21-1.el10_1.noarch.rpm;name=aarch64_rust-ppv-lite86-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ppv-lite86-devel}"
SRC_URI[aarch64_rust-ppv-lite86-devel.sha256sum] = "5a470a542ca65837932d3b2c8d3efcbf02d034c3b371e2549d6777e8d1b4aac7"

RDEPENDS:rust-ppv-lite86+default-devel = " \
 cargo \
 rust-ppv-lite86+std-devel \
 rust-ppv-lite86-devel \
 "
RDEPENDS:rust-ppv-lite86+no_simd-devel = " \
 cargo \
 rust-ppv-lite86-devel \
 "
RDEPENDS:rust-ppv-lite86+simd-devel = " \
 cargo \
 rust-ppv-lite86-devel \
 "
RDEPENDS:rust-ppv-lite86+std-devel = " \
 cargo \
 rust-ppv-lite86-devel \
 "
RDEPENDS:rust-ppv-lite86-devel = " \
 cargo \
 rust \
 rust-zerocopy+default-devel \
 rust-zerocopy+simd-devel \
 "
