# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konversation"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 konversation \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konversation-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df43f9bae53fc59e4f445917718dcc13a0c9ad1b02c8c2ce960bd5199ae0be15"

URI_x86_64_v2_konversation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konversation-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konversation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konversation}"
SRC_URI[x86_64_v2_konversation.sha256sum] = "fc8ee6cec78d57be525cb696293b862b605d536f20df6ca7ab7608b0fb8fd656"

URI_aarch64_konversation = "${EPEL_MIRROR}/aarch64/Packages/k/konversation-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_konversation;unpack=0"
SRC_URI:append = " ${URI_aarch64_konversation}"
SRC_URI[aarch64_konversation.sha256sum] = "55dcfe6ee79082c61d64b7b7f642daf0f14f16d88b0253f79f9ad149dd681d60"

RDEPENDS:konversation = " \
 bash \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 perl-interpreter \
 python3 \
 qca-qt6 \
 qca-qt6-ossl \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
