# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-toml-ng"
PV = "0.7.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-toml-ng+default-devel \
 rust-tree-sitter-toml-ng-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-toml-ng-0.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d45688426f7f6b019d09b8199c07fc19be448afe685241de7311feacd39e59d0"

URI_x86_64_v2_rust-tree-sitter-toml-ng+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-toml-ng+default-devel-0.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-toml-ng+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-toml-ng+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-toml-ng+default-devel.sha256sum] = "7df4212f54b9b6aec070d800a6aa49d5651c7e74259fa9b16cb28bd69e28eac7"

URI_x86_64_v2_rust-tree-sitter-toml-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-toml-ng-devel-0.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-toml-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-toml-ng-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-toml-ng-devel.sha256sum] = "17c40855d3abe87bb499f2114554b541908a9ea8fb3bf5ad2d12203b8d85d25e"

URI_aarch64_rust-tree-sitter-toml-ng+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-toml-ng+default-devel-0.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-toml-ng+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-toml-ng+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-toml-ng+default-devel.sha256sum] = "8b8cc414c7f0eeda91118e1e17e456bb0f1694bee90a4ab878b7f10d6cb11184"

URI_aarch64_rust-tree-sitter-toml-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-toml-ng-devel-0.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-toml-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-toml-ng-devel}"
SRC_URI[aarch64_rust-tree-sitter-toml-ng-devel.sha256sum] = "8ccee73b6133b1d16a9245ea22019dc186b9f41b5c8770bce5f9b6e69f59a9af"

RDEPENDS:rust-tree-sitter-toml-ng+default-devel = " \
 cargo \
 rust-tree-sitter-toml-ng-devel \
 "
RDEPENDS:rust-tree-sitter-toml-ng-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
