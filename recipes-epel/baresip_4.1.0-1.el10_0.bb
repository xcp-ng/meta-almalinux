# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "baresip"
PV = "4.1.0"
PR = "1.el10_0"
PACKAGES = " \
 baresip \
 baresip-aac \
 baresip-alsa \
 baresip-av1 \
 baresip-avcodec \
 baresip-avfilter \
 baresip-avformat \
 baresip-codec2 \
 baresip-ctrl_dbus \
 baresip-devel \
 baresip-g722 \
 baresip-g726 \
 baresip-gst \
 baresip-gtk \
 baresip-jack \
 baresip-mpa \
 baresip-mqtt \
 baresip-opus \
 baresip-pipewire \
 baresip-plc \
 baresip-portaudio \
 baresip-pulse \
 baresip-sdl \
 baresip-snapshot \
 baresip-sndfile \
 baresip-swscale \
 baresip-tools \
 baresip-v4l2 \
 baresip-vp8 \
 baresip-vp9 \
 baresip-x11 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/baresip-4.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc4fd6ce53481ad9a1c181b7c0957531d236a02974005b08143ece2a28533833"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - baresip-avcodec: libavcodec.so.61()(64bit)
# - baresip-avcodec: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - baresip-avcodec: libavutil.so.59()(64bit)
# - baresip-avcodec: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - baresip-avfilter: libavfilter.so.10()(64bit)
# - baresip-avfilter: libavfilter.so.10(LIBAVFILTER_10)(64bit)
# - baresip-avfilter: libavutil.so.59()(64bit)
# - baresip-avfilter: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - baresip-avformat: libavcodec.so.61()(64bit)
# - baresip-avformat: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - baresip-avformat: libavdevice.so.61()(64bit)
# - baresip-avformat: libavdevice.so.61(LIBAVDEVICE_61)(64bit)
# - baresip-avformat: libavformat.so.61()(64bit)
# - baresip-avformat: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - baresip-avformat: libavutil.so.59()(64bit)
# - baresip-avformat: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - baresip-avformat: libswresample.so.5()(64bit)
# - baresip-avformat: libswresample.so.5(LIBSWRESAMPLE_5)(64bit)
# - baresip-swscale: libswscale.so.8()(64bit)
# - baresip-swscale: libswscale.so.8(LIBSWSCALE_8)(64bit)

URI_x86_64_v2_baresip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip}"
SRC_URI[x86_64_v2_baresip.sha256sum] = "8575b8678efda85b05b4f031d49820f64ba6414b1ab64810070464bc0d85da3e"

URI_x86_64_v2_baresip-aac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-aac-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-aac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-aac}"
SRC_URI[x86_64_v2_baresip-aac.sha256sum] = "9adc2f1e6b4a29f694c466f58e1204b37ff43c0df24b26cb84e7c9049bb0db9b"

URI_x86_64_v2_baresip-alsa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-alsa-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-alsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-alsa}"
SRC_URI[x86_64_v2_baresip-alsa.sha256sum] = "f1dd4233fbd5938b7e4b99d49a7026d5b91a29b01749d137e156078fe7a8df5c"

URI_x86_64_v2_baresip-av1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-av1-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-av1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-av1}"
SRC_URI[x86_64_v2_baresip-av1.sha256sum] = "b6c35e571d4a5971e85f3391c23c5f7e4b943cb14ba3b660dd4536de9a3ee90e"

URI_x86_64_v2_baresip-avcodec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avcodec-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avcodec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-avcodec}"
SRC_URI[x86_64_v2_baresip-avcodec.sha256sum] = "0aa0b4d9f6fe3fff3e099b22790c8bb2bce61d1fef209a09f3b5f4d88f26ca4d"

URI_x86_64_v2_baresip-avfilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avfilter-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-avfilter}"
SRC_URI[x86_64_v2_baresip-avfilter.sha256sum] = "f2e3baffc3d5cb987d6531abd1792ccdf6000a7622d335989d94af4b39035a28"

URI_x86_64_v2_baresip-avformat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avformat-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avformat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-avformat}"
SRC_URI[x86_64_v2_baresip-avformat.sha256sum] = "c8e2bfb5913cf1f5f0f438b4cfabeecb41dcbb469f9425109d2b7b8f548db67c"

URI_x86_64_v2_baresip-codec2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-codec2-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-codec2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-codec2}"
SRC_URI[x86_64_v2_baresip-codec2.sha256sum] = "2035401ecf21210db66dd166350806a4cc2f9d26dacca52c0f2bc94ad606fba6"

URI_x86_64_v2_baresip-ctrl_dbus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-ctrl_dbus-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-ctrl_dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-ctrl_dbus}"
SRC_URI[x86_64_v2_baresip-ctrl_dbus.sha256sum] = "b53693ad77d4c707a4e9655648b90ac0868d5dca0c8b0deebb05fffd67ef671b"

URI_x86_64_v2_baresip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-devel-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-devel}"
SRC_URI[x86_64_v2_baresip-devel.sha256sum] = "6c1555c73235b1096278d815a087151b49a572b7fd66eba8aad76342307c6443"

URI_x86_64_v2_baresip-g722 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-g722-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-g722;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-g722}"
SRC_URI[x86_64_v2_baresip-g722.sha256sum] = "fcbd57ce8a224e5cc46c10dbb78dfa75cc769150fe5606f05abcdd672a93679a"

URI_x86_64_v2_baresip-g726 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-g726-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-g726;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-g726}"
SRC_URI[x86_64_v2_baresip-g726.sha256sum] = "edf10b3d0052021c6374ceb51b7b89eb7b779b730e1bcbfa758c3ebef4a702a5"

URI_x86_64_v2_baresip-gst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-gst-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-gst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-gst}"
SRC_URI[x86_64_v2_baresip-gst.sha256sum] = "15cbfb4c68b2e14b81e88a0fc2f936e511929afd581c173dc4191a45dbb2713d"

URI_x86_64_v2_baresip-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-gtk-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-gtk}"
SRC_URI[x86_64_v2_baresip-gtk.sha256sum] = "67b0dd275a622deeb34f5425a0f957064be3da1e16404fea2a70df4eb442b945"

URI_x86_64_v2_baresip-jack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-jack-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-jack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-jack}"
SRC_URI[x86_64_v2_baresip-jack.sha256sum] = "945f8636ed7f7c4926976c2a238c0b0562b14ccc06fe73b923c8f2a9adf1de7d"

URI_x86_64_v2_baresip-mpa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-mpa-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-mpa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-mpa}"
SRC_URI[x86_64_v2_baresip-mpa.sha256sum] = "67f8f5ab3f255716a97b7d723c798fe65adf967cd273a2529aebca85bc766cd2"

URI_x86_64_v2_baresip-mqtt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-mqtt-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-mqtt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-mqtt}"
SRC_URI[x86_64_v2_baresip-mqtt.sha256sum] = "5f5661df9eba0696cf6e471b44474913a4a43a5dfcc881e8801ac42e99b8545a"

URI_x86_64_v2_baresip-opus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-opus-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-opus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-opus}"
SRC_URI[x86_64_v2_baresip-opus.sha256sum] = "fb353be0dcca3222150c8d182f0b2f525e40ac61974dac696480f8ec2ac2e538"

URI_x86_64_v2_baresip-pipewire = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-pipewire-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-pipewire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-pipewire}"
SRC_URI[x86_64_v2_baresip-pipewire.sha256sum] = "a69dc0cb448e6be34437c36e0bd79b1883e5ba51b892a862683ad776e9828b39"

URI_x86_64_v2_baresip-plc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-plc-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-plc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-plc}"
SRC_URI[x86_64_v2_baresip-plc.sha256sum] = "cad0af47bb44f2a5fafa3ff68399de2f83e40a91da395dc0f14e9468a95a38b3"

URI_x86_64_v2_baresip-portaudio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-portaudio-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-portaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-portaudio}"
SRC_URI[x86_64_v2_baresip-portaudio.sha256sum] = "b7c95e415a0ee79dbddaf2eeeca2df12373254fea10aabb41ed29905f2fab030"

URI_x86_64_v2_baresip-pulse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-pulse-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-pulse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-pulse}"
SRC_URI[x86_64_v2_baresip-pulse.sha256sum] = "e9e70e9c549c7d0da9a3781ebee16a6b28c4ad912b351d68ee3f5922e4d7e3c0"

URI_x86_64_v2_baresip-sdl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-sdl-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-sdl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-sdl}"
SRC_URI[x86_64_v2_baresip-sdl.sha256sum] = "5998f95c8f4c470acf4f7d4e72b6fc4621498efd439e065db53b6b5cfb5e8982"

URI_x86_64_v2_baresip-snapshot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-snapshot-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-snapshot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-snapshot}"
SRC_URI[x86_64_v2_baresip-snapshot.sha256sum] = "15d50e98526069e23eafe1b31b562fb491a08c329376ef0d46a99c84a4a29cbb"

URI_x86_64_v2_baresip-sndfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-sndfile-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-sndfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-sndfile}"
SRC_URI[x86_64_v2_baresip-sndfile.sha256sum] = "a4862e54e6a981fb0cad63e374c28eb46f6bf3b1955f788fb64345acebd4babf"

URI_x86_64_v2_baresip-swscale = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-swscale-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-swscale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-swscale}"
SRC_URI[x86_64_v2_baresip-swscale.sha256sum] = "860d2cd657db02a11cbf011dd3cf3c06e10d8a66bd3edf850754a6f9287550d9"

URI_x86_64_v2_baresip-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-tools-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-tools}"
SRC_URI[x86_64_v2_baresip-tools.sha256sum] = "931e791b38b46fb2576b0bfa8af239579e717dd9abf21ca9b09671ece8692d8f"

URI_x86_64_v2_baresip-v4l2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-v4l2-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-v4l2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-v4l2}"
SRC_URI[x86_64_v2_baresip-v4l2.sha256sum] = "418684d2be4b12a7505344137df32b55fc6886d7de2ce4740f3ccca04a99505b"

URI_x86_64_v2_baresip-vp8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-vp8-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-vp8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-vp8}"
SRC_URI[x86_64_v2_baresip-vp8.sha256sum] = "6ee9459b660e12c780a18b10170fc7cc33b313aa37b2e84924ee4730aad0531a"

URI_x86_64_v2_baresip-vp9 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-vp9-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-vp9;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-vp9}"
SRC_URI[x86_64_v2_baresip-vp9.sha256sum] = "07b25a336b791c71aab53ba205086a28e257833b4b100d26ab5041a9a28f0d71"

URI_x86_64_v2_baresip-x11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-x11-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-x11}"
SRC_URI[x86_64_v2_baresip-x11.sha256sum] = "c6e387e61715e90ad876aa96d686faf804b4dec0280401e7225e8b97eb7f40df"

URI_aarch64_baresip = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip}"
SRC_URI[aarch64_baresip.sha256sum] = "5c9ba05c96ae114f007957e203a79e8fabfe3f438085ad33fa5bf63444de194c"

URI_aarch64_baresip-aac = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-aac-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-aac;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-aac}"
SRC_URI[aarch64_baresip-aac.sha256sum] = "889b7b7a8983e5faadf46b4e365f4e6969bbb77892a42aaa9722dab9773a6ea2"

URI_aarch64_baresip-alsa = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-alsa-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-alsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-alsa}"
SRC_URI[aarch64_baresip-alsa.sha256sum] = "9952e5d559017b11e2c949f2349794adb064e5694a2c1dc855066c8fc3b01300"

URI_aarch64_baresip-av1 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-av1-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-av1;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-av1}"
SRC_URI[aarch64_baresip-av1.sha256sum] = "30e549045c819385914c1ea1918ef3d709b23849b012b6326ed653cd0abaab21"

URI_aarch64_baresip-avcodec = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-avcodec-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-avcodec;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-avcodec}"
SRC_URI[aarch64_baresip-avcodec.sha256sum] = "47478b1c5acb9ab15e8cfffab59c48ccb63abf0ae21ff653aa1c30ce25dbac83"

URI_aarch64_baresip-avfilter = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-avfilter-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-avfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-avfilter}"
SRC_URI[aarch64_baresip-avfilter.sha256sum] = "f91921858068a8ae42020b3ad72b72c2d1cca4908efca8ed0ed8f6b448e5d2fb"

URI_aarch64_baresip-avformat = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-avformat-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-avformat;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-avformat}"
SRC_URI[aarch64_baresip-avformat.sha256sum] = "99d98eb5fe68f971403020099b84375318d0047cdd9c81c18e568ae1193d8797"

URI_aarch64_baresip-codec2 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-codec2-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-codec2;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-codec2}"
SRC_URI[aarch64_baresip-codec2.sha256sum] = "5ae12bbabb6ebc1da9538159d8865dd4fbc2120dd5d778f6432995340505462b"

URI_aarch64_baresip-ctrl_dbus = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-ctrl_dbus-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-ctrl_dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-ctrl_dbus}"
SRC_URI[aarch64_baresip-ctrl_dbus.sha256sum] = "cf9372a28257c7d897a4e1c9cb3f2b66e1bab7cf0f4a789059e44814d658a581"

URI_aarch64_baresip-devel = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-devel-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-devel}"
SRC_URI[aarch64_baresip-devel.sha256sum] = "a86007a1ea48df954c6f6f342c093c906fe45d5b0df3ebda6b473c552729dadf"

URI_aarch64_baresip-g722 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-g722-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-g722;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-g722}"
SRC_URI[aarch64_baresip-g722.sha256sum] = "581c54e24110546c7286fab13cef5923ab5ae6a27a880b59d59a26fd7b09cb4b"

URI_aarch64_baresip-g726 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-g726-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-g726;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-g726}"
SRC_URI[aarch64_baresip-g726.sha256sum] = "04aac7b8afb21d33022c53c5fe589912be8e41306c47f119def2bfc4848f3af7"

URI_aarch64_baresip-gst = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-gst-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-gst;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-gst}"
SRC_URI[aarch64_baresip-gst.sha256sum] = "3f47b28a099d379d406637fdb9ea45f1a9c7e51bc6c48c7413ef54b50bf7fc4e"

URI_aarch64_baresip-gtk = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-gtk-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-gtk}"
SRC_URI[aarch64_baresip-gtk.sha256sum] = "13dfec9f53a689d3a926d28b76e74835747cd113b9c780b9f409cbd4943f8757"

URI_aarch64_baresip-jack = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-jack-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-jack;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-jack}"
SRC_URI[aarch64_baresip-jack.sha256sum] = "acc4e3445a87a6215e9b5ffaa3c26b0f16b4043077aa23b99ab10f53e8ace535"

URI_aarch64_baresip-mpa = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-mpa-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-mpa;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-mpa}"
SRC_URI[aarch64_baresip-mpa.sha256sum] = "4f32ec88e85de5e87b250afbbc01caf60eaa5ee9d5f8a74192e1e61993918e82"

URI_aarch64_baresip-mqtt = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-mqtt-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-mqtt;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-mqtt}"
SRC_URI[aarch64_baresip-mqtt.sha256sum] = "8d97b520fd4822fd94ece2e21204492650fb1b173db7e103fc693dc6809a91be"

URI_aarch64_baresip-opus = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-opus-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-opus;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-opus}"
SRC_URI[aarch64_baresip-opus.sha256sum] = "1ce090741bccaf885d1f72fe5163384c1c4a6a6745b3595f15889ba6a974bd13"

URI_aarch64_baresip-pipewire = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-pipewire-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-pipewire;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-pipewire}"
SRC_URI[aarch64_baresip-pipewire.sha256sum] = "7348c21d434358d97e41761fa5e1bf5f77c3ebd91ae2eef62534f5c8bc20b43b"

URI_aarch64_baresip-plc = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-plc-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-plc;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-plc}"
SRC_URI[aarch64_baresip-plc.sha256sum] = "6381d75ffb923bcebcd6a5d0a1f7ea839cc4125f51bdb94135ec0ef381ca7325"

URI_aarch64_baresip-portaudio = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-portaudio-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-portaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-portaudio}"
SRC_URI[aarch64_baresip-portaudio.sha256sum] = "9ce56448d5b1e7066a033598a7b9e59e7c21c61a916d3f48dd795abf3fe0b046"

URI_aarch64_baresip-pulse = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-pulse-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-pulse;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-pulse}"
SRC_URI[aarch64_baresip-pulse.sha256sum] = "479e392dc5502e6788cd22aac0347ee4e8241e3fbee52b958491caea88d7ea88"

URI_aarch64_baresip-sdl = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-sdl-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-sdl;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-sdl}"
SRC_URI[aarch64_baresip-sdl.sha256sum] = "10cd5fc7c8627ba95c79cd0fb72c396ade35c244440526815b93fe19f1b81dbc"

URI_aarch64_baresip-snapshot = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-snapshot-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-snapshot;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-snapshot}"
SRC_URI[aarch64_baresip-snapshot.sha256sum] = "70e2a05b0227599f0e1b015e7988e5168936f9b8daacd3f6d05d96dfe95783a4"

URI_aarch64_baresip-sndfile = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-sndfile-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-sndfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-sndfile}"
SRC_URI[aarch64_baresip-sndfile.sha256sum] = "5e4d4f73fc28925b82284145a301a8b322ed44f63da2988a59421e6e479b3d9e"

URI_aarch64_baresip-swscale = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-swscale-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-swscale;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-swscale}"
SRC_URI[aarch64_baresip-swscale.sha256sum] = "dc31b7dc0f8894f2f732d8dded07474c904f2c77bdffcb3ff0ff4ec43f74585c"

URI_aarch64_baresip-tools = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-tools-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-tools}"
SRC_URI[aarch64_baresip-tools.sha256sum] = "c7cc94f3d3714d823ebef9eeab3dcb31646a53ab13ae66f5eed7906c81a4fdb9"

URI_aarch64_baresip-v4l2 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-v4l2-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-v4l2;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-v4l2}"
SRC_URI[aarch64_baresip-v4l2.sha256sum] = "fa330d77fc13f8cc404869be8689fc17185e81d461108ae048095e947e5daaa2"

URI_aarch64_baresip-vp8 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-vp8-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-vp8;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-vp8}"
SRC_URI[aarch64_baresip-vp8.sha256sum] = "603a907fc797bff4e5da7a103c2df041d375ac1ce4a7195ced8ecb75b59da970"

URI_aarch64_baresip-vp9 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-vp9-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-vp9;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-vp9}"
SRC_URI[aarch64_baresip-vp9.sha256sum] = "73388113013c00646aada2c330218a531c3c858d7daab8ca441d33ea1ce0106c"

URI_aarch64_baresip-x11 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-x11-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_baresip-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-x11}"
SRC_URI[aarch64_baresip-x11.sha256sum] = "369f60a625474669fb162ab84b56126f72814d4235136819c42a84ed9be1317a"

RDEPENDS:baresip = " \
 glibc \
 libre \
 "
RDEPENDS:baresip-aac = " \
 baresip \
 fdk-aac-free \
 glibc \
 "
RDEPENDS:baresip-alsa = " \
 alsa-lib \
 baresip \
 glibc \
 "
RDEPENDS:baresip-av1 = " \
 baresip \
 glibc \
 libaom \
 "
RDEPENDS:baresip-avcodec:x86_64_v2 = " \
 baresip \
 glibc \
"
RDEPENDS:baresip-avcodec:aarch64 = " \
 baresip \
 glibc \
 libavcodec-free \
 libavutil-free \
"
RDEPENDS:baresip-avfilter:x86_64_v2 = " \
 baresip \
 glibc \
"
RDEPENDS:baresip-avfilter:aarch64 = " \
 baresip \
 glibc \
 libavfilter-free \
 libavutil-free \
"
RDEPENDS:baresip-avformat:x86_64_v2 = " \
 baresip \
 glibc \
"
RDEPENDS:baresip-avformat:aarch64 = " \
 baresip \
 glibc \
 libavcodec-free \
 libavdevice-free \
 libavformat-free \
 libavutil-free \
 libswresample-free \
"
RDEPENDS:baresip-codec2 = " \
 baresip \
 codec2 \
 glibc \
 "
RDEPENDS:baresip-ctrl_dbus = " \
 baresip \
 glib2 \
 glibc \
 "
RDEPENDS:baresip-devel = " \
 baresip \
 pkgconf-pkg-config \
 "
RDEPENDS:baresip-g722 = " \
 baresip \
 glibc \
 spandsp \
 "
RDEPENDS:baresip-g726 = " \
 baresip \
 glibc \
 spandsp \
 "
RDEPENDS:baresip-gst = " \
 baresip \
 glib2 \
 glibc \
 gstreamer1 \
 "
RDEPENDS:baresip-gtk = " \
 adwaita-icon-theme \
 baresip \
 glib2 \
 glibc \
 gnome-shell-extension-appindicator \
 gtk3 \
 "
RDEPENDS:baresip-jack = " \
 baresip \
 glibc \
 pipewire-jack-audio-connection-kit-libs \
 "
RDEPENDS:baresip-mpa = " \
 baresip \
 glibc \
 lame-libs \
 mpg123-libs \
 speexdsp \
 twolame-libs \
 "
RDEPENDS:baresip-mqtt = " \
 baresip \
 glibc \
 mosquitto \
 "
RDEPENDS:baresip-opus = " \
 baresip \
 glibc \
 opus \
 "
RDEPENDS:baresip-pipewire = " \
 baresip \
 glibc \
 pipewire-libs \
 "
RDEPENDS:baresip-plc = " \
 baresip \
 glibc \
 spandsp \
 "
RDEPENDS:baresip-portaudio = " \
 baresip \
 glibc \
 portaudio \
 "
RDEPENDS:baresip-pulse = " \
 baresip \
 glibc \
 pulseaudio-libs \
 "
RDEPENDS:baresip-sdl = " \
 baresip \
 glibc \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:baresip-snapshot = " \
 baresip \
 glibc \
 libpng \
 "
RDEPENDS:baresip-sndfile = " \
 baresip \
 glibc \
 libsndfile \
 "
RDEPENDS:baresip-swscale:x86_64_v2 = " \
 baresip \
 glibc \
"
RDEPENDS:baresip-swscale:aarch64 = " \
 baresip \
 glibc \
 libswscale-free \
"
RDEPENDS:baresip-tools = " \
 baresip \
 python3 \
 "
RDEPENDS:baresip-v4l2 = " \
 baresip \
 glibc \
 "
RDEPENDS:baresip-vp8 = " \
 baresip \
 glibc \
 libvpx \
 "
RDEPENDS:baresip-vp9 = " \
 baresip \
 glibc \
 libvpx \
 "
RDEPENDS:baresip-x11 = " \
 baresip \
 glibc \
 libX11 \
 libXext \
 "
