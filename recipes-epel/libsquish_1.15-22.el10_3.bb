# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsquish"
PV = "1.15"
PR = "22.el10_3"
PACKAGES = " \
 libsquish \
 libsquish-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libsquish-1.15-22.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6cd2366cb063beb3c4d5a93178448872b95021fdbc56b35251682dd2165ecb5"

URI_x86_64_v2_libsquish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsquish-1.15-22.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsquish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsquish}"
SRC_URI[x86_64_v2_libsquish.sha256sum] = "b3046500f9f385ce97500722c298b45ccb95c4dbdf656fd12f5015d792114939"

URI_x86_64_v2_libsquish-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsquish-devel-1.15-22.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsquish-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsquish-devel}"
SRC_URI[x86_64_v2_libsquish-devel.sha256sum] = "afc08b5276ae357b0b0e70af19cf40b5600139c7d5042742faff3c5c25ed1818"

URI_aarch64_libsquish = "${EPEL_MIRROR}/aarch64/Packages/l/libsquish-1.15-22.el10_3.aarch64.rpm;name=aarch64_libsquish;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsquish}"
SRC_URI[aarch64_libsquish.sha256sum] = "e82762079dcb11dd8495f0b887cd274f24e9206f34544932fd90d88f266887a7"

URI_aarch64_libsquish-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libsquish-devel-1.15-22.el10_3.aarch64.rpm;name=aarch64_libsquish-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsquish-devel}"
SRC_URI[aarch64_libsquish-devel.sha256sum] = "74c5d3c2090971782e29179f990a029b15b6066209900b1ed88924684b8faede"

RDEPENDS:libsquish = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 "
RDEPENDS:libsquish-devel = " \
 libsquish \
 "
