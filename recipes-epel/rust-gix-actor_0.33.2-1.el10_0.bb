# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-actor"
PV = "0.33.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-actor+default-devel \
 rust-gix-actor+document-features-devel \
 rust-gix-actor+serde-devel \
 rust-gix-actor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-actor-0.33.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca97cb9a6cc2049d17265c3e392adf988ca90cd15a3883d5fd1614356598eb2e"

URI_x86_64_v2_rust-gix-actor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor+default-devel-0.33.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor+default-devel}"
SRC_URI[x86_64_v2_rust-gix-actor+default-devel.sha256sum] = "be31144184baa451a0a3f34d491a62612044ad82cffa82ef90adc931c2ae961a"

URI_x86_64_v2_rust-gix-actor+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor+document-features-devel-0.33.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-actor+document-features-devel.sha256sum] = "61dccf1e2d65aeabbbcb96a422268831b2536bc4d06a6645d6d4ae9f15dd2d74"

URI_x86_64_v2_rust-gix-actor+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor+serde-devel-0.33.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-actor+serde-devel.sha256sum] = "eb116dc1e126361f93adfa2ac65962af3bbe04ac545d17b3bd7dc820cbb00936"

URI_x86_64_v2_rust-gix-actor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor-devel-0.33.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor-devel}"
SRC_URI[x86_64_v2_rust-gix-actor-devel.sha256sum] = "a1e42079fbfe13ee09897e2136d1f4313d21836e3b353b0633850f81c647463e"

URI_aarch64_rust-gix-actor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor+default-devel-0.33.2-1.el10_0.noarch.rpm;name=aarch64_rust-gix-actor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor+default-devel}"
SRC_URI[aarch64_rust-gix-actor+default-devel.sha256sum] = "a72f41bae825d62fee6a7dd9b29b35d6c7d869b3dd2f8961eeeecefa365a5207"

URI_aarch64_rust-gix-actor+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor+document-features-devel-0.33.2-1.el10_0.noarch.rpm;name=aarch64_rust-gix-actor+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor+document-features-devel}"
SRC_URI[aarch64_rust-gix-actor+document-features-devel.sha256sum] = "2fd75a56944541c6f819b30e7a6598dfdf3df54c863a268880664b33bba69438"

URI_aarch64_rust-gix-actor+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor+serde-devel-0.33.2-1.el10_0.noarch.rpm;name=aarch64_rust-gix-actor+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor+serde-devel}"
SRC_URI[aarch64_rust-gix-actor+serde-devel.sha256sum] = "5e21b7c4690e82a110cfebb143125d776ac6199a11e9e44a869e5944571d3124"

URI_aarch64_rust-gix-actor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor-devel-0.33.2-1.el10_0.noarch.rpm;name=aarch64_rust-gix-actor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor-devel}"
SRC_URI[aarch64_rust-gix-actor-devel.sha256sum] = "38a9afc4cee5d999c0b0305745ddf5bcccb85269219d470d7efbfe4b4900e7b7"

RDEPENDS:rust-gix-actor+default-devel = " \
 cargo \
 rust-gix-actor-devel \
 "
RDEPENDS:rust-gix-actor+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-actor-devel \
 "
RDEPENDS:rust-gix-actor+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-actor-devel \
 rust-gix-date+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-actor-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-date+default-devel \
 rust-gix-utils+default-devel \
 rust-itoa+default-devel \
 rust-thiserror+default-devel \
 rust-winnow0.6+default-devel \
 rust-winnow0.6+simd-devel \
 "
