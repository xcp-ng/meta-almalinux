# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zvariant_derive"
PV = "5.8.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-zvariant_derive+default-devel \
 rust-zvariant_derive+gvariant-devel \
 rust-zvariant_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zvariant_derive-5.8.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b76e079b7b63123b9a2a7286e22f968f1b5aefc987acb9b3731752a11a0d5c06"

URI_x86_64_v2_rust-zvariant_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_derive+default-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_derive+default-devel}"
SRC_URI[x86_64_v2_rust-zvariant_derive+default-devel.sha256sum] = "f5dcc311dc657d89824e54a757cc3774e27184da5df82a677510be8bb77d0b46"

URI_x86_64_v2_rust-zvariant_derive+gvariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_derive+gvariant-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_derive+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_derive+gvariant-devel}"
SRC_URI[x86_64_v2_rust-zvariant_derive+gvariant-devel.sha256sum] = "9019e41879ed536099ca6cf997d7cedfa79331f92cbdcf42e0f33a6b04469bbd"

URI_x86_64_v2_rust-zvariant_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_derive-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_derive-devel}"
SRC_URI[x86_64_v2_rust-zvariant_derive-devel.sha256sum] = "d3439d272c7ef1b7af028a371a143188538c9a2f51e00ba17efab382a4b51d9b"

URI_aarch64_rust-zvariant_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_derive+default-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_derive+default-devel}"
SRC_URI[aarch64_rust-zvariant_derive+default-devel.sha256sum] = "c929ca382fa79e1f5bc85a3d90a8bac6805d1fe3e304d6b506af002246a2db94"

URI_aarch64_rust-zvariant_derive+gvariant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_derive+gvariant-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant_derive+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_derive+gvariant-devel}"
SRC_URI[aarch64_rust-zvariant_derive+gvariant-devel.sha256sum] = "9c1c1b8c72c6801d83d6723b5f182354d6c63a0073335ff4d7d0c12e05ff6d2e"

URI_aarch64_rust-zvariant_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_derive-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_derive-devel}"
SRC_URI[aarch64_rust-zvariant_derive-devel.sha256sum] = "e09f6b166559349d7e2ba4bcae76d0934cd47c265082893b729acf7aebdba5d7"

RDEPENDS:rust-zvariant_derive+default-devel = " \
 cargo \
 rust-zvariant_derive-devel \
 "
RDEPENDS:rust-zvariant_derive+gvariant-devel = " \
 cargo \
 rust-zvariant_derive-devel \
 rust-zvariant_utils+gvariant-devel \
 "
RDEPENDS:rust-zvariant_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro-crate+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-zvariant_utils+default-devel \
 "
