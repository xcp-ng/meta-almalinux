# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdsingleapplication"
PV = "1.1.0"
PR = "11.el10_1"
PACKAGES = " \
 kdsingleapplication-qt6 \
 kdsingleapplication-qt6-devel \
 kdsingleapplication-qt6-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdsingleapplication-1.1.0-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83b356874a3905b288b737a3e0fcf514b7fd265c132cfead9b17d61224048d7f"

URI_x86_64_v2_kdsingleapplication-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdsingleapplication-qt6-1.1.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdsingleapplication-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdsingleapplication-qt6}"
SRC_URI[x86_64_v2_kdsingleapplication-qt6.sha256sum] = "d4120cf8afed7a2c6a68c1c4ba6967482f20b5f226da402ae1dff06e3043ee20"

URI_x86_64_v2_kdsingleapplication-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdsingleapplication-qt6-devel-1.1.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdsingleapplication-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdsingleapplication-qt6-devel}"
SRC_URI[x86_64_v2_kdsingleapplication-qt6-devel.sha256sum] = "178711c3a89e0548f3461472b7ec9efc822380dc1bc2d1dc3f2c7727ae42a1da"

URI_x86_64_v2_kdsingleapplication-qt6-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdsingleapplication-qt6-doc-1.1.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kdsingleapplication-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdsingleapplication-qt6-doc}"
SRC_URI[x86_64_v2_kdsingleapplication-qt6-doc.sha256sum] = "d11c367e5c4473b02bd1d5c3417789ef66eddd72c0c24b7021866803c651513f"

URI_aarch64_kdsingleapplication-qt6 = "${EPEL_MIRROR}/aarch64/Packages/k/kdsingleapplication-qt6-1.1.0-11.el10_1.aarch64.rpm;name=aarch64_kdsingleapplication-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdsingleapplication-qt6}"
SRC_URI[aarch64_kdsingleapplication-qt6.sha256sum] = "3ba025136ef997a5f78f1757b0550b270ea4a4186f1837c933c218b4aee8f159"

URI_aarch64_kdsingleapplication-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdsingleapplication-qt6-devel-1.1.0-11.el10_1.aarch64.rpm;name=aarch64_kdsingleapplication-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdsingleapplication-qt6-devel}"
SRC_URI[aarch64_kdsingleapplication-qt6-devel.sha256sum] = "51861dbddb85ba9fdc01e2cf612a96cb673abf389e3dacec90dcbfb633227244"

URI_aarch64_kdsingleapplication-qt6-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kdsingleapplication-qt6-doc-1.1.0-11.el10_1.noarch.rpm;name=aarch64_kdsingleapplication-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdsingleapplication-qt6-doc}"
SRC_URI[aarch64_kdsingleapplication-qt6-doc.sha256sum] = "b24fead43be613a346721f788c411e74193160250ab743fd8c0c794bc7200418"

RDEPENDS:kdsingleapplication-qt6 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kdsingleapplication-qt6-devel = " \
 cmake-filesystem \
 kdsingleapplication-qt6 \
 qt6-qtbase-devel \
 "
RDEPENDS:kdsingleapplication-qt6-doc = " \
 "
