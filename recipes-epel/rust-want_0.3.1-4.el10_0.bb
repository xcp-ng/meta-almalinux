# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-want"
PV = "0.3.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-want+default-devel \
 rust-want-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-want-0.3.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "380cd62f8e2e63f2983da64a9d9f803baf064ff743269accc49b8052f5529f52"

URI_x86_64_v2_rust-want+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-want+default-devel-0.3.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-want+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-want+default-devel}"
SRC_URI[x86_64_v2_rust-want+default-devel.sha256sum] = "068230f443141099c8a8df84873d4c8e43bad6a194b5ff7ffcbed584c5d4db73"

URI_x86_64_v2_rust-want-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-want-devel-0.3.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-want-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-want-devel}"
SRC_URI[x86_64_v2_rust-want-devel.sha256sum] = "59be53d1c3bb03e45ee78b99c1bf5008a7b4fa060ebd971775682e33b65bbb8f"

URI_aarch64_rust-want+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-want+default-devel-0.3.1-4.el10_0.noarch.rpm;name=aarch64_rust-want+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-want+default-devel}"
SRC_URI[aarch64_rust-want+default-devel.sha256sum] = "d4067577504e61eb5c45941b86fd4b832fa04f79a138ca3cc6f3ded0827026a5"

URI_aarch64_rust-want-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-want-devel-0.3.1-4.el10_0.noarch.rpm;name=aarch64_rust-want-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-want-devel}"
SRC_URI[aarch64_rust-want-devel.sha256sum] = "41aa4aa874bde3369f7c1f78741df9fc0cf7d2f5ed9b0a6ad88ab29dc4b53ffb"

RDEPENDS:rust-want+default-devel = " \
 cargo \
 rust-want-devel \
 "
RDEPENDS:rust-want-devel = " \
 cargo \
 rust-try-lock+default-devel \
 "
