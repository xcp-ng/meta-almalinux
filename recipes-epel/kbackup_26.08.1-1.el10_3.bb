# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbackup"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kbackup \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kbackup-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d1b2204f503ce982e0b6af5ae8320ae50bd8e77c13ea09526ebd5c876904d06"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbackup-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbackup;unpack=0"
SRC_URI[x86_64_v2_kbackup.sha256sum] = "bb42b5c9c063e6d8a421ed6d9beb2f73855ada1a5c4ca2eb78efa693adf63816"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kbackup-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kbackup;unpack=0"
SRC_URI[aarch64_kbackup.sha256sum] = "c9cf5b7ae5a75859074658332d1e05e90c1cc788c120e0a22bb2630e76bdf0d7"

RDEPENDS:kbackup = " \
 glibc \
 hicolor-icon-theme \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libarchive \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
