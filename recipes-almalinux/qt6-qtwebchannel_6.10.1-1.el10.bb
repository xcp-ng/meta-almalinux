# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwebchannel"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtwebchannel \
 qt6-qtwebchannel-devel \
 qt6-qtwebchannel-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtwebchannel-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7838e955bbba70a886f13dfdbe68fe9e4077dd10b80d2a6c7e480f8c9a252b67"

URI_x86_64_v2_qt6-qtwebchannel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwebchannel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebchannel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebchannel}"
SRC_URI[x86_64_v2_qt6-qtwebchannel.sha256sum] = "37da7731a324ffa2e731bf4e598b3db9460a14275057e37a85191cb1d2dea9ef"

URI_x86_64_v2_qt6-qtwebchannel-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwebchannel-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebchannel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebchannel-devel}"
SRC_URI[x86_64_v2_qt6-qtwebchannel-devel.sha256sum] = "ae459c7b0d17f6bd25c76f1571f08e245aade1ed0265f11e1a2463edc13ab75d"

URI_x86_64_v2_qt6-qtwebchannel-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtwebchannel-examples-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebchannel-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebchannel-examples}"
SRC_URI[x86_64_v2_qt6-qtwebchannel-examples.sha256sum] = "659de8ac209ccb881d6dccce418cc0240fe223fd337cc6012f91974640fe0cbe"

URI_aarch64_qt6-qtwebchannel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwebchannel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtwebchannel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebchannel}"
SRC_URI[aarch64_qt6-qtwebchannel.sha256sum] = "7fc53c13c4c32ad69d9c849724b0dbde2312e15d30db27f98af6d064fa2984ed"

URI_aarch64_qt6-qtwebchannel-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwebchannel-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtwebchannel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebchannel-devel}"
SRC_URI[aarch64_qt6-qtwebchannel-devel.sha256sum] = "b08773c18125f87e24d2afb76a08326173a9548d6193490254e10034eab8548d"

URI_aarch64_qt6-qtwebchannel-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtwebchannel-examples-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtwebchannel-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebchannel-examples}"
SRC_URI[aarch64_qt6-qtwebchannel-examples.sha256sum] = "0aa51225cefd0651f3902f1649bac20f4f94eb7a045db65c6f2c3b3a3ddd04d4"

RDEPENDS:qt6-qtwebchannel = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtwebchannel-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtwebchannel \
 "
RDEPENDS:qt6-qtwebchannel-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebchannel \
 qt6-qtwebsockets \
 "
