# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_edit"
PV = "0.25.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-toml_edit+debug-devel \
 rust-toml_edit+default-devel \
 rust-toml_edit+display-devel \
 rust-toml_edit+parse-devel \
 rust-toml_edit+serde-devel \
 rust-toml_edit+unbounded-devel \
 rust-toml_edit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_edit-0.25.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf7efa2e441d86596fc10829f8e084dfcfd0323deeecebe685e1f3d9d5f6a101"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-toml_edit+debug-devel: (crate(toml_parser/debug) >= 1.1.2 with crate(toml_parser/debug) < 2.0.0~)
# - rust-toml_edit+debug-devel: (crate(toml_parser/default) >= 1.1.2 with crate(toml_parser/default) < 2.0.0~)
# - rust-toml_edit+parse-devel: (crate(toml_parser/default) >= 1.1.2 with crate(toml_parser/default) < 2.0.0~)

URI_x86_64_v2_rust-toml_edit+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+debug-devel-0.25.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+debug-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+debug-devel.sha256sum] = "d2349a06f931d9d3e080d3276c901a49f8278c0ef284266a332178cbcb2ee25d"

URI_x86_64_v2_rust-toml_edit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+default-devel-0.25.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+default-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+default-devel.sha256sum] = "4ef6624700734d842bd457c385b2dea4ae539bac54998517370c89971dc42bf0"

URI_x86_64_v2_rust-toml_edit+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+display-devel-0.25.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+display-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+display-devel.sha256sum] = "199c96bfa0dbdcfe4afb0b90fb8b2582f3d570afa2b18faeb9452213d69f41a7"

URI_x86_64_v2_rust-toml_edit+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+parse-devel-0.25.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+parse-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+parse-devel.sha256sum] = "1f3ed309cc1a9c9097a062a837e063d941482350f2536198996c8249d9aa0ca5"

URI_x86_64_v2_rust-toml_edit+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+serde-devel-0.25.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+serde-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+serde-devel.sha256sum] = "51559ec8c1860182390ce3ebb7d3792781d4c600b95c4768619f1a4cd7d805d9"

URI_x86_64_v2_rust-toml_edit+unbounded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+unbounded-devel-0.25.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+unbounded-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+unbounded-devel.sha256sum] = "f5b953ffa3980da86a17fdd715802fe288e12015b802648d73afe6255251f85b"

URI_x86_64_v2_rust-toml_edit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit-devel-0.25.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit-devel}"
SRC_URI[x86_64_v2_rust-toml_edit-devel.sha256sum] = "f2f60aa4260d3fb87571e07ff4fd4346afcf2f227f32000e9ebeb4440a9181a5"

URI_aarch64_rust-toml_edit+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+debug-devel-0.25.13-1.el10_3.noarch.rpm;name=aarch64_rust-toml_edit+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+debug-devel}"
SRC_URI[aarch64_rust-toml_edit+debug-devel.sha256sum] = "36bac384bfb629053fc3a40373fbf99cf2940e54442e93c15f52bc80a10868f6"

URI_aarch64_rust-toml_edit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+default-devel-0.25.13-1.el10_3.noarch.rpm;name=aarch64_rust-toml_edit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+default-devel}"
SRC_URI[aarch64_rust-toml_edit+default-devel.sha256sum] = "482ce62bd62277b8992b8828e9913f4f720013b8cc21da96f00fdf1863123d4d"

URI_aarch64_rust-toml_edit+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+display-devel-0.25.13-1.el10_3.noarch.rpm;name=aarch64_rust-toml_edit+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+display-devel}"
SRC_URI[aarch64_rust-toml_edit+display-devel.sha256sum] = "96d134c8bd7b503c97e50d273a84c947cf1c22fbd44d6b1ee8ffc2e321bb871a"

URI_aarch64_rust-toml_edit+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+parse-devel-0.25.13-1.el10_3.noarch.rpm;name=aarch64_rust-toml_edit+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+parse-devel}"
SRC_URI[aarch64_rust-toml_edit+parse-devel.sha256sum] = "688cd9729a451a78852c6320bc58f8900f1ad623635c1b18f5a4475882a432bb"

URI_aarch64_rust-toml_edit+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+serde-devel-0.25.13-1.el10_3.noarch.rpm;name=aarch64_rust-toml_edit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+serde-devel}"
SRC_URI[aarch64_rust-toml_edit+serde-devel.sha256sum] = "12faad38330a37b0b0a33b3a0eb07d0cea73b63933a42e1fbd33dded8d34f611"

URI_aarch64_rust-toml_edit+unbounded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+unbounded-devel-0.25.13-1.el10_3.noarch.rpm;name=aarch64_rust-toml_edit+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+unbounded-devel}"
SRC_URI[aarch64_rust-toml_edit+unbounded-devel.sha256sum] = "2fe11626e42450bdff7452dfb9785c31c9bc407f3bd02f163341f8fb4430c1b0"

URI_aarch64_rust-toml_edit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit-devel-0.25.13-1.el10_3.noarch.rpm;name=aarch64_rust-toml_edit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit-devel}"
SRC_URI[aarch64_rust-toml_edit-devel.sha256sum] = "2a5ce936f5acbf46096a05b9b2987d214b282d38799895fa19a6f68f43a351aa"

RDEPENDS:rust-toml_edit+debug-devel:x86_64_v2 = " \
 cargo \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-toml_edit+display-devel \
 rust-toml_edit-devel \
"
RDEPENDS:rust-toml_edit+debug-devel:aarch64 = " \
 cargo \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-toml_edit+display-devel \
 rust-toml_edit-devel \
 rust-toml_parser+debug-devel \
 rust-toml_parser+default-devel \
"
RDEPENDS:rust-toml_edit+default-devel = " \
 cargo \
 rust-toml_edit+display-devel \
 rust-toml_edit+parse-devel \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit+display-devel = " \
 cargo \
 rust-toml_edit-devel \
 rust-toml_writer+default-devel \
 "
RDEPENDS:rust-toml_edit+parse-devel:x86_64_v2 = " \
 cargo \
 rust-toml_edit-devel \
 rust-winnow+default-devel \
"
RDEPENDS:rust-toml_edit+parse-devel:aarch64 = " \
 cargo \
 rust-toml_edit-devel \
 rust-toml_parser+default-devel \
 rust-winnow+default-devel \
"
RDEPENDS:rust-toml_edit+serde-devel = " \
 cargo \
 rust-serde_core+default-devel \
 rust-serde_spanned+default-devel \
 rust-serde_spanned+serde-devel \
 rust-toml_datetime+serde-devel \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit+unbounded-devel = " \
 cargo \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-indexmap+std-devel \
 rust-toml_datetime+default-devel \
 "
