# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Import-Into"
PV = "1.002005"
PR = "29.el10"
PACKAGES = " \
 perl-Import-Into \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Import-Into-1.002005-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1211e39d80839c2bbcb43c6a16b6432d72969df68d1aae1ad6f5b9d76aa99daf"

URI_x86_64_v2_perl-Import-Into = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Import-Into-1.002005-29.el10.noarch.rpm;name=x86_64_v2_perl-Import-Into;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Import-Into}"
SRC_URI[x86_64_v2_perl-Import-Into.sha256sum] = "801d29f85085efbd9b8db8734a15b8568f37aae1d83422db1431398a7404cbbe"

URI_aarch64_perl-Import-Into = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Import-Into-1.002005-29.el10.noarch.rpm;name=aarch64_perl-Import-Into;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Import-Into}"
SRC_URI[aarch64_perl-Import-Into.sha256sum] = "801d29f85085efbd9b8db8734a15b8568f37aae1d83422db1431398a7404cbbe"

RDEPENDS:perl-Import-Into = " \
 perl-Module-Runtime \
 perl-libs \
 "
