# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unibilium"
PV = "2.1.1"
PR = "7.el10_0"
PACKAGES = " \
 unibilium \
 unibilium-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/unibilium-2.1.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aeaa1fd34202765b8a7d5ad65959dbd122ba85c8cca8872d03306dd0b48930a5"

URI_x86_64_v2_unibilium = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unibilium-2.1.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unibilium;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unibilium}"
SRC_URI[x86_64_v2_unibilium.sha256sum] = "9c1b3996b8a7a53776f40a00b4a5694423f8a5b3562abe29a2124c0e699f9eb5"

URI_x86_64_v2_unibilium-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unibilium-devel-2.1.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unibilium-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unibilium-devel}"
SRC_URI[x86_64_v2_unibilium-devel.sha256sum] = "837f2465ae389b9863ee160ad20feed1c26644f810b2947d456e4485d398987f"

URI_aarch64_unibilium = "${EPEL_MIRROR}/aarch64/Packages/u/unibilium-2.1.1-7.el10_0.aarch64.rpm;name=aarch64_unibilium;unpack=0"
SRC_URI:append = " ${URI_aarch64_unibilium}"
SRC_URI[aarch64_unibilium.sha256sum] = "889767d75d725b79842440b2edaa988c25bcc49fe4a5644ecf0a524597dc1045"

URI_aarch64_unibilium-devel = "${EPEL_MIRROR}/aarch64/Packages/u/unibilium-devel-2.1.1-7.el10_0.aarch64.rpm;name=aarch64_unibilium-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_unibilium-devel}"
SRC_URI[aarch64_unibilium-devel.sha256sum] = "e86b942f8dfacf3c4d95745fa9cfe25f7c79e1f6b33e736a6bf5b8b2e2af45ed"

RDEPENDS:unibilium = " \
 glibc \
 "
RDEPENDS:unibilium-devel = " \
 pkgconf-pkg-config \
 unibilium \
 "
