# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdav"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kdav \
 kf6-kdav-devel \
 kf6-kdav-doc \
 kf6-kdav-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kdav-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "79940fce86b327142f8ff9b01ce6a4b86e48886cd6f79bea31c8fa6f12881d2b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdav;unpack=0"
SRC_URI[x86_64_v2_kf6-kdav.sha256sum] = "16c10b5a7b2c7019d76e89ceb5d68b1cb3439690013c19dc388ab53643b5fa25"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdav-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kdav-devel.sha256sum] = "d36e6944ec1ac92cb6ca221585f07c915460637b2a032d216b5c538f2fc69eda"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdav-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kdav-doc.sha256sum] = "db5d4e0d678118070d3a507f9ca9a2f2e3a531c0e62fe10590db7ed30e6c778f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdav-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kdav-html.sha256sum] = "9d47d325e668023ff35d5e2b713bd8a104c864940d4ab1ed58a880ea5db879aa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kdav;unpack=0"
SRC_URI[aarch64_kf6-kdav.sha256sum] = "d6f4a839fe848da745cf3ee3360eb078f8b901a8565cede021d6f2ccbec004c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kdav-devel;unpack=0"
SRC_URI[aarch64_kf6-kdav-devel.sha256sum] = "05f618f4bbae323c2144e44f9b8273fe400cf53f4d02072a2fd9e6ac5657b2be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kdav-doc;unpack=0"
SRC_URI[aarch64_kf6-kdav-doc.sha256sum] = "ee858ece8f06e64a9e37962170c42c27cbacb04141c0922df6569642a9b4a670"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kdav-html;unpack=0"
SRC_URI[aarch64_kf6-kdav-html.sha256sum] = "c9ddfdcf1112ad961c3df746a48bc7f3c56d965007215bc9bb3386b33bf0eb5d"

RDEPENDS:kf6-kdav = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kdav-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kdav \
 "
RDEPENDS:kf6-kdav-doc = " \
 "
RDEPENDS:kf6-kdav-html = " \
 "
