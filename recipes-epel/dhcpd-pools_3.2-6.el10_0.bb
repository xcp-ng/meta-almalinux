# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dhcpd-pools"
PV = "3.2"
PR = "6.el10_0"
PACKAGES = " \
 dhcpd-pools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dhcpd-pools-3.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aca8705d7336f04d8fe620dbb74b896128bba144a666c740122e9a7521555d38"

URI_x86_64_v2_dhcpd-pools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dhcpd-pools-3.2-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dhcpd-pools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dhcpd-pools}"
SRC_URI[x86_64_v2_dhcpd-pools.sha256sum] = "569066463affa757b9155ce1429919a49675fbed7989dc51d56086e9b85c93d7"

URI_aarch64_dhcpd-pools = "${EPEL_MIRROR}/aarch64/Packages/d/dhcpd-pools-3.2-6.el10_0.aarch64.rpm;name=aarch64_dhcpd-pools;unpack=0"
SRC_URI:append = " ${URI_aarch64_dhcpd-pools}"
SRC_URI[aarch64_dhcpd-pools.sha256sum] = "c522cce93fc8a8a4d45795d419e35ca9798cd49526a510b174533a7125b6272d"

RDEPENDS:dhcpd-pools = " \
 glibc \
 net-snmp-perl-module \
 perl-interpreter \
 perl-libs \
 "
