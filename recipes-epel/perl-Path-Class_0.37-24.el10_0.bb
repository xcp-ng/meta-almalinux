# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Path-Class"
PV = "0.37"
PR = "24.el10_0"
PACKAGES = " \
 perl-Path-Class \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Path-Class-0.37-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77f2939ddadb20877b95f0032fa779210398a7b01abcc37976e20f9d0bc060da"

URI_x86_64_v2_perl-Path-Class = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Path-Class-0.37-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Path-Class;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Path-Class}"
SRC_URI[x86_64_v2_perl-Path-Class.sha256sum] = "d5e6d103387b7df9837c3cd79d2a991e2abe7d8523329b46f302aed44fa84dc4"

URI_aarch64_perl-Path-Class = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Path-Class-0.37-24.el10_0.noarch.rpm;name=aarch64_perl-Path-Class;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Path-Class}"
SRC_URI[aarch64_perl-Path-Class.sha256sum] = "e37128e6ce0718ab08eb84a288ff6aa8f24968e8ce2701e4f0b41684989065d2"

RDEPENDS:perl-Path-Class = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-File-stat \
 perl-IO \
 perl-Path-Class \
 perl-PathTools \
 perl-Perl-OSType \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 perl-parent \
 "
