# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-font-awesome-as-a-crate"
PV = "0.3.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-font-awesome-as-a-crate+default-devel \
 rust-font-awesome-as-a-crate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-font-awesome-as-a-crate-0.3.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7991e4e11e5ca3355d005b8d3df5e4e5a2c81a0b2d9cecd50a32e46b331f2681"

URI_x86_64_v2_rust-font-awesome-as-a-crate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-font-awesome-as-a-crate+default-devel-0.3.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-font-awesome-as-a-crate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-font-awesome-as-a-crate+default-devel}"
SRC_URI[x86_64_v2_rust-font-awesome-as-a-crate+default-devel.sha256sum] = "f372b02018e8085fd221adc3f9c0dbb25caa4b73d2ffe71441860fd5b4ddce00"

URI_x86_64_v2_rust-font-awesome-as-a-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-font-awesome-as-a-crate-devel-0.3.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-font-awesome-as-a-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-font-awesome-as-a-crate-devel}"
SRC_URI[x86_64_v2_rust-font-awesome-as-a-crate-devel.sha256sum] = "409677c2884d9515e489a57928a7e33cc341ab032e56b9f85d374aad0796eeb4"

URI_aarch64_rust-font-awesome-as-a-crate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-font-awesome-as-a-crate+default-devel-0.3.1-1.el10_3.noarch.rpm;name=aarch64_rust-font-awesome-as-a-crate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-font-awesome-as-a-crate+default-devel}"
SRC_URI[aarch64_rust-font-awesome-as-a-crate+default-devel.sha256sum] = "7d531fc02fe0d444bfb91f380d58b459537b956d55f45150a7fcb7af2fdb12b4"

URI_aarch64_rust-font-awesome-as-a-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-font-awesome-as-a-crate-devel-0.3.1-1.el10_3.noarch.rpm;name=aarch64_rust-font-awesome-as-a-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-font-awesome-as-a-crate-devel}"
SRC_URI[aarch64_rust-font-awesome-as-a-crate-devel.sha256sum] = "62ccbd99d903ebd59a617c806f979014c2908c3dfbbe59289a58dd9cf5d0811f"

RDEPENDS:rust-font-awesome-as-a-crate+default-devel = " \
 cargo \
 rust-font-awesome-as-a-crate-devel \
 "
RDEPENDS:rust-font-awesome-as-a-crate-devel = " \
 cargo \
 "
