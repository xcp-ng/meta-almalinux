# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php"
PV = "8.3.29"
PR = "1.el10_1"
PACKAGES = " \
 php \
 php-bcmath \
 php-cli \
 php-common \
 php-dba \
 php-dbg \
 php-devel \
 php-embedded \
 php-enchant \
 php-ffi \
 php-fpm \
 php-gd \
 php-gmp \
 php-intl \
 php-ldap \
 php-mbstring \
 php-mysqlnd \
 php-odbc \
 php-opcache \
 php-pdo \
 php-pgsql \
 php-process \
 php-snmp \
 php-soap \
 php-xml \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/php-8.3.29-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3f91702aba440235b7a115fa45adcba11184bd7b2323d7085879a284b528032"

URI_x86_64_v2_php = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php}"
SRC_URI[x86_64_v2_php.sha256sum] = "13bed711b61d85f42248d6a1457b4f05536e5253652baf46bbab6d356907c4a3"

URI_x86_64_v2_php-bcmath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-bcmath-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-bcmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-bcmath}"
SRC_URI[x86_64_v2_php-bcmath.sha256sum] = "c0628b1c384daec0f8fe78977643cc27317c42c8a79f1bd1b08cf8c886f04c3c"

URI_x86_64_v2_php-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-cli-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-cli}"
SRC_URI[x86_64_v2_php-cli.sha256sum] = "a76c1654485e93798def5fc9c3f439c2b31552b9499cbca3facb4989c310af93"

URI_x86_64_v2_php-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-common-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-common}"
SRC_URI[x86_64_v2_php-common.sha256sum] = "9df84c190ce1c897bd9e860e4d1ac653d5bf6f6f5b883e9b855280f60ae82225"

URI_x86_64_v2_php-dba = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-dba-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-dba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-dba}"
SRC_URI[x86_64_v2_php-dba.sha256sum] = "2fc58a1146a7a7f1ffcf91764987a756e00a76865570db4c18beb7da07e7191b"

URI_x86_64_v2_php-dbg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-dbg-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-dbg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-dbg}"
SRC_URI[x86_64_v2_php-dbg.sha256sum] = "9561f1c9478de24bef369322065d20ad7e6fba7e76bfed1acd7e5955e8f23187"

URI_x86_64_v2_php-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-devel-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-devel}"
SRC_URI[x86_64_v2_php-devel.sha256sum] = "ec6eb1a7049a2102318a47b9e092408039574b2b5f46840ea6bf70ba94ee9d7b"

URI_x86_64_v2_php-embedded = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-embedded-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-embedded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-embedded}"
SRC_URI[x86_64_v2_php-embedded.sha256sum] = "4115fb73f43da00ce58c8da54433606cbb6fec7b5a6256387bc3b207baa1f0ff"

URI_x86_64_v2_php-enchant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-enchant-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-enchant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-enchant}"
SRC_URI[x86_64_v2_php-enchant.sha256sum] = "d167ab5f82ea4e9a69394690196da519ebad14f368a6e46d5f33d1d26cc53e72"

URI_x86_64_v2_php-ffi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-ffi-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-ffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-ffi}"
SRC_URI[x86_64_v2_php-ffi.sha256sum] = "0156b715774b4526028586d052dae93c3ce0a4bff0f654dc87d2a44be5cfec1e"

URI_x86_64_v2_php-fpm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-fpm-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-fpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-fpm}"
SRC_URI[x86_64_v2_php-fpm.sha256sum] = "1b661cfc5844f2fd981601c4aab81a5e117f6f5717ecafbaf2710a1735a0e99e"

URI_x86_64_v2_php-gd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-gd-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-gd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-gd}"
SRC_URI[x86_64_v2_php-gd.sha256sum] = "05116d2f4ac84f7eec11807ad37eaae82a9b66982e543d5fa313bbd5b65c7a16"

URI_x86_64_v2_php-gmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-gmp-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-gmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-gmp}"
SRC_URI[x86_64_v2_php-gmp.sha256sum] = "222cec2ec7cc3e4d9699e78e42c5b48cd76fbd95746bb92b13250fcc026db9d1"

URI_x86_64_v2_php-intl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-intl-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-intl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-intl}"
SRC_URI[x86_64_v2_php-intl.sha256sum] = "58aba7d4117f70e3e3d6e961b4f09284fdd1f3dd6b8d3dbd04e22b2631821540"

URI_x86_64_v2_php-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-ldap-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-ldap}"
SRC_URI[x86_64_v2_php-ldap.sha256sum] = "6546efe1b808d35133c8680de729d09eca66b20f1fba1ed15afbfda1a1449634"

URI_x86_64_v2_php-mbstring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-mbstring-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-mbstring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-mbstring}"
SRC_URI[x86_64_v2_php-mbstring.sha256sum] = "6d119c2e6f8f1a7ec2d2377e62d333763fd86ac2bb81a38bd051602922719b8d"

URI_x86_64_v2_php-mysqlnd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-mysqlnd-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-mysqlnd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-mysqlnd}"
SRC_URI[x86_64_v2_php-mysqlnd.sha256sum] = "745a7630002aeddacde943adc8951a35087b569f7a4f9fdb18b65edea700c918"

URI_x86_64_v2_php-odbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-odbc-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-odbc}"
SRC_URI[x86_64_v2_php-odbc.sha256sum] = "c9b18180e780ad98d154a53cad69d56fe096f3e0f133e3f81142a67db55df765"

URI_x86_64_v2_php-opcache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-opcache-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-opcache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-opcache}"
SRC_URI[x86_64_v2_php-opcache.sha256sum] = "b5e0630ce2ba307baed339b4a96a7163c2273a7fcd6adee23b8adcbea4f8a9aa"

URI_x86_64_v2_php-pdo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pdo-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-pdo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pdo}"
SRC_URI[x86_64_v2_php-pdo.sha256sum] = "40b0b3d9b7e8ea41cbc996a61ff05d118d32f7dddb09821425ce23da020f91e6"

URI_x86_64_v2_php-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pgsql-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pgsql}"
SRC_URI[x86_64_v2_php-pgsql.sha256sum] = "80131dd5b11d85d99296baf27ab4e89ccefe87159c4df0b449780971cb988372"

URI_x86_64_v2_php-process = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-process-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-process}"
SRC_URI[x86_64_v2_php-process.sha256sum] = "d55695a3e8e246949d035a545de9e134beaf8d4ec277340afa52065307cc7e17"

URI_x86_64_v2_php-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-snmp-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-snmp}"
SRC_URI[x86_64_v2_php-snmp.sha256sum] = "f10c6b81aa409a58d07a1d3962b6d8ce6b80e30247f711cf1e5f4c5fd40d9575"

URI_x86_64_v2_php-soap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-soap-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-soap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-soap}"
SRC_URI[x86_64_v2_php-soap.sha256sum] = "c1fa6823967f731870923d5ba07d1e0c18cf98fb783406f50027cd1958994e6f"

URI_x86_64_v2_php-xml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-xml-8.3.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_php-xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-xml}"
SRC_URI[x86_64_v2_php-xml.sha256sum] = "242a0b2a4611d1c7d5657d9aa6b65e2c6b756f015e0e05c3908b952b7c930328"

URI_aarch64_php = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php;unpack=0"
SRC_URI:append = " ${URI_aarch64_php}"
SRC_URI[aarch64_php.sha256sum] = "19bf892ca2d76254ff7c9e14986abd25d59a9702cd92b87e67c737e586313a05"

URI_aarch64_php-bcmath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-bcmath-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-bcmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-bcmath}"
SRC_URI[aarch64_php-bcmath.sha256sum] = "b7e17f8ad567e9bed754c89ec79322e6f19be0236423c2dc9bd5c5dbdbda24b4"

URI_aarch64_php-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-cli-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-cli}"
SRC_URI[aarch64_php-cli.sha256sum] = "303f8aac0fc489e79c2d107a4913cfac72d410df519c631e165a8a5cba8b0d2e"

URI_aarch64_php-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-common-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-common}"
SRC_URI[aarch64_php-common.sha256sum] = "3dede40256563f3ab9911d5c8b96348113851661d051ccd31aa5722451c530b4"

URI_aarch64_php-dba = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-dba-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-dba;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-dba}"
SRC_URI[aarch64_php-dba.sha256sum] = "c1a3a2c86fd8b3975ab069142ac2f67b73151dba26b3c75280f935519384fa87"

URI_aarch64_php-dbg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-dbg-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-dbg;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-dbg}"
SRC_URI[aarch64_php-dbg.sha256sum] = "4820699aad3a6f8eb6418cf2d189a8305bd98ba94a1354f8a5cdb2a680cadd03"

URI_aarch64_php-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-devel-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-devel}"
SRC_URI[aarch64_php-devel.sha256sum] = "e48c994cdc98291311672f903934a74eaa4c3f065ec7785b3583a77309098509"

URI_aarch64_php-embedded = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-embedded-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-embedded;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-embedded}"
SRC_URI[aarch64_php-embedded.sha256sum] = "d8bc1a704ad52986dfdfc4db7366014aab6b5d0513e3350b7083f7e4f654f808"

URI_aarch64_php-enchant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-enchant-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-enchant;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-enchant}"
SRC_URI[aarch64_php-enchant.sha256sum] = "c92f557a94a16cb0e74da46aea7eb711e47be79d76f92e984351c153c256cc4e"

URI_aarch64_php-ffi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-ffi-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-ffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-ffi}"
SRC_URI[aarch64_php-ffi.sha256sum] = "2c73c883e20231c1ab2f5f0580062b9c458740bea20bea2448b69adc2d4e7f97"

URI_aarch64_php-fpm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-fpm-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-fpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-fpm}"
SRC_URI[aarch64_php-fpm.sha256sum] = "45a17837b6d5249a82e4f2a506dc23db041e6e4b046681ba31ea23e30d52d091"

URI_aarch64_php-gd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-gd-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-gd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-gd}"
SRC_URI[aarch64_php-gd.sha256sum] = "dd2e7d2fcc4a04cfab66874211a8a95b6b69f7a41bc1af9c13b1149821a386db"

URI_aarch64_php-gmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-gmp-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-gmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-gmp}"
SRC_URI[aarch64_php-gmp.sha256sum] = "c8455b75ac6e4493c3f85566865b70e7cad4b51e7eb7c00f492e54e5f4a949ae"

URI_aarch64_php-intl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-intl-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-intl;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-intl}"
SRC_URI[aarch64_php-intl.sha256sum] = "39cee3cd2a40dd9df6bc1b74350890bffa93db5177f900786e2d7cfbe7a0a51a"

URI_aarch64_php-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-ldap-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-ldap}"
SRC_URI[aarch64_php-ldap.sha256sum] = "96130c3956a41d69b6f28abd6cdc214befaf9213587af068390e712ca3abb63a"

URI_aarch64_php-mbstring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-mbstring-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-mbstring;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-mbstring}"
SRC_URI[aarch64_php-mbstring.sha256sum] = "b0ec0e6ddee682a9fa607430f340ff9200d6bbaf20e41234443a9d92540aee11"

URI_aarch64_php-mysqlnd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-mysqlnd-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-mysqlnd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-mysqlnd}"
SRC_URI[aarch64_php-mysqlnd.sha256sum] = "3cee83d6fb10dc9fa1ac6eff8a01e4b603f3b770ca682affab29402037a7f953"

URI_aarch64_php-odbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-odbc-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-odbc}"
SRC_URI[aarch64_php-odbc.sha256sum] = "76d77da3b42e45efe032a4b951b44b8cf5ff0098950ee60387dc5294044da739"

URI_aarch64_php-opcache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-opcache-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-opcache;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-opcache}"
SRC_URI[aarch64_php-opcache.sha256sum] = "c0ba88276b7d6d0f59b9fe779d43204d089a00c4ee741ec9374c2d6740d6de48"

URI_aarch64_php-pdo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pdo-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-pdo;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pdo}"
SRC_URI[aarch64_php-pdo.sha256sum] = "c085d7ce033fc69b9ab21d541a3be0388168c2384c3a7fe22c018a4734b3cb1b"

URI_aarch64_php-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pgsql-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pgsql}"
SRC_URI[aarch64_php-pgsql.sha256sum] = "ca2e454cc35ed77ac41da0b548b0b84a48cfbc368d9aea2808e09189e0e27937"

URI_aarch64_php-process = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-process-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-process}"
SRC_URI[aarch64_php-process.sha256sum] = "850c3e309a4790e4d54921ad86db9198ba01c896534637e0aa68682d5913d809"

URI_aarch64_php-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-snmp-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-snmp}"
SRC_URI[aarch64_php-snmp.sha256sum] = "8c1a9eae853c35ef152bda1867f473b03b0f5cdb7bc0d0fbf5d25aa2826cbf56"

URI_aarch64_php-soap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-soap-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-soap;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-soap}"
SRC_URI[aarch64_php-soap.sha256sum] = "2bcd1e08902e182b33d9bafb3fe7008b9b3f2b43f061de905818f028665ecc31"

URI_aarch64_php-xml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-xml-8.3.29-1.el10_1.aarch64.rpm;name=aarch64_php-xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-xml}"
SRC_URI[aarch64_php-xml.sha256sum] = "a080403b9841bc6b5757a142eac3e2ba8238f6ef1e43111ef2190afb2b2362d5"

RDEPENDS:php = " \
 php-common \
 "
RDEPENDS:php-bcmath = " \
 glibc \
 php-common \
 "
RDEPENDS:php-cli = " \
 bash \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-common = " \
 bzip2-libs \
 glibc \
 openssl-libs \
 tzdata \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:php-dba = " \
 glibc \
 lmdb-libs \
 php-common \
 tokyocabinet \
 "
RDEPENDS:php-dbg = " \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-devel = " \
 autoconf \
 automake \
 bash \
 gcc \
 gcc-c++ \
 krb5-devel \
 libtool \
 libxml2-devel \
 make \
 openssl-devel \
 pcre2-devel \
 php-cli \
 zlib-ng-compat-devel \
 "
RDEPENDS:php-embedded = " \
 glibc \
 krb5-libs \
 libcom_err \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-enchant = " \
 enchant2 \
 glibc \
 php-common \
 "
RDEPENDS:php-ffi = " \
 glibc \
 libffi \
 php-common \
 "
RDEPENDS:php-fpm = " \
 bash \
 glibc \
 httpd-filesystem \
 libacl \
 libselinux \
 libxcrypt \
 libxml2 \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 php-common \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:php-gd = " \
 gd \
 glibc \
 php-common \
 "
RDEPENDS:php-gmp = " \
 glibc \
 gmp \
 php-common \
 "
RDEPENDS:php-intl = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 php-common \
 "
RDEPENDS:php-ldap = " \
 cyrus-sasl-lib \
 glibc \
 openldap \
 php-common \
 "
RDEPENDS:php-mbstring = " \
 glibc \
 oniguruma \
 php-common \
 "
RDEPENDS:php-mysqlnd = " \
 glibc \
 php-pdo \
 "
RDEPENDS:php-odbc = " \
 glibc \
 php-pdo \
 unixODBC \
 "
RDEPENDS:php-opcache:x86_64_v2 = " \
 capstone \
 glibc \
 libgcc \
 php-common \
"
RDEPENDS:php-opcache:aarch64 = " \
 capstone \
 glibc \
 php-common \
"
RDEPENDS:php-pdo = " \
 glibc \
 php-common \
 sqlite-libs \
 "
RDEPENDS:php-pgsql = " \
 glibc \
 libpq \
 php-pdo \
 "
RDEPENDS:php-process = " \
 glibc \
 php-common \
 "
RDEPENDS:php-snmp = " \
 glibc \
 net-snmp \
 net-snmp-libs \
 openssl-libs \
 php-common \
 "
RDEPENDS:php-soap = " \
 glibc \
 libxml2 \
 php-common \
 "
RDEPENDS:php-xml = " \
 glibc \
 libxml2 \
 libxslt \
 php-common \
 "
