# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcrash"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kcrash \
 kf6-kcrash-devel \
 kf6-kcrash-doc \
 kf6-kcrash-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcrash-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9def1a001c338ec716a1d00cb93b5eedfa34191f2c307f559715e107bf2dfcd8"

URI_x86_64_v2_kf6-kcrash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcrash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash}"
SRC_URI[x86_64_v2_kf6-kcrash.sha256sum] = "41bd00c55cb96272fa782c29802bf99ad2aa5a36d958d938d0fe5d761cf163bb"

URI_x86_64_v2_kf6-kcrash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcrash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash-devel}"
SRC_URI[x86_64_v2_kf6-kcrash-devel.sha256sum] = "579fe3751e221362808e69ec7ad669ed6f4e751778cad837f86c933cc1e7cd14"

URI_x86_64_v2_kf6-kcrash-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcrash-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash-doc}"
SRC_URI[x86_64_v2_kf6-kcrash-doc.sha256sum] = "b1d38c48836c9d01abe02a17f81665596c5a76acc2c6699d9b4a46fede7080c1"

URI_x86_64_v2_kf6-kcrash-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcrash-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash-html}"
SRC_URI[x86_64_v2_kf6-kcrash-html.sha256sum] = "8911ecf01c5c4a22a09d05458308f20a38980ddf3a43966764c96a2eeacc6d36"

URI_aarch64_kf6-kcrash = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcrash;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash}"
SRC_URI[aarch64_kf6-kcrash.sha256sum] = "2c56c07288137723f226ebc5826b75af13547e61390bff383c0775cb0fa0a81d"

URI_aarch64_kf6-kcrash-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcrash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash-devel}"
SRC_URI[aarch64_kf6-kcrash-devel.sha256sum] = "88414caf66cf5ae2e62d44e1358bc8c6f715b8ef3f4fada440f323970d7a6bc7"

URI_aarch64_kf6-kcrash-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcrash-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash-doc}"
SRC_URI[aarch64_kf6-kcrash-doc.sha256sum] = "eaf25ab8c306c4e88e0a8f43440095f45599f70b2de0575085fd845d2470c7c7"

URI_aarch64_kf6-kcrash-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcrash-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash-html}"
SRC_URI[aarch64_kf6-kcrash-html.sha256sum] = "6b8d3afc07292b0ba0b392679acd30762a34c43e90ab21d0a01f9d8a1b3e65cc"

RDEPENDS:kf6-kcrash = " \
 glibc \
 kf6-kcoreaddons \
 libX11 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcrash-devel = " \
 cmake-filesystem \
 kf6-kcrash \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcrash-doc = " \
 "
RDEPENDS:kf6-kcrash-html = " \
 "
