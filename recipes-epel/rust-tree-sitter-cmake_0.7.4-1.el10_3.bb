# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-cmake"
PV = "0.7.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-cmake+default-devel \
 rust-tree-sitter-cmake-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-cmake-0.7.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "62bb3afdd92da6512c60bd8d2fc72afb7db07c4580b8a1b55198355bd5c3088c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-cmake+default-devel-0.7.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-cmake+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tree-sitter-cmake+default-devel.sha256sum] = "1083ff51e1cf2522f9212f134b0972be58b9fc9ac58eb61aae23491d639c4cb9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-cmake-devel-0.7.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-cmake-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tree-sitter-cmake-devel.sha256sum] = "71e0d79e3a96e73be4abbf8bb64345418638266ae0fe46c1575402e135a0a76e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-cmake+default-devel-0.7.4-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-cmake+default-devel;unpack=0"
SRC_URI[aarch64_rust-tree-sitter-cmake+default-devel.sha256sum] = "bcb3f49fe2b14055462dd3f60a54f354a04c4cb3187a10b921450cec7d3e9b31"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-cmake-devel-0.7.4-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-cmake-devel;unpack=0"
SRC_URI[aarch64_rust-tree-sitter-cmake-devel.sha256sum] = "02a90abdccb89414fcf80155fc3eed337b5a2fce75a0f729f4c05652371a76fe"

RDEPENDS:rust-tree-sitter-cmake+default-devel = " \
 cargo \
 rust-tree-sitter-cmake-devel \
 "
RDEPENDS:rust-tree-sitter-cmake-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
