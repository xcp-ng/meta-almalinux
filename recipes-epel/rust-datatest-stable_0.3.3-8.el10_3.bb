# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-datatest-stable"
PV = "0.3.3"
PR = "8.el10_3"
PACKAGES = " \
 rust-datatest-stable+default-devel \
 rust-datatest-stable+include-dir-devel \
 rust-datatest-stable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-datatest-stable-0.3.3-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a6068b1d16399772c90109c30399a7d04a332b7fe076e94d7520f8f419338c5"

URI_x86_64_v2_rust-datatest-stable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-datatest-stable+default-devel-0.3.3-8.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-datatest-stable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-datatest-stable+default-devel}"
SRC_URI[x86_64_v2_rust-datatest-stable+default-devel.sha256sum] = "4b4fecc8f6a33eb81ef6bcd16683b99e80dae2ff495210087ea9f5b5861c2492"

URI_x86_64_v2_rust-datatest-stable+include-dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-datatest-stable+include-dir-devel-0.3.3-8.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-datatest-stable+include-dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-datatest-stable+include-dir-devel}"
SRC_URI[x86_64_v2_rust-datatest-stable+include-dir-devel.sha256sum] = "2452c1786b37edb9277a7a3edd59ecdc19dc638d2de60d376e95e401e9eb9531"

URI_x86_64_v2_rust-datatest-stable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-datatest-stable-devel-0.3.3-8.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-datatest-stable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-datatest-stable-devel}"
SRC_URI[x86_64_v2_rust-datatest-stable-devel.sha256sum] = "e60338c572ccd534e2c28ce140a60663ff2860c10070aae512162f42a73567dd"

URI_aarch64_rust-datatest-stable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-datatest-stable+default-devel-0.3.3-8.el10_3.noarch.rpm;name=aarch64_rust-datatest-stable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-datatest-stable+default-devel}"
SRC_URI[aarch64_rust-datatest-stable+default-devel.sha256sum] = "f0ed024cb23dd13b0c4b9c36669c7d8240f0b84fc8de59514c77f8136f2d5874"

URI_aarch64_rust-datatest-stable+include-dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-datatest-stable+include-dir-devel-0.3.3-8.el10_3.noarch.rpm;name=aarch64_rust-datatest-stable+include-dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-datatest-stable+include-dir-devel}"
SRC_URI[aarch64_rust-datatest-stable+include-dir-devel.sha256sum] = "96435c0cc80d3e2608129a09db4de213208f98a4407f8179a8946d05ad0451da"

URI_aarch64_rust-datatest-stable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-datatest-stable-devel-0.3.3-8.el10_3.noarch.rpm;name=aarch64_rust-datatest-stable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-datatest-stable-devel}"
SRC_URI[aarch64_rust-datatest-stable-devel.sha256sum] = "f8b860b310bbcf61c7f84b718d9147ae2ddb91949f77c52f4d1342f227e793b2"

RDEPENDS:rust-datatest-stable+default-devel = " \
 cargo \
 rust-datatest-stable-devel \
 "
RDEPENDS:rust-datatest-stable+include-dir-devel = " \
 cargo \
 rust-datatest-stable-devel \
 rust-include_dir+default-devel \
 "
RDEPENDS:rust-datatest-stable-devel = " \
 cargo \
 rust \
 rust-camino+default-devel \
 rust-fancy-regex+default-devel \
 rust-libtest-mimic+default-devel \
 rust-walkdir+default-devel \
 "
