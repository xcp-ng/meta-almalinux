# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_pcg0.9"
PV = "0.9.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_pcg0.9+default-devel \
 rust-rand_pcg0.9+os_rng-devel \
 rust-rand_pcg0.9+serde-devel \
 rust-rand_pcg0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_pcg0.9-0.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2ab59f2e0a41eeb5ea50f0cce97ecbbb3da839f155d87789a25c940596d3d3d"

URI_x86_64_v2_rust-rand_pcg0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg0.9+default-devel-0.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg0.9+default-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg0.9+default-devel.sha256sum] = "00e58fe10d38a31718a2ca4dc5e64168fbe49ac830a77ee142a2238f83620004"

URI_x86_64_v2_rust-rand_pcg0.9+os_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg0.9+os_rng-devel-0.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg0.9+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg0.9+os_rng-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg0.9+os_rng-devel.sha256sum] = "170ffa3a3d7f2ea4237483d624e2234e2cb4536622d958331443fdedc17ec6cc"

URI_x86_64_v2_rust-rand_pcg0.9+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg0.9+serde-devel-0.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg0.9+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg0.9+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg0.9+serde-devel.sha256sum] = "852d5638a899c71b2cf0475eb9152c0e287379867c7c34cf288162fb3259d2c8"

URI_x86_64_v2_rust-rand_pcg0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg0.9-devel-0.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg0.9-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg0.9-devel.sha256sum] = "a16a7318dfa66b3efd692687bb3b5c3f83c61c34e062e3bfc66628828db209a7"

URI_aarch64_rust-rand_pcg0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg0.9+default-devel-0.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_pcg0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg0.9+default-devel}"
SRC_URI[aarch64_rust-rand_pcg0.9+default-devel.sha256sum] = "0a3465ffb2bad1082683d057233d6d269e4cdf5ac26997c159d0dc3cba642ded"

URI_aarch64_rust-rand_pcg0.9+os_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg0.9+os_rng-devel-0.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_pcg0.9+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg0.9+os_rng-devel}"
SRC_URI[aarch64_rust-rand_pcg0.9+os_rng-devel.sha256sum] = "7162677d79b9c29b07a35f245a81d2415d8b0ad866698a35517e4cded53a470d"

URI_aarch64_rust-rand_pcg0.9+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg0.9+serde-devel-0.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_pcg0.9+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg0.9+serde-devel}"
SRC_URI[aarch64_rust-rand_pcg0.9+serde-devel.sha256sum] = "9d9226ed69770e565b6f325fe5e19768c81ffc4f387552de5a486045524c4893"

URI_aarch64_rust-rand_pcg0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg0.9-devel-0.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_pcg0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg0.9-devel}"
SRC_URI[aarch64_rust-rand_pcg0.9-devel.sha256sum] = "5c948813a588ea650b1ea78908ab0f535a14d17d31b1d8e8c18034ee73187373"

RDEPENDS:rust-rand_pcg0.9+default-devel = " \
 cargo \
 rust-rand_pcg0.9-devel \
 "
RDEPENDS:rust-rand_pcg0.9+os_rng-devel = " \
 cargo \
 rust-rand_core0.9+os_rng-devel \
 rust-rand_pcg0.9-devel \
 "
RDEPENDS:rust-rand_pcg0.9+serde-devel = " \
 cargo \
 rust-rand_pcg0.9-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_pcg0.9-devel = " \
 cargo \
 rust \
 rust-rand_core0.9+default-devel \
 "
