# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vim-ale"
PV = "4.0.0"
PR = "3.el10_1"
PACKAGES = " \
 neovim-ale \
 vim-ale \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vim-ale-4.0.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c99d57c250a3422560abeef76790df63d88e4545c272b401510fa4ed8cb099de"

URI_x86_64_v2_neovim-ale = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/neovim-ale-4.0.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_neovim-ale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_neovim-ale}"
SRC_URI[x86_64_v2_neovim-ale.sha256sum] = "703dec4b8c7d33f91ff85e6120ee786880363247f1c83577c139671191b7d48e"

URI_x86_64_v2_vim-ale = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vim-ale-4.0.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_vim-ale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-ale}"
SRC_URI[x86_64_v2_vim-ale.sha256sum] = "4a88acb6efe1e357eb7f4b61908682ff15c215765e23146c0fc4a182df55d40e"

URI_aarch64_neovim-ale = "${EPEL_MIRROR}/aarch64/Packages/n/neovim-ale-4.0.0-3.el10_1.noarch.rpm;name=aarch64_neovim-ale;unpack=0"
SRC_URI:append = " ${URI_aarch64_neovim-ale}"
SRC_URI[aarch64_neovim-ale.sha256sum] = "e23763e97cb271bf4d353defd3250483e1fb30e0c8d4b182e0e2d3656ef220f6"

URI_aarch64_vim-ale = "${EPEL_MIRROR}/aarch64/Packages/v/vim-ale-4.0.0-3.el10_1.noarch.rpm;name=aarch64_vim-ale;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-ale}"
SRC_URI[aarch64_vim-ale.sha256sum] = "7ef07e1d4a6091edd37463eafafada33c2691119797b85ab3c4512522f483d82"

RDEPENDS:neovim-ale = " \
 neovim \
 "
RDEPENDS:vim-ale = " \
 virtual/vim-enhanced_or_vim-X11 \
 "
