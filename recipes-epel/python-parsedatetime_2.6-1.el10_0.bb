# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-parsedatetime"
PV = "2.6"
PR = "1.el10_0"
PACKAGES = " \
 python3-parsedatetime \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-parsedatetime-2.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b50074f5b51fea955e1402834a2bbc25e68715af04e6b3b8fdd7cf31214fd813"

URI_x86_64_v2_python3-parsedatetime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-parsedatetime-2.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-parsedatetime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-parsedatetime}"
SRC_URI[x86_64_v2_python3-parsedatetime.sha256sum] = "959d2a2cd72b7b307c8fe69bdb195c0921c4e7f2eaa772319bcd1f4e3eddf88a"

URI_aarch64_python3-parsedatetime = "${EPEL_MIRROR}/aarch64/Packages/p/python3-parsedatetime-2.6-1.el10_0.noarch.rpm;name=aarch64_python3-parsedatetime;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-parsedatetime}"
SRC_URI[aarch64_python3-parsedatetime.sha256sum] = "6919faef97c7c001ace29f927ca19e952ba4dc3d816d76d0ce1fa2f38b9e0d0c"

RDEPENDS:python3-parsedatetime = " \
 python3 \
 "
