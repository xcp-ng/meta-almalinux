# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-google-auth"
PE = "1"
PV = "2.38.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-google-auth \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-google-auth-2.38.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "804a95c763dc38c19427b9f3151f4cd62f63bddc2555577974ca4aac63e47763"

URI_x86_64_v2_python3-google-auth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth-2.38.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth}"
SRC_URI[x86_64_v2_python3-google-auth.sha256sum] = "ac4d01142115ebc73e68f83f68aa8ada37fdad2e7b10ff9b8b0ddd4b4d2170d6"

URI_aarch64_python3-google-auth = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth-2.38.0-1.el10_0.noarch.rpm;name=aarch64_python3-google-auth;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth}"
SRC_URI[aarch64_python3-google-auth.sha256sum] = "344af235483c103e2dec2c0473a63bdd6e0bc4050f54a113ec19d4d753d055cc"

RDEPENDS:python3-google-auth = " \
 python3 \
 python3-cachetools \
 python3-pyasn1-modules \
 python3-rsa \
 "
