# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "forge-srpm-macros"
PV = "0.4.0"
PR = "6.el10"
PACKAGES = " \
 forge-srpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/forge-srpm-macros-0.4.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dda3d6d6f4b25140aba3f4303d40b9d4d4a3a5156e071d07de7fe12922a042c"

URI_x86_64_v2_forge-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/forge-srpm-macros-0.4.0-6.el10.noarch.rpm;name=x86_64_v2_forge-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_forge-srpm-macros}"
SRC_URI[x86_64_v2_forge-srpm-macros.sha256sum] = "c07ce83b6542f27f1f781c12dc1deee72e422c2ec8df742882e8cec9e4467471"

URI_aarch64_forge-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/forge-srpm-macros-0.4.0-6.el10.noarch.rpm;name=aarch64_forge-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_forge-srpm-macros}"
SRC_URI[aarch64_forge-srpm-macros.sha256sum] = "c07ce83b6542f27f1f781c12dc1deee72e422c2ec8df742882e8cec9e4467471"

RDEPENDS:forge-srpm-macros = " \
 redhat-rpm-config \
 "
