# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "coreutils"
PV = "9.5"
PR = "8.el10_2"
PACKAGES = " \
 coreutils \
 coreutils-common \
 coreutils-single \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/coreutils-9.5-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1f3a06dbe997e1181433450a0efd93ddbd676d77eba528a7e7a78e6bb818d77"

URI_x86_64_v2_coreutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/coreutils-9.5-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_coreutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreutils}"
SRC_URI[x86_64_v2_coreutils.sha256sum] = "bde2964d93f43a764da013d94ab508a78072beb180a08eac5fa6292a9090cee1"
RPROVIDES:coreutils:x86_64_v2 = "virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

URI_x86_64_v2_coreutils-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/coreutils-common-9.5-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_coreutils-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreutils-common}"
SRC_URI[x86_64_v2_coreutils-common.sha256sum] = "859e436a5c500b9c30884d1e2c516f0c66ce700df958ea153145ccf36b0f7490"

URI_x86_64_v2_coreutils-single = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/coreutils-single-9.5-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_coreutils-single;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreutils-single}"
SRC_URI[x86_64_v2_coreutils-single.sha256sum] = "7824ed866dc5e420ad7b40b522358607921074c94bcc885973924c559bf25046"
RPROVIDES:coreutils-single:x86_64_v2 = "virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

URI_aarch64_coreutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/coreutils-9.5-8.el10_2.aarch64.rpm;name=aarch64_coreutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreutils}"
SRC_URI[aarch64_coreutils.sha256sum] = "372cc92678ae19c5c009240bc90cc692939f3d8634264c5161fdc8d954814852"
RPROVIDES:coreutils:aarch64 = "virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

URI_aarch64_coreutils-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/coreutils-common-9.5-8.el10_2.aarch64.rpm;name=aarch64_coreutils-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreutils-common}"
SRC_URI[aarch64_coreutils-common.sha256sum] = "8cefa2faa918fad0510b8aa9fc81ccd9675c71788ef5e081a66c2559631b7db6"

URI_aarch64_coreutils-single = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/coreutils-single-9.5-8.el10_2.aarch64.rpm;name=aarch64_coreutils-single;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreutils-single}"
SRC_URI[aarch64_coreutils-single.sha256sum] = "8be331d98bf027c965aafee6dd7c78de03bcb9db3e93b680302acd66ce23f19c"
RPROVIDES:coreutils-single:aarch64 = "virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

RDEPENDS:coreutils = " \
 coreutils-common \
 glibc \
 gmp \
 libacl \
 libattr \
 libcap \
 libselinux \
 openssl-libs \
 "
RDEPENDS:coreutils-common = " \
 "
RDEPENDS:coreutils-single = " \
 glibc \
 libacl \
 libattr \
 libcap \
 libselinux \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/basename rpm/virtual//usr/bin/chcon rpm/virtual//usr/bin/chmod rpm/virtual//usr/bin/date rpm/virtual//usr/bin/env rpm/virtual//usr/bin/head rpm/virtual//usr/bin/readlink rpm/virtual//usr/bin/realpath rpm/virtual//usr/bin/sha512sum rpm/virtual//usr/bin/tr rpm/virtual/coreutils"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/basename rpm/virtual//usr/bin/chcon rpm/virtual//usr/bin/chmod rpm/virtual//usr/bin/date rpm/virtual//usr/bin/env rpm/virtual//usr/bin/head rpm/virtual//usr/bin/readlink rpm/virtual//usr/bin/realpath rpm/virtual//usr/bin/sha512sum rpm/virtual//usr/bin/tr rpm/virtual/coreutils"
