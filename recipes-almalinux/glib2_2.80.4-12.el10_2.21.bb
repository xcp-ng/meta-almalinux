# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glib2"
PV = "2.80.4"
PR = "12.el10_2.21"
PACKAGES = " \
 glib2 \
 glib2-devel \
 glib2-doc \
 glib2-static \
 glib2-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/glib2-2.80.4-12.el10_2.21.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e6246be31061a093b940818533c942f1e5b69e9481c63803ed8493a99040721"

URI_x86_64_v2_glib2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glib2-2.80.4-12.el10_2.21.x86_64_v2.rpm;name=x86_64_v2_glib2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2}"
SRC_URI[x86_64_v2_glib2.sha256sum] = "1467fe6ddcbcfec184c300d1ee0a81d0fd5a90ba322264bb811444228af7f1b4"

URI_x86_64_v2_glib2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glib2-devel-2.80.4-12.el10_2.21.x86_64_v2.rpm;name=x86_64_v2_glib2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2-devel}"
SRC_URI[x86_64_v2_glib2-devel.sha256sum] = "2ab88cda413d1e6ac9eec3f35b33120723071ee3cc29877280d43e174ea7b787"

URI_x86_64_v2_glib2-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glib2-doc-2.80.4-12.el10_2.21.x86_64_v2.rpm;name=x86_64_v2_glib2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2-doc}"
SRC_URI[x86_64_v2_glib2-doc.sha256sum] = "a0fdc0c70f0725ab6c0b3e1e3f3209ec6807d279739d5e4bf75f169aa4ed5972"

URI_x86_64_v2_glib2-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glib2-static-2.80.4-12.el10_2.21.x86_64_v2.rpm;name=x86_64_v2_glib2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2-static}"
SRC_URI[x86_64_v2_glib2-static.sha256sum] = "872c7a58f4203bd3ccfd926ccb4e19c2d47236ebe8c3da30f0aa0af00985d471"

URI_x86_64_v2_glib2-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glib2-tests-2.80.4-12.el10_2.21.x86_64_v2.rpm;name=x86_64_v2_glib2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2-tests}"
SRC_URI[x86_64_v2_glib2-tests.sha256sum] = "7048b3cdae6ae912000abd468795322a9f54a967df76a87178ffc33aced07e39"

URI_aarch64_glib2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glib2-2.80.4-12.el10_2.21.aarch64.rpm;name=aarch64_glib2;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2}"
SRC_URI[aarch64_glib2.sha256sum] = "977cc1ca4c51deebd30fb0f76ceb4142ae8ce7838b1ad8f8f8ec92c9ec3da8ba"

URI_aarch64_glib2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glib2-devel-2.80.4-12.el10_2.21.aarch64.rpm;name=aarch64_glib2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2-devel}"
SRC_URI[aarch64_glib2-devel.sha256sum] = "c624fb70d208c37669bcdc7d038e4b58f0d9460b3e9ab517237fd8c675da5de8"

URI_aarch64_glib2-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glib2-doc-2.80.4-12.el10_2.21.aarch64.rpm;name=aarch64_glib2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2-doc}"
SRC_URI[aarch64_glib2-doc.sha256sum] = "b30c784ffe553a74b70b04465d5d01b14efaaf1f5744fbe1157fa9e08e50d639"

URI_aarch64_glib2-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glib2-static-2.80.4-12.el10_2.21.aarch64.rpm;name=aarch64_glib2-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2-static}"
SRC_URI[aarch64_glib2-static.sha256sum] = "fefed53a518e860cf0cf46ad5ea46428d1d8559eea05cf09132439a8f5c02fd6"

URI_aarch64_glib2-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glib2-tests-2.80.4-12.el10_2.21.aarch64.rpm;name=aarch64_glib2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2-tests}"
SRC_URI[aarch64_glib2-tests.sha256sum] = "8a351a42694bdb6bd8c8f663ab65a7425c46dd247c531cd72eaee838c504f398"

RDEPENDS:glib2:x86_64_v2 = " \
 bash \
 glibc \
 gnutls \
 libffi \
 libmount \
 libselinux \
 pcre2 \
 zlib-ng-compat \
"
RDEPENDS:glib2:aarch64 = " \
 bash \
 glibc \
 gnutls \
 libffi \
 libgcc \
 libmount \
 libselinux \
 pcre2 \
 zlib-ng-compat \
"
RDEPENDS:glib2-devel = " \
 bash \
 elfutils-libelf \
 glib2 \
 glib2-devel \
 glibc \
 libffi \
 libffi-devel \
 libmount-devel \
 libselinux-devel \
 pcre2-devel \
 pkgconf-pkg-config \
 python3 \
 python3-packaging \
 sysprof-capture-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:glib2-doc = " \
 glib2 \
 "
RDEPENDS:glib2-static = " \
 glib2-devel \
 pcre2-static \
 sysprof-capture-devel \
 "
RDEPENDS:glib2-tests = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 pcre2 \
 python3 \
 "
