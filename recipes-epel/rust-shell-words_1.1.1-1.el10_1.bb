# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-shell-words"
PV = "1.1.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-shell-words+default-devel \
 rust-shell-words+std-devel \
 rust-shell-words-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-shell-words-1.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea05c0feb44b619bbdee81c66065cda47f082041d2f8a328775c9af243400cc8"

URI_x86_64_v2_rust-shell-words+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shell-words+default-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shell-words+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shell-words+default-devel}"
SRC_URI[x86_64_v2_rust-shell-words+default-devel.sha256sum] = "e4585a95222ae84b74b6d89d5c42b1be0e488912fcfd76a1a2aa28163897638a"

URI_x86_64_v2_rust-shell-words+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shell-words+std-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shell-words+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shell-words+std-devel}"
SRC_URI[x86_64_v2_rust-shell-words+std-devel.sha256sum] = "9a4184fe2cf45e35041afa7fb4b65279183797b7413633b81efe63149150b906"

URI_x86_64_v2_rust-shell-words-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shell-words-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shell-words-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shell-words-devel}"
SRC_URI[x86_64_v2_rust-shell-words-devel.sha256sum] = "a4b4a450be2dc1a995bd25501b2380696472aa49b474459b72c2f3ec2b0de39c"

URI_aarch64_rust-shell-words+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shell-words+default-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-shell-words+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shell-words+default-devel}"
SRC_URI[aarch64_rust-shell-words+default-devel.sha256sum] = "23c15a92fa6a4f6415c6cb4d4d43b66b30bd8bebc1a7e52fc3c0ceba60f23ccf"

URI_aarch64_rust-shell-words+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shell-words+std-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-shell-words+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shell-words+std-devel}"
SRC_URI[aarch64_rust-shell-words+std-devel.sha256sum] = "a044e9b9dfa9979bfbda79f00ab5c9efdc04c4484abe0b33b9554526abe6e325"

URI_aarch64_rust-shell-words-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shell-words-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-shell-words-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shell-words-devel}"
SRC_URI[aarch64_rust-shell-words-devel.sha256sum] = "5a9b90f23ccff89011dd355e4fb72d6bc96d404e624b607c4ad5f6bb1650fe57"

RDEPENDS:rust-shell-words+default-devel = " \
 cargo \
 rust-shell-words+std-devel \
 rust-shell-words-devel \
 "
RDEPENDS:rust-shell-words+std-devel = " \
 cargo \
 rust-shell-words-devel \
 "
RDEPENDS:rust-shell-words-devel = " \
 cargo \
 "
