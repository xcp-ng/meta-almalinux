# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-ISA"
PV = "0.36"
PR = "1042.el10_0"
PACKAGES = " \
 perl-Class-ISA \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Class-ISA-0.36-1042.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f6a4ed659a895c8bd3db56dfdf82287891571841487247cb8d6fa104a49f39ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-ISA-0.36-1042.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-ISA;unpack=0"
SRC_URI[x86_64_v2_perl-Class-ISA.sha256sum] = "684f29da3d25b013d5e91c0deae7f1fb8d0989ed426bc48e69412b537803c4c0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-ISA-0.36-1042.el10_0.noarch.rpm;name=aarch64_perl-Class-ISA;unpack=0"
SRC_URI[aarch64_perl-Class-ISA.sha256sum] = "7c2610782504690c8c4855e102574d9e8ef3c181c0935d2d8b25889e9eab84b6"

RDEPENDS:perl-Class-ISA = " \
 perl-deprecate \
 perl-if \
 perl-libs \
 perl-vars \
 "
