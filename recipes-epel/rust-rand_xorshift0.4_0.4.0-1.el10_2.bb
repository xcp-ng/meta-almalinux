# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_xorshift0.4"
PV = "0.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_xorshift0.4+default-devel \
 rust-rand_xorshift0.4+serde-devel \
 rust-rand_xorshift0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_xorshift0.4-0.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5604b3600a8e862f2d2fe4e066598d7f956096d2d2a01ba8235518e69d7952ee"

URI_x86_64_v2_rust-rand_xorshift0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift0.4+default-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift0.4+default-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift0.4+default-devel.sha256sum] = "a774ebfdd9cecf9c10899e200a8818fdab814e4f17752f1d3c19a3a99799b44c"

URI_x86_64_v2_rust-rand_xorshift0.4+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift0.4+serde-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift0.4+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift0.4+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift0.4+serde-devel.sha256sum] = "e0cfbc69e62b2c1ac5b5eefa43ae5b8456c56258bfe55642b1ed52988213865e"

URI_x86_64_v2_rust-rand_xorshift0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift0.4-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift0.4-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift0.4-devel.sha256sum] = "04270df31d18c5944e5ac1fcfeb9018d072304226350c7701cd1b1630cd31a2d"

URI_aarch64_rust-rand_xorshift0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift0.4+default-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xorshift0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift0.4+default-devel}"
SRC_URI[aarch64_rust-rand_xorshift0.4+default-devel.sha256sum] = "f1d664a7f827d82429aad19074a62e61a274fb38bf97c91ca242203dae96b9cc"

URI_aarch64_rust-rand_xorshift0.4+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift0.4+serde-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xorshift0.4+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift0.4+serde-devel}"
SRC_URI[aarch64_rust-rand_xorshift0.4+serde-devel.sha256sum] = "ff9f8d909804cf03f7770b53494458e08b7e0134b24d8a7fb34a8464a46c99f5"

URI_aarch64_rust-rand_xorshift0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift0.4-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xorshift0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift0.4-devel}"
SRC_URI[aarch64_rust-rand_xorshift0.4-devel.sha256sum] = "0a18c360ae4fdcc887ba12f5a54c2c7525e805bfa86a38289a03470d7c127f54"

RDEPENDS:rust-rand_xorshift0.4+default-devel = " \
 cargo \
 rust-rand_xorshift0.4-devel \
 "
RDEPENDS:rust-rand_xorshift0.4+serde-devel = " \
 cargo \
 rust-rand_xorshift0.4-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rand_xorshift0.4-devel = " \
 cargo \
 rust \
 rust-rand_core0.9+default-devel \
 "
