# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Mail-DKIM"
PV = "1.20240827"
PR = "1.el10_0"
PACKAGES = " \
 perl-Mail-DKIM \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Mail-DKIM-1.20240827-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc905e9ba6535e41c4c1c52282e091e890e8190e4b98fb80cb9a82202dbc51bf"

URI_x86_64_v2_perl-Mail-DKIM = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Mail-DKIM-1.20240827-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Mail-DKIM;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Mail-DKIM}"
SRC_URI[x86_64_v2_perl-Mail-DKIM.sha256sum] = "2de31918a10c0d244b223db87dd165df68a40334b8bb42fb6bb9b4d4f78e4af8"

URI_aarch64_perl-Mail-DKIM = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Mail-DKIM-1.20240827-1.el10_0.noarch.rpm;name=aarch64_perl-Mail-DKIM;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Mail-DKIM}"
SRC_URI[aarch64_perl-Mail-DKIM.sha256sum] = "661efa2769e1981cb1cd0c2fe8e3398cbb970668d3115337e9c5343e41840af0"

RDEPENDS:perl-Mail-DKIM = " \
 perl-Carp \
 perl-Crypt-OpenSSL-RSA \
 perl-CryptX \
 perl-Digest-SHA \
 perl-MIME-Base64 \
 perl-Mail-AuthenticationResults \
 perl-Mail-DKIM \
 perl-MailTools \
 perl-Net-DNS \
 perl-base \
 perl-libs \
 "
