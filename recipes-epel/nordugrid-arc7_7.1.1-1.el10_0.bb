# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nordugrid-arc7"
PV = "7.1.1"
PR = "1.el10_0"
PACKAGES:x86_64_v2 = " \
 nordugrid-arc7 \
 nordugrid-arc7-arc-exporter \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-archery-manage \
 nordugrid-arc7-arex \
 nordugrid-arc7-arex-lrms-contrib \
 nordugrid-arc7-client \
 nordugrid-arc7-community-rtes \
 nordugrid-arc7-datadelivery-service \
 nordugrid-arc7-devel \
 nordugrid-arc7-hed \
 nordugrid-arc7-infosys-ldap \
 nordugrid-arc7-monitor \
 nordugrid-arc7-plugins-globus \
 nordugrid-arc7-plugins-globus-common \
 nordugrid-arc7-plugins-gridftp \
 nordugrid-arc7-plugins-internal \
 nordugrid-arc7-plugins-lcas-lcmaps \
 nordugrid-arc7-plugins-needed \
 nordugrid-arc7-plugins-python \
 nordugrid-arc7-plugins-s3 \
 nordugrid-arc7-plugins-xrootd \
 nordugrid-arc7-test-utils \
 nordugrid-arc7-wn \
 python3-arcrest \
 python3-nordugrid-arc7 \
"
PACKAGES:aarch64 = " \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-archery-manage \
 nordugrid-arc7-arex \
 nordugrid-arc7-arex-lrms-contrib \
 nordugrid-arc7-client \
 nordugrid-arc7-community-rtes \
 nordugrid-arc7-datadelivery-service \
 nordugrid-arc7-devel \
 nordugrid-arc7-hed \
 nordugrid-arc7-infosys-ldap \
 nordugrid-arc7-monitor \
 nordugrid-arc7-plugins-globus \
 nordugrid-arc7-plugins-globus-common \
 nordugrid-arc7-plugins-gridftp \
 nordugrid-arc7-plugins-internal \
 nordugrid-arc7-plugins-lcas-lcmaps \
 nordugrid-arc7-plugins-needed \
 nordugrid-arc7-plugins-python \
 nordugrid-arc7-plugins-s3 \
 nordugrid-arc7-plugins-xrootd \
 nordugrid-arc7-test-utils \
 nordugrid-arc7-wn \
 python3-arcrest \
 python3-nordugrid-arc7 \
"

URI_src = "${EPELSRC_MIRROR}/Packages/n/nordugrid-arc7-7.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b53d361c6e3e4710265b9a3b721dfa1fced820cf7424524d6065b5d2839d853a"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - nordugrid-arc7-arc-exporter: python3-prometheus_client

URI_x86_64_v2_nordugrid-arc7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7}"
SRC_URI[x86_64_v2_nordugrid-arc7.sha256sum] = "2496d70181d22745f9b497b1732374f6a474aafbc1b2165eaa5877ed01d9198f"

URI_x86_64_v2_nordugrid-arc7-arc-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arc-exporter-7.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-arc-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arc-exporter}"
SRC_URI[x86_64_v2_nordugrid-arc7-arc-exporter.sha256sum] = "9ee406a81e374a2e4caaa862f5de229a63f3d7a4ad7fb0314254d4e64a3d2f38"

URI_x86_64_v2_nordugrid-arc7-arcctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arcctl-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arcctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arcctl}"
SRC_URI[x86_64_v2_nordugrid-arc7-arcctl.sha256sum] = "5e1e04f5e6914720d0859f28a45741c22802df009d141294d957b4a2adaa8bf7"

URI_x86_64_v2_nordugrid-arc7-arcctl-service = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arcctl-service-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arcctl-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arcctl-service}"
SRC_URI[x86_64_v2_nordugrid-arc7-arcctl-service.sha256sum] = "ca03a3df1da84e9f41ad006901edfcae0c543465bd2eb38fe67e9533a537dee5"

URI_x86_64_v2_nordugrid-arc7-archery-manage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-archery-manage-7.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-archery-manage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-archery-manage}"
SRC_URI[x86_64_v2_nordugrid-arc7-archery-manage.sha256sum] = "c166121eb55317c044d1bf59f367e3dd2c4c786b1968a056afadf336a0db0b26"

URI_x86_64_v2_nordugrid-arc7-arex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arex-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arex}"
SRC_URI[x86_64_v2_nordugrid-arc7-arex.sha256sum] = "7356bec6c1f8b5e0dfec2c9fc05ce6cd2b054b88cf335dd5576bb275492588da"

URI_x86_64_v2_nordugrid-arc7-arex-lrms-contrib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arex-lrms-contrib-7.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-arex-lrms-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arex-lrms-contrib}"
SRC_URI[x86_64_v2_nordugrid-arc7-arex-lrms-contrib.sha256sum] = "3febda4c4337d2d8da95005f20cf9170342f3c4072d4a75ca8143cabc2c60d0d"

URI_x86_64_v2_nordugrid-arc7-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-client-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-client}"
SRC_URI[x86_64_v2_nordugrid-arc7-client.sha256sum] = "93d48df200348181fa1ae72e3a9062cc3b5a547325ee79f92725bf073c0c2597"

URI_x86_64_v2_nordugrid-arc7-community-rtes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-community-rtes-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-community-rtes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-community-rtes}"
SRC_URI[x86_64_v2_nordugrid-arc7-community-rtes.sha256sum] = "23c5bf2b0c30658714bec7efae31bb667f0f28181991326e92792cc310448c97"

URI_x86_64_v2_nordugrid-arc7-datadelivery-service = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-datadelivery-service-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-datadelivery-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-datadelivery-service}"
SRC_URI[x86_64_v2_nordugrid-arc7-datadelivery-service.sha256sum] = "a40e7a693048e885fa11c26678fa762d92713a87b35eeeba97fbbadc84ed694e"

URI_x86_64_v2_nordugrid-arc7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-devel-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-devel}"
SRC_URI[x86_64_v2_nordugrid-arc7-devel.sha256sum] = "9ab08330a44127a76d07e29943a10e4239a227afbe8ef6a6ee3059da12f8b6e4"

URI_x86_64_v2_nordugrid-arc7-hed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-hed-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-hed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-hed}"
SRC_URI[x86_64_v2_nordugrid-arc7-hed.sha256sum] = "49b79b087c60e7007e668a917747e0ee4203e2b7cd1dea35b4d917fccb3071c0"

URI_x86_64_v2_nordugrid-arc7-infosys-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-infosys-ldap-7.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-infosys-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-infosys-ldap}"
SRC_URI[x86_64_v2_nordugrid-arc7-infosys-ldap.sha256sum] = "be7361c48eb1ecffab6bd0382ab5d8371b23e3125742f658a56223e63de7f60f"

URI_x86_64_v2_nordugrid-arc7-monitor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-monitor-7.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-monitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-monitor}"
SRC_URI[x86_64_v2_nordugrid-arc7-monitor.sha256sum] = "4e2402c8f9b2ff368f85499b11d491c4962cdfe7d8ab46c47ec19958ce4b063e"

URI_x86_64_v2_nordugrid-arc7-plugins-globus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-globus-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-globus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-globus}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-globus.sha256sum] = "ef22f487e6e38a15968f77f818c70b76d1cc33edeaf91b9d5d22ddadbbf2f5f6"

URI_x86_64_v2_nordugrid-arc7-plugins-globus-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-globus-common-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-globus-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-globus-common}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-globus-common.sha256sum] = "ae65c74341e6c254da73161090ffe19a51e685e0e77ba5b905185cc1738035fd"

URI_x86_64_v2_nordugrid-arc7-plugins-gridftp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-gridftp-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-gridftp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-gridftp}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-gridftp.sha256sum] = "7374f713265fd4db7f35fedd4d5390c4932a15c7f99c836e80e3623bd65287b8"

URI_x86_64_v2_nordugrid-arc7-plugins-internal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-internal-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-internal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-internal}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-internal.sha256sum] = "18415e5c1e485296ee421e0405a48881ac666c5fcc1b2dd8571666f0af66f021"

URI_x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-lcas-lcmaps-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps.sha256sum] = "1d02c73dbbb18011cf1c5672173bee54d7a04a951196fe60cc2b8f512965e2b1"

URI_x86_64_v2_nordugrid-arc7-plugins-needed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-needed-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-needed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-needed}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-needed.sha256sum] = "181189527d34a148bde83fdd7d9606dcfa09b0c259bf8edd5fcc6873bb4b969f"

URI_x86_64_v2_nordugrid-arc7-plugins-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-python-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-python}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-python.sha256sum] = "d5b2ac5b35ca584033ad82eb3eafbf3ffeab03f919b365cab0eed07568885f73"

URI_x86_64_v2_nordugrid-arc7-plugins-s3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-s3-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-s3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-s3}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-s3.sha256sum] = "b4b1c59ff433bfbcc77085bead4cb769b2f4c4c270dbe6234714401f690ef9e4"

URI_x86_64_v2_nordugrid-arc7-plugins-xrootd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-xrootd-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-xrootd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-xrootd}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-xrootd.sha256sum] = "c9ee7e8cf19727c200381b6f9009d20bf05795668e9b24533b0f3486f009ed23"

URI_x86_64_v2_nordugrid-arc7-test-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-test-utils-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-test-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-test-utils}"
SRC_URI[x86_64_v2_nordugrid-arc7-test-utils.sha256sum] = "307191e91418c917a14fbf21f3fd1517d11e5976436f7405b8709c5edeae2f15"

URI_x86_64_v2_nordugrid-arc7-wn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-wn-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-wn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-wn}"
SRC_URI[x86_64_v2_nordugrid-arc7-wn.sha256sum] = "43008212d66ce0947e4114e7dce528394ebd1e4ba8cb94b19498326d524b3fa4"

URI_x86_64_v2_python3-arcrest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-arcrest-7.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-arcrest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-arcrest}"
SRC_URI[x86_64_v2_python3-arcrest.sha256sum] = "40bfd676827639cc53104cf8399c1778321a19e2b332961850e58dc0ee5c9af1"

URI_x86_64_v2_python3-nordugrid-arc7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nordugrid-arc7-7.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nordugrid-arc7}"
SRC_URI[x86_64_v2_python3-nordugrid-arc7.sha256sum] = "cbd79179c9e00a1cb6838349db0aa92306d1e386565709c869a1ae11f28bcaa5"

URI_aarch64_nordugrid-arc7 = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7}"
SRC_URI[aarch64_nordugrid-arc7.sha256sum] = "deedc382edb1b577e375acf45b81334add791f841b74a4c556d624815703ae2e"

URI_aarch64_nordugrid-arc7-arcctl = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arcctl-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-arcctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arcctl}"
SRC_URI[aarch64_nordugrid-arc7-arcctl.sha256sum] = "eeb1f0f41fcf50aa91ea572c9d48cabd31935ceaf385078bbfd7afb09f18262a"

URI_aarch64_nordugrid-arc7-arcctl-service = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arcctl-service-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-arcctl-service;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arcctl-service}"
SRC_URI[aarch64_nordugrid-arc7-arcctl-service.sha256sum] = "033e3fd0835a3c30489c8c0bcd3b46ea9010f62fa021609011e9a17b2ba9238d"

URI_aarch64_nordugrid-arc7-archery-manage = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-archery-manage-7.1.1-1.el10_0.noarch.rpm;name=aarch64_nordugrid-arc7-archery-manage;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-archery-manage}"
SRC_URI[aarch64_nordugrid-arc7-archery-manage.sha256sum] = "ea1b519b1d790e899b84b529e5a00fa49c696caea61ee2437bd080ee43294767"

URI_aarch64_nordugrid-arc7-arex = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arex-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-arex;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arex}"
SRC_URI[aarch64_nordugrid-arc7-arex.sha256sum] = "626ec00c8a7c8557a08794fc2d4d78b2f33dc76e9b998e447128845a7dc3ed4b"

URI_aarch64_nordugrid-arc7-arex-lrms-contrib = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arex-lrms-contrib-7.1.1-1.el10_0.noarch.rpm;name=aarch64_nordugrid-arc7-arex-lrms-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arex-lrms-contrib}"
SRC_URI[aarch64_nordugrid-arc7-arex-lrms-contrib.sha256sum] = "f7c6dbe5617b34ed0befb3ee69e1ab8b109edfaf2a0ef62ad5407c2e49ce480f"

URI_aarch64_nordugrid-arc7-client = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-client-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-client}"
SRC_URI[aarch64_nordugrid-arc7-client.sha256sum] = "b3a0d910a8ae9e6a939290b381d35bbee096b92efcf7da2573969d99d81fb20d"

URI_aarch64_nordugrid-arc7-community-rtes = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-community-rtes-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-community-rtes;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-community-rtes}"
SRC_URI[aarch64_nordugrid-arc7-community-rtes.sha256sum] = "3edb4ecac4c3f72c66034084e280cfecbf6b6d76c3477b0d3e534f2038eb422c"

URI_aarch64_nordugrid-arc7-datadelivery-service = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-datadelivery-service-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-datadelivery-service;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-datadelivery-service}"
SRC_URI[aarch64_nordugrid-arc7-datadelivery-service.sha256sum] = "254e7c5076ee04111d0de8a3b1afc9676e6c522e4d5f4d6e51ea50fd82e32000"

URI_aarch64_nordugrid-arc7-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-devel-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-devel}"
SRC_URI[aarch64_nordugrid-arc7-devel.sha256sum] = "89aeec8a18a99f984626dfec30ec583c26127694e4f33327b4b11c02dab78250"

URI_aarch64_nordugrid-arc7-hed = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-hed-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-hed;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-hed}"
SRC_URI[aarch64_nordugrid-arc7-hed.sha256sum] = "eb1c37af6fe5c56231f84d28d62d699627fcaddb765ddb5f9cc95f77f62b1dcc"

URI_aarch64_nordugrid-arc7-infosys-ldap = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-infosys-ldap-7.1.1-1.el10_0.noarch.rpm;name=aarch64_nordugrid-arc7-infosys-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-infosys-ldap}"
SRC_URI[aarch64_nordugrid-arc7-infosys-ldap.sha256sum] = "f899fbd319ecdcf45d62469d7b7a660f69e4650dbf80726a188d07a1308515d1"

URI_aarch64_nordugrid-arc7-monitor = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-monitor-7.1.1-1.el10_0.noarch.rpm;name=aarch64_nordugrid-arc7-monitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-monitor}"
SRC_URI[aarch64_nordugrid-arc7-monitor.sha256sum] = "ca4e08f6c12e74c72c47e0f4053206ba6be7c18598a25e6b625d36c281dae010"

URI_aarch64_nordugrid-arc7-plugins-globus = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-globus-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-globus;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-globus}"
SRC_URI[aarch64_nordugrid-arc7-plugins-globus.sha256sum] = "089f455da691e04752d34a4563123962e28ba03e92e14c59d774b6a4bf5dfe34"

URI_aarch64_nordugrid-arc7-plugins-globus-common = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-globus-common-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-globus-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-globus-common}"
SRC_URI[aarch64_nordugrid-arc7-plugins-globus-common.sha256sum] = "3f4ca2687022bae17ce911d10ff1352c601db7c9e67bcada1e4fbf0ba3f6e85e"

URI_aarch64_nordugrid-arc7-plugins-gridftp = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-gridftp-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-gridftp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-gridftp}"
SRC_URI[aarch64_nordugrid-arc7-plugins-gridftp.sha256sum] = "545a93fa3e2ef20eec4a7d461a1627f1d59ee13f3d7d56aedd440590d1061fc0"

URI_aarch64_nordugrid-arc7-plugins-internal = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-internal-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-internal;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-internal}"
SRC_URI[aarch64_nordugrid-arc7-plugins-internal.sha256sum] = "cb6bf73d0b488886876529e599fb5ebfaa0e0e4f8cec0502f10e013aba6cae78"

URI_aarch64_nordugrid-arc7-plugins-lcas-lcmaps = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-lcas-lcmaps-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-lcas-lcmaps;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-lcas-lcmaps}"
SRC_URI[aarch64_nordugrid-arc7-plugins-lcas-lcmaps.sha256sum] = "1a5550497622b8ff5c1308026ea3fa452dd299eddb12ac96d58c49b883df0bce"

URI_aarch64_nordugrid-arc7-plugins-needed = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-needed-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-needed;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-needed}"
SRC_URI[aarch64_nordugrid-arc7-plugins-needed.sha256sum] = "b49c5cf06c1a0f53f61c1df1c768ebf2b605720d881d4266b6c283a5a3d7095b"

URI_aarch64_nordugrid-arc7-plugins-python = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-python-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-python}"
SRC_URI[aarch64_nordugrid-arc7-plugins-python.sha256sum] = "30de1f0562c04ef0f0aeab1a67d13391093a6ae2c27da8d7e0b45bfa07814e45"

URI_aarch64_nordugrid-arc7-plugins-s3 = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-s3-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-s3;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-s3}"
SRC_URI[aarch64_nordugrid-arc7-plugins-s3.sha256sum] = "30c002971a32f3996ec4f23a1c6b447774e18d7e618dada62c12ec7f35d01e3d"

URI_aarch64_nordugrid-arc7-plugins-xrootd = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-xrootd-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-xrootd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-xrootd}"
SRC_URI[aarch64_nordugrid-arc7-plugins-xrootd.sha256sum] = "209c51a4d662fe902a4971681eceb54b8dfbf9cb4fc6e6b93bae8d2e073abb5d"

URI_aarch64_nordugrid-arc7-test-utils = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-test-utils-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-test-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-test-utils}"
SRC_URI[aarch64_nordugrid-arc7-test-utils.sha256sum] = "2cb5e6d77cf079603e82d812f645fd55106f78fec4403e9b71c42de9b9024ccb"

URI_aarch64_nordugrid-arc7-wn = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-wn-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_nordugrid-arc7-wn;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-wn}"
SRC_URI[aarch64_nordugrid-arc7-wn.sha256sum] = "4bc7e88fa25c63156efa6533ed03b313554677ace39e50929b4e6d5de3f52f35"

URI_aarch64_python3-arcrest = "${EPEL_MIRROR}/aarch64/Packages/p/python3-arcrest-7.1.1-1.el10_0.noarch.rpm;name=aarch64_python3-arcrest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-arcrest}"
SRC_URI[aarch64_python3-arcrest.sha256sum] = "54ecb2ec09224915dbd39918f1ef16f0ad9906727811d4a70b4acdd7e6ae4878"

URI_aarch64_python3-nordugrid-arc7 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nordugrid-arc7-7.1.1-1.el10_0.aarch64.rpm;name=aarch64_python3-nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nordugrid-arc7}"
SRC_URI[aarch64_python3-nordugrid-arc7.sha256sum] = "cc1d9317a8ea029e590303031e50e47d28775d828c7d21306ca90b485a93dc91"

RDEPENDS:nordugrid-arc7 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 hostname \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nspr \
 nss \
 nss-util \
 openssl \
 openssl-libs \
 python3 \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-arc-exporter = " \
 python3 \
 "
RDEPENDS:nordugrid-arc7-arcctl = " \
 nordugrid-arc7 \
 python3 \
 python3-jwcrypto \
 "
RDEPENDS:nordugrid-arc7-arcctl-service = " \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl \
 python3 \
 "
RDEPENDS:nordugrid-arc7-archery-manage = " \
 python3 \
 python3-dns \
 python3-ldap \
 "
RDEPENDS:nordugrid-arc7-arex = " \
 bash \
 findutils \
 glib2 \
 glibc \
 glibmm2.68 \
 hostname \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 logrotate \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-hed \
 nordugrid-arc7-plugins-needed \
 nspr \
 nss \
 nss-util \
 openssl \
 openssl-libs \
 perl-Data-Dumper \
 perl-Digest-SHA1 \
 perl-DirHandle \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-JSON-XS \
 perl-MIME-Base64 \
 perl-POSIX \
 perl-PathTools \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Time-Local \
 perl-XML-Simple \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-vars \
 procps-ng \
 python3 \
 sqlite-libs \
 systemd \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-arex-lrms-contrib = " \
 bash \
 nordugrid-arc7-arex \
 perl-DBI \
 perl-Data-Dumper \
 perl-Exporter \
 perl-POSIX \
 perl-Sys-Hostname \
 perl-XML-Simple \
 perl-libs \
 "
RDEPENDS:nordugrid-arc7-client = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-needed \
 openssl-libs \
 "
RDEPENDS:nordugrid-arc7-community-rtes = " \
 gnupg2 \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arex \
 python3 \
 python3-dns \
 "
RDEPENDS:nordugrid-arc7-datadelivery-service = " \
 bash \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 logrotate \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-hed \
 nordugrid-arc7-plugins-needed \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 systemd \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-devel = " \
 glib2 \
 glibc \
 glibmm2.68 \
 glibmm2.68-devel \
 libgcc \
 libstdc++ \
 libxml2-devel \
 nordugrid-arc7 \
 openssl-devel \
 "
RDEPENDS:nordugrid-arc7-hed = " \
 bash \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 systemd \
 systemd-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-infosys-ldap = " \
 bash \
 bdii \
 glue-schema \
 logrotate \
 nordugrid-arc7-arcctl-service \
 openldap-servers \
 policycoreutils-python-utils \
 systemd \
 "
RDEPENDS:nordugrid-arc7-monitor = " \
 nordugrid-arc7 \
 php \
 php-gd \
 php-ldap \
 "
RDEPENDS:nordugrid-arc7-plugins-globus = " \
 nordugrid-arc7-plugins-gridftp \
 nordugrid-arc7-plugins-lcas-lcmaps \
 "
RDEPENDS:nordugrid-arc7-plugins-globus-common = " \
 glib2 \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-gsi-callback \
 globus-gssapi-gsi \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-gridftp = " \
 glib2 \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-ftp-client \
 globus-ftp-control \
 globus-io \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-globus-common \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-internal = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nordugrid-arc7-arex \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-lcas-lcmaps = " \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gssapi-gsi \
 libgcc \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-globus-common \
 openssl-libs \
 "
RDEPENDS:nordugrid-arc7-plugins-needed = " \
 glib2 \
 glibc \
 glibmm2.68 \
 ldns \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-python = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 python3-libs \
 python3-nordugrid-arc7 \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-s3 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libs3 \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-xrootd = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 xrootd-client-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-test-utils = " \
 glibc \
 libgcc \
 libsigc++30 \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-needed \
 "
RDEPENDS:nordugrid-arc7-wn = " \
 glibc \
 "
RDEPENDS:python3-arcrest = " \
 python3 \
 python3-cryptography \
 "
RDEPENDS:python3-nordugrid-arc7 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 python3 \
 python3-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
