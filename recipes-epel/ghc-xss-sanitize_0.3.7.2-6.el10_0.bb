# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-xss-sanitize"
PV = "0.3.7.2"
PR = "6.el10_0"
PACKAGES = " \
 ghc-xss-sanitize \
 ghc-xss-sanitize-devel \
 ghc-xss-sanitize-doc \
 ghc-xss-sanitize-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-xss-sanitize-0.3.7.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "864170bf3005ff9e46c06c231705edc62630fd944b510560a8f135af3db2acb9"

URI_x86_64_v2_ghc-xss-sanitize = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xss-sanitize-0.3.7.2-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xss-sanitize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xss-sanitize}"
SRC_URI[x86_64_v2_ghc-xss-sanitize.sha256sum] = "0a8b5f489956397b1233902c68d3f74f1110e98c2a764fdb201f33e51696f010"

URI_x86_64_v2_ghc-xss-sanitize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xss-sanitize-devel-0.3.7.2-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xss-sanitize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xss-sanitize-devel}"
SRC_URI[x86_64_v2_ghc-xss-sanitize-devel.sha256sum] = "1a29b3584f43110e95b0e0f1aea3628cdc344d42798d379709869f0a5086adbb"

URI_x86_64_v2_ghc-xss-sanitize-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xss-sanitize-doc-0.3.7.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-xss-sanitize-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xss-sanitize-doc}"
SRC_URI[x86_64_v2_ghc-xss-sanitize-doc.sha256sum] = "8dc627636955661d15fbb2e2152847a9e7f5463f172d434ce5a7234e7f56f762"

URI_x86_64_v2_ghc-xss-sanitize-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xss-sanitize-prof-0.3.7.2-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xss-sanitize-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xss-sanitize-prof}"
SRC_URI[x86_64_v2_ghc-xss-sanitize-prof.sha256sum] = "42b18bc8b05fbd45deb514e388dfd69a3b67dbf81120e1440da4df7eb9304ff2"

URI_aarch64_ghc-xss-sanitize = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xss-sanitize-0.3.7.2-6.el10_0.aarch64.rpm;name=aarch64_ghc-xss-sanitize;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xss-sanitize}"
SRC_URI[aarch64_ghc-xss-sanitize.sha256sum] = "e1ef98a86b8858effc4e6b6c1785530b2fd0f28a679db64fec092fbd6010dec9"

URI_aarch64_ghc-xss-sanitize-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xss-sanitize-devel-0.3.7.2-6.el10_0.aarch64.rpm;name=aarch64_ghc-xss-sanitize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xss-sanitize-devel}"
SRC_URI[aarch64_ghc-xss-sanitize-devel.sha256sum] = "3bbec3fe46a0bb8a2efcf70131addc1a7e53d07bc8a85ee84ba29ef8169ff3c8"

URI_aarch64_ghc-xss-sanitize-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xss-sanitize-doc-0.3.7.2-6.el10_0.noarch.rpm;name=aarch64_ghc-xss-sanitize-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xss-sanitize-doc}"
SRC_URI[aarch64_ghc-xss-sanitize-doc.sha256sum] = "be7270fa00bda98a25f8c440fa773278ba3078682e80abb6ac423c0056883255"

URI_aarch64_ghc-xss-sanitize-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xss-sanitize-prof-0.3.7.2-6.el10_0.aarch64.rpm;name=aarch64_ghc-xss-sanitize-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xss-sanitize-prof}"
SRC_URI[aarch64_ghc-xss-sanitize-prof.sha256sum] = "f8e1d2e4348222a00f291964f6514b4643d18f43efb4420d7ec9f992ada0373a"

RDEPENDS:ghc-xss-sanitize = " \
 ghc-array \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-css-text \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-network-uri \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-scientific \
 ghc-stm \
 ghc-tagsoup \
 ghc-template-haskell \
 ghc-text \
 ghc-th-compat \
 ghc-transformers \
 ghc-utf8-string \
 glibc \
 gmp \
 "
RDEPENDS:ghc-xss-sanitize-devel = " \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-css-text-devel \
 ghc-network-uri-devel \
 ghc-tagsoup-devel \
 ghc-text-devel \
 ghc-utf8-string-devel \
 ghc-xss-sanitize \
 "
RDEPENDS:ghc-xss-sanitize-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-xss-sanitize-prof = " \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-css-text-prof \
 ghc-network-uri-prof \
 ghc-tagsoup-prof \
 ghc-text-prof \
 ghc-utf8-string-prof \
 ghc-xss-sanitize-devel \
 "
