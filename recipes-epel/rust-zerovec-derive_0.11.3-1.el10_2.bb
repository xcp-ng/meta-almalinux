# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerovec-derive"
PV = "0.11.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-zerovec-derive+default-devel \
 rust-zerovec-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerovec-derive-0.11.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7238347c86489301f44a1addd6dae8ec793da7872aa1b87dde9c49c278f600cc"

URI_x86_64_v2_rust-zerovec-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-derive+default-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec-derive+default-devel}"
SRC_URI[x86_64_v2_rust-zerovec-derive+default-devel.sha256sum] = "8f261da80c69ec812050ae83cd19f9a4fb6d5640cdc3e76b20c5a4de6045cbaa"

URI_x86_64_v2_rust-zerovec-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-derive-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec-derive-devel}"
SRC_URI[x86_64_v2_rust-zerovec-derive-devel.sha256sum] = "25c71e8cfe51d0fab6c00547410c28a9a383885ae9026a93ec64fce82c1b03c7"

URI_aarch64_rust-zerovec-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-derive+default-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-zerovec-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec-derive+default-devel}"
SRC_URI[aarch64_rust-zerovec-derive+default-devel.sha256sum] = "1041040bec2b92ab62586341aa23017703fb34207310842fb1cde6c162867dd2"

URI_aarch64_rust-zerovec-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-derive-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-zerovec-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec-derive-devel}"
SRC_URI[aarch64_rust-zerovec-derive-devel.sha256sum] = "0ebb45129be2ec14a1e8714396032901787fdb0c6cec994af46a35a06ca007dd"

RDEPENDS:rust-zerovec-derive+default-devel = " \
 cargo \
 rust-zerovec-derive-devel \
 "
RDEPENDS:rust-zerovec-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 "
