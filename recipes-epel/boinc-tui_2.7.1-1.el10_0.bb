# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "boinc-tui"
PV = "2.7.1"
PR = "1.el10_0"
PACKAGES = " \
 boinc-tui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/boinc-tui-2.7.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "930b331bf31f04d3ae583ab3f9621a900920044ecbb9c1b73fffeefb61c0c0d8"

URI_x86_64_v2_boinc-tui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/boinc-tui-2.7.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_boinc-tui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boinc-tui}"
SRC_URI[x86_64_v2_boinc-tui.sha256sum] = "22bb0fd6edf35ec7aaacd29ea7ce0b2c46cda7d489d906cb4eb1729cc0439246"

URI_aarch64_boinc-tui = "${EPEL_MIRROR}/aarch64/Packages/b/boinc-tui-2.7.1-1.el10_0.aarch64.rpm;name=aarch64_boinc-tui;unpack=0"
SRC_URI:append = " ${URI_aarch64_boinc-tui}"
SRC_URI[aarch64_boinc-tui.sha256sum] = "46ad9268fd0df932e39722126a365b700f1bee42f03e324100fb08944770a707"

RDEPENDS:boinc-tui = " \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 openssl-libs \
 "
