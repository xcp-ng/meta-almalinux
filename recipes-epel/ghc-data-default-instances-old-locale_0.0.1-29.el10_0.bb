# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-data-default-instances-old-locale"
PV = "0.0.1"
PR = "29.el10_0"
PACKAGES = " \
 ghc-data-default-instances-old-locale \
 ghc-data-default-instances-old-locale-devel \
 ghc-data-default-instances-old-locale-doc \
 ghc-data-default-instances-old-locale-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-data-default-instances-old-locale-0.0.1-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2aa834d7ff3c0d98ea2e038db9cbb725577e1313a9531909e8044d2bc1d32815"

URI_x86_64_v2_ghc-data-default-instances-old-locale = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-instances-old-locale-0.0.1-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default-instances-old-locale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-instances-old-locale}"
SRC_URI[x86_64_v2_ghc-data-default-instances-old-locale.sha256sum] = "fcad4d7347e92cf1ee630053b3ab4c25acfae829836cd8fa06b9e858681f9fcb"

URI_x86_64_v2_ghc-data-default-instances-old-locale-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-instances-old-locale-devel-0.0.1-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default-instances-old-locale-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-instances-old-locale-devel}"
SRC_URI[x86_64_v2_ghc-data-default-instances-old-locale-devel.sha256sum] = "aa305515b12f0cc90e0e7fe603fa5f7bc1da1d032612233dd3c2032729b15b17"

URI_x86_64_v2_ghc-data-default-instances-old-locale-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-instances-old-locale-doc-0.0.1-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-data-default-instances-old-locale-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-instances-old-locale-doc}"
SRC_URI[x86_64_v2_ghc-data-default-instances-old-locale-doc.sha256sum] = "b36d60f6b2d26d2237e4458dd355c1c435bc5b50247807f2f365f59bfe89c24c"

URI_x86_64_v2_ghc-data-default-instances-old-locale-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-instances-old-locale-prof-0.0.1-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default-instances-old-locale-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-instances-old-locale-prof}"
SRC_URI[x86_64_v2_ghc-data-default-instances-old-locale-prof.sha256sum] = "718b2ee6d0f7632690e6ae089961c977ac5c0efe0ceb79c13872faf6fb96d6c6"

URI_aarch64_ghc-data-default-instances-old-locale = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-instances-old-locale-0.0.1-29.el10_0.aarch64.rpm;name=aarch64_ghc-data-default-instances-old-locale;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-instances-old-locale}"
SRC_URI[aarch64_ghc-data-default-instances-old-locale.sha256sum] = "cb061d7c78c310b40aaef9a719a4c3d9c5326e405106c07c6178134f3ef7a6af"

URI_aarch64_ghc-data-default-instances-old-locale-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-instances-old-locale-devel-0.0.1-29.el10_0.aarch64.rpm;name=aarch64_ghc-data-default-instances-old-locale-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-instances-old-locale-devel}"
SRC_URI[aarch64_ghc-data-default-instances-old-locale-devel.sha256sum] = "81c49f1b06bec5705a0f2a7c5f1d5aa42af4c13eb48caf2e60e246a16a139a2c"

URI_aarch64_ghc-data-default-instances-old-locale-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-instances-old-locale-doc-0.0.1-29.el10_0.noarch.rpm;name=aarch64_ghc-data-default-instances-old-locale-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-instances-old-locale-doc}"
SRC_URI[aarch64_ghc-data-default-instances-old-locale-doc.sha256sum] = "ff9faa178eafacc159fd862f1bc29f048bf8d9996df3ae1ac87b6fed702457d7"

URI_aarch64_ghc-data-default-instances-old-locale-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-instances-old-locale-prof-0.0.1-29.el10_0.aarch64.rpm;name=aarch64_ghc-data-default-instances-old-locale-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-instances-old-locale-prof}"
SRC_URI[aarch64_ghc-data-default-instances-old-locale-prof.sha256sum] = "4fb97e4349b8d314345a0f1c1076e97bd49bc4d7628cc37ab4a0548f81e31338"

RDEPENDS:ghc-data-default-instances-old-locale = " \
 ghc-base \
 ghc-data-default-class \
 ghc-ghc-bignum \
 ghc-old-locale \
 glibc \
 gmp \
 "
RDEPENDS:ghc-data-default-instances-old-locale-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-data-default-class-devel \
 ghc-data-default-instances-old-locale \
 ghc-old-locale-devel \
 "
RDEPENDS:ghc-data-default-instances-old-locale-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-data-default-instances-old-locale-prof = " \
 ghc-base-prof \
 ghc-data-default-class-prof \
 ghc-data-default-instances-old-locale-devel \
 ghc-old-locale-prof \
 "
