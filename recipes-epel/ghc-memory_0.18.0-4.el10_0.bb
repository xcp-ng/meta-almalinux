# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-memory"
PV = "0.18.0"
PR = "4.el10_0"
PACKAGES = " \
 ghc-memory \
 ghc-memory-devel \
 ghc-memory-doc \
 ghc-memory-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-memory-0.18.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b67ed1b9548d2d5192728773ff44d4c1b642cb95cb55e37d478415470befb5c6"

URI_x86_64_v2_ghc-memory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-memory-0.18.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-memory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-memory}"
SRC_URI[x86_64_v2_ghc-memory.sha256sum] = "cb23c9d4972545dae753e25aa370d50ca66ac2bdb44f50a6164dbbd6ad635468"

URI_x86_64_v2_ghc-memory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-memory-devel-0.18.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-memory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-memory-devel}"
SRC_URI[x86_64_v2_ghc-memory-devel.sha256sum] = "e10397708e40f1591eac82f5080e905142ea164e8d825eb000d7c6f6053264d0"

URI_x86_64_v2_ghc-memory-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-memory-doc-0.18.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-memory-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-memory-doc}"
SRC_URI[x86_64_v2_ghc-memory-doc.sha256sum] = "3a35dc08a0147006e80bebb6235a311239e1f41653a6141d9733fb80c94fead6"

URI_x86_64_v2_ghc-memory-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-memory-prof-0.18.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-memory-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-memory-prof}"
SRC_URI[x86_64_v2_ghc-memory-prof.sha256sum] = "397ea32b9fd0c8de329027f0a06bda6b90e3dc6b5d63467b887fc9c7468558fd"

URI_aarch64_ghc-memory = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-memory-0.18.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-memory;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-memory}"
SRC_URI[aarch64_ghc-memory.sha256sum] = "794b8a49c2f97ef6c0890577b99add140f87eeb8b6cef1d63ac16fee217d3b18"

URI_aarch64_ghc-memory-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-memory-devel-0.18.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-memory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-memory-devel}"
SRC_URI[aarch64_ghc-memory-devel.sha256sum] = "c7d01b714f35ea0d99255458f9034374289309b7a1e069523b292d002567c665"

URI_aarch64_ghc-memory-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-memory-doc-0.18.0-4.el10_0.noarch.rpm;name=aarch64_ghc-memory-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-memory-doc}"
SRC_URI[aarch64_ghc-memory-doc.sha256sum] = "1beedcdbc6926145627766bd236677979ba54ce22d79989ae8a99e1beb183f00"

URI_aarch64_ghc-memory-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-memory-prof-0.18.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-memory-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-memory-prof}"
SRC_URI[aarch64_ghc-memory-prof.sha256sum] = "ca762e573e1d73d68e3c1dafe36e549800f6836f1b0b1ea99d54b19893c74c00"

RDEPENDS:ghc-memory = " \
 ghc-array \
 ghc-base \
 ghc-basement \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-memory-devel = " \
 ghc-base-devel \
 ghc-basement-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-memory \
 "
RDEPENDS:ghc-memory-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-memory-prof = " \
 ghc-base-prof \
 ghc-basement-prof \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 ghc-memory-devel \
 "
