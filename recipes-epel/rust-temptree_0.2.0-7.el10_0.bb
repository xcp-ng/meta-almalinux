# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-temptree"
PV = "0.2.0"
PR = "7.el10_0"
PACKAGES = " \
 rust-temptree+default-devel \
 rust-temptree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-temptree-0.2.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3a31a6f479d33e0232a0fef8b4be37c29f18e4324f3e2a64726e8af723854c3"

URI_x86_64_v2_rust-temptree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-temptree+default-devel-0.2.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-temptree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-temptree+default-devel}"
SRC_URI[x86_64_v2_rust-temptree+default-devel.sha256sum] = "635f41752886619d5d48db7890ac69f77687faff3759c528afd553fe34842ffb"

URI_x86_64_v2_rust-temptree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-temptree-devel-0.2.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-temptree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-temptree-devel}"
SRC_URI[x86_64_v2_rust-temptree-devel.sha256sum] = "3f991b5fa76bafc0be08042099326e286d3d871a1fdd8aa8c147c2e7b72612cb"

URI_aarch64_rust-temptree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-temptree+default-devel-0.2.0-7.el10_0.noarch.rpm;name=aarch64_rust-temptree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-temptree+default-devel}"
SRC_URI[aarch64_rust-temptree+default-devel.sha256sum] = "9f693891c57538f741edc5ad6ad82d8fb46036d1a4bd6d7c09a186f27394a575"

URI_aarch64_rust-temptree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-temptree-devel-0.2.0-7.el10_0.noarch.rpm;name=aarch64_rust-temptree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-temptree-devel}"
SRC_URI[aarch64_rust-temptree-devel.sha256sum] = "f89273868c1b756863c9b1fe49b03f66240e228565c675e143591cea74209074"

RDEPENDS:rust-temptree+default-devel = " \
 cargo \
 rust-temptree-devel \
 "
RDEPENDS:rust-temptree-devel = " \
 bash \
 cargo \
 rust-tempfile+default-devel \
 "
