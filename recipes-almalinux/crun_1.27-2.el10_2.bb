# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crun"
PV = "1.27"
PR = "2.el10_2"
PACKAGES = " \
 crun \
 crun-krun \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/crun-1.27-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ff82677be9a40305b258c05d3759df5bc887cb736c8ba5ccd3e5b004be5365d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crun-1.27-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_crun;unpack=0"
SRC_URI[x86_64_v2_crun.sha256sum] = "8e5a80b2f138b2dcfdde71f7abe990060fe8628ce83178e902e6b1909ab71959"
RPROVIDES:crun:append:x86_64_v2 = " virtual/oci-runtime"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crun-krun-1.27-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_crun-krun;unpack=0"
SRC_URI[x86_64_v2_crun-krun.sha256sum] = "306374930e1ab0e0e28ce3dde8a311bbc6ff5f0fc54244957a0d2be25e0a0ad3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crun-1.27-2.el10_2.aarch64.rpm;name=aarch64_crun;unpack=0"
SRC_URI[aarch64_crun.sha256sum] = "c037689372b57c830efa3bf4539164a001dcdd20aa270950b4f8c0a7f0ae8257"
RPROVIDES:crun:append:aarch64 = " virtual/oci-runtime"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crun-krun-1.27-2.el10_2.aarch64.rpm;name=aarch64_crun-krun;unpack=0"
SRC_URI[aarch64_crun-krun.sha256sum] = "62f9a7e2aa2f4ffbb2066fbfc3cc2f539986968ea60cafa3e5cf5a66bb5781af"

RDEPENDS:crun = " \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 systemd-libs \
 "
RDEPENDS:crun-krun = " \
 crun \
 libkrun \
 "
