# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kjumpingcube"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kjumpingcube \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kjumpingcube-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3295e2964d2d49988e9fd5c390fb8810f0a43ec79fc2156f8f964ee431faa582"

URI_x86_64_v2_kjumpingcube = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjumpingcube-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjumpingcube;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kjumpingcube}"
SRC_URI[x86_64_v2_kjumpingcube.sha256sum] = "845dd8bb57d438cba9d77823b4a11be799890f5ced88ac8902e90c5129dd1b7d"

URI_aarch64_kjumpingcube = "${EPEL_MIRROR}/aarch64/Packages/k/kjumpingcube-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kjumpingcube;unpack=0"
SRC_URI:append = " ${URI_aarch64_kjumpingcube}"
SRC_URI[aarch64_kjumpingcube.sha256sum] = "6fee1eb2bdafb883a14afd35629bbc66af32739ca2346db392c9759d17fd9743"

RDEPENDS:kjumpingcube = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
