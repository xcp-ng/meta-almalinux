# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sereal-Decoder"
PV = "5.006"
PR = "1.el10_3"
PACKAGES = " \
 perl-Sereal-Decoder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sereal-Decoder-5.006-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b5e0c4a78ebd033b0dcc6c60595cd360a6cc5e1cd7dadf6f642391d399bdb3b"

URI_x86_64_v2_perl-Sereal-Decoder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sereal-Decoder-5.006-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sereal-Decoder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sereal-Decoder}"
SRC_URI[x86_64_v2_perl-Sereal-Decoder.sha256sum] = "9cee763356a8da91be2a88d280e3f26546c9d45401066f3feffcffe8c7bc71a4"

URI_aarch64_perl-Sereal-Decoder = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sereal-Decoder-5.006-1.el10_3.aarch64.rpm;name=aarch64_perl-Sereal-Decoder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sereal-Decoder}"
SRC_URI[aarch64_perl-Sereal-Decoder.sha256sum] = "0dbbecbda17d0ac41b7b59512f9482992e5308d1f8249d8e1ecf67ea53b6addb"

RDEPENDS:perl-Sereal-Decoder = " \
 csnappy \
 glibc \
 libzstd \
 miniz \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
