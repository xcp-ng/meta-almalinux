# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdfp"
PV = "1.0.17"
PR = "1.el10_2"
PACKAGES = " \
 libdfp \
 libdfp-devel \
 libdfp-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdfp-1.0.17-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6362cdec131b0af8d44c5cb52800c1888635675471dbd8f447dda1d22bb83d8"

URI_x86_64_v2_libdfp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdfp-1.0.17-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdfp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdfp}"
SRC_URI[x86_64_v2_libdfp.sha256sum] = "9fa43d0eead9b2f4844acb0ea791360cc296dd591b95175eed180158a45574f8"

URI_x86_64_v2_libdfp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdfp-devel-1.0.17-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdfp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdfp-devel}"
SRC_URI[x86_64_v2_libdfp-devel.sha256sum] = "d5e207e339a9275795c4db80ef5782237f7dfb9b93956f38c45edf198cdd54de"

URI_x86_64_v2_libdfp-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdfp-static-1.0.17-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdfp-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdfp-static}"
SRC_URI[x86_64_v2_libdfp-static.sha256sum] = "9f518b515c7e664c4ac05556a2b57d397b17b382edde3ea45730dd61e9828688"

URI_aarch64_libdfp = "${EPEL_MIRROR}/aarch64/Packages/l/libdfp-1.0.17-1.el10_2.aarch64.rpm;name=aarch64_libdfp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdfp}"
SRC_URI[aarch64_libdfp.sha256sum] = "fd7609699931c64229ecf993cc095c978a99a4bc3e915e1763d8f8a192d33cc6"

URI_aarch64_libdfp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdfp-devel-1.0.17-1.el10_2.aarch64.rpm;name=aarch64_libdfp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdfp-devel}"
SRC_URI[aarch64_libdfp-devel.sha256sum] = "42d46dbce80812b2a42120a195986074d77c0a04bae8562007acbece3a45acc2"

URI_aarch64_libdfp-static = "${EPEL_MIRROR}/aarch64/Packages/l/libdfp-static-1.0.17-1.el10_2.aarch64.rpm;name=aarch64_libdfp-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdfp-static}"
SRC_URI[aarch64_libdfp-static.sha256sum] = "71e1ff243ba398b6fbebcd9d06fccb72bed7c2713a00d75ecfb351397832fb33"

RDEPENDS:libdfp = " \
 glibc \
 libgcc \
 "
RDEPENDS:libdfp-devel = " \
 libdfp \
 pkgconf-pkg-config \
 "
RDEPENDS:libdfp-static = " \
 libdfp-devel \
 pkgconf-pkg-config \
 "
