# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_edit"
PV = "0.25.15"
PR = "1.el10_3"
PACKAGES = " \
 rust-toml_edit+debug-devel \
 rust-toml_edit+default-devel \
 rust-toml_edit+display-devel \
 rust-toml_edit+parse-devel \
 rust-toml_edit+serde-devel \
 rust-toml_edit+unbounded-devel \
 rust-toml_edit-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-toml_edit-0.25.15-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a89375fb47854e8c9aa1477ddbc2581351d28680aa50f4d771959c01310618e3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+debug-devel-0.25.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_edit+debug-devel.sha256sum] = "cd6596d6edb796a02c4016a8b220f8431bf57bd4273910d17dace9a918c940c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+default-devel-0.25.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_edit+default-devel.sha256sum] = "3406b960dd7f2ef6cddf3b91404791f696ec0346af48ff47da363f3e10a06c79"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+display-devel-0.25.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+display-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_edit+display-devel.sha256sum] = "7a3c85d1de8c37e676075e0a4916150fc6ebbe88b4341f1b7821c6934e719cb2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+parse-devel-0.25.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+parse-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_edit+parse-devel.sha256sum] = "b9b661dbb8998e041daedd591c7980d936213da23888f4522f17f187b49cdc3d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+serde-devel-0.25.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_edit+serde-devel.sha256sum] = "7dd64bfb5658bad5478f7770359b0796a6dac109c390e8641aff421a48774901"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+unbounded-devel-0.25.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+unbounded-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_edit+unbounded-devel.sha256sum] = "8080cc81bf07bacc5ec5f8098d4cbbb980202592e06a30eefe05d819b2f49e49"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit-devel-0.25.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_edit-devel.sha256sum] = "3ada9cf084186eadcb068e4c0f454e15c1edb79470a910c049df756c114e6d27"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+debug-devel-0.25.15-1.el10_3.noarch.rpm;name=aarch64_rust-toml_edit+debug-devel;unpack=0"
SRC_URI[aarch64_rust-toml_edit+debug-devel.sha256sum] = "591d4d960504478a58339f18a3a37b0be51a9bdda3f6ae8ccc21359e7fc4c724"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+default-devel-0.25.15-1.el10_3.noarch.rpm;name=aarch64_rust-toml_edit+default-devel;unpack=0"
SRC_URI[aarch64_rust-toml_edit+default-devel.sha256sum] = "b693db9e9d8a005573cfaa2abb17de73f5d86c3080fb397a23881a0de33d467d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+display-devel-0.25.15-1.el10_3.noarch.rpm;name=aarch64_rust-toml_edit+display-devel;unpack=0"
SRC_URI[aarch64_rust-toml_edit+display-devel.sha256sum] = "34e9726eb0588c2c34a3131fb03d3434734ecce83a830cf106884f39a78731ec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+parse-devel-0.25.15-1.el10_3.noarch.rpm;name=aarch64_rust-toml_edit+parse-devel;unpack=0"
SRC_URI[aarch64_rust-toml_edit+parse-devel.sha256sum] = "1f868e1f42a3bdf85d1cbf21f3223a2ff7972e7645df40aeee956b088fead49b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+serde-devel-0.25.15-1.el10_3.noarch.rpm;name=aarch64_rust-toml_edit+serde-devel;unpack=0"
SRC_URI[aarch64_rust-toml_edit+serde-devel.sha256sum] = "54dd2f991eeba6dd3cbc7732e37ced0bab61fcd09fb3e3663a826bfc14c5d1a2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+unbounded-devel-0.25.15-1.el10_3.noarch.rpm;name=aarch64_rust-toml_edit+unbounded-devel;unpack=0"
SRC_URI[aarch64_rust-toml_edit+unbounded-devel.sha256sum] = "765b624a766c930b4efe8e02028e64673f4d911372436040fbd7f4515447e6ab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit-devel-0.25.15-1.el10_3.noarch.rpm;name=aarch64_rust-toml_edit-devel;unpack=0"
SRC_URI[aarch64_rust-toml_edit-devel.sha256sum] = "3f137ebd7e5af9d9e15a79c25354e99424fd88d5ccdd08788317bed33de5a279"

RDEPENDS:rust-toml_edit+debug-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-toml_edit+display-devel \
 rust-toml_edit-devel \
 rust-toml_parser+debug-devel \
 rust-toml_parser+default-devel \
 "
RDEPENDS:rust-toml_edit+default-devel = " \
 cargo \
 rust-toml_edit+display-devel \
 rust-toml_edit+parse-devel \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit+display-devel = " \
 cargo \
 rust-toml_edit-devel \
 rust-toml_writer+default-devel \
 "
RDEPENDS:rust-toml_edit+parse-devel = " \
 cargo \
 rust-toml_edit-devel \
 rust-toml_parser+default-devel \
 rust-winnow+default-devel \
 "
RDEPENDS:rust-toml_edit+serde-devel = " \
 cargo \
 rust-serde_core+default-devel \
 rust-serde_spanned+default-devel \
 rust-serde_spanned+serde-devel \
 rust-toml_datetime+serde-devel \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit+unbounded-devel = " \
 cargo \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-indexmap+std-devel \
 rust-toml_datetime+default-devel \
 "
