# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi"
PV = "10.3.0"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 dracut-kiwi-lib \
 dracut-kiwi-live \
 dracut-kiwi-oem-dump \
 dracut-kiwi-oem-repart \
 dracut-kiwi-overlay \
 dracut-kiwi-verity \
 kiwi-cli \
 kiwi-pxeboot \
 kiwi-systemdeps \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-image-validation \
 kiwi-systemdeps-iso-media \
 python3-kiwi \
"
PACKAGES:aarch64 = " \
 dracut-kiwi-lib \
 dracut-kiwi-live \
 dracut-kiwi-oem-dump \
 dracut-kiwi-oem-repart \
 dracut-kiwi-overlay \
 dracut-kiwi-verity \
 kiwi-cli \
 kiwi-systemdeps \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-image-validation \
 kiwi-systemdeps-iso-media \
 python3-kiwi \
"

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiwi-10.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6cb05721755b34b23dd91f7bdb1cc43b27c4aaff96e96876d4c1f9ca99ff860"

URI_x86_64_v2_dracut-kiwi-lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-lib-10.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-lib}"
SRC_URI[x86_64_v2_dracut-kiwi-lib.sha256sum] = "3be57536938f3c7d1d6ba22c4c5be0599f84ac42667650ccaa7b7e1321a88ad3"

URI_x86_64_v2_dracut-kiwi-live = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-live-10.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-live;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-live}"
SRC_URI[x86_64_v2_dracut-kiwi-live.sha256sum] = "cf291cc0a55b5521a87307e95e0c93c65689bd935c5b94e46f639641bf14146a"

URI_x86_64_v2_dracut-kiwi-oem-dump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-oem-dump-10.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-oem-dump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-oem-dump}"
SRC_URI[x86_64_v2_dracut-kiwi-oem-dump.sha256sum] = "295893092504dfe5ef5598c2b0ae5adeb6df1b7262ff9af5b7230fd969cc66ae"

URI_x86_64_v2_dracut-kiwi-oem-repart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-oem-repart-10.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-oem-repart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-oem-repart}"
SRC_URI[x86_64_v2_dracut-kiwi-oem-repart.sha256sum] = "3e14b80576bf65e026e252f0e118712245d6b39eeffb66c028ce08c9bd08ef9d"

URI_x86_64_v2_dracut-kiwi-overlay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-overlay-10.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-overlay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-overlay}"
SRC_URI[x86_64_v2_dracut-kiwi-overlay.sha256sum] = "9e20dd5bcc0b0f908a216621d848d959a3bad83e0c128dd43b0d7bbff9f74e1b"

URI_x86_64_v2_dracut-kiwi-verity = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-verity-10.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dracut-kiwi-verity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-verity}"
SRC_URI[x86_64_v2_dracut-kiwi-verity.sha256sum] = "bcbdb5975a078948659e480b02a0d58fc2f0ff797bbab28810b04c653de56dfa"

URI_x86_64_v2_kiwi-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-cli-10.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-cli}"
SRC_URI[x86_64_v2_kiwi-cli.sha256sum] = "a19226197f2e6ecfdcb394f9e45ab5b279c10ff8ee42549a36809038b5dbc81f"

URI_x86_64_v2_kiwi-pxeboot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-pxeboot-10.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-pxeboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-pxeboot}"
SRC_URI[x86_64_v2_kiwi-pxeboot.sha256sum] = "483273e0e00b3e9d9400e62262ba87f6dd49306464d96ddce92bcb93b13218ad"

URI_x86_64_v2_kiwi-systemdeps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-10.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps}"
SRC_URI[x86_64_v2_kiwi-systemdeps.sha256sum] = "9e9a92f26c9027e29f6b8af00bdf9eecd226b68e0bd63efe5408fef5f34c387d"

URI_x86_64_v2_kiwi-systemdeps-bootloaders = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-bootloaders-10.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-bootloaders;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-bootloaders}"
SRC_URI[x86_64_v2_kiwi-systemdeps-bootloaders.sha256sum] = "4f2287666cbeb768095ef7b321323e2a26edd7053c592dbdf249ab1c8f729f41"

URI_x86_64_v2_kiwi-systemdeps-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-containers-10.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-containers}"
SRC_URI[x86_64_v2_kiwi-systemdeps-containers.sha256sum] = "8634270fd46bcd825ae685f02cfdb8d561163ee29e4877a55bafc0afb4f2424c"

URI_x86_64_v2_kiwi-systemdeps-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-core-10.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-core}"
SRC_URI[x86_64_v2_kiwi-systemdeps-core.sha256sum] = "209a39cc65a12e2cfef34125247d876146c158c7676f28810502ac2377988264"

URI_x86_64_v2_kiwi-systemdeps-disk-images = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-disk-images-10.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-disk-images;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-disk-images}"
SRC_URI[x86_64_v2_kiwi-systemdeps-disk-images.sha256sum] = "e679dcb9a4c0f46879ee05961e2794c5618289eaf765d3321da827afa3ea3e7e"

URI_x86_64_v2_kiwi-systemdeps-filesystems = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-filesystems-10.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-filesystems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-filesystems}"
SRC_URI[x86_64_v2_kiwi-systemdeps-filesystems.sha256sum] = "fe77430fc7302b9d4807dbd52b53fb71279cd9ce3d006664f9c881b13f1411a2"

URI_x86_64_v2_kiwi-systemdeps-image-validation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-image-validation-10.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-image-validation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-image-validation}"
SRC_URI[x86_64_v2_kiwi-systemdeps-image-validation.sha256sum] = "3e2f3c6e47c1cf8a1e3b957d0ccfaad58cd3fcf2ba9325d7d80f781f3e246db6"

URI_x86_64_v2_kiwi-systemdeps-iso-media = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-iso-media-10.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-iso-media;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-iso-media}"
SRC_URI[x86_64_v2_kiwi-systemdeps-iso-media.sha256sum] = "7f8e9cdc149fb3820d23cdea7565340f37163e928b24e16fac519ea45137729c"

URI_x86_64_v2_python3-kiwi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-10.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kiwi}"
SRC_URI[x86_64_v2_python3-kiwi.sha256sum] = "9fe0757cd89606f3511676973ce4208cbabacedc60e35a0c3e24bec62e687d56"

URI_aarch64_dracut-kiwi-lib = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-lib-10.3.0-1.el10_2.noarch.rpm;name=aarch64_dracut-kiwi-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-lib}"
SRC_URI[aarch64_dracut-kiwi-lib.sha256sum] = "d61ddf76d26f73d8b4fc3c8f942ee571b9742d24f5b82feefd4724a54ff1f852"

URI_aarch64_dracut-kiwi-live = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-live-10.3.0-1.el10_2.noarch.rpm;name=aarch64_dracut-kiwi-live;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-live}"
SRC_URI[aarch64_dracut-kiwi-live.sha256sum] = "0171397e9245c958adfbdbbb051734ba0da30c0cd2e1995e3685d18c17c6b0b7"

URI_aarch64_dracut-kiwi-oem-dump = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-oem-dump-10.3.0-1.el10_2.noarch.rpm;name=aarch64_dracut-kiwi-oem-dump;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-oem-dump}"
SRC_URI[aarch64_dracut-kiwi-oem-dump.sha256sum] = "f733cc214169b0c7c455c649ef3637fcc9a5acb2951cc0ce3291b47bf214ed65"

URI_aarch64_dracut-kiwi-oem-repart = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-oem-repart-10.3.0-1.el10_2.noarch.rpm;name=aarch64_dracut-kiwi-oem-repart;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-oem-repart}"
SRC_URI[aarch64_dracut-kiwi-oem-repart.sha256sum] = "acbbb450637b322056d21c281725ab3b723ed31369b1193bd3dbcf2dc7ffa795"

URI_aarch64_dracut-kiwi-overlay = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-overlay-10.3.0-1.el10_2.noarch.rpm;name=aarch64_dracut-kiwi-overlay;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-overlay}"
SRC_URI[aarch64_dracut-kiwi-overlay.sha256sum] = "1610027a4cb4bad9a4d46d2c0fe31018b714b981fe52057a90ab5def7aec208b"

URI_aarch64_dracut-kiwi-verity = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-verity-10.3.0-1.el10_2.aarch64.rpm;name=aarch64_dracut-kiwi-verity;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-verity}"
SRC_URI[aarch64_dracut-kiwi-verity.sha256sum] = "d687d5dd43c975a313e7b00f1214f34dc195133828a9bddfe7f017c2eb396bf3"

URI_aarch64_kiwi-cli = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-cli-10.3.0-1.el10_2.noarch.rpm;name=aarch64_kiwi-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-cli}"
SRC_URI[aarch64_kiwi-cli.sha256sum] = "d1a2264671345822d03fd219015a5673764f6fe851c0fbdfc6d99b4144a96a37"

URI_aarch64_kiwi-systemdeps = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-10.3.0-1.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps}"
SRC_URI[aarch64_kiwi-systemdeps.sha256sum] = "45fe469835b278eb3f03026fc25b2b1f6ef3aaa1a74ce8eb4084c64dee43f9d2"

URI_aarch64_kiwi-systemdeps-bootloaders = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-bootloaders-10.3.0-1.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-bootloaders;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-bootloaders}"
SRC_URI[aarch64_kiwi-systemdeps-bootloaders.sha256sum] = "68e186bce128cedf782f054f2bc95db7a191ec898cce991c20ab21c669d8c7c2"

URI_aarch64_kiwi-systemdeps-containers = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-containers-10.3.0-1.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-containers}"
SRC_URI[aarch64_kiwi-systemdeps-containers.sha256sum] = "a62fba434e32c5e4e7f5890a7b861f39a4875ae1a0f7e95769e971bb34a0cf91"

URI_aarch64_kiwi-systemdeps-core = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-core-10.3.0-1.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-core}"
SRC_URI[aarch64_kiwi-systemdeps-core.sha256sum] = "ab82b30a4090eddc2ce95676b4caac6a696579b7f2821b4f66b7952ff4383c60"

URI_aarch64_kiwi-systemdeps-disk-images = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-disk-images-10.3.0-1.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-disk-images;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-disk-images}"
SRC_URI[aarch64_kiwi-systemdeps-disk-images.sha256sum] = "1963298a5e2d7d3e014044654b1815c395ea79ef8473e0ca0a1b775b65505612"

URI_aarch64_kiwi-systemdeps-filesystems = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-filesystems-10.3.0-1.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-filesystems;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-filesystems}"
SRC_URI[aarch64_kiwi-systemdeps-filesystems.sha256sum] = "22d78b72ade77fd5bf9b0e8fa9f2188c0848735f953c513a1804efa5b1ce98d7"

URI_aarch64_kiwi-systemdeps-image-validation = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-image-validation-10.3.0-1.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-image-validation;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-image-validation}"
SRC_URI[aarch64_kiwi-systemdeps-image-validation.sha256sum] = "ee5bc7020ccaf20d12945518f388b30068bb16544b876187c7dddc2fc50f4481"

URI_aarch64_kiwi-systemdeps-iso-media = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-iso-media-10.3.0-1.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-iso-media;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-iso-media}"
SRC_URI[aarch64_kiwi-systemdeps-iso-media.sha256sum] = "52b0e2435fb830a98767f86d6b27a9e48c8cd3c6e2836f3ebf294f08f59b7761"

URI_aarch64_python3-kiwi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-10.3.0-1.el10_2.noarch.rpm;name=aarch64_python3-kiwi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kiwi}"
SRC_URI[aarch64_python3-kiwi.sha256sum] = "d31d5dcc84f2de85b69a836e1c50d2387f7629941e62e2c32f62b83ab45d6f70"

RDEPENDS:dracut-kiwi-lib = " \
 bash \
 bc \
 cryptsetup \
 curl \
 device-mapper \
 dialog \
 dracut \
 e2fsprogs \
 gdisk \
 grep \
 kpartx \
 lvm2 \
 mdadm \
 parted \
 pv \
 util-linux \
 virtual/coreutils \
 xfsprogs \
 xz \
 "
RDEPENDS:dracut-kiwi-live = " \
 bash \
 device-mapper \
 dialog \
 dracut \
 dracut-kiwi-lib \
 dracut-network \
 e2fsprogs \
 parted \
 util-linux \
 xfsprogs \
 "
RDEPENDS:dracut-kiwi-oem-dump = " \
 bash \
 dracut-kiwi-lib \
 gawk \
 kexec-tools \
 "
RDEPENDS:dracut-kiwi-oem-repart = " \
 bash \
 dracut-kiwi-lib \
 "
RDEPENDS:dracut-kiwi-overlay = " \
 bash \
 dracut \
 dracut-kiwi-lib \
 util-linux \
 "
RDEPENDS:dracut-kiwi-verity = " \
 bash \
 dracut \
 dracut-kiwi-lib \
 glibc \
 "
RDEPENDS:kiwi-cli = " \
 bash \
 bash-completion \
 python3-kiwi \
 "
RDEPENDS:kiwi-pxeboot = " \
 syslinux \
 tftp-server \
 "
RDEPENDS:kiwi-systemdeps = " \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-iso-media \
 "
RDEPENDS:kiwi-systemdeps-bootloaders:x86_64_v2 = " \
 grub2-efi-x64 \
 grub2-efi-x64-modules \
 grub2-pc \
 grub2-pc-modules \
 grub2-tools \
 grub2-tools-efi \
 grub2-tools-extra \
 grub2-tools-minimal \
 kiwi-systemdeps-core \
"
RDEPENDS:kiwi-systemdeps-bootloaders:aarch64 = " \
 grub2-efi-aa64-modules \
 grub2-tools \
 grub2-tools-extra \
 grub2-tools-minimal \
 kiwi-systemdeps-core \
"
RDEPENDS:kiwi-systemdeps-containers = " \
 appx-util \
 buildah \
 skopeo \
 "
RDEPENDS:kiwi-systemdeps-core = " \
 dnf \
 file \
 lsof \
 microdnf \
 mtools \
 openssl \
 python3-dnf \
 rsync \
 screen \
 sed \
 tar \
 xz \
 "
RDEPENDS:kiwi-systemdeps-disk-images = " \
 cryptsetup \
 gdisk \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-iso-media \
 kpartx \
 lvm2 \
 mdadm \
 open-vmdk \
 parted \
 util-linux \
 "
RDEPENDS:kiwi-systemdeps-filesystems = " \
 dosfstools \
 e2fsprogs \
 erofs-utils \
 kiwi-systemdeps-core \
 qemu-img \
 squashfs-tools \
 xfsprogs \
 "
RDEPENDS:kiwi-systemdeps-image-validation = " \
 python3-solv \
 "
RDEPENDS:kiwi-systemdeps-iso-media:x86_64_v2 = " \
 grub2-efi-x64-cdboot \
 isomd5sum \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-core \
 kiwi-systemdeps-filesystems \
 syslinux \
 syslinux-nonlinux \
 xorriso \
"
RDEPENDS:kiwi-systemdeps-iso-media:aarch64 = " \
 grub2-efi-aa64-cdboot \
 isomd5sum \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-core \
 kiwi-systemdeps-filesystems \
 xorriso \
"
RDEPENDS:python3-kiwi = " \
 kiwi-systemdeps-core \
 python3 \
 python3-docopt-ng \
 python3-lxml \
 python3-pyyaml \
 python3-requests \
 python3-simplejson \
 "
