# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "centpkg"
PV = "0.10.1"
PR = "1.el10_0"
PACKAGES = " \
 centpkg \
 centpkg-sig \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/centpkg-0.10.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bf76b243d74a78e0aab6347bdbefa8b6417908d5c9f3a8f054bd180ad3f19df"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - centpkg: python3.12dist(python-gitlab)

URI_x86_64_v2_centpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/centpkg-0.10.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_centpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_centpkg}"
SRC_URI[x86_64_v2_centpkg.sha256sum] = "e426d4fe115b00a461cd8d7f4c2a68935f75deb464807a0407847b53b603608b"

URI_x86_64_v2_centpkg-sig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/centpkg-sig-0.10.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_centpkg-sig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_centpkg-sig}"
SRC_URI[x86_64_v2_centpkg-sig.sha256sum] = "356622322f8461398dbd1c36c2e3cbb76ef065a13dac304f2fd60f0b7fe174ab"

URI_aarch64_centpkg = "${EPEL_MIRROR}/aarch64/Packages/c/centpkg-0.10.1-1.el10_0.noarch.rpm;name=aarch64_centpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_centpkg}"
SRC_URI[aarch64_centpkg.sha256sum] = "9af6654e1833bf5e26e95d5e772a3a24caaf539ec3b30d336c9fff78cc9a5353"

URI_aarch64_centpkg-sig = "${EPEL_MIRROR}/aarch64/Packages/c/centpkg-sig-0.10.1-1.el10_0.noarch.rpm;name=aarch64_centpkg-sig;unpack=0"
SRC_URI:append = " ${URI_aarch64_centpkg-sig}"
SRC_URI[aarch64_centpkg-sig.sha256sum] = "6193c628378f8ee71b8e0a12051af4f4d2fe828a47670de1843c92074a33efb8"

RDEPENDS:centpkg:x86_64_v2 = " \
 python3 \
 python3-GitPython \
 python3-cryptography \
 python3-pycurl \
 python3-pyyaml \
 python3-rpkg \
"
RDEPENDS:centpkg:aarch64 = " \
 python3 \
 python3-GitPython \
 python3-cryptography \
 python3-gitlab \
 python3-pycurl \
 python3-pyyaml \
 python3-rpkg \
"
RDEPENDS:centpkg-sig = " \
 centpkg \
 python3 \
 "
