# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-date"
PV = "0.9.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-date+default-devel \
 rust-gix-date+document-features-devel \
 rust-gix-date+serde-devel \
 rust-gix-date-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-date-0.9.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f28fb6a5ad52e192c3b1fab662afea3c2583b769cf6bb8cad25d90ad4519e94b"

URI_x86_64_v2_rust-gix-date+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date+default-devel-0.9.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date+default-devel}"
SRC_URI[x86_64_v2_rust-gix-date+default-devel.sha256sum] = "0fd4ad19b3af159a70bf56d7af55de7198f3f9255b8c5662c751a3b0c214a0e9"

URI_x86_64_v2_rust-gix-date+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date+document-features-devel-0.9.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-date+document-features-devel.sha256sum] = "67d4401c766db259a45a3b49f2bf266bc344bc717065810cd1d77df42b7380ad"

URI_x86_64_v2_rust-gix-date+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date+serde-devel-0.9.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-date+serde-devel.sha256sum] = "e055480df2b74bbb188b1df4e5124c0b279c50447bf0873e22ba0e446dacba25"

URI_x86_64_v2_rust-gix-date-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date-devel-0.9.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date-devel}"
SRC_URI[x86_64_v2_rust-gix-date-devel.sha256sum] = "15dae886a15a0edc9b069a17539250b83915da910bdd906785c589c5ed7e01ff"

URI_aarch64_rust-gix-date+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date+default-devel-0.9.4-1.el10_0.noarch.rpm;name=aarch64_rust-gix-date+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date+default-devel}"
SRC_URI[aarch64_rust-gix-date+default-devel.sha256sum] = "03437076d14edd1c02a8326963606d702b9fc6e85d906c64e83894235b907065"

URI_aarch64_rust-gix-date+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date+document-features-devel-0.9.4-1.el10_0.noarch.rpm;name=aarch64_rust-gix-date+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date+document-features-devel}"
SRC_URI[aarch64_rust-gix-date+document-features-devel.sha256sum] = "b56c23830f97227106e22d305c967fbc4fb6340c25aadfad6658e2f8cbb0af01"

URI_aarch64_rust-gix-date+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date+serde-devel-0.9.4-1.el10_0.noarch.rpm;name=aarch64_rust-gix-date+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date+serde-devel}"
SRC_URI[aarch64_rust-gix-date+serde-devel.sha256sum] = "eb5175fcd9fa89871ad4812137825e212d19d45efff13efa4ab7824c771f65cc"

URI_aarch64_rust-gix-date-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date-devel-0.9.4-1.el10_0.noarch.rpm;name=aarch64_rust-gix-date-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date-devel}"
SRC_URI[aarch64_rust-gix-date-devel.sha256sum] = "3c8cf511d05064e89fa535b61abe035fa463cd80c5d6f96e4fde21b6a713021a"

RDEPENDS:rust-gix-date+default-devel = " \
 cargo \
 rust-gix-date-devel \
 "
RDEPENDS:rust-gix-date+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-date-devel \
 "
RDEPENDS:rust-gix-date+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-date-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-date-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-itoa+default-devel \
 rust-jiff+default-devel \
 rust-thiserror+default-devel \
 "
