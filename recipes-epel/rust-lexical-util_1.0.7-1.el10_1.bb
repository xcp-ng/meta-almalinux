# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexical-util"
PV = "1.0.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-lexical-util+compact-devel \
 rust-lexical-util+default-devel \
 rust-lexical-util+f128-devel \
 rust-lexical-util+f16-devel \
 rust-lexical-util+float16-devel \
 rust-lexical-util+format-devel \
 rust-lexical-util+lint-devel \
 rust-lexical-util+parse-floats-devel \
 rust-lexical-util+parse-integers-devel \
 rust-lexical-util+power-of-two-devel \
 rust-lexical-util+radix-devel \
 rust-lexical-util+std-devel \
 rust-lexical-util+write-floats-devel \
 rust-lexical-util+write-integers-devel \
 rust-lexical-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexical-util-1.0.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b6723df8036e4beb3921caf3e7977abb6d18339c3efff4b0c3fa06cac3d1843"

URI_x86_64_v2_rust-lexical-util+compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+compact-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+compact-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+compact-devel.sha256sum] = "82984edbd98d4ff58faabb75f763d030c51e4a55bdf90b72250587995385a933"

URI_x86_64_v2_rust-lexical-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+default-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+default-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+default-devel.sha256sum] = "9eabec359860d7eb46bddc534f0c668f62e6e923138d8b6f204b1942b25ceeac"

URI_x86_64_v2_rust-lexical-util+f128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+f128-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+f128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+f128-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+f128-devel.sha256sum] = "801b846cf639afc5657af7579948b0cc909f29ee7a7ab63bbc2b91b844ee7aaa"

URI_x86_64_v2_rust-lexical-util+f16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+f16-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+f16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+f16-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+f16-devel.sha256sum] = "4509a76050a2b5e24a9703fb2f55ebdb12d1317219a797cd07b1f479463d4589"

URI_x86_64_v2_rust-lexical-util+float16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+float16-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+float16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+float16-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+float16-devel.sha256sum] = "51377036ec862bfd2c36abbfddd189823085ef1329f9a24c3f04cfb0493a5be6"

URI_x86_64_v2_rust-lexical-util+format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+format-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+format-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+format-devel.sha256sum] = "0205bc72cebb9d65ae5f568e513ad8279a9c6951de8cebbe87bd77c272aecc51"

URI_x86_64_v2_rust-lexical-util+lint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+lint-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+lint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+lint-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+lint-devel.sha256sum] = "8b0d940a640daa2434c7e27b7ea5f306b87da1cbd84459b1ac817c780550e576"

URI_x86_64_v2_rust-lexical-util+parse-floats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+parse-floats-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+parse-floats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+parse-floats-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+parse-floats-devel.sha256sum] = "701dc34aee8f4141d0900d3e7f7a5af549ecfcf833b41fcee53cfab3a1c80e17"

URI_x86_64_v2_rust-lexical-util+parse-integers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+parse-integers-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+parse-integers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+parse-integers-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+parse-integers-devel.sha256sum] = "4e2d8c09583198c8c01121dab95e275c5550c2d4ad3abc4b1be9fa095db20732"

URI_x86_64_v2_rust-lexical-util+power-of-two-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+power-of-two-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+power-of-two-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+power-of-two-devel.sha256sum] = "db691f28f757592303c05188b39adf6c6a2da09e124e0741d5496dbc4501a05b"

URI_x86_64_v2_rust-lexical-util+radix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+radix-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+radix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+radix-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+radix-devel.sha256sum] = "dee45d61ea7df1ea1422747e51c0aa15ab6870469091a6630b49ff0d9b8088d2"

URI_x86_64_v2_rust-lexical-util+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+std-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+std-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+std-devel.sha256sum] = "cb926dcbf4cc8a174ddfc086e37a2cfb40d1692e495fd853ccad7bb8deeb01c6"

URI_x86_64_v2_rust-lexical-util+write-floats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+write-floats-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+write-floats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+write-floats-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+write-floats-devel.sha256sum] = "8332c99916772214fe9c7fecc0311ae281910a748d6feb03c2287db519dc224c"

URI_x86_64_v2_rust-lexical-util+write-integers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+write-integers-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+write-integers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+write-integers-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+write-integers-devel.sha256sum] = "eaf64bc0d7e60e1e4edac668519908d36aa869f9e14d56d72333d8ebb1a82ff7"

URI_x86_64_v2_rust-lexical-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util-devel-1.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util-devel}"
SRC_URI[x86_64_v2_rust-lexical-util-devel.sha256sum] = "6d8e8ddd4121927211fc7c63638a2db4679a9c68c443ad44c9fe9156bc6556f8"

URI_aarch64_rust-lexical-util+compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+compact-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util+compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+compact-devel}"
SRC_URI[aarch64_rust-lexical-util+compact-devel.sha256sum] = "ef69a5c9300c56487d34823ab6b464cd1a34dbcb7c8102327a875d5f96d7778e"

URI_aarch64_rust-lexical-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+default-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+default-devel}"
SRC_URI[aarch64_rust-lexical-util+default-devel.sha256sum] = "2e8d7fed675eaac789390b0c512d3a240d1a8a40ca1b5a7e1fd3ee19bc137855"

URI_aarch64_rust-lexical-util+f128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+f128-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util+f128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+f128-devel}"
SRC_URI[aarch64_rust-lexical-util+f128-devel.sha256sum] = "5e9a4c02596ee88a559a5680cfd4863b6eaeab392515eebbc079d950901a355e"

URI_aarch64_rust-lexical-util+f16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+f16-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util+f16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+f16-devel}"
SRC_URI[aarch64_rust-lexical-util+f16-devel.sha256sum] = "ef6952ec87e63580ae65d5169a463ae04003ae580c3345238d7a235672dd2d70"

URI_aarch64_rust-lexical-util+float16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+float16-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util+float16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+float16-devel}"
SRC_URI[aarch64_rust-lexical-util+float16-devel.sha256sum] = "f2aa9260c2879079395077105f4116bfde9d8b41a0568b60042623ebc6dea85b"

URI_aarch64_rust-lexical-util+format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+format-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util+format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+format-devel}"
SRC_URI[aarch64_rust-lexical-util+format-devel.sha256sum] = "ec859a711b6f3b3fa65f7780ead94167bbdfa4699a7f8e751544e8ced0711e1b"

URI_aarch64_rust-lexical-util+lint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+lint-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util+lint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+lint-devel}"
SRC_URI[aarch64_rust-lexical-util+lint-devel.sha256sum] = "e00346af0e8c9e2f720810cc3f9c3f09efcf21e6da8abe31d687e3b83617672e"

URI_aarch64_rust-lexical-util+parse-floats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+parse-floats-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util+parse-floats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+parse-floats-devel}"
SRC_URI[aarch64_rust-lexical-util+parse-floats-devel.sha256sum] = "b722f9e0628cbdea349ba276610d3534c2778ebad94c4237cbbb80f74328ae23"

URI_aarch64_rust-lexical-util+parse-integers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+parse-integers-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util+parse-integers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+parse-integers-devel}"
SRC_URI[aarch64_rust-lexical-util+parse-integers-devel.sha256sum] = "1722d1b10b21f1d7b1137ec5538e04bc9514f76a3a96a9685c57004b9de2e342"

URI_aarch64_rust-lexical-util+power-of-two-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+power-of-two-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+power-of-two-devel}"
SRC_URI[aarch64_rust-lexical-util+power-of-two-devel.sha256sum] = "be91c63bf208c771df939b5b115c6db317b02063747ff000ff067bad03922d23"

URI_aarch64_rust-lexical-util+radix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+radix-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util+radix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+radix-devel}"
SRC_URI[aarch64_rust-lexical-util+radix-devel.sha256sum] = "d29f4b83b582792fbf5f8637b39fd460f5b07d35934a1c54c33f373de37569f2"

URI_aarch64_rust-lexical-util+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+std-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+std-devel}"
SRC_URI[aarch64_rust-lexical-util+std-devel.sha256sum] = "7c220740cdc90bd49a727ad0af5bf5c7090efa8f613c62e587dbc60e7986642a"

URI_aarch64_rust-lexical-util+write-floats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+write-floats-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util+write-floats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+write-floats-devel}"
SRC_URI[aarch64_rust-lexical-util+write-floats-devel.sha256sum] = "19acf3fc9efc3114635c9b18e992f26e483591a86b2a97d5161e4400e27daa72"

URI_aarch64_rust-lexical-util+write-integers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+write-integers-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util+write-integers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+write-integers-devel}"
SRC_URI[aarch64_rust-lexical-util+write-integers-devel.sha256sum] = "4bfcf9049e81e19cc53f78f6c520a8bec2a875d2849b3b13ad9f7e907879306a"

URI_aarch64_rust-lexical-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util-devel-1.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util-devel}"
SRC_URI[aarch64_rust-lexical-util-devel.sha256sum] = "03be39ec893ceb5b3fa52ecbce6eeb7127f4746744151ef01f9949ba3ba614e1"

RDEPENDS:rust-lexical-util+compact-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+default-devel = " \
 cargo \
 rust-lexical-util+std-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+f128-devel = " \
 cargo \
 rust-lexical-util+parse-floats-devel \
 rust-lexical-util+write-floats-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+f16-devel = " \
 cargo \
 rust-lexical-util+float16-devel \
 rust-lexical-util+parse-floats-devel \
 rust-lexical-util+write-floats-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+float16-devel = " \
 cargo \
 rust-float16+default-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+format-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+lint-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+parse-floats-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+parse-integers-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+power-of-two-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+radix-devel = " \
 cargo \
 rust-lexical-util+power-of-two-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+std-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+write-floats-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+write-integers-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util-devel = " \
 cargo \
 rust \
 "
