# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-tree"
PV = "0.4.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-tracing-tree+default-devel \
 rust-tracing-tree+time-devel \
 rust-tracing-tree+tracing-log-devel \
 rust-tracing-tree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-tree-0.4.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c30296d04367e764ec012f324dd997b92460719d650a8eaa81766e1c45c8e2b"

URI_x86_64_v2_rust-tracing-tree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-tree+default-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-tree+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-tree+default-devel.sha256sum] = "4ec197ad606944cac959788f8e8f5ca7d94868fef48675075176eb31d9a047b1"

URI_x86_64_v2_rust-tracing-tree+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-tree+time-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-tree+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-tree+time-devel}"
SRC_URI[x86_64_v2_rust-tracing-tree+time-devel.sha256sum] = "72afff3b2013556d1bb54279a40be1c098a6724c9fd6a64131e3fa6455dd5541"

URI_x86_64_v2_rust-tracing-tree+tracing-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-tree+tracing-log-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-tree+tracing-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-tree+tracing-log-devel}"
SRC_URI[x86_64_v2_rust-tracing-tree+tracing-log-devel.sha256sum] = "b8350f302978dc694f5119fc6f420a6327d96db24f29686fb15b3bf4aa7de23a"

URI_x86_64_v2_rust-tracing-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-tree-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-tree-devel}"
SRC_URI[x86_64_v2_rust-tracing-tree-devel.sha256sum] = "e86e4c2d93ce2511b28516f2d58d928425534d444e5c881501a4a789ac1ccf66"

URI_aarch64_rust-tracing-tree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-tree+default-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-tree+default-devel}"
SRC_URI[aarch64_rust-tracing-tree+default-devel.sha256sum] = "efef7b725749ca8ba10f735f13638b8c932371c89699fd4b6e149a81528468e8"

URI_aarch64_rust-tracing-tree+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-tree+time-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-tree+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-tree+time-devel}"
SRC_URI[aarch64_rust-tracing-tree+time-devel.sha256sum] = "cd872ab6037985d6726bc65744a8a71314da7e11da4822fb8ac073ef13fdf9d9"

URI_aarch64_rust-tracing-tree+tracing-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-tree+tracing-log-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-tree+tracing-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-tree+tracing-log-devel}"
SRC_URI[aarch64_rust-tracing-tree+tracing-log-devel.sha256sum] = "ebff4ddd5f22649bb9af3e1090b796fc87a1e7375aa1f446a87baebbde1ff959"

URI_aarch64_rust-tracing-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-tree-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-tree-devel}"
SRC_URI[aarch64_rust-tracing-tree-devel.sha256sum] = "7a2fc42039aa7b789a28f382d5be92529c102580af49666afabdd2802e90d039"

RDEPENDS:rust-tracing-tree+default-devel = " \
 cargo \
 rust-tracing-tree+tracing-log-devel \
 rust-tracing-tree-devel \
 "
RDEPENDS:rust-tracing-tree+time-devel = " \
 cargo \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 rust-tracing-tree-devel \
 "
RDEPENDS:rust-tracing-tree+tracing-log-devel = " \
 cargo \
 rust-tracing-log+log-tracer-devel \
 rust-tracing-log+std-devel \
 rust-tracing-log-devel \
 rust-tracing-tree-devel \
 "
RDEPENDS:rust-tracing-tree-devel = " \
 cargo \
 rust \
 rust-nu-ansi-term+default-devel \
 rust-tracing-core+default-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+registry-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber-devel \
 "
