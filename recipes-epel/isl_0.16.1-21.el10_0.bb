# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "isl"
PV = "0.16.1"
PR = "21.el10_0"
PACKAGES = " \
 isl \
 isl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/isl-0.16.1-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de4e5a54d571cfc7b874e22598217b48a403e46ab6e7ae5220e88ac513f107d0"

URI_x86_64_v2_isl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isl-0.16.1-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isl}"
SRC_URI[x86_64_v2_isl.sha256sum] = "7b8206e44f56c3cb7120bf18407d5e0955a38e2353ec006e0e0153b370af5731"

URI_x86_64_v2_isl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isl-devel-0.16.1-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isl-devel}"
SRC_URI[x86_64_v2_isl-devel.sha256sum] = "0f97a0cf9a6b8383f648c6d2108d75f2461bd8383ff78538567fc961258191f7"

URI_aarch64_isl = "${EPEL_MIRROR}/aarch64/Packages/i/isl-0.16.1-21.el10_0.aarch64.rpm;name=aarch64_isl;unpack=0"
SRC_URI:append = " ${URI_aarch64_isl}"
SRC_URI[aarch64_isl.sha256sum] = "a8717873450c25ca63394e05dbcf464219f0b0554878466af11a18cb7acd8d71"

URI_aarch64_isl-devel = "${EPEL_MIRROR}/aarch64/Packages/i/isl-devel-0.16.1-21.el10_0.aarch64.rpm;name=aarch64_isl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_isl-devel}"
SRC_URI[aarch64_isl-devel.sha256sum] = "c8c088bae46f2c7f6f88becba0584dd6660d954eb6a7cd6100ec1a64abe6a96a"

RDEPENDS:isl = " \
 glibc \
 gmp \
 "
RDEPENDS:isl-devel = " \
 gmp-devel \
 isl \
 pkgconf-pkg-config \
 "
