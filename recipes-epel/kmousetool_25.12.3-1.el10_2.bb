# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmousetool"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kmousetool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmousetool-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "067827a58dd15eb805d3c1967b4f5438d1f864a46ab790be3ad785c4fd81c718"

URI_x86_64_v2_kmousetool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmousetool-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmousetool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmousetool}"
SRC_URI[x86_64_v2_kmousetool.sha256sum] = "252a53cedc81b00a5c39c0e2aed3e0d3f79154ccd4021894e5669daa531d279c"

URI_aarch64_kmousetool = "${EPEL_MIRROR}/aarch64/Packages/k/kmousetool-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmousetool;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmousetool}"
SRC_URI[aarch64_kmousetool.sha256sum] = "6661d3bc28badf4a0a44b8db583141a9205518c7a113444f732f9e70e29c4a68"

RDEPENDS:kmousetool = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libX11 \
 libXtst \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
