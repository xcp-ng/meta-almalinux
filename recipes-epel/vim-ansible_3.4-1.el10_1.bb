# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vim-ansible"
PV = "3.4"
PR = "1.el10_1"
PACKAGES = " \
 vim-ansible \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/vim-ansible-3.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6a988ed8250fea93bcac7e23a4c30f9451a57120778b222f799653f0892c5a11"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vim-ansible-3.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_vim-ansible;unpack=0"
SRC_URI[x86_64_v2_vim-ansible.sha256sum] = "bcd4760d103feb490b7a92a067c460343174d8362ae1f2b2e9b3a3cca68dce82"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vim-ansible-3.4-1.el10_1.noarch.rpm;name=aarch64_vim-ansible;unpack=0"
SRC_URI[aarch64_vim-ansible.sha256sum] = "7296397590e553f9296bef201581f6e5ea773e4190f79e24994150cf1f7a3c5c"

RDEPENDS:vim-ansible = " \
 vim-filesystem \
 "
