# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "powerpc-utils"
PV = "1.3.13"
PR = "5.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/powerpc-utils-1.3.13-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72e534814a8ee09228fd732183bcf5c59dad3fa383a333ddb1c57730c21c622e"

