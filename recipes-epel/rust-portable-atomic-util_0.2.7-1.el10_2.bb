# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-portable-atomic-util"
PV = "0.2.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util+default-devel \
 rust-portable-atomic-util+serde-devel \
 rust-portable-atomic-util+std-devel \
 rust-portable-atomic-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-portable-atomic-util-0.2.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7ce669f52aa17b33a4fc17a606b2d7f933b01804631ec116874ffaa1aed156b"

URI_x86_64_v2_rust-portable-atomic-util+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+alloc-devel-0.2.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util+alloc-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util+alloc-devel.sha256sum] = "37d97c7f90f91f49c64cf51bafeed83c27f0a4718b7b58618c226874cb74b990"

URI_x86_64_v2_rust-portable-atomic-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+default-devel-0.2.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util+default-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util+default-devel.sha256sum] = "c306b932aaf202e3d74bcdf3230cae881cbf721561127e0e212477a51334d604"

URI_x86_64_v2_rust-portable-atomic-util+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+serde-devel-0.2.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util+serde-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util+serde-devel.sha256sum] = "2d13af4c925a0297e1c27a10c4333a5392eaf33ddb42737a92cbb37332ca7133"

URI_x86_64_v2_rust-portable-atomic-util+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+std-devel-0.2.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util+std-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util+std-devel.sha256sum] = "3e3fb3869922a8eb3aec5b28a0e3bb7e4f435c1bc42a25cc89d22fa96a221034"

URI_x86_64_v2_rust-portable-atomic-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util-devel-0.2.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util-devel.sha256sum] = "cda93e3781fc21c211bd6b0086a6d5188b1e0201dc2f0113f7cbb65a6280f1fc"

URI_aarch64_rust-portable-atomic-util+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+alloc-devel-0.2.7-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic-util+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util+alloc-devel}"
SRC_URI[aarch64_rust-portable-atomic-util+alloc-devel.sha256sum] = "5f9a1cc0279b4a9bf7b10d9390c5e29ea557247c9fbfb7fd7176a1b4a655c99c"

URI_aarch64_rust-portable-atomic-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+default-devel-0.2.7-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util+default-devel}"
SRC_URI[aarch64_rust-portable-atomic-util+default-devel.sha256sum] = "0441c4afba26096b4bec5af6340bead37f555c3e4d57ffd715e0bd13355d1472"

URI_aarch64_rust-portable-atomic-util+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+serde-devel-0.2.7-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic-util+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util+serde-devel}"
SRC_URI[aarch64_rust-portable-atomic-util+serde-devel.sha256sum] = "6e1ccffa703cd20e0c85190d16b052374529189663a4dfd35397861670b09362"

URI_aarch64_rust-portable-atomic-util+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+std-devel-0.2.7-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util+std-devel}"
SRC_URI[aarch64_rust-portable-atomic-util+std-devel.sha256sum] = "77669c4d97e2fb4b20736100c0917e7153d7ae49427c552b11d00cb8155f60ee"

URI_aarch64_rust-portable-atomic-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util-devel-0.2.7-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util-devel}"
SRC_URI[aarch64_rust-portable-atomic-util-devel.sha256sum] = "6f7e1e0de045c085707a9977905c8eb8055b8f22449bb385df9030e4e9d896a3"

RDEPENDS:rust-portable-atomic-util+alloc-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util+default-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util+serde-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-portable-atomic-util+std-devel = " \
 cargo \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util-devel = " \
 cargo \
 rust \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 "
