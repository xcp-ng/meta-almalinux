# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-haskell"
PV = "0.23.1"
PR = "2.el10_1"
PACKAGES = " \
 rust-tree-sitter-haskell+default-devel \
 rust-tree-sitter-haskell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-haskell-0.23.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e85ef93b0e0678c5d2c36a0dab6f7f96db6bfe31415ca588e83af52b0d45a5d4"

URI_x86_64_v2_rust-tree-sitter-haskell+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-haskell+default-devel-0.23.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-haskell+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-haskell+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-haskell+default-devel.sha256sum] = "42cb2f442a65a6d21c1c2caeb43b581322e350d8e6cda2d0ef1636d2ea01e2d6"

URI_x86_64_v2_rust-tree-sitter-haskell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-haskell-devel-0.23.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-haskell-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-haskell-devel.sha256sum] = "9e823e251b4d5f3aa1a86137fbce1249cf089e97566b8131025c7b5fb7364769"

URI_aarch64_rust-tree-sitter-haskell+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-haskell+default-devel-0.23.1-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-haskell+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-haskell+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-haskell+default-devel.sha256sum] = "8ba6412859841db63b33de109d5ab5fa0b44269941cdbe4d79a686bdc4fedfb8"

URI_aarch64_rust-tree-sitter-haskell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-haskell-devel-0.23.1-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-haskell-devel}"
SRC_URI[aarch64_rust-tree-sitter-haskell-devel.sha256sum] = "83186de97decc80d64f564bb1c7310c929f092e486950daa1aaf35251f6eb896"

RDEPENDS:rust-tree-sitter-haskell+default-devel = " \
 cargo \
 rust-tree-sitter-haskell-devel \
 "
RDEPENDS:rust-tree-sitter-haskell-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
