# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lock_api"
PV = "0.4.14"
PR = "1.el10_0"
PACKAGES = " \
 rust-lock_api+arc_lock-devel \
 rust-lock_api+atomic_usize-devel \
 rust-lock_api+default-devel \
 rust-lock_api+nightly-devel \
 rust-lock_api+owning_ref-devel \
 rust-lock_api+serde-devel \
 rust-lock_api-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lock_api-0.4.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eaf05eaca0c29002b73cdb19ede79492bbe0af8a905aaca2bdce32872d11cddb"

URI_x86_64_v2_rust-lock_api+arc_lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+arc_lock-devel-0.4.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+arc_lock-devel}"
SRC_URI[x86_64_v2_rust-lock_api+arc_lock-devel.sha256sum] = "24b639b6c22eb02a312a8e33265dbdfa49f7aa7f714337a9c7341aba5ae28469"

URI_x86_64_v2_rust-lock_api+atomic_usize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+atomic_usize-devel-0.4.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+atomic_usize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+atomic_usize-devel}"
SRC_URI[x86_64_v2_rust-lock_api+atomic_usize-devel.sha256sum] = "adb7d2a22de576e4bd8cb65ea8c57bbcd957c4215ecb72f3489778ff648fbd57"

URI_x86_64_v2_rust-lock_api+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+default-devel-0.4.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+default-devel}"
SRC_URI[x86_64_v2_rust-lock_api+default-devel.sha256sum] = "4b5c48b25b07e86f09ab3d9385480f76557b64113feaa82e85567d13fde67ff4"

URI_x86_64_v2_rust-lock_api+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+nightly-devel-0.4.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+nightly-devel}"
SRC_URI[x86_64_v2_rust-lock_api+nightly-devel.sha256sum] = "2135c526ba0efadc0fed7a515f72d4568dc129c2125f75abc01e69702a348ea2"

URI_x86_64_v2_rust-lock_api+owning_ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+owning_ref-devel-0.4.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+owning_ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+owning_ref-devel}"
SRC_URI[x86_64_v2_rust-lock_api+owning_ref-devel.sha256sum] = "433dcc7487d5af0e7dcbd2e3b8cfa15cb7db06aa73491d9443cb4e530b69b787"

URI_x86_64_v2_rust-lock_api+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+serde-devel-0.4.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+serde-devel}"
SRC_URI[x86_64_v2_rust-lock_api+serde-devel.sha256sum] = "bd0575bc4db11d18fcb41d854fbb15635f009c5dfdcd38b3b2995a3287956c14"

URI_x86_64_v2_rust-lock_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api-devel-0.4.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api-devel}"
SRC_URI[x86_64_v2_rust-lock_api-devel.sha256sum] = "51544466e7802c9222c4f9dd6b4dc32a8ccfabdb50131ce025aad3f4940cfd3d"

URI_aarch64_rust-lock_api+arc_lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+arc_lock-devel-0.4.14-1.el10_0.noarch.rpm;name=aarch64_rust-lock_api+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+arc_lock-devel}"
SRC_URI[aarch64_rust-lock_api+arc_lock-devel.sha256sum] = "d5a1df540602c1e9205734c05bb326016eec571f51a2abc30b57050ce6132468"

URI_aarch64_rust-lock_api+atomic_usize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+atomic_usize-devel-0.4.14-1.el10_0.noarch.rpm;name=aarch64_rust-lock_api+atomic_usize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+atomic_usize-devel}"
SRC_URI[aarch64_rust-lock_api+atomic_usize-devel.sha256sum] = "fde128b84dae61df344941d791fdd58544a4affd97de81ec25da4b6c1f607752"

URI_aarch64_rust-lock_api+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+default-devel-0.4.14-1.el10_0.noarch.rpm;name=aarch64_rust-lock_api+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+default-devel}"
SRC_URI[aarch64_rust-lock_api+default-devel.sha256sum] = "5ba0242f4eb1ba00db893f550c7fe5e74e98a3a64161a4bc337490fc2f87f0b5"

URI_aarch64_rust-lock_api+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+nightly-devel-0.4.14-1.el10_0.noarch.rpm;name=aarch64_rust-lock_api+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+nightly-devel}"
SRC_URI[aarch64_rust-lock_api+nightly-devel.sha256sum] = "865310c54d721ec9ea32fcc6f2f7094b1faf1189ca168b12cfadaef9abfa2f50"

URI_aarch64_rust-lock_api+owning_ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+owning_ref-devel-0.4.14-1.el10_0.noarch.rpm;name=aarch64_rust-lock_api+owning_ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+owning_ref-devel}"
SRC_URI[aarch64_rust-lock_api+owning_ref-devel.sha256sum] = "55c003bcf291c778c0d7fade92a1326cc784547e1b73988db710ecca5af22018"

URI_aarch64_rust-lock_api+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+serde-devel-0.4.14-1.el10_0.noarch.rpm;name=aarch64_rust-lock_api+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+serde-devel}"
SRC_URI[aarch64_rust-lock_api+serde-devel.sha256sum] = "99bd3e2a5bcd254f97ae86e5d9e7f26d5ef3d46db2f851c0fcb0c4289e776eda"

URI_aarch64_rust-lock_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api-devel-0.4.14-1.el10_0.noarch.rpm;name=aarch64_rust-lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api-devel}"
SRC_URI[aarch64_rust-lock_api-devel.sha256sum] = "751005fdb81bc6392fabf7420201e6d50eabaf91dffebda12f03f80bc5cc7419"

RDEPENDS:rust-lock_api+arc_lock-devel = " \
 cargo \
 rust-lock_api-devel \
 "
RDEPENDS:rust-lock_api+atomic_usize-devel = " \
 cargo \
 rust-lock_api-devel \
 "
RDEPENDS:rust-lock_api+default-devel = " \
 cargo \
 rust-lock_api+atomic_usize-devel \
 rust-lock_api-devel \
 "
RDEPENDS:rust-lock_api+nightly-devel = " \
 cargo \
 rust-lock_api-devel \
 "
RDEPENDS:rust-lock_api+owning_ref-devel = " \
 cargo \
 rust-lock_api-devel \
 rust-owning_ref+default-devel \
 "
RDEPENDS:rust-lock_api+serde-devel = " \
 cargo \
 rust-lock_api-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-lock_api-devel = " \
 cargo \
 rust \
 rust-scopeguard-devel \
 "
