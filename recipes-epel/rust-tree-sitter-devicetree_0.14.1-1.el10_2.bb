# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-devicetree"
PV = "0.14.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-devicetree+default-devel \
 rust-tree-sitter-devicetree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-devicetree-0.14.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab35e70c626cd0bbe94df72033d42aa64fe4d1eb24c14d7c49578203b5ddfbcc"

URI_x86_64_v2_rust-tree-sitter-devicetree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-devicetree+default-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-devicetree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-devicetree+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-devicetree+default-devel.sha256sum] = "c6c45f10f8b2c90d13ffa9e3459846d97191699b9334469a5bcb2abcb22821ad"

URI_x86_64_v2_rust-tree-sitter-devicetree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-devicetree-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-devicetree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-devicetree-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-devicetree-devel.sha256sum] = "6affe2d87029eb4efcb737d0b75e9d31be505ff0bdeb41c18978d83a951cda31"

URI_aarch64_rust-tree-sitter-devicetree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-devicetree+default-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-devicetree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-devicetree+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-devicetree+default-devel.sha256sum] = "984d6b75502e3197d7a5177de1f964bccc8f412747264a776976a09df5f95cde"

URI_aarch64_rust-tree-sitter-devicetree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-devicetree-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-devicetree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-devicetree-devel}"
SRC_URI[aarch64_rust-tree-sitter-devicetree-devel.sha256sum] = "6498fa3f068570853a34e7108b7a08331c4d0e321fd9d0933010bb23fc4a904e"

RDEPENDS:rust-tree-sitter-devicetree+default-devel = " \
 cargo \
 rust-tree-sitter-devicetree-devel \
 "
RDEPENDS:rust-tree-sitter-devicetree-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
