# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libwmf"
PV = "0.2.13"
PR = "6.el10_0"
PACKAGES = " \
 libwmf \
 libwmf-devel \
 libwmf-lite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libwmf-0.2.13-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "066ddbe2cfc2717a9419785562023641a3a3979ee0068d57285c87356acc1f65"

URI_x86_64_v2_libwmf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwmf-0.2.13-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwmf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwmf}"
SRC_URI[x86_64_v2_libwmf.sha256sum] = "fecfaa1665f78280dd70bf99850a8bcd884a83b3a06a98d68fdfeb8685a12c94"

URI_x86_64_v2_libwmf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwmf-devel-0.2.13-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwmf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwmf-devel}"
SRC_URI[x86_64_v2_libwmf-devel.sha256sum] = "3f9026064ecaad6cb99ec4d28a449b9e5d5e8a192fb96ce40aad95bed02b217c"

URI_x86_64_v2_libwmf-lite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwmf-lite-0.2.13-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwmf-lite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwmf-lite}"
SRC_URI[x86_64_v2_libwmf-lite.sha256sum] = "8e44c78b9b6ee6119eaf3f84e53bcd989af4ced41a6913ac24e68045dfa62129"

URI_aarch64_libwmf = "${EPEL_MIRROR}/aarch64/Packages/l/libwmf-0.2.13-6.el10_0.aarch64.rpm;name=aarch64_libwmf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwmf}"
SRC_URI[aarch64_libwmf.sha256sum] = "f1fe5828e2d11d06d65ed34312a6cfcca4b7f1c2a9aeadd69536df9d1cd57747"

URI_aarch64_libwmf-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libwmf-devel-0.2.13-6.el10_0.aarch64.rpm;name=aarch64_libwmf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwmf-devel}"
SRC_URI[aarch64_libwmf-devel.sha256sum] = "beb71113b22a38fe72caa975ecd38d60b77abfce7446128b202c27a5afc8e20a"

URI_aarch64_libwmf-lite = "${EPEL_MIRROR}/aarch64/Packages/l/libwmf-lite-0.2.13-6.el10_0.aarch64.rpm;name=aarch64_libwmf-lite;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwmf-lite}"
SRC_URI[aarch64_libwmf-lite.sha256sum] = "bfc3999c6ae9385e7e081046ae9ec7e6e7d09734185eeae5a7809f5e7e37ef56"

RDEPENDS:libwmf = " \
 bash \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libX11 \
 libjpeg-turbo \
 libpng \
 libwmf-lite \
 libxml2 \
 urw-base35-fonts \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libwmf-devel = " \
 bash \
 freetype-devel \
 libX11-devel \
 libjpeg-turbo-devel \
 libpng-devel \
 libwmf \
 libwmf-lite \
 libxml2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libwmf-lite = " \
 glibc \
 "
