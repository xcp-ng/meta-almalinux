# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fiat-crypto"
PV = "0.3.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-fiat-crypto+default-devel \
 rust-fiat-crypto+std-devel \
 rust-fiat-crypto-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fiat-crypto-0.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82ea31bc8cc82b705ceb4cc5c8b8f06ddace208e3737a3124e30b10e7daffed6"

URI_x86_64_v2_rust-fiat-crypto+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fiat-crypto+default-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fiat-crypto+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fiat-crypto+default-devel}"
SRC_URI[x86_64_v2_rust-fiat-crypto+default-devel.sha256sum] = "40c76965bad7b78af20253ac0257723e09061f354ab4ff41d9db6003be87783a"

URI_x86_64_v2_rust-fiat-crypto+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fiat-crypto+std-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fiat-crypto+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fiat-crypto+std-devel}"
SRC_URI[x86_64_v2_rust-fiat-crypto+std-devel.sha256sum] = "f071193f1b2c14ff58a9079f08c96d93a552b219b1230decfd9e9cac9009dc83"

URI_x86_64_v2_rust-fiat-crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fiat-crypto-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fiat-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fiat-crypto-devel}"
SRC_URI[x86_64_v2_rust-fiat-crypto-devel.sha256sum] = "a40545bd2bdbd33e8fa700024c657dde8cd6eeec78a00c48203f82069e4f1b7e"

URI_aarch64_rust-fiat-crypto+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fiat-crypto+default-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-fiat-crypto+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fiat-crypto+default-devel}"
SRC_URI[aarch64_rust-fiat-crypto+default-devel.sha256sum] = "bb2885e9e12af878a707af09aaa96ec1b509235799a11d583154bf8a5e85ef0b"

URI_aarch64_rust-fiat-crypto+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fiat-crypto+std-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-fiat-crypto+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fiat-crypto+std-devel}"
SRC_URI[aarch64_rust-fiat-crypto+std-devel.sha256sum] = "388bf1b1fe4ca403abea032c1b4b73fac3ae0096ec84e281212884659ba99408"

URI_aarch64_rust-fiat-crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fiat-crypto-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-fiat-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fiat-crypto-devel}"
SRC_URI[aarch64_rust-fiat-crypto-devel.sha256sum] = "ee14b8d8819850c1b6a86cd1ca13ba255c9ff44d12d029b5e870e9c6a603eef5"

RDEPENDS:rust-fiat-crypto+default-devel = " \
 cargo \
 rust-fiat-crypto+std-devel \
 rust-fiat-crypto-devel \
 "
RDEPENDS:rust-fiat-crypto+std-devel = " \
 cargo \
 rust-fiat-crypto-devel \
 "
RDEPENDS:rust-fiat-crypto-devel = " \
 cargo \
 rust \
 "
