# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "container-tools"
PV = "1"
PR = "16.el10"
PACKAGES = " \
 container-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/container-tools-1-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "465c4d8ef260abb23a5926e1a66a68a0513893c83503b32545810d62231cdd46"

URI_x86_64_v2_container-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/container-tools-1-16.el10.noarch.rpm;name=x86_64_v2_container-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_container-tools}"
SRC_URI[x86_64_v2_container-tools.sha256sum] = "0309b0435b74e3a8fddb90cf71308a9f0d6a5fbc285b1c33504a7f84386fe72c"

URI_aarch64_container-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/container-tools-1-16.el10.noarch.rpm;name=aarch64_container-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_container-tools}"
SRC_URI[aarch64_container-tools.sha256sum] = "0309b0435b74e3a8fddb90cf71308a9f0d6a5fbc285b1c33504a7f84386fe72c"

RDEPENDS:container-tools = " \
 aardvark-dns \
 buildah \
 cockpit-podman \
 conmon \
 container-selinux \
 containers-common \
 crun \
 fuse-overlayfs \
 netavark \
 podman \
 podman-docker \
 python3-podman \
 skopeo \
 slirp4netns \
 toolbox \
 udica \
 "
