# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdiamond"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdiamond \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdiamond-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "805163b43b2f8d3f61652409a9ff14b6d33378cd31ff79ced447d8d696f4d18d"

URI_x86_64_v2_kdiamond = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdiamond-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdiamond;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdiamond}"
SRC_URI[x86_64_v2_kdiamond.sha256sum] = "44fbe4ab058d03d9c2df7d2ba3dc49c719e373ba9de85c7d1964346f0fda7e05"

URI_aarch64_kdiamond = "${EPEL_MIRROR}/aarch64/Packages/k/kdiamond-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdiamond;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdiamond}"
SRC_URI[aarch64_kdiamond.sha256sum] = "4ad4763e1f163104d59aeaee86eafd89c2fa10cd3c4a58f9251a8a5e99a7fda0"

RDEPENDS:kdiamond = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
