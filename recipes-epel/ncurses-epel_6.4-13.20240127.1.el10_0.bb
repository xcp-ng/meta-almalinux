# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ncurses-epel"
PV = "6.4"
PR = "13.20240127.1.el10_0"
PACKAGES = " \
 ncurses-compat-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ncurses-epel-6.4-13.20240127.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbefb93db5fb0bd7b1d8b8e0f274ac2d3c387799b5e016d6c7c3e65f14ae1315"

URI_x86_64_v2_ncurses-compat-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ncurses-compat-libs-6.4-13.20240127.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ncurses-compat-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncurses-compat-libs}"
SRC_URI[x86_64_v2_ncurses-compat-libs.sha256sum] = "9242e7f77fd75ace532513c1ed0eae76466a0a94239289ecda0e652f3034ded0"

URI_aarch64_ncurses-compat-libs = "${EPEL_MIRROR}/aarch64/Packages/n/ncurses-compat-libs-6.4-13.20240127.1.el10_0.aarch64.rpm;name=aarch64_ncurses-compat-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncurses-compat-libs}"
SRC_URI[aarch64_ncurses-compat-libs.sha256sum] = "fc4a21e1ae7204f4a2271448e2089f1667643a88575e7bfdebe2e6bbc93fa3cd"

RDEPENDS:ncurses-compat-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-base \
 "
