# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-HTTP"
PV = "4000.4.1"
PR = "7.el10_0"
PACKAGES = " \
 ghc-HTTP \
 ghc-HTTP-devel \
 ghc-HTTP-doc \
 ghc-HTTP-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-HTTP-4000.4.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c096f7d2f904d2be56877d2387a45e19443b2d69f351e4cff24e1b2b49faa79"

URI_x86_64_v2_ghc-HTTP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HTTP-4000.4.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-HTTP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HTTP}"
SRC_URI[x86_64_v2_ghc-HTTP.sha256sum] = "b5a97d287984b88c6226632fefb4629886ee611c46223b8880755050cf8678e0"

URI_x86_64_v2_ghc-HTTP-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HTTP-devel-4000.4.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-HTTP-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HTTP-devel}"
SRC_URI[x86_64_v2_ghc-HTTP-devel.sha256sum] = "3a82dd105b23693ce188fb7577fa7f70f35fc11d2906bea2cce279623b4efce7"

URI_x86_64_v2_ghc-HTTP-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HTTP-doc-4000.4.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-HTTP-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HTTP-doc}"
SRC_URI[x86_64_v2_ghc-HTTP-doc.sha256sum] = "88deeebf13e93b3664ce40ad363a2622533f7fb0120f7da3cef09353de72ed77"

URI_x86_64_v2_ghc-HTTP-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HTTP-prof-4000.4.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-HTTP-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HTTP-prof}"
SRC_URI[x86_64_v2_ghc-HTTP-prof.sha256sum] = "4f3f828a81e8901d4604e578a74eaeb0dda67aeb89b546d1dd504357a9efcab8"

URI_aarch64_ghc-HTTP = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HTTP-4000.4.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-HTTP;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HTTP}"
SRC_URI[aarch64_ghc-HTTP.sha256sum] = "7243bb86810186169523cd70433e82a4b03b91a9171b91d358b4bc4c05216283"

URI_aarch64_ghc-HTTP-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HTTP-devel-4000.4.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-HTTP-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HTTP-devel}"
SRC_URI[aarch64_ghc-HTTP-devel.sha256sum] = "27526a67fd8e4679f83cf0117486c0f5bab85599c50f0e5a30807868c3523350"

URI_aarch64_ghc-HTTP-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HTTP-doc-4000.4.1-7.el10_0.noarch.rpm;name=aarch64_ghc-HTTP-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HTTP-doc}"
SRC_URI[aarch64_ghc-HTTP-doc.sha256sum] = "fd86fc9a08d6c527331df32f11a5c2ebcae97332679190a54300657618d947a9"

URI_aarch64_ghc-HTTP-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HTTP-prof-4000.4.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-HTTP-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HTTP-prof}"
SRC_URI[aarch64_ghc-HTTP-prof.sha256sum] = "85d80a1739b0ec9213a1d0257011b7952038de9ccb7253987098d0a4d00a307c"

RDEPENDS:ghc-HTTP = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-parsec \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-th-compat \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-HTTP-devel = " \
 ghc-HTTP \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-mtl-devel \
 ghc-network-devel \
 ghc-network-uri-devel \
 ghc-parsec-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-HTTP-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-HTTP-prof = " \
 ghc-HTTP-devel \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-mtl-prof \
 ghc-network-prof \
 ghc-network-uri-prof \
 ghc-parsec-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 "
