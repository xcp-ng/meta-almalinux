# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-quh"
PV = "0.20110816"
PR = "31.el10"
PACKAGES = " \
 hunspell-quh \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-quh-0.20110816-31.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ad909b6ce674f9bc0d7687559b5133e159cca16248d6108c89194483616526e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-quh-0.20110816-31.el10.noarch.rpm;name=x86_64_v2_hunspell-quh;unpack=0"
SRC_URI[x86_64_v2_hunspell-quh.sha256sum] = "8b70e9f62db81d8c92031337de5d89abd6043a029552b10d4a560e27aaaf134f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-quh-0.20110816-31.el10.noarch.rpm;name=aarch64_hunspell-quh;unpack=0"
SRC_URI[aarch64_hunspell-quh.sha256sum] = "8b70e9f62db81d8c92031337de5d89abd6043a029552b10d4a560e27aaaf134f"

RDEPENDS:hunspell-quh = " \
 hunspell \
 "
