# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbd"
PV = "2.6.4"
PR = "8.el10"
PACKAGES = " \
 kbd \
 kbd-legacy \
 kbd-misc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kbd-2.6.4-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8dfbec2c50ec2b8deb1171ff7ccf1df35b493e8a8d7769dac0e1bc9aa9189b29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kbd-2.6.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_kbd;unpack=0"
SRC_URI[x86_64_v2_kbd.sha256sum] = "d108cfa99845cb04ba6dcc02eb25c6497d47ddee1693ce4351449dff465aacc9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kbd-legacy-2.6.4-8.el10.noarch.rpm;name=x86_64_v2_kbd-legacy;unpack=0"
SRC_URI[x86_64_v2_kbd-legacy.sha256sum] = "0c96f9c36b3093a973e2f7042cb02bb2bddf44daa313d4d2cf417be17204fa31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kbd-misc-2.6.4-8.el10.noarch.rpm;name=x86_64_v2_kbd-misc;unpack=0"
SRC_URI[x86_64_v2_kbd-misc.sha256sum] = "ef181ff69837c76309e8d227c3d5d78e15fd982bb401b11d4f513422ab4ea3cb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kbd-2.6.4-8.el10.aarch64.rpm;name=aarch64_kbd;unpack=0"
SRC_URI[aarch64_kbd.sha256sum] = "fdd72f8185294c839f3ac421a1628ea1bfc46611820c3edd8ced418d1d4e0343"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kbd-legacy-2.6.4-8.el10.noarch.rpm;name=aarch64_kbd-legacy;unpack=0"
SRC_URI[aarch64_kbd-legacy.sha256sum] = "0c96f9c36b3093a973e2f7042cb02bb2bddf44daa313d4d2cf417be17204fa31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kbd-misc-2.6.4-8.el10.noarch.rpm;name=aarch64_kbd-misc;unpack=0"
SRC_URI[aarch64_kbd-misc.sha256sum] = "ef181ff69837c76309e8d227c3d5d78e15fd982bb401b11d4f513422ab4ea3cb"

RDEPENDS:kbd = " \
 bash \
 glibc \
 kbd-legacy \
 kbd-misc \
 pam-libs \
 "
RDEPENDS:kbd-legacy = " \
 "
RDEPENDS:kbd-misc = " \
 "
