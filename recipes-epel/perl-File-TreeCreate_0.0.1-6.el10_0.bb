# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-TreeCreate"
PV = "0.0.1"
PR = "6.el10_0"
PACKAGES = " \
 perl-File-TreeCreate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-TreeCreate-0.0.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be2c0c244d9263cc0a1f99ecee880fe3586e07f87a7d35f9b520bc64a86e4faa"

URI_x86_64_v2_perl-File-TreeCreate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-TreeCreate-0.0.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-TreeCreate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-TreeCreate}"
SRC_URI[x86_64_v2_perl-File-TreeCreate.sha256sum] = "4fbd76386a7342f66671e1813ac303209bc264ce87ea07b7ef4c3d0a5142417a"

URI_aarch64_perl-File-TreeCreate = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-TreeCreate-0.0.1-6.el10_0.noarch.rpm;name=aarch64_perl-File-TreeCreate;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-TreeCreate}"
SRC_URI[aarch64_perl-File-TreeCreate.sha256sum] = "f6273c0ac9cf8c1c8d416fb04201459e976148648cf8ceed2e54cc9ae93dba8c"

RDEPENDS:perl-File-TreeCreate = " \
 perl-Carp \
 perl-PathTools \
 perl-autodie \
 perl-libs \
 "
