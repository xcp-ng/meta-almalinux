# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "amavisd-milter"
PV = "1.7.2"
PR = "9.el10_0"
PACKAGES = " \
 amavisd-milter \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/amavisd-milter-1.7.2-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e8c2828fe53c39dc1b7ef5cd7511e05b5ee66897e69315712c07f15d79c4fc3a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amavisd-milter-1.7.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amavisd-milter;unpack=0"
SRC_URI[x86_64_v2_amavisd-milter.sha256sum] = "eec1aca7846768418656de9ef21b52ec7782aea9cc7e6329eff213b8ce184fce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/amavisd-milter-1.7.2-9.el10_0.aarch64.rpm;name=aarch64_amavisd-milter;unpack=0"
SRC_URI[aarch64_amavisd-milter.sha256sum] = "06bd053b24e4dd7b84ce3f6d0ea77266798cb7b124304d2a4826cab42b1a6b8d"

RDEPENDS:amavisd-milter = " \
 amavis \
 bash \
 glibc \
 sendmail-milter \
 systemd \
 "
