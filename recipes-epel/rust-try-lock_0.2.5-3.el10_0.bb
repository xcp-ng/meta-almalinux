# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-try-lock"
PV = "0.2.5"
PR = "3.el10_0"
PACKAGES = " \
 rust-try-lock+default-devel \
 rust-try-lock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-try-lock-0.2.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b30d861fa50da1f8ec597517d1d6f6bfd0f673b0355399cc70dbd6cfcf5b42e"

URI_x86_64_v2_rust-try-lock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-try-lock+default-devel-0.2.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-try-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-try-lock+default-devel}"
SRC_URI[x86_64_v2_rust-try-lock+default-devel.sha256sum] = "22bb36e06d7b5b56ff59b093e7ae2db5897e8145d1ea8eec3a23b09929e31e77"

URI_x86_64_v2_rust-try-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-try-lock-devel-0.2.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-try-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-try-lock-devel}"
SRC_URI[x86_64_v2_rust-try-lock-devel.sha256sum] = "904ec87b6fff23894d9b09b2ff8824ce51a12b15c1f4a67782c981df1c5b2dad"

URI_aarch64_rust-try-lock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-try-lock+default-devel-0.2.5-3.el10_0.noarch.rpm;name=aarch64_rust-try-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-try-lock+default-devel}"
SRC_URI[aarch64_rust-try-lock+default-devel.sha256sum] = "c025a8b4045513fbeee5f7b61942f8f2814f74f2bbc677cc326a9a21cc7f09f1"

URI_aarch64_rust-try-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-try-lock-devel-0.2.5-3.el10_0.noarch.rpm;name=aarch64_rust-try-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-try-lock-devel}"
SRC_URI[aarch64_rust-try-lock-devel.sha256sum] = "211087b5985192e295a10afb98e16a139bd6eaa4622a13e47f7fa50dd1982ae7"

RDEPENDS:rust-try-lock+default-devel = " \
 cargo \
 rust-try-lock-devel \
 "
RDEPENDS:rust-try-lock-devel = " \
 cargo \
 "
