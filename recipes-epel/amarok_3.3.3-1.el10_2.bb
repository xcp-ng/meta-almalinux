# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "amarok"
PV = "3.3.3"
PR = "1.el10_2"
PACKAGES = " \
 amarok \
 amarok-doc \
 amarok-libs \
 amarok-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/amarok-3.3.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2abe855d84a6f0b79fb20d6221c96ce83016b34ebba37818cf9e79bc7c19a267"

URI_x86_64_v2_amarok = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amarok-3.3.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amarok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amarok}"
SRC_URI[x86_64_v2_amarok.sha256sum] = "94ea380bd3b2f9a337ebe3bf66060e5440205a4a9d0d1c8e7b8add80883de847"

URI_x86_64_v2_amarok-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amarok-doc-3.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_amarok-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amarok-doc}"
SRC_URI[x86_64_v2_amarok-doc.sha256sum] = "467bb5cba5cd08e81332a8f8d57338c3f6081ef7b64b547ddb4f0a3fc551850a"

URI_x86_64_v2_amarok-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amarok-libs-3.3.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amarok-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amarok-libs}"
SRC_URI[x86_64_v2_amarok-libs.sha256sum] = "034ba8a91b5a160a8a75c7b5265d96eb82910ab43b5706c5faba26e579380145"

URI_x86_64_v2_amarok-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amarok-utils-3.3.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amarok-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amarok-utils}"
SRC_URI[x86_64_v2_amarok-utils.sha256sum] = "c00dab55bdcedacee94a857e8b270e5ef2c098e3a6c59c51888346452143da5d"

URI_aarch64_amarok = "${EPEL_MIRROR}/aarch64/Packages/a/amarok-3.3.3-1.el10_2.aarch64.rpm;name=aarch64_amarok;unpack=0"
SRC_URI:append = " ${URI_aarch64_amarok}"
SRC_URI[aarch64_amarok.sha256sum] = "5d9cb92dbbc1961b3384be2a118702234f0947a52b99ad34c0e49e88087825da"

URI_aarch64_amarok-doc = "${EPEL_MIRROR}/aarch64/Packages/a/amarok-doc-3.3.3-1.el10_2.noarch.rpm;name=aarch64_amarok-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_amarok-doc}"
SRC_URI[aarch64_amarok-doc.sha256sum] = "eb4f1222c90d1cb6a4c29020e1ffd0e7bba0d48d73851951c89a30e0cec93cf5"

URI_aarch64_amarok-libs = "${EPEL_MIRROR}/aarch64/Packages/a/amarok-libs-3.3.3-1.el10_2.aarch64.rpm;name=aarch64_amarok-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_amarok-libs}"
SRC_URI[aarch64_amarok-libs.sha256sum] = "4e6ee02747a076a24172ebaf47a7bbd5a9e386a25a5b507b3b61927a836d01c4"

URI_aarch64_amarok-utils = "${EPEL_MIRROR}/aarch64/Packages/a/amarok-utils-3.3.3-1.el10_2.aarch64.rpm;name=aarch64_amarok-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_amarok-utils}"
SRC_URI[aarch64_amarok-utils.sha256sum] = "a2a3d19a9ca439ad50295d04fb218276ff3911409251d13e66e17cca3fd071ac"

RDEPENDS:amarok = " \
 amarok-libs \
 amarok-utils \
 fftw-libs-double \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kwidgetsaddons \
 kf6-solid \
 kf6-threadweaver \
 libstdc++ \
 mariadb-connector-c \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 taglib \
 virtual/libmariadbd.so.19___64bit_ \
 "
RDEPENDS:amarok-doc = " \
 amarok \
 "
RDEPENDS:amarok-libs = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 kf6-karchive \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kstatusnotifieritem \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 kf6-threadweaver \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 qt6-qttools \
 taglib \
 "
RDEPENDS:amarok-utils = " \
 amarok-libs \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
