# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdesu"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kdesu \
 kf6-kdesu-devel \
 kf6-kdesu-doc \
 kf6-kdesu-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdesu-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87af45e029b86577a831705f74f0a6441978725629d3156d2103614667b4866a"

URI_x86_64_v2_kf6-kdesu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdesu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdesu}"
SRC_URI[x86_64_v2_kf6-kdesu.sha256sum] = "eaee6b973695af67962b92bbbeb613fd0e927c1a4490989e5bea29acd068c155"

URI_x86_64_v2_kf6-kdesu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdesu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdesu-devel}"
SRC_URI[x86_64_v2_kf6-kdesu-devel.sha256sum] = "ba016e59448ab45388c72bbec0fa2c2004ad85f7d9a9fd0e1202bb886a4f6ce7"

URI_x86_64_v2_kf6-kdesu-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdesu-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdesu-doc}"
SRC_URI[x86_64_v2_kf6-kdesu-doc.sha256sum] = "32919e8cf432c6e74891ff4a90302365a623267e30891b401f2fe6265ea25e1d"

URI_x86_64_v2_kf6-kdesu-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdesu-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdesu-html}"
SRC_URI[x86_64_v2_kf6-kdesu-html.sha256sum] = "08a015414009e84e04762dfd816375bc516a2aa5e7c620de8b60a28bbfb6f367"

URI_aarch64_kf6-kdesu = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdesu;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdesu}"
SRC_URI[aarch64_kf6-kdesu.sha256sum] = "023a915b7dff51c30022d8787e525dee3bc821b0a66b1df73de9559d0a27ecb4"

URI_aarch64_kf6-kdesu-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdesu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdesu-devel}"
SRC_URI[aarch64_kf6-kdesu-devel.sha256sum] = "4eb77e16f538e5be4fb9d871e62d07f1a07337c9690c95da3c9eccb16c3644d8"

URI_aarch64_kf6-kdesu-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdesu-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdesu-doc}"
SRC_URI[aarch64_kf6-kdesu-doc.sha256sum] = "368abbc489e20c2a8b1eeb5851461a7bffb5f504c1861ea3ec19e534f6763119"

URI_aarch64_kf6-kdesu-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdesu-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdesu-html}"
SRC_URI[aarch64_kf6-kdesu-html.sha256sum] = "dcd44ce9f9737b41a3dcad127ebf6638f2b7f4385f7268db09a6e9bea095f51d"

RDEPENDS:kf6-kdesu = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpty \
 libX11 \
 libstdc++ \
 qt6-qtbase \
 sudo \
 "
RDEPENDS:kf6-kdesu-devel = " \
 cmake-filesystem \
 kf6-kdesu \
 kf6-kpty-devel \
 "
RDEPENDS:kf6-kdesu-doc = " \
 "
RDEPENDS:kf6-kdesu-html = " \
 "
