# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-vsort"
PV = "0.2.0"
PR = "6.el10_3"
PACKAGES = " \
 rust-vsort+default-devel \
 rust-vsort-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-vsort-0.2.0-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0224160d1796b7ef680579734dfe2e7778ae25c06ed599b9e08b36a41068560f"

URI_x86_64_v2_rust-vsort+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vsort+default-devel-0.2.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vsort+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vsort+default-devel}"
SRC_URI[x86_64_v2_rust-vsort+default-devel.sha256sum] = "74e28d468e577423e12f12fdd81854647821186ef51379cbb70d3e1e4f6fd692"

URI_x86_64_v2_rust-vsort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vsort-devel-0.2.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vsort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vsort-devel}"
SRC_URI[x86_64_v2_rust-vsort-devel.sha256sum] = "037a7880a0c1903eb9ee1fed7b2441d39dedbfb4897da9cae3daa86f4dd7fa41"

URI_aarch64_rust-vsort+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vsort+default-devel-0.2.0-6.el10_3.noarch.rpm;name=aarch64_rust-vsort+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vsort+default-devel}"
SRC_URI[aarch64_rust-vsort+default-devel.sha256sum] = "d2b07a5bcefffc9255147b1bf9913dc5bcdf1ef75a7cbe3161d6f1388decd78b"

URI_aarch64_rust-vsort-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vsort-devel-0.2.0-6.el10_3.noarch.rpm;name=aarch64_rust-vsort-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vsort-devel}"
SRC_URI[aarch64_rust-vsort-devel.sha256sum] = "7ab87153017191c31269590a988543d919534ef8d92d5f95516c0311dde27e78"

RDEPENDS:rust-vsort+default-devel = " \
 cargo \
 rust-vsort-devel \
 "
RDEPENDS:rust-vsort-devel = " \
 cargo \
 "
