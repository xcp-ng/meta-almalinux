# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgoldrunner"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kgoldrunner \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgoldrunner-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bf61b9c997cba5926c4aea34831c289baaaec58d5bb0e23d653144a951b56a0"

URI_x86_64_v2_kgoldrunner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgoldrunner-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgoldrunner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgoldrunner}"
SRC_URI[x86_64_v2_kgoldrunner.sha256sum] = "32dc86b801679c0d7a371de98e21a76f9ea08adeeb69dfc0b6381db392100998"

URI_aarch64_kgoldrunner = "${EPEL_MIRROR}/aarch64/Packages/k/kgoldrunner-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kgoldrunner;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgoldrunner}"
SRC_URI[aarch64_kgoldrunner.sha256sum] = "2224e575bfc51e9631d51ff6643116fbf82fb294c439ce9f0ef66bf0e694d9d4"

RDEPENDS:kgoldrunner = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
