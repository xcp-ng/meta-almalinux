# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lorax-templates-rhel"
PV = "10.3"
PR = "2.el10"
PACKAGES = " \
 lorax-templates-almalinux \
 lorax-templates-rhel \
 lorax-templates-rhel-64k \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lorax-templates-rhel-10.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7dff802cf5ed18a61cc46e161b873c072aa3cf7fa0cd0b7b05a4a38bfa4fb4a5"

URI_x86_64_v2_lorax-templates-almalinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-almalinux-10.3-2.el10.noarch.rpm;name=x86_64_v2_lorax-templates-almalinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-templates-almalinux}"
SRC_URI[x86_64_v2_lorax-templates-almalinux.sha256sum] = "5a9d15d44ea1adcb8c9a8a246c51a9f8f3c5a25cd451a6c52d055edb2c10a1cd"
RPROVIDES:lorax-templates-almalinux:x86_64_v2 = "virtual/lorax-templates"

URI_x86_64_v2_lorax-templates-rhel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-rhel-10.3-2.el10.noarch.rpm;name=x86_64_v2_lorax-templates-rhel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-templates-rhel}"
SRC_URI[x86_64_v2_lorax-templates-rhel.sha256sum] = "b47fa9f8ae796f4d4bb2409279719089364d8d1830ad63f2e674a69ae31d1432"
RPROVIDES:lorax-templates-rhel:x86_64_v2 = "virtual/lorax-templates"

URI_x86_64_v2_lorax-templates-rhel-64k = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-rhel-64k-10.3-2.el10.noarch.rpm;name=x86_64_v2_lorax-templates-rhel-64k;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-templates-rhel-64k}"
SRC_URI[x86_64_v2_lorax-templates-rhel-64k.sha256sum] = "32e72ca80db93af09ce7c16f77959760b2b71c9121270b2df822cd3dce6553ea"

URI_aarch64_lorax-templates-almalinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-almalinux-10.3-2.el10.noarch.rpm;name=aarch64_lorax-templates-almalinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-templates-almalinux}"
SRC_URI[aarch64_lorax-templates-almalinux.sha256sum] = "5a9d15d44ea1adcb8c9a8a246c51a9f8f3c5a25cd451a6c52d055edb2c10a1cd"
RPROVIDES:lorax-templates-almalinux:aarch64 = "virtual/lorax-templates"

URI_aarch64_lorax-templates-rhel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-rhel-10.3-2.el10.noarch.rpm;name=aarch64_lorax-templates-rhel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-templates-rhel}"
SRC_URI[aarch64_lorax-templates-rhel.sha256sum] = "b47fa9f8ae796f4d4bb2409279719089364d8d1830ad63f2e674a69ae31d1432"
RPROVIDES:lorax-templates-rhel:aarch64 = "virtual/lorax-templates"

URI_aarch64_lorax-templates-rhel-64k = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-rhel-64k-10.3-2.el10.noarch.rpm;name=aarch64_lorax-templates-rhel-64k;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-templates-rhel-64k}"
SRC_URI[aarch64_lorax-templates-rhel-64k.sha256sum] = "32e72ca80db93af09ce7c16f77959760b2b71c9121270b2df822cd3dce6553ea"

RDEPENDS:lorax-templates-almalinux = " \
 lorax \
 "
RDEPENDS:lorax-templates-rhel = " \
 lorax \
 "
RDEPENDS:lorax-templates-rhel-64k = " \
 lorax \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/lorax-templates"

PROVIDES:append:aarch64 = " rpm/virtual/lorax-templates"
