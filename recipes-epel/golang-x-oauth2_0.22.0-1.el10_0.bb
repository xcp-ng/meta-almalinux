# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-x-oauth2"
PV = "0.22.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-x-oauth2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-x-oauth2-0.22.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9774f51aa687c0101719e158da1b2294dbc41f7d8911088112494b3c327b605"

URI_x86_64_v2_golang-x-oauth2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-x-oauth2-devel-0.22.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-x-oauth2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-x-oauth2-devel}"
SRC_URI[x86_64_v2_golang-x-oauth2-devel.sha256sum] = "5f94cfd0bfb744606e2720a11c5cb1465880673a2dcc405f2979ebe60b6e4cdf"

URI_aarch64_golang-x-oauth2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-x-oauth2-devel-0.22.0-1.el10_0.noarch.rpm;name=aarch64_golang-x-oauth2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-x-oauth2-devel}"
SRC_URI[aarch64_golang-x-oauth2-devel.sha256sum] = "99d81a892b3c3345d4a388a6ac37d65278b3d55499ceeca263f241019d70f630"

RDEPENDS:golang-x-oauth2-devel = " \
 go-filesystem \
 golang-cloud-google-compute-metadata-devel \
 "
