# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MIME-EncWords"
PV = "1.015.0"
PR = "2.el10_0"
PACKAGES = " \
 perl-MIME-EncWords \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MIME-EncWords-1.015.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c76c5b1f4f6923ddae32d5cc545ea4bc92ca6bf2a71a2a635a5e359a0cd68041"

URI_x86_64_v2_perl-MIME-EncWords = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MIME-EncWords-1.015.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MIME-EncWords;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MIME-EncWords}"
SRC_URI[x86_64_v2_perl-MIME-EncWords.sha256sum] = "494eeb5e09f552488b8c258885113e799c325fab1eca144f25184d70053a9360"

URI_aarch64_perl-MIME-EncWords = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MIME-EncWords-1.015.0-2.el10_0.noarch.rpm;name=aarch64_perl-MIME-EncWords;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MIME-EncWords}"
SRC_URI[aarch64_perl-MIME-EncWords.sha256sum] = "b2b70bd885e86b1e141d32d88657864c3eeae5a2b810860800c63712752779de"

RDEPENDS:perl-MIME-EncWords = " \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-MIME-Base64 \
 perl-MIME-Charset \
 perl-MIME-EncWords \
 perl-base \
 perl-libs \
 perl-vars \
 "
