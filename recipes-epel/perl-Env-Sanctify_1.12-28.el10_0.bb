# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Env-Sanctify"
PV = "1.12"
PR = "28.el10_0"
PACKAGES = " \
 perl-Env-Sanctify \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Env-Sanctify-1.12-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ebf4f95cc90233cfc83bdb40682640ca61941244d8a753d2406ac4d37c9d7e3"

URI_x86_64_v2_perl-Env-Sanctify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Env-Sanctify-1.12-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Env-Sanctify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Env-Sanctify}"
SRC_URI[x86_64_v2_perl-Env-Sanctify.sha256sum] = "4df2654b2e560918fb72859de727b171eb03b43bc1a19e19c89550392ce63076"

URI_aarch64_perl-Env-Sanctify = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Env-Sanctify-1.12-28.el10_0.noarch.rpm;name=aarch64_perl-Env-Sanctify;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Env-Sanctify}"
SRC_URI[aarch64_perl-Env-Sanctify.sha256sum] = "ab194def93be71e5065f422870319ee52126c0ff33283b290564baac58ad9e1e"

RDEPENDS:perl-Env-Sanctify = " \
 perl-libs \
 "
