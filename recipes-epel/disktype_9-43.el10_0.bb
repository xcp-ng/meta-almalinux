# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "disktype"
PV = "9"
PR = "43.el10_0"
PACKAGES = " \
 disktype \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/disktype-9-43.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3cc5c76fdc5aa91f0c42041827f7c7813d65f8827292547cd0f21fa231db3555"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/disktype-9-43.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_disktype;unpack=0"
SRC_URI[x86_64_v2_disktype.sha256sum] = "9367abcd943f5ef1d6c2b12621b87e25248da909214cd3eb5c8684bbb7f71540"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/disktype-9-43.el10_0.aarch64.rpm;name=aarch64_disktype;unpack=0"
SRC_URI[aarch64_disktype.sha256sum] = "8e4e9e3f678dd5a211c49bc89ffb9d4d00c4aba77d6ede100a88887ba7a65c48"

RDEPENDS:disktype = " \
 glibc \
 libewf \
 "
