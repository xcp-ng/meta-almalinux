# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ipyparallel"
PV = "9.1.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-ipyparallel \
 python3-ipyparallel+test \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ipyparallel-9.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0facd8526acc1523fd5e82b86d31c2b751cacb42a357828c8642cfa866dddd28"

URI_x86_64_v2_python3-ipyparallel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipyparallel-9.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipyparallel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipyparallel}"
SRC_URI[x86_64_v2_python3-ipyparallel.sha256sum] = "266630a924379c525e8278a7622ab25da4a84742f8200fb0446069976da8214e"

URI_x86_64_v2_python3-ipyparallel+test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipyparallel+test-9.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipyparallel+test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipyparallel+test}"
SRC_URI[x86_64_v2_python3-ipyparallel+test.sha256sum] = "90ba8c901b3096ecf06c707355764b132f68ccc75b79352ca88316d2df27ec28"

URI_aarch64_python3-ipyparallel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipyparallel-9.1.0-1.el10_1.noarch.rpm;name=aarch64_python3-ipyparallel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipyparallel}"
SRC_URI[aarch64_python3-ipyparallel.sha256sum] = "c78ac2bb1efdf270ea4a384726161e7bce5d31c29c727f9adce69353c3fb6724"

URI_aarch64_python3-ipyparallel+test = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipyparallel+test-9.1.0-1.el10_1.noarch.rpm;name=aarch64_python3-ipyparallel+test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipyparallel+test}"
SRC_URI[aarch64_python3-ipyparallel+test.sha256sum] = "755c0cad46f52674dbe5387d0da94ec2ab9d6a760f1952b308e25366f5ac5e5d"

RDEPENDS:python3-ipyparallel = " \
 python-jupyter-filesystem \
 python3 \
 python3-dateutil \
 python3-decorator \
 python3-ipykernel \
 python3-ipython \
 python3-jupyter-client \
 python3-psutil \
 python3-pyzmq \
 python3-tornado \
 python3-tqdm \
 python3-traitlets \
 "
RDEPENDS:python3-ipyparallel+test = " \
 python3 \
 python3-ipyparallel \
 python3-ipython \
 python3-ipython+test \
 python3-pytest \
 python3-pytest-asyncio \
 python3-pytest-cov \
 python3-testpath \
 "
