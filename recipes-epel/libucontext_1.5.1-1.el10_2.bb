# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libucontext"
PV = "1.5.1"
PR = "1.el10_2"
PACKAGES = " \
 libucontext \
 libucontext-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libucontext-1.5.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce0ebc4c38c4e63e526e520ed29de9c71c4a35e22b20186f9f3689e660b68e1f"

URI_x86_64_v2_libucontext = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libucontext-1.5.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libucontext;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libucontext}"
SRC_URI[x86_64_v2_libucontext.sha256sum] = "8fbc5f7013f77bb2572b01b18abf350ddd075446fd7393be04a4eb0202daa83a"

URI_x86_64_v2_libucontext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libucontext-devel-1.5.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libucontext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libucontext-devel}"
SRC_URI[x86_64_v2_libucontext-devel.sha256sum] = "6c0572d4a90797b35d466d2e7eb71af66e269b3cb192b787aea574eba382a554"

URI_aarch64_libucontext = "${EPEL_MIRROR}/aarch64/Packages/l/libucontext-1.5.1-1.el10_2.aarch64.rpm;name=aarch64_libucontext;unpack=0"
SRC_URI:append = " ${URI_aarch64_libucontext}"
SRC_URI[aarch64_libucontext.sha256sum] = "68a39064cf326312562976a0441786931b8a414c3d3aff2b2971fc4029693b21"

URI_aarch64_libucontext-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libucontext-devel-1.5.1-1.el10_2.aarch64.rpm;name=aarch64_libucontext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libucontext-devel}"
SRC_URI[aarch64_libucontext-devel.sha256sum] = "ff21e9c010d14009a487c53838827ef89ecf43bc91191ad171a0b3b1c0cdf976"

RDEPENDS:libucontext = " \
 glibc \
 "
RDEPENDS:libucontext-devel = " \
 libucontext \
 pkgconf-pkg-config \
 "
