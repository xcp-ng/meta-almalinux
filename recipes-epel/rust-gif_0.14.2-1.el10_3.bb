# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gif"
PV = "0.14.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-gif+color_quant-devel \
 rust-gif+default-devel \
 rust-gif+raii_no_panic-devel \
 rust-gif+std-devel \
 rust-gif-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gif-0.14.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14d486093d1e5b8be72d1ff4321f5f6a2e8f3db7127b802d70018d6ef30af17d"

URI_x86_64_v2_rust-gif+color_quant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+color_quant-devel-0.14.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+color_quant-devel}"
SRC_URI[x86_64_v2_rust-gif+color_quant-devel.sha256sum] = "5c61cbb9f1e29564fd1db447c3f7184e0e6e5adc2e8cdda9a24747e0589c6755"

URI_x86_64_v2_rust-gif+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+default-devel-0.14.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+default-devel}"
SRC_URI[x86_64_v2_rust-gif+default-devel.sha256sum] = "2d156058a203a6c26fd76501d04bd007739eceb8ade018ea3f31d156cb3e7fe5"

URI_x86_64_v2_rust-gif+raii_no_panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+raii_no_panic-devel-0.14.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+raii_no_panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+raii_no_panic-devel}"
SRC_URI[x86_64_v2_rust-gif+raii_no_panic-devel.sha256sum] = "09131a3c4fd5e8d0c329f7d69b0be4b507d9d9c8182948294996c201ea45bc8b"

URI_x86_64_v2_rust-gif+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+std-devel-0.14.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+std-devel}"
SRC_URI[x86_64_v2_rust-gif+std-devel.sha256sum] = "3e5a19695d770432d8845be648c1cb4978703081d8cc30e6f30af104a9fb3346"

URI_x86_64_v2_rust-gif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif-devel-0.14.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif-devel}"
SRC_URI[x86_64_v2_rust-gif-devel.sha256sum] = "88df6668612d5d7467d3bf0ab1d1431b5bffa1fbc9d3586a2dd1249b6081527b"

URI_aarch64_rust-gif+color_quant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+color_quant-devel-0.14.2-1.el10_3.noarch.rpm;name=aarch64_rust-gif+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+color_quant-devel}"
SRC_URI[aarch64_rust-gif+color_quant-devel.sha256sum] = "c1ad4fc7429ce0a78389f3a80017ed28f5a36228ee9fa0e05b2dfb602a2c4b70"

URI_aarch64_rust-gif+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+default-devel-0.14.2-1.el10_3.noarch.rpm;name=aarch64_rust-gif+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+default-devel}"
SRC_URI[aarch64_rust-gif+default-devel.sha256sum] = "78a8d85ae81aee8856ff8dce31a8239d7632cb6e1b9b5a50c7ea265c5a634de5"

URI_aarch64_rust-gif+raii_no_panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+raii_no_panic-devel-0.14.2-1.el10_3.noarch.rpm;name=aarch64_rust-gif+raii_no_panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+raii_no_panic-devel}"
SRC_URI[aarch64_rust-gif+raii_no_panic-devel.sha256sum] = "8aa213407075ac48706c911b311442d1189fe2ef91efd1a566a65e3eed0e9fb6"

URI_aarch64_rust-gif+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+std-devel-0.14.2-1.el10_3.noarch.rpm;name=aarch64_rust-gif+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+std-devel}"
SRC_URI[aarch64_rust-gif+std-devel.sha256sum] = "5aec1710a7f2ac93506fa865fed5cf8a5a171a472bf7ada2b3cb3cb3755515b7"

URI_aarch64_rust-gif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif-devel-0.14.2-1.el10_3.noarch.rpm;name=aarch64_rust-gif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif-devel}"
SRC_URI[aarch64_rust-gif-devel.sha256sum] = "06715c37b4159e9f05444490b8f7f662aec8e03f9f3dd3ceea563607502cb8b0"

RDEPENDS:rust-gif+color_quant-devel = " \
 cargo \
 rust-color_quant+default-devel \
 rust-gif-devel \
 "
RDEPENDS:rust-gif+default-devel = " \
 cargo \
 rust-gif+color_quant-devel \
 rust-gif+raii_no_panic-devel \
 rust-gif+std-devel \
 rust-gif-devel \
 "
RDEPENDS:rust-gif+raii_no_panic-devel = " \
 cargo \
 rust-gif-devel \
 "
RDEPENDS:rust-gif+std-devel = " \
 cargo \
 rust-gif-devel \
 "
RDEPENDS:rust-gif-devel = " \
 cargo \
 rust \
 rust-weezl+default-devel \
 "
