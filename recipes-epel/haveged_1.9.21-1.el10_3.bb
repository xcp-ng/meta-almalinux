# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "haveged"
PV = "1.9.21"
PR = "1.el10_3"
PACKAGES = " \
 haveged \
 haveged-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/h/haveged-1.9.21-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f822538ba4d2a0db15d023242dee63afdeaf346f01c4c77962b91c9c42d60ade"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/haveged-1.9.21-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_haveged;unpack=0"
SRC_URI[x86_64_v2_haveged.sha256sum] = "d281d8ae71841f44584942cc1adb0609faaf3dccb21d02e19ce62ab277d9a074"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/haveged-devel-1.9.21-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_haveged-devel;unpack=0"
SRC_URI[x86_64_v2_haveged-devel.sha256sum] = "36168d4836bfbd8c6e32cc00e16ea75dd76a5b8ed7c64ecbe5bbae71666aa927"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/haveged-1.9.21-1.el10_3.aarch64.rpm;name=aarch64_haveged;unpack=0"
SRC_URI[aarch64_haveged.sha256sum] = "822357e71e004dd5d36b6a21e323c30bdaeddca7481389ed439d981da8351d4e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/haveged-devel-1.9.21-1.el10_3.aarch64.rpm;name=aarch64_haveged-devel;unpack=0"
SRC_URI[aarch64_haveged-devel.sha256sum] = "c701c4fbb6c5b949087ee198d93c0268253f2c42f750ca6149c561a71f1bee8f"

RDEPENDS:haveged = " \
 bash \
 glibc \
 systemd \
 "
RDEPENDS:haveged-devel = " \
 haveged \
 "
