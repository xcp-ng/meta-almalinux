# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xxhash"
PV = "0.8.4"
PR = "1.el10_3"
PACKAGES = " \
 xxhash \
 xxhash-devel \
 xxhash-doc \
 xxhash-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/x/xxhash-0.8.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fe7d216072cd721d801f3bb1de8a1e7da35d6a9a36857b216dec56e41b22f733"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xxhash-0.8.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xxhash;unpack=0"
SRC_URI[x86_64_v2_xxhash.sha256sum] = "73c46715e8adfeb168cc1ccd56c8c0d9343f8cce89885b98aabbf3fcd78165cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xxhash-devel-0.8.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xxhash-devel;unpack=0"
SRC_URI[x86_64_v2_xxhash-devel.sha256sum] = "5abbe6c4b0c8d2dca5d961a74d007009b3953766d78b819cce28bae6d44ae2d2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xxhash-doc-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_xxhash-doc;unpack=0"
SRC_URI[x86_64_v2_xxhash-doc.sha256sum] = "dc1fc04f07694ad2a8b8e186489683d63caa5ea47f07b98450bc992bb1da6600"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xxhash-libs-0.8.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xxhash-libs;unpack=0"
SRC_URI[x86_64_v2_xxhash-libs.sha256sum] = "3d529a598f755eef9b72e17c3f471ae538e43b3b25950112889c31ab142fa7ba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xxhash-0.8.4-1.el10_3.aarch64.rpm;name=aarch64_xxhash;unpack=0"
SRC_URI[aarch64_xxhash.sha256sum] = "e75b93a8b804139ccb746dc91e0577afd836f9f9d3381c9ff19dd4eefab3ffce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xxhash-devel-0.8.4-1.el10_3.aarch64.rpm;name=aarch64_xxhash-devel;unpack=0"
SRC_URI[aarch64_xxhash-devel.sha256sum] = "498f2c664bc8d995bb6ff5cdbaab22059f8655319bcb4b986fd8411fea260b4f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xxhash-doc-0.8.4-1.el10_3.noarch.rpm;name=aarch64_xxhash-doc;unpack=0"
SRC_URI[aarch64_xxhash-doc.sha256sum] = "13922e0eaf1ae91d82c700e490e5e603e9ff6042fcb8620e2c95604d09a2b150"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xxhash-libs-0.8.4-1.el10_3.aarch64.rpm;name=aarch64_xxhash-libs;unpack=0"
SRC_URI[aarch64_xxhash-libs.sha256sum] = "8e083c4df8adf1b9e2acedc9010e487e6161af1effec348ab0e2ec0a20c47154"

RDEPENDS:xxhash = " \
 glibc \
 "
RDEPENDS:xxhash-devel = " \
 pkgconf-pkg-config \
 xxhash-libs \
 "
RDEPENDS:xxhash-doc = " \
 "
RDEPENDS:xxhash-libs = " \
 glibc \
 "
