# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MooseX-Types-JSON"
PV = "1.01"
PR = "13.el10_3"
PACKAGES = " \
 perl-MooseX-Types-JSON \
 perl-MooseX-Types-JSON-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MooseX-Types-JSON-1.01-13.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e94562ff9a8323a05a0629e51209be90fa81b1c61b13bd61bef30b211fd7d1ff"

URI_x86_64_v2_perl-MooseX-Types-JSON = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MooseX-Types-JSON-1.01-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MooseX-Types-JSON;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MooseX-Types-JSON}"
SRC_URI[x86_64_v2_perl-MooseX-Types-JSON.sha256sum] = "685796cdff6d8d441b567217ccd5e5713eafb0da1ca1b518562cdd825e885d3f"

URI_x86_64_v2_perl-MooseX-Types-JSON-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MooseX-Types-JSON-tests-1.01-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MooseX-Types-JSON-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MooseX-Types-JSON-tests}"
SRC_URI[x86_64_v2_perl-MooseX-Types-JSON-tests.sha256sum] = "4a9fb8444ab31ccf427fd08d604313f191b073cdd9b9db63bb344e0d8a2ff24f"

URI_aarch64_perl-MooseX-Types-JSON = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MooseX-Types-JSON-1.01-13.el10_3.noarch.rpm;name=aarch64_perl-MooseX-Types-JSON;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MooseX-Types-JSON}"
SRC_URI[aarch64_perl-MooseX-Types-JSON.sha256sum] = "46a530f597865fa137194839512d26f4f7a0ed5084eeccdcda3fcfe3b0eac255"

URI_aarch64_perl-MooseX-Types-JSON-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MooseX-Types-JSON-tests-1.01-13.el10_3.noarch.rpm;name=aarch64_perl-MooseX-Types-JSON-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MooseX-Types-JSON-tests}"
SRC_URI[aarch64_perl-MooseX-Types-JSON-tests.sha256sum] = "c77ebbe6472cdad506e0c4bf13e06d7c06d0b4794684a2e6bc7132b21bae7156"

RDEPENDS:perl-MooseX-Types-JSON = " \
 perl-JSON \
 perl-JSON-XS \
 perl-Moose \
 perl-MooseX-Types \
 perl-libs \
 "
RDEPENDS:perl-MooseX-Types-JSON-tests = " \
 perl-MooseX-Types-JSON \
 perl-Test-Harness \
 "
