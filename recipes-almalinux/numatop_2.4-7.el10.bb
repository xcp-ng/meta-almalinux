# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "numatop"
PV = "2.4"
PR = "7.el10"
PACKAGES:x86_64_v2 = " \
 numatop \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/numatop-2.4-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ccfe7119200685d71f392092a51263b7f6e7af22ddaf2521ff6f69db66e93a67"

URI_x86_64_v2_numatop = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/numatop-2.4-7.el10.x86_64_v2.rpm;name=x86_64_v2_numatop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_numatop}"
SRC_URI[x86_64_v2_numatop.sha256sum] = "58bc32efc97c994715059ab42d693c31079a4b6a7d234352ba79528da9aa53d2"

RDEPENDS:numatop = " \
 glibc \
 ncurses-libs \
 numactl-libs \
 "
