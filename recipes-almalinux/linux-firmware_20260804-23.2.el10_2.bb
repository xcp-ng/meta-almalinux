# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linux-firmware"
PV = "20260804"
PR = "23.2.el10_2"
PACKAGES = " \
 amd-gpu-firmware \
 amd-ucode-firmware \
 atheros-firmware \
 brcmfmac-firmware \
 cirrus-audio-firmware \
 dvb-firmware \
 intel-audio-firmware \
 intel-gpu-firmware \
 intel-vsc-firmware \
 iwlegacy-firmware \
 iwlwifi-dvm-firmware \
 iwlwifi-mvm-firmware \
 libertas-firmware \
 linux-firmware \
 linux-firmware-whence \
 mlxsw_spectrum-firmware \
 mrvlprestera-firmware \
 mt7xxx-firmware \
 netronome-firmware \
 nvidia-gpu-firmware \
 nxpwireless-firmware \
 qcom-firmware \
 realtek-firmware \
 tiwilink-firmware \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/linux-firmware-20260804-23.2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d696514aafc5159125374e0acd7f164cdb4c4ded060e0f80999f7ef82e7be73f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/amd-gpu-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_amd-gpu-firmware;unpack=0"
SRC_URI[x86_64_v2_amd-gpu-firmware.sha256sum] = "f2dc91fb1152250d6f525f9671ad5eec861cbd1abcecfb768f488475c7ca23c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/amd-ucode-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_amd-ucode-firmware;unpack=0"
SRC_URI[x86_64_v2_amd-ucode-firmware.sha256sum] = "04a2a71562b6f3fbe32de1b2041f3279bfad493643bee3e4a867224773d5fbff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/atheros-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_atheros-firmware;unpack=0"
SRC_URI[x86_64_v2_atheros-firmware.sha256sum] = "aec95ef2b0596d977eff0d68e7667f3bb6c28efa0a97c337f4122eb120a84ba6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/brcmfmac-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_brcmfmac-firmware;unpack=0"
SRC_URI[x86_64_v2_brcmfmac-firmware.sha256sum] = "0d099fe5fc34fd8b815acd3575dbda0ed225f6dc2508168b67018335cc7d0d50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cirrus-audio-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_cirrus-audio-firmware;unpack=0"
SRC_URI[x86_64_v2_cirrus-audio-firmware.sha256sum] = "52099b53899066c3a685666d01bdc0e65c9d2e01b9f5d8a0885e3fa4f0b78f2c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dvb-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_dvb-firmware;unpack=0"
SRC_URI[x86_64_v2_dvb-firmware.sha256sum] = "620e9d6fee784a4de467b2821c9504e78c0b87f78f63a43b4eb74ef165e3d3dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-audio-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_intel-audio-firmware;unpack=0"
SRC_URI[x86_64_v2_intel-audio-firmware.sha256sum] = "8260b105cef5e961f2b45ffb34837622d6680619e82b29b36ad2b9e2588bae55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/intel-gpu-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_intel-gpu-firmware;unpack=0"
SRC_URI[x86_64_v2_intel-gpu-firmware.sha256sum] = "125bc83cc4790bae689a74bc79f76c31a445e5a9baa4ae64058f70537ebba361"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-vsc-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_intel-vsc-firmware;unpack=0"
SRC_URI[x86_64_v2_intel-vsc-firmware.sha256sum] = "9a25fddf311ee83b33d999470be653c6b97b38837856e1e4d915ded483dd12f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlegacy-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_iwlegacy-firmware;unpack=0"
SRC_URI[x86_64_v2_iwlegacy-firmware.sha256sum] = "e77183977dfaa1483cd6c1a8eed972bc44d7c9e55c4e7416d98e003be8f5771d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlwifi-dvm-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_iwlwifi-dvm-firmware;unpack=0"
SRC_URI[x86_64_v2_iwlwifi-dvm-firmware.sha256sum] = "4fed130bab714b8507d950ff7f86af16f80723184b720284fd194a215eb4e52d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlwifi-mvm-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_iwlwifi-mvm-firmware;unpack=0"
SRC_URI[x86_64_v2_iwlwifi-mvm-firmware.sha256sum] = "28fa7782987e91dd8fefae911c252350d82a4ee98fb39a38cb6f97a3dd428528"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libertas-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_libertas-firmware;unpack=0"
SRC_URI[x86_64_v2_libertas-firmware.sha256sum] = "5208e53d3e8e7b177d62dd30462d40f6384224dd0a2a0b86b047a5aa67b1d731"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/linux-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_linux-firmware;unpack=0"
SRC_URI[x86_64_v2_linux-firmware.sha256sum] = "5014741e94bb623dea69b2d71823d6dd45f9e692b9c937d82c25119df9540ab6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/linux-firmware-whence-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_linux-firmware-whence;unpack=0"
SRC_URI[x86_64_v2_linux-firmware-whence.sha256sum] = "e519e16f9c6794b9159cde782ea4f7074d67f06235e69c2e71eab078567a96b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mlxsw_spectrum-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_mlxsw_spectrum-firmware;unpack=0"
SRC_URI[x86_64_v2_mlxsw_spectrum-firmware.sha256sum] = "8265a4aa2db39dff89e2e7e53d7609f2ec88d54744c853acd2ff2e580cf83823"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mrvlprestera-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_mrvlprestera-firmware;unpack=0"
SRC_URI[x86_64_v2_mrvlprestera-firmware.sha256sum] = "8d7e73ef83073f2d6f8c7dd18e25239ec7c4be87d20e8da28195d5b1de785241"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mt7xxx-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_mt7xxx-firmware;unpack=0"
SRC_URI[x86_64_v2_mt7xxx-firmware.sha256sum] = "f842f82f1c3fb390e549ea6b6db04ace50803a2b9aa5499f305d5bc00d2ea1a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/netronome-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_netronome-firmware;unpack=0"
SRC_URI[x86_64_v2_netronome-firmware.sha256sum] = "385af3b0b2b814e3ceed3d44f9e6465c04ca2e17425f4f536d8c9c2fd7a43855"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nvidia-gpu-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_nvidia-gpu-firmware;unpack=0"
SRC_URI[x86_64_v2_nvidia-gpu-firmware.sha256sum] = "c83817ee9dd53c88a2e35e9515be819ed852ceedacebe64229f6ca4a85c3b27b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nxpwireless-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_nxpwireless-firmware;unpack=0"
SRC_URI[x86_64_v2_nxpwireless-firmware.sha256sum] = "cc34dc48735d3d9ecd081202119bb82be09e980ebd46da60d0ddd54587f894d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/qcom-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_qcom-firmware;unpack=0"
SRC_URI[x86_64_v2_qcom-firmware.sha256sum] = "93a048e7c109d273d8deabae5ba985a8aa876eb9d6a5a1771a53d325cca0fd64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/realtek-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_realtek-firmware;unpack=0"
SRC_URI[x86_64_v2_realtek-firmware.sha256sum] = "2f1219f4f07334f95955c43476efbdec39dcfe9ec8f564214ce604999f302a39"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tiwilink-firmware-20260804-23.2.el10_2.noarch.rpm;name=x86_64_v2_tiwilink-firmware;unpack=0"
SRC_URI[x86_64_v2_tiwilink-firmware.sha256sum] = "f96cbfc9206df8cb1c3de55d7b2f39f505319ddd29f1adef8cb3b3187bf21b42"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/amd-gpu-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_amd-gpu-firmware;unpack=0"
SRC_URI[aarch64_amd-gpu-firmware.sha256sum] = "f2dc91fb1152250d6f525f9671ad5eec861cbd1abcecfb768f488475c7ca23c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/amd-ucode-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_amd-ucode-firmware;unpack=0"
SRC_URI[aarch64_amd-ucode-firmware.sha256sum] = "04a2a71562b6f3fbe32de1b2041f3279bfad493643bee3e4a867224773d5fbff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/atheros-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_atheros-firmware;unpack=0"
SRC_URI[aarch64_atheros-firmware.sha256sum] = "aec95ef2b0596d977eff0d68e7667f3bb6c28efa0a97c337f4122eb120a84ba6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/brcmfmac-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_brcmfmac-firmware;unpack=0"
SRC_URI[aarch64_brcmfmac-firmware.sha256sum] = "0d099fe5fc34fd8b815acd3575dbda0ed225f6dc2508168b67018335cc7d0d50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cirrus-audio-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_cirrus-audio-firmware;unpack=0"
SRC_URI[aarch64_cirrus-audio-firmware.sha256sum] = "52099b53899066c3a685666d01bdc0e65c9d2e01b9f5d8a0885e3fa4f0b78f2c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dvb-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_dvb-firmware;unpack=0"
SRC_URI[aarch64_dvb-firmware.sha256sum] = "620e9d6fee784a4de467b2821c9504e78c0b87f78f63a43b4eb74ef165e3d3dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/intel-audio-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_intel-audio-firmware;unpack=0"
SRC_URI[aarch64_intel-audio-firmware.sha256sum] = "8260b105cef5e961f2b45ffb34837622d6680619e82b29b36ad2b9e2588bae55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/intel-gpu-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_intel-gpu-firmware;unpack=0"
SRC_URI[aarch64_intel-gpu-firmware.sha256sum] = "125bc83cc4790bae689a74bc79f76c31a445e5a9baa4ae64058f70537ebba361"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/intel-vsc-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_intel-vsc-firmware;unpack=0"
SRC_URI[aarch64_intel-vsc-firmware.sha256sum] = "9a25fddf311ee83b33d999470be653c6b97b38837856e1e4d915ded483dd12f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlegacy-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_iwlegacy-firmware;unpack=0"
SRC_URI[aarch64_iwlegacy-firmware.sha256sum] = "e77183977dfaa1483cd6c1a8eed972bc44d7c9e55c4e7416d98e003be8f5771d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlwifi-dvm-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_iwlwifi-dvm-firmware;unpack=0"
SRC_URI[aarch64_iwlwifi-dvm-firmware.sha256sum] = "4fed130bab714b8507d950ff7f86af16f80723184b720284fd194a215eb4e52d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlwifi-mvm-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_iwlwifi-mvm-firmware;unpack=0"
SRC_URI[aarch64_iwlwifi-mvm-firmware.sha256sum] = "28fa7782987e91dd8fefae911c252350d82a4ee98fb39a38cb6f97a3dd428528"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libertas-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_libertas-firmware;unpack=0"
SRC_URI[aarch64_libertas-firmware.sha256sum] = "5208e53d3e8e7b177d62dd30462d40f6384224dd0a2a0b86b047a5aa67b1d731"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/linux-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_linux-firmware;unpack=0"
SRC_URI[aarch64_linux-firmware.sha256sum] = "5014741e94bb623dea69b2d71823d6dd45f9e692b9c937d82c25119df9540ab6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/linux-firmware-whence-20260804-23.2.el10_2.noarch.rpm;name=aarch64_linux-firmware-whence;unpack=0"
SRC_URI[aarch64_linux-firmware-whence.sha256sum] = "e519e16f9c6794b9159cde782ea4f7074d67f06235e69c2e71eab078567a96b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mlxsw_spectrum-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_mlxsw_spectrum-firmware;unpack=0"
SRC_URI[aarch64_mlxsw_spectrum-firmware.sha256sum] = "8265a4aa2db39dff89e2e7e53d7609f2ec88d54744c853acd2ff2e580cf83823"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mrvlprestera-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_mrvlprestera-firmware;unpack=0"
SRC_URI[aarch64_mrvlprestera-firmware.sha256sum] = "8d7e73ef83073f2d6f8c7dd18e25239ec7c4be87d20e8da28195d5b1de785241"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mt7xxx-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_mt7xxx-firmware;unpack=0"
SRC_URI[aarch64_mt7xxx-firmware.sha256sum] = "f842f82f1c3fb390e549ea6b6db04ace50803a2b9aa5499f305d5bc00d2ea1a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/netronome-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_netronome-firmware;unpack=0"
SRC_URI[aarch64_netronome-firmware.sha256sum] = "385af3b0b2b814e3ceed3d44f9e6465c04ca2e17425f4f536d8c9c2fd7a43855"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nvidia-gpu-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_nvidia-gpu-firmware;unpack=0"
SRC_URI[aarch64_nvidia-gpu-firmware.sha256sum] = "c83817ee9dd53c88a2e35e9515be819ed852ceedacebe64229f6ca4a85c3b27b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nxpwireless-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_nxpwireless-firmware;unpack=0"
SRC_URI[aarch64_nxpwireless-firmware.sha256sum] = "cc34dc48735d3d9ecd081202119bb82be09e980ebd46da60d0ddd54587f894d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/qcom-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_qcom-firmware;unpack=0"
SRC_URI[aarch64_qcom-firmware.sha256sum] = "93a048e7c109d273d8deabae5ba985a8aa876eb9d6a5a1771a53d325cca0fd64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/realtek-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_realtek-firmware;unpack=0"
SRC_URI[aarch64_realtek-firmware.sha256sum] = "2f1219f4f07334f95955c43476efbdec39dcfe9ec8f564214ce604999f302a39"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tiwilink-firmware-20260804-23.2.el10_2.noarch.rpm;name=aarch64_tiwilink-firmware;unpack=0"
SRC_URI[aarch64_tiwilink-firmware.sha256sum] = "f96cbfc9206df8cb1c3de55d7b2f39f505319ddd29f1adef8cb3b3187bf21b42"

RDEPENDS:amd-gpu-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:amd-ucode-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:atheros-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:brcmfmac-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:cirrus-audio-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:dvb-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-audio-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-gpu-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-vsc-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlegacy-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlwifi-dvm-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlwifi-mvm-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:libertas-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:linux-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:linux-firmware-whence = " \
 "
RDEPENDS:mlxsw_spectrum-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:mrvlprestera-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:mt7xxx-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:netronome-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:nvidia-gpu-firmware = " \
 linux-firmware \
 linux-firmware-whence \
 "
RDEPENDS:nxpwireless-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:qcom-firmware = " \
 atheros-firmware \
 linux-firmware-whence \
 "
RDEPENDS:realtek-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:tiwilink-firmware = " \
 linux-firmware-whence \
 "
