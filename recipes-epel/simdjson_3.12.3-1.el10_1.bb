# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "simdjson"
PV = "3.12.3"
PR = "1.el10_1"
PACKAGES = " \
 simdjson \
 simdjson-devel \
 simdjson-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/simdjson-3.12.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe3c390fcae139634d55b0596008e10d7d508efa5229a7024e9dc550ce6fe009"

URI_x86_64_v2_simdjson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simdjson-3.12.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_simdjson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_simdjson}"
SRC_URI[x86_64_v2_simdjson.sha256sum] = "31ed501e942b2e1b882888d99ab56f2704fc54aa6648df9157ffa532affaf589"

URI_x86_64_v2_simdjson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simdjson-devel-3.12.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_simdjson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_simdjson-devel}"
SRC_URI[x86_64_v2_simdjson-devel.sha256sum] = "e77a395897bee5500e5ded49800251d7fb65aef25c1662d98694873a1b3ad56c"

URI_x86_64_v2_simdjson-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simdjson-doc-3.12.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_simdjson-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_simdjson-doc}"
SRC_URI[x86_64_v2_simdjson-doc.sha256sum] = "4cf8daa19ad1d522e1b0a6ec62f9f93f21ca056c25e3eee9f0e380e7c7c79285"

URI_aarch64_simdjson = "${EPEL_MIRROR}/aarch64/Packages/s/simdjson-3.12.3-1.el10_1.aarch64.rpm;name=aarch64_simdjson;unpack=0"
SRC_URI:append = " ${URI_aarch64_simdjson}"
SRC_URI[aarch64_simdjson.sha256sum] = "24e355cdfd3518bcb3afea2697afd8eb062df056fc311f4cec8e627926d1cbe7"

URI_aarch64_simdjson-devel = "${EPEL_MIRROR}/aarch64/Packages/s/simdjson-devel-3.12.3-1.el10_1.aarch64.rpm;name=aarch64_simdjson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_simdjson-devel}"
SRC_URI[aarch64_simdjson-devel.sha256sum] = "0f8a0dffc944f2ea28e7a5df1ccd610a3a1d48538127f35b2c70abf1051f30a8"

URI_aarch64_simdjson-doc = "${EPEL_MIRROR}/aarch64/Packages/s/simdjson-doc-3.12.3-1.el10_1.aarch64.rpm;name=aarch64_simdjson-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_simdjson-doc}"
SRC_URI[aarch64_simdjson-doc.sha256sum] = "638474f6028b093095d4b9e3d81cc671399f9a9839c1ce18bdbceb338c9da91d"

RDEPENDS:simdjson = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:simdjson-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 simdjson \
 "
RDEPENDS:simdjson-doc = " \
 "
