# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kreversi"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kreversi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kreversi-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6326d5d49af9e04b7fdff91d56fa0ef8ff953566da087a3a9c4f6d9165190b1"

URI_x86_64_v2_kreversi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kreversi-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kreversi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kreversi}"
SRC_URI[x86_64_v2_kreversi.sha256sum] = "70783aaaf65297ec83e15e2783a73879ece792c4aea606b1e4547e84f4905bb8"

URI_aarch64_kreversi = "${EPEL_MIRROR}/aarch64/Packages/k/kreversi-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kreversi;unpack=0"
SRC_URI:append = " ${URI_aarch64_kreversi}"
SRC_URI[aarch64_kreversi.sha256sum] = "fb84b343a002839d6f5362247c9e29b0f2a6c6ef1c25c3bd56855f091dee00cc"

RDEPENDS:kreversi = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
