# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-nytimes-gziphandler"
PV = "1.1.1"
PR = "16.el10_0"
PACKAGES = " \
 golang-github-nytimes-gziphandler-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-nytimes-gziphandler-1.1.1-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ff423ff45b6c942d71def8e640e62ebaaef49ad687533ef0c53c070c7ec112b"

URI_x86_64_v2_golang-github-nytimes-gziphandler-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-nytimes-gziphandler-devel-1.1.1-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-nytimes-gziphandler-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-nytimes-gziphandler-devel}"
SRC_URI[x86_64_v2_golang-github-nytimes-gziphandler-devel.sha256sum] = "b1090d71240dbf02ade63b61faad73b16b0d3a926333d345cc8513d2299253dd"

URI_aarch64_golang-github-nytimes-gziphandler-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-nytimes-gziphandler-devel-1.1.1-16.el10_0.noarch.rpm;name=aarch64_golang-github-nytimes-gziphandler-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-nytimes-gziphandler-devel}"
SRC_URI[aarch64_golang-github-nytimes-gziphandler-devel.sha256sum] = "8c87391532d2d0d7b2ac5a606ef7b5a40ef458b8ef2dbad2534b32c902ad7e41"

RDEPENDS:golang-github-nytimes-gziphandler-devel = " \
 go-filesystem \
 "
