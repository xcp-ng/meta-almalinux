# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rapidyaml"
PV = "0.7.2"
PR = "8.el10_3"
PACKAGES = " \
 python3-rapidyaml \
 rapidyaml \
 rapidyaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rapidyaml-0.7.2-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3d4d63036bcc750e04f573068df6d732baaa75ebd86e9ea5fe1b76d070fd0c2"

URI_x86_64_v2_python3-rapidyaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rapidyaml-0.7.2-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-rapidyaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rapidyaml}"
SRC_URI[x86_64_v2_python3-rapidyaml.sha256sum] = "266cfa7db1a0471e1bb0d9d1889d2f7b8d1262f2ee9bb74846277931febf0213"

URI_x86_64_v2_rapidyaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rapidyaml-0.7.2-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rapidyaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rapidyaml}"
SRC_URI[x86_64_v2_rapidyaml.sha256sum] = "3e580d98a03c1ec38dac615e73684845981b8095909ff3c973de51ff9ac0cf7a"

URI_x86_64_v2_rapidyaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rapidyaml-devel-0.7.2-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rapidyaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rapidyaml-devel}"
SRC_URI[x86_64_v2_rapidyaml-devel.sha256sum] = "bc68a8aa9d0f4b122205c0db2899a99cdd7ea2439c406c5c24fa69efca7e6fe7"

URI_aarch64_python3-rapidyaml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rapidyaml-0.7.2-8.el10_3.aarch64.rpm;name=aarch64_python3-rapidyaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rapidyaml}"
SRC_URI[aarch64_python3-rapidyaml.sha256sum] = "a82b0a86ba781348eb1b94dd67fff759861a6812719aa531ad2e348e5b30ca5b"

URI_aarch64_rapidyaml = "${EPEL_MIRROR}/aarch64/Packages/r/rapidyaml-0.7.2-8.el10_3.aarch64.rpm;name=aarch64_rapidyaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_rapidyaml}"
SRC_URI[aarch64_rapidyaml.sha256sum] = "9aa3d95dc5ea505a16bf847c6e49819a63ef2724b61065edc4461b9a22436a7a"

URI_aarch64_rapidyaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rapidyaml-devel-0.7.2-8.el10_3.aarch64.rpm;name=aarch64_rapidyaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rapidyaml-devel}"
SRC_URI[aarch64_rapidyaml-devel.sha256sum] = "4d00fdb2ca611b1c43e550cc4bfcaac184aca298e7f7283b89a2b343d731deca"

RDEPENDS:python3-rapidyaml = " \
 c4core \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-deprecation \
 "
RDEPENDS:rapidyaml = " \
 c4core \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:rapidyaml-devel = " \
 c4core-devel \
 cmake-filesystem \
 rapidyaml \
 "
