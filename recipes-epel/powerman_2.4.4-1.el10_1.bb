# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "powerman"
PV = "2.4.4"
PR = "1.el10_1"
PACKAGES = " \
 powerman \
 powerman-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/powerman-2.4.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af3a9655d529c1d053296681dd6d09fa866b6673c648b92337d095907e61a58d"

URI_x86_64_v2_powerman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerman-2.4.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_powerman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_powerman}"
SRC_URI[x86_64_v2_powerman.sha256sum] = "2676d126b1b7da1c62ebb053e8ed2ceebb4adf713edd7b5ccfb0bb7768effbd0"

URI_x86_64_v2_powerman-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerman-devel-2.4.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_powerman-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_powerman-devel}"
SRC_URI[x86_64_v2_powerman-devel.sha256sum] = "3ff5195a6cde832a376aa14261e65ecb315793d621edd4bab8b899425aa11636"

URI_aarch64_powerman = "${EPEL_MIRROR}/aarch64/Packages/p/powerman-2.4.4-1.el10_1.aarch64.rpm;name=aarch64_powerman;unpack=0"
SRC_URI:append = " ${URI_aarch64_powerman}"
SRC_URI[aarch64_powerman.sha256sum] = "2b2a5d5c73b5fec0d7d8e3fcfe380ac3f7b067ff744832565b0e0df5f1864572"

URI_aarch64_powerman-devel = "${EPEL_MIRROR}/aarch64/Packages/p/powerman-devel-2.4.4-1.el10_1.aarch64.rpm;name=aarch64_powerman-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_powerman-devel}"
SRC_URI[aarch64_powerman-devel.sha256sum] = "dbbdbf9012e6ead9b8e81636e171ed47b86c93370c358f17f2e2cfb556e58502"

RDEPENDS:powerman = " \
 bash \
 glibc \
 jansson \
 libgenders \
 net-snmp-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:powerman-devel = " \
 pkgconf-pkg-config \
 powerman \
 "
