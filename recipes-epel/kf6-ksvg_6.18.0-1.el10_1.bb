# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ksvg"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-ksvg \
 kf6-ksvg-devel \
 kf6-ksvg-doc \
 kf6-ksvg-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ksvg-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1bd327efbe669bf135a5f7442d7bed52edd65e7ce5bd3ebec2fc546e082e3c9"

URI_x86_64_v2_kf6-ksvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ksvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg}"
SRC_URI[x86_64_v2_kf6-ksvg.sha256sum] = "8b0aca201d5d0b1574ea3cce4fca3975de60e60a3d5e337fd30af9a26b043cfe"

URI_x86_64_v2_kf6-ksvg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ksvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg-devel}"
SRC_URI[x86_64_v2_kf6-ksvg-devel.sha256sum] = "8c0858d6612d46a5c7567ef5f16ff16d49abd670d68441365aa3045f5d9c5670"

URI_x86_64_v2_kf6-ksvg-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ksvg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg-doc}"
SRC_URI[x86_64_v2_kf6-ksvg-doc.sha256sum] = "62cd71161acc1ebe87cd6861eccffcb9bdfbe5a758c01148004992083f20a468"

URI_x86_64_v2_kf6-ksvg-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ksvg-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg-html}"
SRC_URI[x86_64_v2_kf6-ksvg-html.sha256sum] = "0cef6a597239b2c9b844221a45b6ab495304e587732b79aee54a89878cfcb5d0"

URI_aarch64_kf6-ksvg = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-ksvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg}"
SRC_URI[aarch64_kf6-ksvg.sha256sum] = "a13846b87e129c2769ddac35472ce4dcf8866d960130c313e3daa2d7874443d9"

URI_aarch64_kf6-ksvg-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-ksvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg-devel}"
SRC_URI[aarch64_kf6-ksvg-devel.sha256sum] = "657a3d3b9030ef4f2ea0768670455d52985b4062c2e64c3c4943fa8a21db8a6e"

URI_aarch64_kf6-ksvg-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-ksvg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg-doc}"
SRC_URI[aarch64_kf6-ksvg-doc.sha256sum] = "6f784796473bb49edcb5e02ded4019d21a4c7851e7f26cc79e75d9218a137037"

URI_aarch64_kf6-ksvg-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-ksvg-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg-html}"
SRC_URI[aarch64_kf6-ksvg-html.sha256sum] = "10535702c6ab9bcdbc0906bfc0b0f57be7618e8637b9368611abeae31fc7e5c2"

RDEPENDS:kf6-ksvg = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kirigami \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:kf6-ksvg-devel = " \
 cmake-filesystem \
 kf6-ksvg \
 "
RDEPENDS:kf6-ksvg-doc = " \
 "
RDEPENDS:kf6-ksvg-html = " \
 "
