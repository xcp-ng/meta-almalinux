# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-multi_test"
PV = "0.1.2"
PR = "20.el10_1"
PACKAGES = " \
 rubygem-multi_test \
 rubygem-multi_test-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-multi_test-0.1.2-20.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfca2b8ea2e408df20fe2eaa0e336d7c478e12289f0e8e6f652f006dc6b20329"

URI_x86_64_v2_rubygem-multi_test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-multi_test-0.1.2-20.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-multi_test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-multi_test}"
SRC_URI[x86_64_v2_rubygem-multi_test.sha256sum] = "533c8098fa07bbc645f642ef7485a853b826b2eab79d31727d6548e5876feee0"

URI_x86_64_v2_rubygem-multi_test-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-multi_test-doc-0.1.2-20.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-multi_test-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-multi_test-doc}"
SRC_URI[x86_64_v2_rubygem-multi_test-doc.sha256sum] = "f27aabd890f8b38dc917efccb14f7095bb9ecad82335ba9df037aaba1c79bbab"

URI_aarch64_rubygem-multi_test = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-multi_test-0.1.2-20.el10_1.noarch.rpm;name=aarch64_rubygem-multi_test;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-multi_test}"
SRC_URI[aarch64_rubygem-multi_test.sha256sum] = "01b2567a42aefff380e360a0cd0e76aa45e15d79ff0e5ca11808c3ebe5506b1c"

URI_aarch64_rubygem-multi_test-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-multi_test-doc-0.1.2-20.el10_1.noarch.rpm;name=aarch64_rubygem-multi_test-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-multi_test-doc}"
SRC_URI[aarch64_rubygem-multi_test-doc.sha256sum] = "3b90dde2924872b0bb3b1ce15229d7bbb85f89655f0054b2f2ed36e7505a87d2"

RDEPENDS:rubygem-multi_test = " \
 rubygems \
 "
RDEPENDS:rubygem-multi_test-doc = " \
 bash \
 rubygem-multi_test \
 "
