# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onefetch-image"
PV = "2.23.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-onefetch-image+default-devel \
 rust-onefetch-image-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onefetch-image-2.23.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0d0d53ea10eef7d38e513e51dd7c3bdd78ab99d00d2c7dbb74eb5c40a0de076"

URI_x86_64_v2_rust-onefetch-image+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-image+default-devel-2.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-image+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-image+default-devel}"
SRC_URI[x86_64_v2_rust-onefetch-image+default-devel.sha256sum] = "1c7ac6ddb44103363dfdc5c6aca68dbabb7ba48f4c9458bc293cde47b6f073be"

URI_x86_64_v2_rust-onefetch-image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-image-devel-2.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-image-devel}"
SRC_URI[x86_64_v2_rust-onefetch-image-devel.sha256sum] = "92efdc8cedf8a6958bbd1ac50c335a8837f480a2ccdd2c1fca98045a52bdbbe1"

URI_aarch64_rust-onefetch-image+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-image+default-devel-2.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-onefetch-image+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-image+default-devel}"
SRC_URI[aarch64_rust-onefetch-image+default-devel.sha256sum] = "fc949626f473312408e6fdcab8887aab8db184f3c9e02d1f03ba855b92dea8ff"

URI_aarch64_rust-onefetch-image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-image-devel-2.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-onefetch-image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-image-devel}"
SRC_URI[aarch64_rust-onefetch-image-devel.sha256sum] = "933e7f99021c11d8785a0c9d67f5510678d45c1933f453b50ea9e1b37612cdb9"

RDEPENDS:rust-onefetch-image+default-devel = " \
 cargo \
 rust-onefetch-image-devel \
 "
RDEPENDS:rust-onefetch-image-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-base64+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-color_quant+default-devel \
 rust-image+color_quant-devel \
 rust-image+jpeg-devel \
 rust-image+png-devel \
 rust-image+webp-devel \
 rust-image-devel \
 rust-libc+default-devel \
 "
