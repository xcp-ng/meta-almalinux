# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-powershell"
PV = "0.5.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-colcon-powershell \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-powershell-0.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4d7e8df3e9ea6ecf4aeead5e2970e4c522bff4338e78538be502a5e0fdbb4ae2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-powershell-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-powershell;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-powershell.sha256sum] = "c96b8ff9a107b3b511664b107828809fffed080e6ac26060dd3b043efda76e8f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-powershell-0.5.0-1.el10_3.noarch.rpm;name=aarch64_python3-colcon-powershell;unpack=0"
SRC_URI[aarch64_python3-colcon-powershell.sha256sum] = "0a82c455a537540a4ada64e3cf6ad5a13dffbccd4fd62fda280fc568fc02206a"

RDEPENDS:python3-colcon-powershell = " \
 python3 \
 python3-colcon-core \
 "
