# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdmx"
PV = "1.1.5"
PR = "5.el10_0"
PACKAGES = " \
 libdmx \
 libdmx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdmx-1.1.5-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3a5323c94ef46b5b1747020a17fdd7870467bfa53d266fe30755358186b7668"

URI_x86_64_v2_libdmx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdmx-1.1.5-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdmx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdmx}"
SRC_URI[x86_64_v2_libdmx.sha256sum] = "fbf0074c41c2ad110f31e2980371b34a7569a8ca8862ce83c20ff973befa02e4"

URI_x86_64_v2_libdmx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdmx-devel-1.1.5-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdmx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdmx-devel}"
SRC_URI[x86_64_v2_libdmx-devel.sha256sum] = "bcbee54c5fb6cab1562999a6a75102805f08c5e55be31ea81cc3575f65f4efad"

URI_aarch64_libdmx = "${EPEL_MIRROR}/aarch64/Packages/l/libdmx-1.1.5-5.el10_0.aarch64.rpm;name=aarch64_libdmx;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdmx}"
SRC_URI[aarch64_libdmx.sha256sum] = "a46f572cef268b2a5ca16857033c7a3b7398b7ef25dc8ad0b01ea5601023f806"

URI_aarch64_libdmx-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdmx-devel-1.1.5-5.el10_0.aarch64.rpm;name=aarch64_libdmx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdmx-devel}"
SRC_URI[aarch64_libdmx-devel.sha256sum] = "ecc9c80ccce8adcafa5828d9de36a354a66220aadf66640b3546bb392044962f"

RDEPENDS:libdmx = " \
 glibc \
 libX11 \
 libXext \
 "
RDEPENDS:libdmx-devel = " \
 libX11-devel \
 libXext-devel \
 libdmx \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
