# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konsole"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 konsole \
 konsole-part \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/konsole-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "484b2200c7f0afdfc9997041d863104dd231e438a5f23a59c673e268cf5ec265"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konsole-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konsole;unpack=0"
SRC_URI[x86_64_v2_konsole.sha256sum] = "6124e4f218359115bd35d87723ae52097ebccada790b250b273f31ff20b70a6e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konsole-part-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konsole-part;unpack=0"
SRC_URI[x86_64_v2_konsole-part.sha256sum] = "822fa162d1e2c17be2fcc577c78c6044b410585eb138c265154a55fd13ac0997"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/konsole-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_konsole;unpack=0"
SRC_URI[aarch64_konsole.sha256sum] = "0135b8ca5e987b3ad0b828849c716c31e7392706297cb34bda62faaadd942193"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/konsole-part-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_konsole-part;unpack=0"
SRC_URI[aarch64_konsole-part.sha256sum] = "ef96775e247c4a3e8a3d24e2cc37f9abf5c48ee6f4495abc431ab36d1e9e39d7"

RDEPENDS:konsole = " \
 bash \
 glibc \
 keditbookmarks \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 konsole-part \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:konsole-part = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kpty \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libicu \
 libssh \
 libstdc++ \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
