# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-domdf-python-tools"
PV = "3.9.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-domdf-python-tools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-domdf-python-tools-3.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "59a47b105326c301bb7763a5fc5e6bc91d850b678fae47eb45862730353c7c77"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-domdf-python-tools-3.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-domdf-python-tools;unpack=0"
SRC_URI[x86_64_v2_python3-domdf-python-tools.sha256sum] = "8c479f07ead114d766a143e3f94a189560700d495d7e0f60885607ebca58577f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-domdf-python-tools-3.9.0-1.el10_0.noarch.rpm;name=aarch64_python3-domdf-python-tools;unpack=0"
SRC_URI[aarch64_python3-domdf-python-tools.sha256sum] = "50f823883441ae1cceeb87bc0428b2168e0e477c4d3cca8758c3eb9bf41be218"

RDEPENDS:python3-domdf-python-tools = " \
 python3 \
 python3-natsort \
 python3-typing-extensions \
 "
