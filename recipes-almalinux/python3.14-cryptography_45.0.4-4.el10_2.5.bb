# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-cryptography"
PV = "45.0.4"
PR = "4.el10_2.5"
PACKAGES = " \
 python3.14-cryptography \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-cryptography-45.0.4-4.el10_2.5.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c48ee6ae17a1a756b08247e42b06eed6492e08245a5d73a8d722f2908b2673e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-cryptography-45.0.4-4.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_python3.14-cryptography;unpack=0"
SRC_URI[x86_64_v2_python3.14-cryptography.sha256sum] = "7feb7fd760ff25dc94a7f6ab0caf0b2308f596e433687c8361ed1219f18f98ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-cryptography-45.0.4-4.el10_2.5.aarch64.rpm;name=aarch64_python3.14-cryptography;unpack=0"
SRC_URI[aarch64_python3.14-cryptography.sha256sum] = "d4c9a59ff999b05786687b025010cddaa37ff665c177e18eebe564d84f89a6ec"

RDEPENDS:python3.14-cryptography = " \
 glibc \
 libgcc \
 openssl-libs \
 python3.14 \
 python3.14-cffi \
 "
