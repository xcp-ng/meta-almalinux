# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-puzpy"
PV = "0.3.2"
PR = "3.el10_2"
PACKAGES = " \
 python3-puzpy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-puzpy-0.3.2-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32ff2ef9155b86accf129f51818dc74343a78429641a8206ed62b7f45cfdcb20"

URI_x86_64_v2_python3-puzpy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-puzpy-0.3.2-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-puzpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-puzpy}"
SRC_URI[x86_64_v2_python3-puzpy.sha256sum] = "1790881b04fb2c699d38cc7351ab2c734f4017fd83eb719dd06981f77e293909"

URI_aarch64_python3-puzpy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-puzpy-0.3.2-3.el10_2.noarch.rpm;name=aarch64_python3-puzpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-puzpy}"
SRC_URI[aarch64_python3-puzpy.sha256sum] = "6365e1f4305cf748970e8c8d96aef033f3283424fb899508d96541c2f146050f"

RDEPENDS:python3-puzpy = " \
 python3 \
 "
