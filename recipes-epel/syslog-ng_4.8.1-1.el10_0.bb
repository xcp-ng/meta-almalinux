# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "syslog-ng"
PV = "4.8.1"
PR = "1.el10_0"
PACKAGES = " \
 syslog-ng \
 syslog-ng-amqp \
 syslog-ng-bigquery \
 syslog-ng-bpf \
 syslog-ng-devel \
 syslog-ng-geoip \
 syslog-ng-grpc \
 syslog-ng-http \
 syslog-ng-kafka \
 syslog-ng-loki \
 syslog-ng-mongodb \
 syslog-ng-opentelemetry \
 syslog-ng-python \
 syslog-ng-python-modules \
 syslog-ng-redis \
 syslog-ng-riemann \
 syslog-ng-slog \
 syslog-ng-snmp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/syslog-ng-4.8.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d04873bb40174631f000dd99f72e06922cccba7291ffe7c4d00d14668db87a1"

URI_x86_64_v2_syslog-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng}"
SRC_URI[x86_64_v2_syslog-ng.sha256sum] = "38843c6565b5b927f3c28f0c6ff2f0ba73d1ce3fa968d18084056e6aff071dc3"
RPROVIDES:syslog-ng:x86_64_v2 = "virtual/syslog"

URI_x86_64_v2_syslog-ng-amqp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-amqp-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-amqp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-amqp}"
SRC_URI[x86_64_v2_syslog-ng-amqp.sha256sum] = "3d3f3039d681572e2dde6ed902a19763115fa6af2ae8ef716b2d47a6b13dcb7e"

URI_x86_64_v2_syslog-ng-bigquery = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-bigquery-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-bigquery;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-bigquery}"
SRC_URI[x86_64_v2_syslog-ng-bigquery.sha256sum] = "f7607bc1a104cd4ff49dcf2f3d813da6aac0f197af61b29b243bd71659b977b9"

URI_x86_64_v2_syslog-ng-bpf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-bpf-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-bpf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-bpf}"
SRC_URI[x86_64_v2_syslog-ng-bpf.sha256sum] = "5f463bf0364e1f7efb1b22fd4e206ac105c4a4962407ca0805269ebc4d76a150"

URI_x86_64_v2_syslog-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-devel-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-devel}"
SRC_URI[x86_64_v2_syslog-ng-devel.sha256sum] = "706a266a6674b47063470fb72b00650f0a6c305200bd46b818362e44e9483317"

URI_x86_64_v2_syslog-ng-geoip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-geoip-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-geoip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-geoip}"
SRC_URI[x86_64_v2_syslog-ng-geoip.sha256sum] = "79523b681ea82febf06c97c9f8d67bddb4a40cf08c348fd45c374360b2c71207"

URI_x86_64_v2_syslog-ng-grpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-grpc-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-grpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-grpc}"
SRC_URI[x86_64_v2_syslog-ng-grpc.sha256sum] = "bfbf6a702378238dfc7e4f10ed2dc13421a0ff54749a1dc1eeffea7edbce69c2"

URI_x86_64_v2_syslog-ng-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-http-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-http}"
SRC_URI[x86_64_v2_syslog-ng-http.sha256sum] = "3fa2536751efe9a19c5bdd3a8934cd342bf6f5e8f734e665ca70d58135f2c180"

URI_x86_64_v2_syslog-ng-kafka = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-kafka-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-kafka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-kafka}"
SRC_URI[x86_64_v2_syslog-ng-kafka.sha256sum] = "72653e53c8d1cd149a7dd8cc5c258c79c5cbe5d4015a266bf0d01b37bbdb881a"

URI_x86_64_v2_syslog-ng-loki = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-loki-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-loki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-loki}"
SRC_URI[x86_64_v2_syslog-ng-loki.sha256sum] = "af61f1ebaae6619b3813005e79c437ffb00ba83bfe71d7aa438a1f91b1f7f2d3"

URI_x86_64_v2_syslog-ng-mongodb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-mongodb-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-mongodb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-mongodb}"
SRC_URI[x86_64_v2_syslog-ng-mongodb.sha256sum] = "43935455fd00af56b6b9669886c13c5e3f4e9313e47717627243d632090898aa"

URI_x86_64_v2_syslog-ng-opentelemetry = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-opentelemetry-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-opentelemetry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-opentelemetry}"
SRC_URI[x86_64_v2_syslog-ng-opentelemetry.sha256sum] = "6e85366c40598ef14febb715d45c2032bfb9ae6eebb9fb7c6ce57030c13078fe"

URI_x86_64_v2_syslog-ng-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-python-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-python}"
SRC_URI[x86_64_v2_syslog-ng-python.sha256sum] = "457f09ed00741a3897bd5347afba98fbd465fca3e984c59789dd3b520a340b1d"

URI_x86_64_v2_syslog-ng-python-modules = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-python-modules-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-python-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-python-modules}"
SRC_URI[x86_64_v2_syslog-ng-python-modules.sha256sum] = "c7a331e5fe9584b44ad2eff6aa00d2736e3075ab4c5e8278da6425249be09830"

URI_x86_64_v2_syslog-ng-redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-redis-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-redis}"
SRC_URI[x86_64_v2_syslog-ng-redis.sha256sum] = "dfa0b9a7c7dfe8e7262786557553a9ae17adb20b98400ee76a1a339aa92faf67"

URI_x86_64_v2_syslog-ng-riemann = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-riemann-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-riemann;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-riemann}"
SRC_URI[x86_64_v2_syslog-ng-riemann.sha256sum] = "7065ccc69d6f60ef44f32842f4065dc720c88dc605a43f24692e191895e6273c"

URI_x86_64_v2_syslog-ng-slog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-slog-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-slog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-slog}"
SRC_URI[x86_64_v2_syslog-ng-slog.sha256sum] = "97668234696d2ea69883a017f083b679f3761269e6e46c09ab95e28efd730c77"

URI_x86_64_v2_syslog-ng-snmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-snmp-4.8.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-snmp}"
SRC_URI[x86_64_v2_syslog-ng-snmp.sha256sum] = "4cf59cbef4cec826acdce48402a6938e73832f9926c093d46a71acd6e0edac93"

URI_aarch64_syslog-ng = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng}"
SRC_URI[aarch64_syslog-ng.sha256sum] = "4c638551231be2bec1f332db773bf0d51151860df3be9db7787d7869a3bc68eb"
RPROVIDES:syslog-ng:aarch64 = "virtual/syslog"

URI_aarch64_syslog-ng-amqp = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-amqp-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-amqp;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-amqp}"
SRC_URI[aarch64_syslog-ng-amqp.sha256sum] = "c55d03392768b22a9ad0a444f4793a1b2e7c64bfd38d28480ee565bb247ce603"

URI_aarch64_syslog-ng-bigquery = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-bigquery-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-bigquery;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-bigquery}"
SRC_URI[aarch64_syslog-ng-bigquery.sha256sum] = "9221bb185a3d44a1e89fe08d37cdd9e1065d6e3942a33d7bf492bf984c611482"

URI_aarch64_syslog-ng-bpf = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-bpf-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-bpf;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-bpf}"
SRC_URI[aarch64_syslog-ng-bpf.sha256sum] = "09f8045f1f0ce7aedd873a1a9121f2ddfea61a0e475b4f5133132dccc0b917bd"

URI_aarch64_syslog-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-devel-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-devel}"
SRC_URI[aarch64_syslog-ng-devel.sha256sum] = "09ba80e9237f9ce54725f91374bcc9de9437302f5ecc91b4b8ce0ab8531e18ad"

URI_aarch64_syslog-ng-geoip = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-geoip-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-geoip;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-geoip}"
SRC_URI[aarch64_syslog-ng-geoip.sha256sum] = "cb7ef0adb41b1c6671c99c6648553fdd765c29f8dfe6e7765ee75c8ced29c35a"

URI_aarch64_syslog-ng-grpc = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-grpc-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-grpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-grpc}"
SRC_URI[aarch64_syslog-ng-grpc.sha256sum] = "6fb6b215b0e85c9e5cffdb09990ada95a5a1efa7e68896f37553349191531fb6"

URI_aarch64_syslog-ng-http = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-http-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-http}"
SRC_URI[aarch64_syslog-ng-http.sha256sum] = "ea89a1cf246b3418d1c066c415a39bccb5f389087377bd292e4c9d692152299a"

URI_aarch64_syslog-ng-kafka = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-kafka-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-kafka;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-kafka}"
SRC_URI[aarch64_syslog-ng-kafka.sha256sum] = "21de5e513ed2e1ea74890a2fc9037c352098398c0b7b41bd469e81b75280f6bf"

URI_aarch64_syslog-ng-loki = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-loki-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-loki;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-loki}"
SRC_URI[aarch64_syslog-ng-loki.sha256sum] = "5f9cf5c1e3879f471a2b8f11945de4894bfba5a1b356405738e3d187148fa0ad"

URI_aarch64_syslog-ng-mongodb = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-mongodb-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-mongodb;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-mongodb}"
SRC_URI[aarch64_syslog-ng-mongodb.sha256sum] = "62cb9072ad8ee5337e55c93f991d1a353829f5d6b791297000c1c9078b2c2b51"

URI_aarch64_syslog-ng-opentelemetry = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-opentelemetry-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-opentelemetry;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-opentelemetry}"
SRC_URI[aarch64_syslog-ng-opentelemetry.sha256sum] = "1485c606a7105eb136f258007ab9fb31f9a8a269ab68482c4b84995e279b90f4"

URI_aarch64_syslog-ng-python = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-python-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-python}"
SRC_URI[aarch64_syslog-ng-python.sha256sum] = "f54df0f3855cc38b7d8974ee76c32bc51675b2289c5199b487926ac5014e29f8"

URI_aarch64_syslog-ng-python-modules = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-python-modules-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-python-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-python-modules}"
SRC_URI[aarch64_syslog-ng-python-modules.sha256sum] = "49e4a968fe76a4b93154b9da9f5ba1859243c8a797098d8e970708fa418694ad"

URI_aarch64_syslog-ng-redis = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-redis-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-redis}"
SRC_URI[aarch64_syslog-ng-redis.sha256sum] = "60a86bf4e17087dea92fd312912c10eaae1c002e8d056d0f2aa32bedc2a8b9db"

URI_aarch64_syslog-ng-riemann = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-riemann-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-riemann;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-riemann}"
SRC_URI[aarch64_syslog-ng-riemann.sha256sum] = "78c875a035200502e9941221301ec92076d0eb5bad11830b13e101460ad83fe7"

URI_aarch64_syslog-ng-slog = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-slog-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-slog;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-slog}"
SRC_URI[aarch64_syslog-ng-slog.sha256sum] = "ef83cb5516cd5fb9302d4761bdac15c6a2068025af708977d9f9e7d84c917667"

URI_aarch64_syslog-ng-snmp = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-snmp-4.8.1-1.el10_0.aarch64.rpm;name=aarch64_syslog-ng-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-snmp}"
SRC_URI[aarch64_syslog-ng-snmp.sha256sum] = "c803dd14626537b4ca3e350feae95eaa89b541cd248c5440ca7e619abf81b7bf"

RDEPENDS:syslog-ng = " \
 bash \
 gawk \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libcap \
 libgcc \
 libnet \
 libstdc++ \
 logrotate \
 openssl-libs \
 pcre2 \
 systemd \
 systemd-libs \
 "
RDEPENDS:syslog-ng-amqp = " \
 glibc \
 librabbitmq \
 syslog-ng \
 "
RDEPENDS:syslog-ng-bigquery = " \
 abseil-cpp \
 c-ares \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 ivykis \
 json-c \
 libcap \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcre2 \
 protobuf \
 re2 \
 syslog-ng \
 syslog-ng-grpc \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:syslog-ng-bpf = " \
 glibc \
 libbpf \
 syslog-ng \
 "
RDEPENDS:syslog-ng-devel = " \
 bash \
 glib2-devel \
 pkgconf-pkg-config \
 python3 \
 syslog-ng \
 "
RDEPENDS:syslog-ng-geoip = " \
 glibc \
 libmaxminddb \
 syslog-ng \
 "
RDEPENDS:syslog-ng-grpc = " \
 abseil-cpp \
 c-ares \
 glibc \
 grpc \
 grpc-cpp \
 libgcc \
 libstdc++ \
 openssl-libs \
 protobuf \
 re2 \
 syslog-ng \
 zlib-ng-compat \
 "
RDEPENDS:syslog-ng-http = " \
 glibc \
 syslog-ng \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:syslog-ng-kafka = " \
 glibc \
 librdkafka \
 syslog-ng \
 "
RDEPENDS:syslog-ng-loki = " \
 abseil-cpp \
 c-ares \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 ivykis \
 json-c \
 libcap \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcre2 \
 protobuf \
 re2 \
 syslog-ng \
 syslog-ng-grpc \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:syslog-ng-mongodb = " \
 glibc \
 libbson \
 mongo-c-driver-libs \
 syslog-ng \
 "
RDEPENDS:syslog-ng-opentelemetry = " \
 abseil-cpp \
 c-ares \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 ivykis \
 json-c \
 libcap \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcre2 \
 protobuf \
 re2 \
 syslog-ng \
 syslog-ng-grpc \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:syslog-ng-python = " \
 glibc \
 ivykis \
 python3-libs \
 syslog-ng \
 "
RDEPENDS:syslog-ng-python-modules = " \
 python3-cachetools \
 python3-certifi \
 python3-charset-normalizer \
 python3-dateutil \
 python3-google-auth \
 python3-idna \
 python3-kubernetes \
 python3-oauthlib \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-rsa \
 python3-six \
 python3-urllib3 \
 python3-websocket-client \
 syslog-ng \
 syslog-ng-python \
 "
RDEPENDS:syslog-ng-redis = " \
 glibc \
 hiredis \
 syslog-ng \
 "
RDEPENDS:syslog-ng-riemann = " \
 glibc \
 riemann-c-client \
 syslog-ng \
 "
RDEPENDS:syslog-ng-slog = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libcap \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
 "
RDEPENDS:syslog-ng-snmp = " \
 glibc \
 net-snmp-libs \
 openssl-libs \
 syslog-ng \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/syslog"

PROVIDES:append:aarch64 = " rpm/virtual/syslog"
