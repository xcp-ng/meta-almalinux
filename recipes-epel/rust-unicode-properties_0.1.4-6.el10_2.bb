# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-properties"
PV = "0.1.4"
PR = "6.el10_2"
PACKAGES = " \
 rust-unicode-properties+default-devel \
 rust-unicode-properties+emoji-devel \
 rust-unicode-properties+general-category-devel \
 rust-unicode-properties-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-properties-0.1.4-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af3948d34b6ae1d4ef9784b427fd6a3b6fa8eea766cc8a069d79c1fe00f68fc5"

URI_x86_64_v2_rust-unicode-properties+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-properties+default-devel-0.1.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-properties+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-properties+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-properties+default-devel.sha256sum] = "3c223e758c5c5fe326945f5bb2a98cb7b3bf708b21488c1821d41df4bb97cc16"

URI_x86_64_v2_rust-unicode-properties+emoji-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-properties+emoji-devel-0.1.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-properties+emoji-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-properties+emoji-devel}"
SRC_URI[x86_64_v2_rust-unicode-properties+emoji-devel.sha256sum] = "7f1d0967fe5899ebd87bb2ac2eb6a8fee3f9c867263c8df16c072be7aed343e9"

URI_x86_64_v2_rust-unicode-properties+general-category-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-properties+general-category-devel-0.1.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-properties+general-category-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-properties+general-category-devel}"
SRC_URI[x86_64_v2_rust-unicode-properties+general-category-devel.sha256sum] = "c2ed044b71238bfe12fb1777b6aa8b2f14023831115b4977487b8daff4a39ef5"

URI_x86_64_v2_rust-unicode-properties-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-properties-devel-0.1.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-properties-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-properties-devel}"
SRC_URI[x86_64_v2_rust-unicode-properties-devel.sha256sum] = "232e297f4ed6baf3bfc12464ebe1aefe307dc6d253ec507babbf492529233cc0"

URI_aarch64_rust-unicode-properties+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-properties+default-devel-0.1.4-6.el10_2.noarch.rpm;name=aarch64_rust-unicode-properties+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-properties+default-devel}"
SRC_URI[aarch64_rust-unicode-properties+default-devel.sha256sum] = "6453ab6a5840ee3fdf088fe95c72df699ba30686d517ff360838c130c099b379"

URI_aarch64_rust-unicode-properties+emoji-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-properties+emoji-devel-0.1.4-6.el10_2.noarch.rpm;name=aarch64_rust-unicode-properties+emoji-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-properties+emoji-devel}"
SRC_URI[aarch64_rust-unicode-properties+emoji-devel.sha256sum] = "3dbfd365c8a952f7d7f3d47a07f468134d50b2bf6fc7f1ba02533e6de00dd80b"

URI_aarch64_rust-unicode-properties+general-category-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-properties+general-category-devel-0.1.4-6.el10_2.noarch.rpm;name=aarch64_rust-unicode-properties+general-category-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-properties+general-category-devel}"
SRC_URI[aarch64_rust-unicode-properties+general-category-devel.sha256sum] = "dbda909cb8e84678cf0f3c5dfb084abc95758e8b40c2e2eb9256ba9c7bccb05f"

URI_aarch64_rust-unicode-properties-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-properties-devel-0.1.4-6.el10_2.noarch.rpm;name=aarch64_rust-unicode-properties-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-properties-devel}"
SRC_URI[aarch64_rust-unicode-properties-devel.sha256sum] = "161cadfbaef48899c373e670574eacb09736c2f8ad1d75c3cc634e56f75d1944"

RDEPENDS:rust-unicode-properties+default-devel = " \
 cargo \
 rust-unicode-properties+emoji-devel \
 rust-unicode-properties+general-category-devel \
 rust-unicode-properties-devel \
 "
RDEPENDS:rust-unicode-properties+emoji-devel = " \
 cargo \
 rust-unicode-properties-devel \
 "
RDEPENDS:rust-unicode-properties+general-category-devel = " \
 cargo \
 rust-unicode-properties-devel \
 "
RDEPENDS:rust-unicode-properties-devel = " \
 cargo \
 "
