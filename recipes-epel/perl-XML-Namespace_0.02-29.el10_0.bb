# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-Namespace"
PV = "0.02"
PR = "29.el10_0"
PACKAGES = " \
 perl-XML-Namespace \
 perl-XML-Namespace-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XML-Namespace-0.02-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa1fbecb90b2e496378e60439024024a2f5fd2eeb744c7842ee5ef974b89f851"

URI_x86_64_v2_perl-XML-Namespace = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-Namespace-0.02-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-Namespace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-Namespace}"
SRC_URI[x86_64_v2_perl-XML-Namespace.sha256sum] = "ef14f73cfefd5211952ba5e61938f1383f2af15be79e61e99623deb44be8a32e"

URI_x86_64_v2_perl-XML-Namespace-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-Namespace-tests-0.02-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-Namespace-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-Namespace-tests}"
SRC_URI[x86_64_v2_perl-XML-Namespace-tests.sha256sum] = "1f331d0cd27fb0f2a6c6d92272efb1c0f6771873efef62ce04e7d462bc21a7b6"

URI_aarch64_perl-XML-Namespace = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-Namespace-0.02-29.el10_0.noarch.rpm;name=aarch64_perl-XML-Namespace;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-Namespace}"
SRC_URI[aarch64_perl-XML-Namespace.sha256sum] = "904cb66431e31136a04b44a0821968dc5f9cd15f15798e18ee2f7590bb577f72"

URI_aarch64_perl-XML-Namespace-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-Namespace-tests-0.02-29.el10_0.noarch.rpm;name=aarch64_perl-XML-Namespace-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-Namespace-tests}"
SRC_URI[aarch64_perl-XML-Namespace-tests.sha256sum] = "917cf3f1b77b046692289c8229c4b05ec2c3f75e750c3b1e3a1248ee6bd83aa7"

RDEPENDS:perl-XML-Namespace = " \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-XML-Namespace-tests = " \
 bash \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-XML-Namespace \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
