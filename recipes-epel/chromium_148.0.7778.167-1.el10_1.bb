# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chromium"
PV = "148.0.7778.167"
PR = "1.el10_1"
PACKAGES = " \
 chromedriver \
 chromium \
 chromium-common \
 chromium-headless \
 chromium-qt5-ui \
 chromium-qt6-ui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/chromium-148.0.7778.167-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b848757bf028224129992b2f3eb5df8b0d7ee43d7b01f8cac400ce83a496578"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - chromium-headless: libavcodec.so.61()(64bit)
# - chromium-headless: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - chromium-headless: libavformat.so.61()(64bit)
# - chromium-headless: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - chromium-headless: libavutil.so.59()(64bit)
# - chromium-headless: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - chromium: libavcodec.so.61()(64bit)
# - chromium: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - chromium: libavformat.so.61()(64bit)
# - chromium: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - chromium: libavutil.so.59()(64bit)
# - chromium: libavutil.so.59(LIBAVUTIL_59)(64bit)

URI_x86_64_v2_chromedriver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromedriver-148.0.7778.167-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromedriver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chromedriver}"
SRC_URI[x86_64_v2_chromedriver.sha256sum] = "c0df2dc854c08494e2a4287f33a6e3d47c437c0e8801559014efa69d89845adb"

URI_x86_64_v2_chromium = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-148.0.7778.167-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chromium}"
SRC_URI[x86_64_v2_chromium.sha256sum] = "a1257f0da1f58f5af89ce14cb9976054ea6080e6540769ba46d8cd10021c2ee4"

URI_x86_64_v2_chromium-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-common-148.0.7778.167-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chromium-common}"
SRC_URI[x86_64_v2_chromium-common.sha256sum] = "3b347bdb67d76030be134ead81ef2da76c173038423a6d2581aa008d6075bb86"

URI_x86_64_v2_chromium-headless = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-headless-148.0.7778.167-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chromium-headless}"
SRC_URI[x86_64_v2_chromium-headless.sha256sum] = "1c3a784e892ca51ecd6947caf380983e02fa86b5826ba07eaf221aa5617e7b26"

URI_x86_64_v2_chromium-qt5-ui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-qt5-ui-148.0.7778.167-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-qt5-ui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chromium-qt5-ui}"
SRC_URI[x86_64_v2_chromium-qt5-ui.sha256sum] = "ef1474dab6dee0877c7c8b8b6380acc2feac89ff9420e19719e47c4df862dbd2"

URI_x86_64_v2_chromium-qt6-ui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-qt6-ui-148.0.7778.167-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-qt6-ui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chromium-qt6-ui}"
SRC_URI[x86_64_v2_chromium-qt6-ui.sha256sum] = "ef5053848e4b213d33b6d62c0c1a6f5e6ffaa75968e50d314af461c71f5d0a4d"

URI_aarch64_chromedriver = "${EPEL_MIRROR}/aarch64/Packages/c/chromedriver-148.0.7778.167-1.el10_1.aarch64.rpm;name=aarch64_chromedriver;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromedriver}"
SRC_URI[aarch64_chromedriver.sha256sum] = "5d711a070d8a53cc66de32ac7f2f212fe81273bbb115c271d9693dbbaf1a4094"

URI_aarch64_chromium = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-148.0.7778.167-1.el10_1.aarch64.rpm;name=aarch64_chromium;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium}"
SRC_URI[aarch64_chromium.sha256sum] = "35e053df5e6e96b7e1dda974af314fc23605d76248505bbe92401680cb21cb91"

URI_aarch64_chromium-common = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-common-148.0.7778.167-1.el10_1.aarch64.rpm;name=aarch64_chromium-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-common}"
SRC_URI[aarch64_chromium-common.sha256sum] = "456155684abd46585806c8a458da0fe42d3fc48a4db3843ebbce763120b5e1ba"

URI_aarch64_chromium-headless = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-headless-148.0.7778.167-1.el10_1.aarch64.rpm;name=aarch64_chromium-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-headless}"
SRC_URI[aarch64_chromium-headless.sha256sum] = "6954c6c19f5ddfa9753d0438dcefb6695a7df88e0c1d1fe43c96da6cadabbe0e"

URI_aarch64_chromium-qt5-ui = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-qt5-ui-148.0.7778.167-1.el10_1.aarch64.rpm;name=aarch64_chromium-qt5-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-qt5-ui}"
SRC_URI[aarch64_chromium-qt5-ui.sha256sum] = "1d1cfd8ca5969552986e840b114f65e095cd5ae457a062d7fe64c33c71151b8e"

URI_aarch64_chromium-qt6-ui = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-qt6-ui-148.0.7778.167-1.el10_1.aarch64.rpm;name=aarch64_chromium-qt6-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-qt6-ui}"
SRC_URI[aarch64_chromium-qt6-ui.sha256sum] = "a1d1a04dc7bb41d662b543a340fbe1c23ba8e60f1ce54e9e61791d1e8a26ae1b"

RDEPENDS:chromedriver = " \
 chromium-common \
 double-conversion \
 glib2 \
 glibc \
 libbrotli \
 libgcc \
 libxcb \
 libzstd \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:chromium:x86_64_v2 = " \
 alsa-lib \
 at-spi2-atk \
 at-spi2-core \
 atk \
 bash \
 cairo \
 chromium-common \
 cups-libs \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gtk4 \
 harfbuzz \
 lcms2 \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libbrotli \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libusb1 \
 libwebp \
 libxcb \
 libxkbcommon \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-mdns \
 nss-util \
 openjpeg2 \
 opus \
 pango \
 pipewire-libs \
 policycoreutils \
 policycoreutils-python-utils \
 systemd-libs \
"
RDEPENDS:chromium:aarch64 = " \
 alsa-lib \
 at-spi2-atk \
 at-spi2-core \
 atk \
 bash \
 cairo \
 chromium-common \
 cups-libs \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gtk4 \
 harfbuzz \
 lcms2 \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbrotli \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libusb1 \
 libwebp \
 libxcb \
 libxkbcommon \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-mdns \
 nss-util \
 openjpeg2 \
 opus \
 pango \
 pipewire-libs \
 policycoreutils \
 policycoreutils-python-utils \
 systemd-libs \
"
RDEPENDS:chromium-common = " \
 glibc \
 libX11 \
 libXNVCtrl \
 libdrm \
 libgcc \
 libxcb \
 "
RDEPENDS:chromium-headless:x86_64_v2 = " \
 alsa-lib \
 at-spi2-core \
 atk \
 chromium-common \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 harfbuzz \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libbrotli \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libwebp \
 libxcb \
 libxkbcommon \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-util \
 opus \
 pipewire-libs \
 systemd-libs \
"
RDEPENDS:chromium-headless:aarch64 = " \
 alsa-lib \
 at-spi2-core \
 atk \
 chromium-common \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 harfbuzz \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbrotli \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libwebp \
 libxcb \
 libxkbcommon \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-util \
 opus \
 pipewire-libs \
 systemd-libs \
"
RDEPENDS:chromium-qt5-ui = " \
 chromium \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:chromium-qt6-ui = " \
 chromium \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
