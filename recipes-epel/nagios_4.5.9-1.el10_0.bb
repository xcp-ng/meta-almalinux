# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nagios"
PV = "4.5.9"
PR = "1.el10_0"
PACKAGES = " \
 nagios \
 nagios-common \
 nagios-contrib \
 nagios-devel \
 nagios-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nagios-4.5.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68f81564f090b619ecd15c487dd3681ba2abceaa54c16e7913ec940e1088ec78"

URI_x86_64_v2_nagios = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-4.5.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios}"
SRC_URI[x86_64_v2_nagios.sha256sum] = "f95116c65fcea00622f9326750a3e55f0f82ef76256862db6340579881ebe15f"

URI_x86_64_v2_nagios-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-common-4.5.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-common}"
SRC_URI[x86_64_v2_nagios-common.sha256sum] = "50e9cc51a6ce0d422af11b89e11367371ffe0635645865d37266ee733315dc4a"

URI_x86_64_v2_nagios-contrib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-contrib-4.5.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-contrib}"
SRC_URI[x86_64_v2_nagios-contrib.sha256sum] = "6cc2968e58089e4cfa1903d3c63c3b232251e0c7e3f15260e24b11c2e2f4e705"

URI_x86_64_v2_nagios-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-devel-4.5.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-devel}"
SRC_URI[x86_64_v2_nagios-devel.sha256sum] = "67c18d7adf8fcfd7bbe1b44841ad55a53fc86025103aead2c869ae3919ab27c1"

URI_x86_64_v2_nagios-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-selinux-4.5.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nagios-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-selinux}"
SRC_URI[x86_64_v2_nagios-selinux.sha256sum] = "055b0f5f07d59711708bf8c1e8c68c11341662d2e425dac8d35f6db7720ffe73"

URI_aarch64_nagios = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-4.5.9-1.el10_0.aarch64.rpm;name=aarch64_nagios;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios}"
SRC_URI[aarch64_nagios.sha256sum] = "df6e8a46acfb83ef0c4abcbe678da830d57dbfb09e3d6b86f48bd7ed5016ef37"

URI_aarch64_nagios-common = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-common-4.5.9-1.el10_0.aarch64.rpm;name=aarch64_nagios-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-common}"
SRC_URI[aarch64_nagios-common.sha256sum] = "2b594c2a3e1eca7893e00aed0e0c087053580199f32b39b262bfd04b748271c8"

URI_aarch64_nagios-contrib = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-contrib-4.5.9-1.el10_0.aarch64.rpm;name=aarch64_nagios-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-contrib}"
SRC_URI[aarch64_nagios-contrib.sha256sum] = "9fb025d8ba7d7ff1158265dfc4047c15cd1ad1fd09ecd076f224ee8e56468448"

URI_aarch64_nagios-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-devel-4.5.9-1.el10_0.aarch64.rpm;name=aarch64_nagios-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-devel}"
SRC_URI[aarch64_nagios-devel.sha256sum] = "953d99a7da78d00bb91c51a16987e6a942ecd73ece878fa0d2df792825e4eba5"

URI_aarch64_nagios-selinux = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-selinux-4.5.9-1.el10_0.noarch.rpm;name=aarch64_nagios-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-selinux}"
SRC_URI[aarch64_nagios-selinux.sha256sum] = "44981a0bf0a59eeceab87ee0a747d110e3df222a258e44e5b4b3c5f9db94877e"

RDEPENDS:nagios = " \
 bash \
 gd \
 glibc \
 httpd \
 nagios-common \
 nagios-plugins-disk \
 nagios-plugins-http \
 nagios-plugins-load \
 nagios-plugins-ping \
 nagios-plugins-procs \
 nagios-plugins-ssh \
 nagios-plugins-swap \
 nagios-plugins-users \
 nagios-selinux \
 openssl-libs \
 php \
 s-nail \
 "
RDEPENDS:nagios-common = " \
 shadow-utils \
 "
RDEPENDS:nagios-contrib = " \
 glibc \
 nagios \
 perl-File-Basename \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:nagios-devel = " \
 nagios \
 "
RDEPENDS:nagios-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
