# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-walkdir"
PV = "2.5.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-walkdir+default-devel \
 rust-walkdir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-walkdir-2.5.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8179274612b144c5fa5dd26e5e184fe98ee1d1d07fb333d54c3d41a62a84c80a"

URI_x86_64_v2_rust-walkdir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-walkdir+default-devel-2.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-walkdir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-walkdir+default-devel}"
SRC_URI[x86_64_v2_rust-walkdir+default-devel.sha256sum] = "b7b9c155721f59c61e8c2fae30ac1e7011e065f44b2c24d49e96c2cf01d49023"

URI_x86_64_v2_rust-walkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-walkdir-devel-2.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-walkdir-devel}"
SRC_URI[x86_64_v2_rust-walkdir-devel.sha256sum] = "ea3671de8d042e8f5598bdc12d0af813c6c4e949f7268328374c6793413ad028"

URI_aarch64_rust-walkdir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-walkdir+default-devel-2.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-walkdir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-walkdir+default-devel}"
SRC_URI[aarch64_rust-walkdir+default-devel.sha256sum] = "6348d1e21b15f7fc0b84839b75808f075ded80f3afdc3f5455f06c348028b5a9"

URI_aarch64_rust-walkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-walkdir-devel-2.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-walkdir-devel}"
SRC_URI[aarch64_rust-walkdir-devel.sha256sum] = "e927ab7e9d91b7f4f191adf58cbe9bb420b50a926ca87f3f23de6ef39372736a"

RDEPENDS:rust-walkdir+default-devel = " \
 cargo \
 rust-walkdir-devel \
 "
RDEPENDS:rust-walkdir-devel = " \
 cargo \
 rust-same-file+default-devel \
 "
