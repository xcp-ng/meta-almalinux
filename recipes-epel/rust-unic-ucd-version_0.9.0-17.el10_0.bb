# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-ucd-version"
PV = "0.9.0"
PR = "17.el10_0"
PACKAGES = " \
 rust-unic-ucd-version+default-devel \
 rust-unic-ucd-version-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-ucd-version-0.9.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11b98aa5f992041197066499ad3e7315fafc325806c1a7ff965ee98e67e807bd"

URI_x86_64_v2_rust-unic-ucd-version+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-version+default-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-version+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-version+default-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-version+default-devel.sha256sum] = "4887dbc18db2e71adc0a11fd3e05bc74991485bd114f77d73f188396f7ce8c96"

URI_x86_64_v2_rust-unic-ucd-version-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-version-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-version-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-version-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-version-devel.sha256sum] = "1277c32a994b8049490e452f5229535b8daf89388a2034fd7d17ba1fd097fb58"

URI_aarch64_rust-unic-ucd-version+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-version+default-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-ucd-version+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-version+default-devel}"
SRC_URI[aarch64_rust-unic-ucd-version+default-devel.sha256sum] = "f3298d823fe160ca3a10d74c42af8fb0b2a9a5257b8098f1e8b5033605bcee23"

URI_aarch64_rust-unic-ucd-version-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-version-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-ucd-version-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-version-devel}"
SRC_URI[aarch64_rust-unic-ucd-version-devel.sha256sum] = "52f9cbb524a0bbe2e9ef780abc614e6fcfa970c59bec2f560455eda9910353cc"

RDEPENDS:rust-unic-ucd-version+default-devel = " \
 cargo \
 rust-unic-ucd-version-devel \
 "
RDEPENDS:rust-unic-ucd-version-devel = " \
 cargo \
 rust-unic-common+default-devel \
 "
