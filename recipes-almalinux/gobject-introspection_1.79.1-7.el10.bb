# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gobject-introspection"
PV = "1.79.1"
PR = "7.el10"
PACKAGES = " \
 gobject-introspection \
 gobject-introspection-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gobject-introspection-1.79.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4978184a1a17c041d349b84ba6a276f0b9f7b07086fbceb9af335c061cb98fc8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gobject-introspection-1.79.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_gobject-introspection;unpack=0"
SRC_URI[x86_64_v2_gobject-introspection.sha256sum] = "bdc32530f59237b4c588ea24c1817ee47c5648f49c45cf784c6ef091baeb7c87"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gobject-introspection-devel-1.79.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_gobject-introspection-devel;unpack=0"
SRC_URI[x86_64_v2_gobject-introspection-devel.sha256sum] = "60a0afbbcbb2a481e7c97af1005a99cdafd923d5dbcdedafff55976cac55bddd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gobject-introspection-1.79.1-7.el10.aarch64.rpm;name=aarch64_gobject-introspection;unpack=0"
SRC_URI[aarch64_gobject-introspection.sha256sum] = "68b8b53ef9617bf72f1c1a79da6a6a95742b9a3ef57958b5a9db828238c41fa8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gobject-introspection-devel-1.79.1-7.el10.aarch64.rpm;name=aarch64_gobject-introspection-devel;unpack=0"
SRC_URI[aarch64_gobject-introspection-devel.sha256sum] = "bae8dbff2c080ef1fb03e070462f30dc396c2c3bde7a4c81ce49b17a448d5fe9"

RDEPENDS:gobject-introspection = " \
 glib2 \
 glibc \
 libffi \
 "
RDEPENDS:gobject-introspection-devel = " \
 glib2 \
 glib2-devel \
 glibc \
 gobject-introspection \
 gobject-introspection-devel \
 libffi \
 libtool \
 pkgconf-pkg-config \
 python3 \
 python3-mako \
 python3-markdown \
 python3-setuptools \
 "
