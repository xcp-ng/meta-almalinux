# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vkroots"
PV = "0^20250716git51c3213"
PR = "4.el10_1"
PACKAGES = " \
 vkroots-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vkroots-0^20250716git51c3213-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51cc91bdf8284a673f0dcf9a27c1ffa0ecd80863c2de35889dc5325c35a460e3"

URI_x86_64_v2_vkroots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vkroots-devel-0^20250716git51c3213-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_vkroots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vkroots-devel}"
SRC_URI[x86_64_v2_vkroots-devel.sha256sum] = "3b37853e6669e529d0e7c42249835a03926c940c041293d96b23b9ef51a98f2f"

URI_aarch64_vkroots-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vkroots-devel-0^20250716git51c3213-4.el10_1.noarch.rpm;name=aarch64_vkroots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vkroots-devel}"
SRC_URI[aarch64_vkroots-devel.sha256sum] = "d3262e89685f87114b43c8ed4faf616f3dbf44d334a1b14750f4d1487b0f9675"

RDEPENDS:vkroots-devel = " \
 pkgconf-pkg-config \
 "
