# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "make"
PE = "1"
PV = "4.4.1"
PR = "9.el10"
PACKAGES = " \
 make \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/make-4.4.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "50df7869980464ca91c642ad37ec57eb0c36401066fbed344cf4d3666a8a061a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/make-4.4.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_make;unpack=0"
SRC_URI[x86_64_v2_make.sha256sum] = "6e1dce95ec84dd2f727abb78a936cbd754bd7ecc6c9ce63098c76f01a350121f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/make-4.4.1-9.el10.aarch64.rpm;name=aarch64_make;unpack=0"
SRC_URI[aarch64_make.sha256sum] = "9bb0bfca468d3bf7235efa7c79fe6734f1c7f875c3aa0e31e02f9fd5d09dfccb"

RDEPENDS:make = " \
 glibc \
 "
