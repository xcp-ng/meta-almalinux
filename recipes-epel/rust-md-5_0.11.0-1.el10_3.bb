# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-md-5"
PV = "0.11.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-md-5+alloc-devel \
 rust-md-5+default-devel \
 rust-md-5+oid-devel \
 rust-md-5+zeroize-devel \
 rust-md-5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-md-5-0.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bdad6801d1c3dc93293e0d74bf99f7d95e70d5d2656b041018b51cef708d28e"

URI_x86_64_v2_rust-md-5+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5+alloc-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5+alloc-devel}"
SRC_URI[x86_64_v2_rust-md-5+alloc-devel.sha256sum] = "2b59511f2af177653d23c0112c70c023eed1d9e06805ed0e512fee8acda4bf6d"

URI_x86_64_v2_rust-md-5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5+default-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5+default-devel}"
SRC_URI[x86_64_v2_rust-md-5+default-devel.sha256sum] = "46a3423a6d9ec9f84b56aefdd1380f6ca7900b19c4108c700949621f94c67cbf"

URI_x86_64_v2_rust-md-5+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5+oid-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5+oid-devel}"
SRC_URI[x86_64_v2_rust-md-5+oid-devel.sha256sum] = "9222164260373d1fc282afba44adcb721eb047041f224801683cbaf2cd3f1718"

URI_x86_64_v2_rust-md-5+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5+zeroize-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5+zeroize-devel}"
SRC_URI[x86_64_v2_rust-md-5+zeroize-devel.sha256sum] = "42258ef24adcfa019e7d1bbe4441fb5fee49c34e05bb3384f57a8986383778c7"

URI_x86_64_v2_rust-md-5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5-devel}"
SRC_URI[x86_64_v2_rust-md-5-devel.sha256sum] = "2028799a098a8172ab491cee1b218217210c38ec2ad6701f1e701ad04671b505"

URI_aarch64_rust-md-5+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5+alloc-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-md-5+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5+alloc-devel}"
SRC_URI[aarch64_rust-md-5+alloc-devel.sha256sum] = "20634aa6429179533d6d47967a8e37b9b1758eb50a249e7866cda6ae35b3c823"

URI_aarch64_rust-md-5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5+default-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-md-5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5+default-devel}"
SRC_URI[aarch64_rust-md-5+default-devel.sha256sum] = "766502e9fe1d61e846898e0a6d199683261d9bf6793a7a55778be18e3e38ac94"

URI_aarch64_rust-md-5+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5+oid-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-md-5+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5+oid-devel}"
SRC_URI[aarch64_rust-md-5+oid-devel.sha256sum] = "f011facda48db1ec18ee4a17a49bb686a65d2fdf062be6990e8886e7a5254624"

URI_aarch64_rust-md-5+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5+zeroize-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-md-5+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5+zeroize-devel}"
SRC_URI[aarch64_rust-md-5+zeroize-devel.sha256sum] = "e3b7ea0581df4042adc7e53749abc05a244bac1e88ff61323f2f346e054edf13"

URI_aarch64_rust-md-5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-md-5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5-devel}"
SRC_URI[aarch64_rust-md-5-devel.sha256sum] = "28edf66cd339a125dba06e0b5ce6b9cbb93158090e0db361fd212e23a5a849c7"

RDEPENDS:rust-md-5+alloc-devel = " \
 cargo \
 rust-digest+alloc-devel \
 rust-md-5-devel \
 "
RDEPENDS:rust-md-5+default-devel = " \
 cargo \
 rust-md-5+alloc-devel \
 rust-md-5+oid-devel \
 rust-md-5-devel \
 "
RDEPENDS:rust-md-5+oid-devel = " \
 cargo \
 rust-digest+oid-devel \
 rust-md-5-devel \
 "
RDEPENDS:rust-md-5+zeroize-devel = " \
 cargo \
 rust-digest+zeroize-devel \
 rust-md-5-devel \
 "
RDEPENDS:rust-md-5-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-digest+default-devel \
 "
