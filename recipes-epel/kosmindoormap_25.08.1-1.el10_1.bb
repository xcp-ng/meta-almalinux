# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kosmindoormap"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kosmindoormap \
 kosmindoormap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kosmindoormap-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2c8152e08a041f19ada7a1273a4407ff43c57127aa765082c7db0f9bf15b1aa"

URI_x86_64_v2_kosmindoormap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kosmindoormap-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kosmindoormap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kosmindoormap}"
SRC_URI[x86_64_v2_kosmindoormap.sha256sum] = "e8cbb620e298a151eea7ce60e7945bc6cf2171e73b168e1b9dd64f3304dc6d99"

URI_x86_64_v2_kosmindoormap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kosmindoormap-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kosmindoormap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kosmindoormap-devel}"
SRC_URI[x86_64_v2_kosmindoormap-devel.sha256sum] = "4524f51e36337388800bcdb826c2e9749120b39355310b5a336881b821a97d2d"

URI_aarch64_kosmindoormap = "${EPEL_MIRROR}/aarch64/Packages/k/kosmindoormap-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kosmindoormap;unpack=0"
SRC_URI:append = " ${URI_aarch64_kosmindoormap}"
SRC_URI[aarch64_kosmindoormap.sha256sum] = "07fae6042c6b3f619f8bf632bc65cfd01fa20c5a819362e6b3b5617b3b1cfa72"

URI_aarch64_kosmindoormap-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kosmindoormap-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kosmindoormap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kosmindoormap-devel}"
SRC_URI[aarch64_kosmindoormap-devel.sha256sum] = "5066bee9e5d9a4e11a3e8407e3d705e62e48375c95ca974b866e8502b39b1a29"

RDEPENDS:kosmindoormap = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kservice \
 kopeninghours \
 kpublictransport \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kosmindoormap-devel = " \
 cmake-filesystem \
 kosmindoormap \
 "
