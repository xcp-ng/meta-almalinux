# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-mongodb"
PV = "1.21.5"
PR = "1.el10_1"
PACKAGES = " \
 php-pecl-mongodb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-mongodb-1.21.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "730f001f580e236b3c53de8532b67a080ee0ae8780bb5c50dfbaa536ae944f24"

URI_x86_64_v2_php-pecl-mongodb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-mongodb-1.21.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-mongodb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-mongodb}"
SRC_URI[x86_64_v2_php-pecl-mongodb.sha256sum] = "52ab59fe08f99c7a1b1096afddb6c01dfd4ac2308ec8bdd8c1ae8c951ce8a753"

URI_aarch64_php-pecl-mongodb = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-mongodb-1.21.5-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-mongodb;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-mongodb}"
SRC_URI[aarch64_php-pecl-mongodb.sha256sum] = "6a31259d547bb59d993422956d42203cdef8cb3ca435b26a1781c07e0b644352"

RDEPENDS:php-pecl-mongodb = " \
 glibc \
 libbson \
 libmongocrypt \
 mongo-c-driver-libs \
 php-common \
 "
