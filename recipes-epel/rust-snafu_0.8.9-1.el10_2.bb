# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snafu"
PV = "0.8.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-snafu+alloc-devel \
 rust-snafu+backtrace-devel \
 rust-snafu+backtraces-impl-backtrace-crate-devel \
 rust-snafu+default-devel \
 rust-snafu+futures-core-crate-devel \
 rust-snafu+futures-crate-devel \
 rust-snafu+futures-devel \
 rust-snafu+guide-devel \
 rust-snafu+internal-dev-dependencies-devel \
 rust-snafu+pin-project-devel \
 rust-snafu+rust_1_61-devel \
 rust-snafu+rust_1_65-devel \
 rust-snafu+rust_1_81-devel \
 rust-snafu+std-devel \
 rust-snafu+unstable-core-error-devel \
 rust-snafu+unstable-provider-api-devel \
 rust-snafu+unstable-try-trait-devel \
 rust-snafu-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snafu-0.8.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f2edd970d4bc11538cffd976bafce62d0d5302ae40b3aed9b5a868bdc6feaa8"

URI_x86_64_v2_rust-snafu+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+alloc-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+alloc-devel}"
SRC_URI[x86_64_v2_rust-snafu+alloc-devel.sha256sum] = "f2764b893161235fe6a5f77a99ff5c47aa85a1eea0584a5c39c32ea1984d6e19"

URI_x86_64_v2_rust-snafu+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+backtrace-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+backtrace-devel}"
SRC_URI[x86_64_v2_rust-snafu+backtrace-devel.sha256sum] = "925e1468c4bf2d75700a4a538fe8bba7acb182af2119c46561406d03cf1fc7a6"

URI_x86_64_v2_rust-snafu+backtraces-impl-backtrace-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+backtraces-impl-backtrace-crate-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+backtraces-impl-backtrace-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+backtraces-impl-backtrace-crate-devel}"
SRC_URI[x86_64_v2_rust-snafu+backtraces-impl-backtrace-crate-devel.sha256sum] = "7e074da64592c552c58c39a840ad7105d25aa4105002c9148a2b55da269cc728"

URI_x86_64_v2_rust-snafu+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+default-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+default-devel}"
SRC_URI[x86_64_v2_rust-snafu+default-devel.sha256sum] = "501ad8a4c1e3e2ffadea961a2977e19e0471ea73161e8031bac0bce8b22bfed6"

URI_x86_64_v2_rust-snafu+futures-core-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+futures-core-crate-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+futures-core-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+futures-core-crate-devel}"
SRC_URI[x86_64_v2_rust-snafu+futures-core-crate-devel.sha256sum] = "4cb0bb34a0c4d9136adb1136c9593c754576336144b0bf39f807fe8a108af18d"

URI_x86_64_v2_rust-snafu+futures-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+futures-crate-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+futures-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+futures-crate-devel}"
SRC_URI[x86_64_v2_rust-snafu+futures-crate-devel.sha256sum] = "107c737200a8f19915a8d3bf01b9def89156a3226032eaef8a40a9d2dfd8bf77"

URI_x86_64_v2_rust-snafu+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+futures-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+futures-devel}"
SRC_URI[x86_64_v2_rust-snafu+futures-devel.sha256sum] = "8a95c981bcb276b51b601384750b2317eca31936640c0aa13f8748ee170d029a"

URI_x86_64_v2_rust-snafu+guide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+guide-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+guide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+guide-devel}"
SRC_URI[x86_64_v2_rust-snafu+guide-devel.sha256sum] = "444d191b6ed5ae9afe85f57442c1761b31e7a5ee0555eec3dcab4d84da6f43ff"

URI_x86_64_v2_rust-snafu+internal-dev-dependencies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+internal-dev-dependencies-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+internal-dev-dependencies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+internal-dev-dependencies-devel}"
SRC_URI[x86_64_v2_rust-snafu+internal-dev-dependencies-devel.sha256sum] = "9883eb936c648bcd8f32fb50051b7fdaea1ca2f73d659ad21fafcd2edeef2635"

URI_x86_64_v2_rust-snafu+pin-project-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+pin-project-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+pin-project-devel}"
SRC_URI[x86_64_v2_rust-snafu+pin-project-devel.sha256sum] = "a1203ccf1376df497ef6e8def161d4ee97d16e1cc1006b6e9588b1ff142d2347"

URI_x86_64_v2_rust-snafu+rust_1_61-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+rust_1_61-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+rust_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+rust_1_61-devel}"
SRC_URI[x86_64_v2_rust-snafu+rust_1_61-devel.sha256sum] = "aff64ca27fded3c4a93e9abbe7228aab12f2b5bec9ecaf0e5482c1c3ad821967"

URI_x86_64_v2_rust-snafu+rust_1_65-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+rust_1_65-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+rust_1_65-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+rust_1_65-devel}"
SRC_URI[x86_64_v2_rust-snafu+rust_1_65-devel.sha256sum] = "c576522525706e2f21fdb5d62b5b5c2404a2df0b2c045aa7bc425923d777f202"

URI_x86_64_v2_rust-snafu+rust_1_81-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+rust_1_81-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+rust_1_81-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+rust_1_81-devel}"
SRC_URI[x86_64_v2_rust-snafu+rust_1_81-devel.sha256sum] = "f8e6c24657f1c202b9cfab04ae20163ad414c1bc62cb63f36c6aa2763928ea42"

URI_x86_64_v2_rust-snafu+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+std-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+std-devel}"
SRC_URI[x86_64_v2_rust-snafu+std-devel.sha256sum] = "ffb7942ef3c253ae95aed47d78bdf88d29582f96167985665330d10eb792a3b9"

URI_x86_64_v2_rust-snafu+unstable-core-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+unstable-core-error-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+unstable-core-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+unstable-core-error-devel}"
SRC_URI[x86_64_v2_rust-snafu+unstable-core-error-devel.sha256sum] = "1f800f1db194deb364d89582325b74ad9d1ba75919bb538a2af11d23e5e18281"

URI_x86_64_v2_rust-snafu+unstable-provider-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+unstable-provider-api-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+unstable-provider-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+unstable-provider-api-devel}"
SRC_URI[x86_64_v2_rust-snafu+unstable-provider-api-devel.sha256sum] = "873db8b04877c2b0e0ecc9f8fae35df8b200eeb35564c675086594342472eee6"

URI_x86_64_v2_rust-snafu+unstable-try-trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+unstable-try-trait-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+unstable-try-trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+unstable-try-trait-devel}"
SRC_URI[x86_64_v2_rust-snafu+unstable-try-trait-devel.sha256sum] = "2a774b3df0eb90b26af4522093a47e3352697235271bcf0c918b4a8af4af32df"

URI_x86_64_v2_rust-snafu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-devel}"
SRC_URI[x86_64_v2_rust-snafu-devel.sha256sum] = "35f78167108b0e84af66b017556745b38ea64fe851bb0b26f61469c40007388e"

URI_aarch64_rust-snafu+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+alloc-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+alloc-devel}"
SRC_URI[aarch64_rust-snafu+alloc-devel.sha256sum] = "72092eb856600bd220db92afcf30c44995fc835292d158c65e829badd4599189"

URI_aarch64_rust-snafu+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+backtrace-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+backtrace-devel}"
SRC_URI[aarch64_rust-snafu+backtrace-devel.sha256sum] = "312df881dd76bed4e27ebac0f2db591543b8d0d301b64eab733d415db710402f"

URI_aarch64_rust-snafu+backtraces-impl-backtrace-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+backtraces-impl-backtrace-crate-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+backtraces-impl-backtrace-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+backtraces-impl-backtrace-crate-devel}"
SRC_URI[aarch64_rust-snafu+backtraces-impl-backtrace-crate-devel.sha256sum] = "3fd2e3bd66ac01ebbbc28b845cde99b38ff6627f68423426eb14f7884b400ecd"

URI_aarch64_rust-snafu+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+default-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+default-devel}"
SRC_URI[aarch64_rust-snafu+default-devel.sha256sum] = "6138fe97ef868f8c0be3e8c7e899d71f1eecfbad0bd544ccb6467aed8180b9ad"

URI_aarch64_rust-snafu+futures-core-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+futures-core-crate-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+futures-core-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+futures-core-crate-devel}"
SRC_URI[aarch64_rust-snafu+futures-core-crate-devel.sha256sum] = "4b3a7a82eada1b00fbea42782d56aee6e297f35f60c6fada9c856ba06564fc22"

URI_aarch64_rust-snafu+futures-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+futures-crate-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+futures-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+futures-crate-devel}"
SRC_URI[aarch64_rust-snafu+futures-crate-devel.sha256sum] = "61efb5af67650766ed891346ac9943c9b5cfe3fc1f65afda4417f43974801df6"

URI_aarch64_rust-snafu+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+futures-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+futures-devel}"
SRC_URI[aarch64_rust-snafu+futures-devel.sha256sum] = "b486015e5c3d2242c8b9e3dddbd421d27f18e459b8ade4d3147aa1b1c142d80f"

URI_aarch64_rust-snafu+guide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+guide-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+guide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+guide-devel}"
SRC_URI[aarch64_rust-snafu+guide-devel.sha256sum] = "88e20cc91739d9bae890808c11a317819236ce0b574f5f006e257a8d03392184"

URI_aarch64_rust-snafu+internal-dev-dependencies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+internal-dev-dependencies-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+internal-dev-dependencies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+internal-dev-dependencies-devel}"
SRC_URI[aarch64_rust-snafu+internal-dev-dependencies-devel.sha256sum] = "96d630f18185b1b3d17614343faf1a86ef95b16130aeff580faad8dfc1d44602"

URI_aarch64_rust-snafu+pin-project-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+pin-project-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+pin-project-devel}"
SRC_URI[aarch64_rust-snafu+pin-project-devel.sha256sum] = "c379fdeb716f57d0dc57e5179565ee788ab90316836307964ae43212fe1f96dd"

URI_aarch64_rust-snafu+rust_1_61-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+rust_1_61-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+rust_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+rust_1_61-devel}"
SRC_URI[aarch64_rust-snafu+rust_1_61-devel.sha256sum] = "fdeb728329372b1510828e2f4524e030de21471cfc875219ba76ee8c3d6b5e48"

URI_aarch64_rust-snafu+rust_1_65-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+rust_1_65-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+rust_1_65-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+rust_1_65-devel}"
SRC_URI[aarch64_rust-snafu+rust_1_65-devel.sha256sum] = "81f4edd243d42a8959d4ee6c6c5ce5e660c2e3a94e2370e6814f9e2685d7245f"

URI_aarch64_rust-snafu+rust_1_81-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+rust_1_81-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+rust_1_81-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+rust_1_81-devel}"
SRC_URI[aarch64_rust-snafu+rust_1_81-devel.sha256sum] = "c12a8fc0f0aa61787a8ff92b46b2ce2a942b6fb51102b0aee4462958a7bbe509"

URI_aarch64_rust-snafu+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+std-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+std-devel}"
SRC_URI[aarch64_rust-snafu+std-devel.sha256sum] = "3f9dcafbbeb8112e90c75d52fdafda1c39bb1ade91d082875bd11f4ddfe40e47"

URI_aarch64_rust-snafu+unstable-core-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+unstable-core-error-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+unstable-core-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+unstable-core-error-devel}"
SRC_URI[aarch64_rust-snafu+unstable-core-error-devel.sha256sum] = "ac308bea14308f40c412b610d888e5b2b23322cd0ec85f6a6c53eebabf297088"

URI_aarch64_rust-snafu+unstable-provider-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+unstable-provider-api-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+unstable-provider-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+unstable-provider-api-devel}"
SRC_URI[aarch64_rust-snafu+unstable-provider-api-devel.sha256sum] = "a0798c3508299e6f9e29ef7fa97cb49a90fcf2be7a8f772d575c16ac8f10fc04"

URI_aarch64_rust-snafu+unstable-try-trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+unstable-try-trait-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu+unstable-try-trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+unstable-try-trait-devel}"
SRC_URI[aarch64_rust-snafu+unstable-try-trait-devel.sha256sum] = "3dc4a0248ea46d7900254515720c7845f179eaf5a6187a46fb93e68a284f55af"

URI_aarch64_rust-snafu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-devel}"
SRC_URI[aarch64_rust-snafu-devel.sha256sum] = "796d6d6420f5d68cdb0833ea6a9d2dbfde12429350d1ab20a234779a29e19063"

RDEPENDS:rust-snafu+alloc-devel = " \
 cargo \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+backtraces-impl-backtrace-crate-devel = " \
 cargo \
 rust-snafu+backtrace-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+default-devel = " \
 cargo \
 rust-snafu+rust_1_65-devel \
 rust-snafu+std-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+futures-core-crate-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+futures-crate-devel = " \
 cargo \
 rust-futures-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+futures-devel = " \
 cargo \
 rust-snafu+futures-core-crate-devel \
 rust-snafu+pin-project-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+guide-devel = " \
 cargo \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+internal-dev-dependencies-devel = " \
 cargo \
 rust-snafu+futures-crate-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+pin-project-devel = " \
 cargo \
 rust-pin-project-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+rust_1_61-devel = " \
 cargo \
 rust-snafu-derive+rust_1_61-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+rust_1_65-devel = " \
 cargo \
 rust-snafu+rust_1_61-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+rust_1_81-devel = " \
 cargo \
 rust-snafu+rust_1_65-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+std-devel = " \
 cargo \
 rust-snafu+alloc-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+unstable-core-error-devel = " \
 cargo \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+unstable-provider-api-devel = " \
 cargo \
 rust-snafu-derive+unstable-provider-api-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+unstable-try-trait-devel = " \
 cargo \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu-devel = " \
 bash \
 cargo \
 rust \
 rust-snafu-derive+default-devel \
 "
