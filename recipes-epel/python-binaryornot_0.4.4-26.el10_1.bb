# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-binaryornot"
PV = "0.4.4"
PR = "26.el10_1"
PACKAGES = " \
 python-binaryornot-docs \
 python3-binaryornot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-binaryornot-0.4.4-26.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a951d8667e603a02a3a2df45d40ef3b678d371f5b552753c0cd1f493a5f55aa"

URI_x86_64_v2_python-binaryornot-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-binaryornot-docs-0.4.4-26.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-binaryornot-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-binaryornot-docs}"
SRC_URI[x86_64_v2_python-binaryornot-docs.sha256sum] = "0f5f6a1d5cf6edcea35f77ff093db1d6dfdf0ec0545b0f39b806384d03bc85b8"

URI_x86_64_v2_python3-binaryornot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-binaryornot-0.4.4-26.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-binaryornot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-binaryornot}"
SRC_URI[x86_64_v2_python3-binaryornot.sha256sum] = "9d6a5f630996c66bc5d0c00d048aff2c569b94a1aeaead54ef3704638d1d7004"

URI_aarch64_python-binaryornot-docs = "${EPEL_MIRROR}/aarch64/Packages/p/python-binaryornot-docs-0.4.4-26.el10_1.noarch.rpm;name=aarch64_python-binaryornot-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-binaryornot-docs}"
SRC_URI[aarch64_python-binaryornot-docs.sha256sum] = "32f3709541da022f7438d8249aa0f4757bd4ee9d27657bb11baf10bac5805eb4"

URI_aarch64_python3-binaryornot = "${EPEL_MIRROR}/aarch64/Packages/p/python3-binaryornot-0.4.4-26.el10_1.noarch.rpm;name=aarch64_python3-binaryornot;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-binaryornot}"
SRC_URI[aarch64_python3-binaryornot.sha256sum] = "a84afa83efc43a0266a3aa5c8c96b79f40fbbe2d0942ebe2062d3cb326b5fc7c"

RDEPENDS:python-binaryornot-docs = " \
 "
RDEPENDS:python3-binaryornot = " \
 python3 \
 python3-chardet \
 "
