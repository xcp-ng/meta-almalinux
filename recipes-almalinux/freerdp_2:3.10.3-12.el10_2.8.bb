# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freerdp"
PE = "2"
PV = "3.10.3"
PR = "12.el10_2.8"
PACKAGES = " \
 freerdp \
 freerdp-devel \
 freerdp-libs \
 freerdp-server \
 libwinpr \
 libwinpr-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/freerdp-3.10.3-12.el10_2.8.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7a566ebaf1da8efb893360feddeb25711bc4bf97944db59c1e8a6d2e45a89ce"

URI_x86_64_v2_freerdp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freerdp-3.10.3-12.el10_2.8.x86_64_v2.rpm;name=x86_64_v2_freerdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp}"
SRC_URI[x86_64_v2_freerdp.sha256sum] = "10d440b689bfca614616a858fe81fca53221b49709f7bcb8cdae418bbb3701a0"

URI_x86_64_v2_freerdp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freerdp-devel-3.10.3-12.el10_2.8.x86_64_v2.rpm;name=x86_64_v2_freerdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp-devel}"
SRC_URI[x86_64_v2_freerdp-devel.sha256sum] = "811f1e3ef40b86714a42b340b548e161ffda0050ed06c873d48bdc095fd21918"

URI_x86_64_v2_freerdp-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freerdp-libs-3.10.3-12.el10_2.8.x86_64_v2.rpm;name=x86_64_v2_freerdp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp-libs}"
SRC_URI[x86_64_v2_freerdp-libs.sha256sum] = "073d3c0a9ba078f3f2f1631c80c297696354705aed4b87bfe12cbccbcc232826"

URI_x86_64_v2_freerdp-server = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freerdp-server-3.10.3-12.el10_2.8.x86_64_v2.rpm;name=x86_64_v2_freerdp-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp-server}"
SRC_URI[x86_64_v2_freerdp-server.sha256sum] = "567be7828c4043fd2d546da035812702c2648cc7cbc708c60e9dc486e475582f"

URI_x86_64_v2_libwinpr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwinpr-3.10.3-12.el10_2.8.x86_64_v2.rpm;name=x86_64_v2_libwinpr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwinpr}"
SRC_URI[x86_64_v2_libwinpr.sha256sum] = "e54bb73d25ea5dc566192397b2a99c71949301a47bbc17f247419c8d41b04c0d"

URI_x86_64_v2_libwinpr-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwinpr-devel-3.10.3-12.el10_2.8.x86_64_v2.rpm;name=x86_64_v2_libwinpr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwinpr-devel}"
SRC_URI[x86_64_v2_libwinpr-devel.sha256sum] = "7cb83c06589c27364569239a5eb521f07b403435bbe5dfefa7461714e49e63ad"

URI_aarch64_freerdp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freerdp-3.10.3-12.el10_2.8.aarch64.rpm;name=aarch64_freerdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp}"
SRC_URI[aarch64_freerdp.sha256sum] = "4650cecde09e307c1dafce84d0138eb6e3116c21714729bc3878b93b8d4f2ff3"

URI_aarch64_freerdp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freerdp-devel-3.10.3-12.el10_2.8.aarch64.rpm;name=aarch64_freerdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp-devel}"
SRC_URI[aarch64_freerdp-devel.sha256sum] = "99a8a2868c8a85f3132e3a897c0d90bb7e0f5359c162a67790bf5781b6f8b784"

URI_aarch64_freerdp-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freerdp-libs-3.10.3-12.el10_2.8.aarch64.rpm;name=aarch64_freerdp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp-libs}"
SRC_URI[aarch64_freerdp-libs.sha256sum] = "0cb124937e6d186599910ac7aae8074f9100ac1e53bb93f8dcd3b45e5351dd3b"

URI_aarch64_freerdp-server = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freerdp-server-3.10.3-12.el10_2.8.aarch64.rpm;name=aarch64_freerdp-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp-server}"
SRC_URI[aarch64_freerdp-server.sha256sum] = "18ed90d5c37d10412115660520d430a230b2a6f1f511802d107e4bee4823c396"

URI_aarch64_libwinpr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwinpr-3.10.3-12.el10_2.8.aarch64.rpm;name=aarch64_libwinpr;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwinpr}"
SRC_URI[aarch64_libwinpr.sha256sum] = "bc41947dc0aeb51f1e50f99a9dba0e652b12ffca7187870268b664a26e419b95"

URI_aarch64_libwinpr-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwinpr-devel-3.10.3-12.el10_2.8.aarch64.rpm;name=aarch64_libwinpr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwinpr-devel}"
SRC_URI[aarch64_libwinpr-devel.sha256sum] = "5a10eba08f6513c1da7b5ca7c9bbecfce299007a90246740a9f23835b5d44728"

RDEPENDS:freerdp = " \
 freerdp-libs \
 glibc \
 libX11 \
 libXcursor \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libXrender \
 libwayland-client \
 libwayland-cursor \
 libwinpr \
 libxkbcommon \
 "
RDEPENDS:freerdp-devel = " \
 cmake \
 cmake-filesystem \
 freerdp-devel \
 freerdp-libs \
 libwinpr-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:freerdp-libs = " \
 alsa-lib \
 cairo \
 cups-libs \
 fdk-aac-free \
 fuse3-libs \
 glibc \
 gsm \
 lame-libs \
 libX11 \
 libXdamage \
 libXext \
 libXfixes \
 libXinerama \
 libXtst \
 libgcc \
 libstdc++ \
 libusb1 \
 libwinpr \
 libxkbfile \
 openssl-libs \
 opus \
 pam-libs \
 pulseaudio-libs \
 zlib-ng-compat \
 "
RDEPENDS:freerdp-server = " \
 freerdp-libs \
 glibc \
 libwinpr \
 "
RDEPENDS:libwinpr = " \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libicu \
 libjpeg-turbo \
 libpng \
 libwebp \
 openssl-libs \
 "
RDEPENDS:libwinpr-devel = " \
 cmake \
 cmake-filesystem \
 libwinpr \
 libwinpr-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
