# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgedit-gfls"
PV = "0.2.1"
PR = "1.el10_0"
PACKAGES = " \
 libgedit-gfls \
 libgedit-gfls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgedit-gfls-0.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd556e9ad108e569ad84b75d324117dc494d862525dbfe4d2b89641b8ffc198a"

URI_x86_64_v2_libgedit-gfls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-gfls-0.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-gfls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-gfls}"
SRC_URI[x86_64_v2_libgedit-gfls.sha256sum] = "b8534a1b88e4ea1ce633b03f9758682d5c9e3a8f2c7c3d6df00687019949ff39"

URI_x86_64_v2_libgedit-gfls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-gfls-devel-0.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-gfls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-gfls-devel}"
SRC_URI[x86_64_v2_libgedit-gfls-devel.sha256sum] = "d3e82d0ba5c3e2a17874d6cbbedfda837322999ac3c614615b5313e69bcba72b"

URI_aarch64_libgedit-gfls = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-gfls-0.2.1-1.el10_0.aarch64.rpm;name=aarch64_libgedit-gfls;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-gfls}"
SRC_URI[aarch64_libgedit-gfls.sha256sum] = "5dcd46c5fd2d3498130e760fbac0b72e81fb9ffd6a37b288735f551a19b83736"

URI_aarch64_libgedit-gfls-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-gfls-devel-0.2.1-1.el10_0.aarch64.rpm;name=aarch64_libgedit-gfls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-gfls-devel}"
SRC_URI[aarch64_libgedit-gfls-devel.sha256sum] = "b2abb6f1d59f97cd9dacd41fa96d17ff02836001c69159b0c19f9021a14641d3"

RDEPENDS:libgedit-gfls = " \
 glib2 \
 glibc \
 "
RDEPENDS:libgedit-gfls-devel = " \
 glib2-devel \
 libgedit-gfls \
 pkgconf-pkg-config \
 "
