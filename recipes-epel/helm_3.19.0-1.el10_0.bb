# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "helm"
PV = "3.19.0"
PR = "1.el10_0"
PACKAGES = " \
 helm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/helm-3.19.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c37ed491830e193165d935a8c823fa8091d1e4c864e770d0a139fbee87a9f323"

URI_x86_64_v2_helm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/helm-3.19.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_helm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_helm}"
SRC_URI[x86_64_v2_helm.sha256sum] = "92ccf40b89a43f9114f044a7cc91dc14bf949a179056975801e0d01dcf9c0f64"

URI_aarch64_helm = "${EPEL_MIRROR}/aarch64/Packages/h/helm-3.19.0-1.el10_0.aarch64.rpm;name=aarch64_helm;unpack=0"
SRC_URI:append = " ${URI_aarch64_helm}"
SRC_URI[aarch64_helm.sha256sum] = "00e3c2b07642435b3884c5e5be7d324d7cc0f7c879ec4ad203cf50bfb98e5193"

RDEPENDS:helm = " \
 glibc \
 "
