# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-automod"
PV = "1.0.17"
PR = "1.el10_3"
PACKAGES = " \
 rust-automod+default-devel \
 rust-automod-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-automod-1.0.17-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e68354cfdd7bf907d96dfed799818a969a9257f191536da102fc50dde2eaaa3"

URI_x86_64_v2_rust-automod+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-automod+default-devel-1.0.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-automod+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-automod+default-devel}"
SRC_URI[x86_64_v2_rust-automod+default-devel.sha256sum] = "22aa4225b1ed358d810f632498cd1751c754dfcaffc2181b08b63e7b4fcb73c6"

URI_x86_64_v2_rust-automod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-automod-devel-1.0.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-automod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-automod-devel}"
SRC_URI[x86_64_v2_rust-automod-devel.sha256sum] = "99b803351afcae2599cea8a75d501f087c5c859af158b8af011033192c59a793"

URI_aarch64_rust-automod+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-automod+default-devel-1.0.17-1.el10_3.noarch.rpm;name=aarch64_rust-automod+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-automod+default-devel}"
SRC_URI[aarch64_rust-automod+default-devel.sha256sum] = "03c6defebacee780872499d6b08c2d38b1fd2953e4202c86aabd843eb99f9e66"

URI_aarch64_rust-automod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-automod-devel-1.0.17-1.el10_3.noarch.rpm;name=aarch64_rust-automod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-automod-devel}"
SRC_URI[aarch64_rust-automod-devel.sha256sum] = "18258698acdbb68839a2f6e00fbff51cb5a281d2fbce8d27ebcb8b555a13987d"

RDEPENDS:rust-automod+default-devel = " \
 cargo \
 rust-automod-devel \
 "
RDEPENDS:rust-automod-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
