# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vaultwarden-web"
PV = "2026.6.4"
PR = "1.el10_3"
PACKAGES = " \
 vaultwarden-web \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vaultwarden-web-2026.6.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66dc0202207d188112364b9730545ad8cca3bdab6aa62ed16e93ff5d5568bcbc"

URI_x86_64_v2_vaultwarden-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vaultwarden-web-2026.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_vaultwarden-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vaultwarden-web}"
SRC_URI[x86_64_v2_vaultwarden-web.sha256sum] = "2430b44368193347b9546487ed473507f64ddebc69df833f59696e0447cd9426"

URI_aarch64_vaultwarden-web = "${EPEL_MIRROR}/aarch64/Packages/v/vaultwarden-web-2026.6.4-1.el10_3.noarch.rpm;name=aarch64_vaultwarden-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_vaultwarden-web}"
SRC_URI[aarch64_vaultwarden-web.sha256sum] = "fe0091cee558143acfd5a001ae191a35bd2ceba61b5deeb574df8cc3992d0ea4"

RDEPENDS:vaultwarden-web = " \
 "
