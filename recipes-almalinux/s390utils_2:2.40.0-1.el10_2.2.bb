# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "s390utils"
PE = "2"
PV = "2.40.0"
PR = "1.el10_2.2"
PACKAGES = " \
 s390utils \
 s390utils-se-data \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/s390utils-2.40.0-1.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "712391d83fefe7e7c379ea0299066950b1210bea16976f8974552c9ff4aefd5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/s390utils-2.40.0-1.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_s390utils;unpack=0"
SRC_URI[x86_64_v2_s390utils.sha256sum] = "f550bdff72576cbdffe744c52a2ece4873384732638869f653affe38a77f5b25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/s390utils-se-data-2.40.0-1.el10_2.2.noarch.rpm;name=x86_64_v2_s390utils-se-data;unpack=0"
SRC_URI[x86_64_v2_s390utils-se-data.sha256sum] = "a3ae17b2aa96eb69662d96b5e8c080c7d7e8d29e9778644625c3f0f88dfafa8b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/s390utils-2.40.0-1.el10_2.2.aarch64.rpm;name=aarch64_s390utils;unpack=0"
SRC_URI[aarch64_s390utils.sha256sum] = "9e30a559b0c645b5f492eb007e09078a9575bff6176eb11d57786d95ec707ad0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/s390utils-se-data-2.40.0-1.el10_2.2.noarch.rpm;name=aarch64_s390utils-se-data;unpack=0"
SRC_URI[aarch64_s390utils-se-data.sha256sum] = "a3ae17b2aa96eb69662d96b5e8c080c7d7e8d29e9778644625c3f0f88dfafa8b"

RDEPENDS:s390utils = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 s390utils-se-data \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:s390utils-se-data = " \
 "
