# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-new_debug_unreachable"
PV = "1.0.6"
PR = "2.el10_0"
PACKAGES = " \
 rust-new_debug_unreachable+default-devel \
 rust-new_debug_unreachable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-new_debug_unreachable-1.0.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43792f1aa67afe6dfa2030b6872abf61f297b332d3b172339237ab00594a4a13"

URI_x86_64_v2_rust-new_debug_unreachable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-new_debug_unreachable+default-devel-1.0.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-new_debug_unreachable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-new_debug_unreachable+default-devel}"
SRC_URI[x86_64_v2_rust-new_debug_unreachable+default-devel.sha256sum] = "9d5d33d58aa7ea841923ef2eff1aada38ea368b610e343da38b9df1b5d09f5e4"

URI_x86_64_v2_rust-new_debug_unreachable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-new_debug_unreachable-devel-1.0.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-new_debug_unreachable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-new_debug_unreachable-devel}"
SRC_URI[x86_64_v2_rust-new_debug_unreachable-devel.sha256sum] = "a92a527c20fbf0f8260aba0e47ec846c9f9472be819d5cf473ff5a1390a4a6cc"

URI_aarch64_rust-new_debug_unreachable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-new_debug_unreachable+default-devel-1.0.6-2.el10_0.noarch.rpm;name=aarch64_rust-new_debug_unreachable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-new_debug_unreachable+default-devel}"
SRC_URI[aarch64_rust-new_debug_unreachable+default-devel.sha256sum] = "ccd82c632544ee91f96b77fa55ad3bbd5438937b5bae413cd4a3f16842e2f45b"

URI_aarch64_rust-new_debug_unreachable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-new_debug_unreachable-devel-1.0.6-2.el10_0.noarch.rpm;name=aarch64_rust-new_debug_unreachable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-new_debug_unreachable-devel}"
SRC_URI[aarch64_rust-new_debug_unreachable-devel.sha256sum] = "bb695d1d85414ce99edb0bba1227951241f9b630bdb55438923fbbf1d81ab0c8"

RDEPENDS:rust-new_debug_unreachable+default-devel = " \
 cargo \
 rust-new_debug_unreachable-devel \
 "
RDEPENDS:rust-new_debug_unreachable-devel = " \
 cargo \
 "
