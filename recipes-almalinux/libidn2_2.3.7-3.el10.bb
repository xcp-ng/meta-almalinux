# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libidn2"
PV = "2.3.7"
PR = "3.el10"
PACKAGES = " \
 idn2 \
 libidn2 \
 libidn2-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libidn2-2.3.7-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa83bdd419c8c6364d039daf524eaacc15edd1be020396fb174cd8e80b21d76f"

URI_x86_64_v2_idn2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idn2-2.3.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_idn2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idn2}"
SRC_URI[x86_64_v2_idn2.sha256sum] = "f739efba97cea32a5a4425bbe18a31937ec724b486e1638d960234f4a397452d"

URI_x86_64_v2_libidn2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libidn2-2.3.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_libidn2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libidn2}"
SRC_URI[x86_64_v2_libidn2.sha256sum] = "cf11ba9b604d4729b7c6c5d7e54eda60282412b2d9ca4b8b661c4222de146a73"

URI_x86_64_v2_libidn2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libidn2-devel-2.3.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_libidn2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libidn2-devel}"
SRC_URI[x86_64_v2_libidn2-devel.sha256sum] = "cd9451a4d2b360bac2f62dda5cb7190c13a5cff3a4eab363e4cce81695522e92"

URI_aarch64_idn2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idn2-2.3.7-3.el10.aarch64.rpm;name=aarch64_idn2;unpack=0"
SRC_URI:append = " ${URI_aarch64_idn2}"
SRC_URI[aarch64_idn2.sha256sum] = "b3a8c615c53da5846171bda4f6fbf1c5fbda476c14f51e475b53e156dd922442"

URI_aarch64_libidn2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libidn2-2.3.7-3.el10.aarch64.rpm;name=aarch64_libidn2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libidn2}"
SRC_URI[aarch64_libidn2.sha256sum] = "c1b303786923dadf259477d2f09e716b9f747c8b7ab1277f32f5c4cd0d537990"

URI_aarch64_libidn2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libidn2-devel-2.3.7-3.el10.aarch64.rpm;name=aarch64_libidn2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libidn2-devel}"
SRC_URI[aarch64_libidn2-devel.sha256sum] = "4c60ac591483d49deec95ad9180aafcc2f80809a4072b2c9bed0419688a0baae"

RDEPENDS:idn2 = " \
 glibc \
 libidn2 \
 libunistring \
 "
RDEPENDS:libidn2 = " \
 glibc \
 libunistring \
 "
RDEPENDS:libidn2-devel = " \
 libidn2 \
 pkgconf-pkg-config \
 "
