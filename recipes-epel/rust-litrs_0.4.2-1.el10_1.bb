# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-litrs"
PV = "0.4.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-litrs+check_suffix-devel \
 rust-litrs+default-devel \
 rust-litrs+proc-macro2-devel \
 rust-litrs+unicode-xid-devel \
 rust-litrs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-litrs-0.4.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "479723d2ff0565ee62511dc5d6b05fff14479bc38ecf71a34ebe129b5812928a"

URI_x86_64_v2_rust-litrs+check_suffix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs+check_suffix-devel-0.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs+check_suffix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs+check_suffix-devel}"
SRC_URI[x86_64_v2_rust-litrs+check_suffix-devel.sha256sum] = "ee8247f22fafe9270a8e537436394a15f710c258852c1f8acfe2bff904de49b5"

URI_x86_64_v2_rust-litrs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs+default-devel-0.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs+default-devel}"
SRC_URI[x86_64_v2_rust-litrs+default-devel.sha256sum] = "2d0298f91e2dd806664c6588eaacf3625bcb6f15adfc239a34c4c0c1b9a0c7f1"

URI_x86_64_v2_rust-litrs+proc-macro2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs+proc-macro2-devel-0.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs+proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs+proc-macro2-devel}"
SRC_URI[x86_64_v2_rust-litrs+proc-macro2-devel.sha256sum] = "65c3ba359eaeb8d6238c16401336b4139caa52159aef07f069eafad29abb28bc"

URI_x86_64_v2_rust-litrs+unicode-xid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs+unicode-xid-devel-0.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs+unicode-xid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs+unicode-xid-devel}"
SRC_URI[x86_64_v2_rust-litrs+unicode-xid-devel.sha256sum] = "7cfe337f79ac1cb06deabb33e9f8694869a8d7e7434df82eaf2e991b52f6f5c2"

URI_x86_64_v2_rust-litrs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs-devel-0.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs-devel}"
SRC_URI[x86_64_v2_rust-litrs-devel.sha256sum] = "29b41e35c7c7d71fae8854d3edd016267b90b8fc9af51378375e226c99815eab"

URI_aarch64_rust-litrs+check_suffix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs+check_suffix-devel-0.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-litrs+check_suffix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs+check_suffix-devel}"
SRC_URI[aarch64_rust-litrs+check_suffix-devel.sha256sum] = "d29007935f89fe526ec3946992545473df6f327e7336f9cf849a73f3de86a71e"

URI_aarch64_rust-litrs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs+default-devel-0.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-litrs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs+default-devel}"
SRC_URI[aarch64_rust-litrs+default-devel.sha256sum] = "e35be8bfa6e9001b2c1e9625084ac6b934e05d8c9679251a8a0b9ccd24479b1b"

URI_aarch64_rust-litrs+proc-macro2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs+proc-macro2-devel-0.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-litrs+proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs+proc-macro2-devel}"
SRC_URI[aarch64_rust-litrs+proc-macro2-devel.sha256sum] = "c588bf6ae5d8d4ab813ea5af4fc4d0e6c29ab5c485608ab763446da4cf200837"

URI_aarch64_rust-litrs+unicode-xid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs+unicode-xid-devel-0.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-litrs+unicode-xid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs+unicode-xid-devel}"
SRC_URI[aarch64_rust-litrs+unicode-xid-devel.sha256sum] = "60094c6e7b92cbc21742be85cf9619e4b83968d672fcc615b7208dfde07fa9d9"

URI_aarch64_rust-litrs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs-devel-0.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-litrs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs-devel}"
SRC_URI[aarch64_rust-litrs-devel.sha256sum] = "e4e7295fa2d4436141b965ea2498d9a9dc053c0c1e778ede37e5f8c922e02d50"

RDEPENDS:rust-litrs+check_suffix-devel = " \
 cargo \
 rust-litrs+unicode-xid-devel \
 rust-litrs-devel \
 "
RDEPENDS:rust-litrs+default-devel = " \
 cargo \
 rust-litrs+proc-macro2-devel \
 rust-litrs-devel \
 "
RDEPENDS:rust-litrs+proc-macro2-devel = " \
 cargo \
 rust-litrs-devel \
 rust-proc-macro2+default-devel \
 "
RDEPENDS:rust-litrs+unicode-xid-devel = " \
 cargo \
 rust-litrs-devel \
 rust-unicode-xid+default-devel \
 "
RDEPENDS:rust-litrs-devel = " \
 cargo \
 rust \
 "
