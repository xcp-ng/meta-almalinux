# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-supports-hyperlinks"
PV = "3.2.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-supports-hyperlinks+default-devel \
 rust-supports-hyperlinks-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-supports-hyperlinks-3.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6aa7fed81f6adde0687b013a303adf8fd39223d436e2aea893ee567cb4a73327"

URI_x86_64_v2_rust-supports-hyperlinks+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-supports-hyperlinks+default-devel-3.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-supports-hyperlinks+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-supports-hyperlinks+default-devel}"
SRC_URI[x86_64_v2_rust-supports-hyperlinks+default-devel.sha256sum] = "9152fb848f3bc1b2dcec21b29f1001c3c0a22808dd816174cae7bdece21d4976"

URI_x86_64_v2_rust-supports-hyperlinks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-supports-hyperlinks-devel-3.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-supports-hyperlinks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-supports-hyperlinks-devel}"
SRC_URI[x86_64_v2_rust-supports-hyperlinks-devel.sha256sum] = "a4fbf0e6b6c24f142407dc9fd9ee69f4df49349f67082bda5b14b9ccbbf1d24f"

URI_aarch64_rust-supports-hyperlinks+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-supports-hyperlinks+default-devel-3.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-supports-hyperlinks+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-supports-hyperlinks+default-devel}"
SRC_URI[aarch64_rust-supports-hyperlinks+default-devel.sha256sum] = "16bdf0bd9e75d8504d88d0ed8b44bc0c981e41fc83b75521e92baa155d796411"

URI_aarch64_rust-supports-hyperlinks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-supports-hyperlinks-devel-3.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-supports-hyperlinks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-supports-hyperlinks-devel}"
SRC_URI[aarch64_rust-supports-hyperlinks-devel.sha256sum] = "9d7e7522d144c2f68955ccb41bcf09930f2c8d06d9e7578037a9228e0e1cbb54"

RDEPENDS:rust-supports-hyperlinks+default-devel = " \
 cargo \
 rust-supports-hyperlinks-devel \
 "
RDEPENDS:rust-supports-hyperlinks-devel = " \
 cargo \
 rust \
 "
