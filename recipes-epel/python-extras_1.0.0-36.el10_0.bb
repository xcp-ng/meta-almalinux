# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-extras"
PV = "1.0.0"
PR = "36.el10_0"
PACKAGES = " \
 python3-extras \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-extras-1.0.0-36.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a46f7746f0685bf4d0546810f4a5500b6783696bf1d5769b4ec74547d36ce6b"

URI_x86_64_v2_python3-extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-extras-1.0.0-36.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-extras}"
SRC_URI[x86_64_v2_python3-extras.sha256sum] = "c101bea6f286ee860fcd074aa2e97cb94d716a122eb1c803cca928fe24369d6b"

URI_aarch64_python3-extras = "${EPEL_MIRROR}/aarch64/Packages/p/python3-extras-1.0.0-36.el10_0.noarch.rpm;name=aarch64_python3-extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-extras}"
SRC_URI[aarch64_python3-extras.sha256sum] = "0b1c08542bfd14d6722795044e59d55b5b182bf264fc6fc420dedb4266a603e5"

RDEPENDS:python3-extras = " \
 python3 \
 "
