# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-oauth"
PV = "2.0.10"
PR = "1.el10_1"
PACKAGES = " \
 php-pecl-oauth \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-pecl-oauth-2.0.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "620f45ea2838c1719791439d15aa408d455453ce17cc2d6668d077c4bb2d393e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-oauth-2.0.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-oauth;unpack=0"
SRC_URI[x86_64_v2_php-pecl-oauth.sha256sum] = "dc907d1a3823739e1383676e1c7b7ca628008a681908cc4e10f58dd86b895ca8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-oauth-2.0.10-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-oauth;unpack=0"
SRC_URI[aarch64_php-pecl-oauth.sha256sum] = "b6d7094b378e51c0ac7c719da38f6c53b18787d6b0e65458f3ef6b060c0a8842"

RDEPENDS:php-pecl-oauth = " \
 glibc \
 php-common \
 virtual/libcurl.so.4___64bit_ \
 "
