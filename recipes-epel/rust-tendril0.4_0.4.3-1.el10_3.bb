# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tendril0.4"
PV = "0.4.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-tendril0.4+bench-devel \
 rust-tendril0.4+default-devel \
 rust-tendril0.4+encoding_rs-devel \
 rust-tendril0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tendril0.4-0.4.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "360c70b40a62cb2ac4cb7a794c49f16521348efc040292c41cd47235dd0ef61e"

URI_x86_64_v2_rust-tendril0.4+bench-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tendril0.4+bench-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tendril0.4+bench-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tendril0.4+bench-devel}"
SRC_URI[x86_64_v2_rust-tendril0.4+bench-devel.sha256sum] = "dcb327cc880bcf95214425bea8a79a669c49c2c8bd46ff71347f10d4c0db4789"

URI_x86_64_v2_rust-tendril0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tendril0.4+default-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tendril0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tendril0.4+default-devel}"
SRC_URI[x86_64_v2_rust-tendril0.4+default-devel.sha256sum] = "fd8d8ef7832b85ce60e717b54ba6de1791cb0c6010f2f86beee457e6e5aa16ec"

URI_x86_64_v2_rust-tendril0.4+encoding_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tendril0.4+encoding_rs-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tendril0.4+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tendril0.4+encoding_rs-devel}"
SRC_URI[x86_64_v2_rust-tendril0.4+encoding_rs-devel.sha256sum] = "fd3a8e9fe5481277a94090abe5787312b2a3fd9af7e1f6e18bb66ca953a64950"

URI_x86_64_v2_rust-tendril0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tendril0.4-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tendril0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tendril0.4-devel}"
SRC_URI[x86_64_v2_rust-tendril0.4-devel.sha256sum] = "0a823e7cc9a3b7c4f66dc132d86e20de4c63c0acda06316efc39f1274750935f"

URI_aarch64_rust-tendril0.4+bench-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tendril0.4+bench-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-tendril0.4+bench-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tendril0.4+bench-devel}"
SRC_URI[aarch64_rust-tendril0.4+bench-devel.sha256sum] = "9775961b718a77558d019afe8b3d57707b86471d755ef18fb2b5a80f4c792b72"

URI_aarch64_rust-tendril0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tendril0.4+default-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-tendril0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tendril0.4+default-devel}"
SRC_URI[aarch64_rust-tendril0.4+default-devel.sha256sum] = "301adf734cf6f00eb20c0cf55e16b76928980e8b8c9c63c6016f08fac7f5bc18"

URI_aarch64_rust-tendril0.4+encoding_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tendril0.4+encoding_rs-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-tendril0.4+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tendril0.4+encoding_rs-devel}"
SRC_URI[aarch64_rust-tendril0.4+encoding_rs-devel.sha256sum] = "d44d5c57b60abd5bf5dbcd4d34e5d0c1c9b02ae05a4d0ab072a8fe8db985b186"

URI_aarch64_rust-tendril0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tendril0.4-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-tendril0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tendril0.4-devel}"
SRC_URI[aarch64_rust-tendril0.4-devel.sha256sum] = "88b049dbc7a025c98351046b16f8f64092bf9726129b44d55d50b6cce395237c"

RDEPENDS:rust-tendril0.4+bench-devel = " \
 cargo \
 rust-tendril0.4-devel \
 "
RDEPENDS:rust-tendril0.4+default-devel = " \
 cargo \
 rust-tendril0.4-devel \
 "
RDEPENDS:rust-tendril0.4+encoding_rs-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-tendril0.4-devel \
 "
RDEPENDS:rust-tendril0.4-devel = " \
 cargo \
 rust-futf+default-devel \
 rust-mac+default-devel \
 rust-utf-8+default-devel \
 "
