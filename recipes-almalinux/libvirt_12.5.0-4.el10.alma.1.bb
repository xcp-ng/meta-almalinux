# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvirt"
PV = "12.5.0"
PR = "4.el10.alma.1"
PACKAGES = " \
 libvirt \
 libvirt-client \
 libvirt-client-qemu \
 libvirt-daemon \
 libvirt-daemon-common \
 libvirt-daemon-config-network \
 libvirt-daemon-config-nwfilter \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-daemon-driver-storage-core \
 libvirt-daemon-driver-storage-disk \
 libvirt-daemon-driver-storage-iscsi \
 libvirt-daemon-driver-storage-logical \
 libvirt-daemon-driver-storage-mpath \
 libvirt-daemon-driver-storage-rbd \
 libvirt-daemon-driver-storage-scsi \
 libvirt-daemon-kvm \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-plugin-sanlock \
 libvirt-daemon-proxy \
 libvirt-devel \
 libvirt-docs \
 libvirt-libs \
 libvirt-nss \
 libvirt-ssh-proxy \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvirt-12.5.0-4.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "121aa21ab69221e84c74617813a7ca8fc51d90ab90ec14a55521c8f0b57a0d7a"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - libvirt-daemon-plugin-sanlock: augeas

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - libvirt-daemon-plugin-sanlock: augeas

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt;unpack=0"
SRC_URI[x86_64_v2_libvirt.sha256sum] = "d069dee439a30deeac54a501800c6e30205c43466f0688cabdcdf1fd7ee259d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-client-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-client;unpack=0"
SRC_URI[x86_64_v2_libvirt-client.sha256sum] = "53b329824f1dcf79a3ad2d000aa775e2f2f4353d0f3e26ee33a4f884fc329b44"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-client-qemu-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-client-qemu;unpack=0"
SRC_URI[x86_64_v2_libvirt-client-qemu.sha256sum] = "99e052de35806e697c74e9dca82f73812a976864d2462deeb2c36d3dd103f4ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon.sha256sum] = "190d00b7ef38990cb09f1712f3758f40294b92fb4cd44f67b350ba92af8d4030"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-common-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-common;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-common.sha256sum] = "d442c44ebbb6b15dc582d3e4004a7948d651471691473db1341254bfd1cca73b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-config-network-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-config-network;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-config-network.sha256sum] = "752907b63071685196dedada29c1150b46f98ef94b42db87327fc5d25ccf1838"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-config-nwfilter-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-config-nwfilter;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-config-nwfilter.sha256sum] = "5bdf7727d1f2abea114f692910393afe2eae1396132ad517569e630b55382416"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-interface-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-interface;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-interface.sha256sum] = "4f538029f968da224190c8a5f7c2ab1439a6b2d95a4d507f339d9a58e08ac06e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-network-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-network;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-network.sha256sum] = "73374c4857aeb91c4a2170288e39199ba0dc0bd6b2bc31f50e9073a7996bc87a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-nodedev-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-nodedev;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-nodedev.sha256sum] = "60ce1c7281cdc5fcb0dffacde95895c69eef2500b444e4c7a83fa871965d0727"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-nwfilter-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-nwfilter;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-nwfilter.sha256sum] = "23b4ec0530a9172b3d78aaadf859f2419937130c09cc07d3f580985a274148c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-qemu-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-qemu;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-qemu.sha256sum] = "f04163c8eb5bbc0a225ec09efd9e28919fc1cb990955da5549fddbe3c3567bfd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-secret-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-secret;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-secret.sha256sum] = "4a59202912c018184b5fdce33b4e13c988ab9ca7b04f02822433f3c5ecf73675"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage.sha256sum] = "11fcc955ad5a5adb46c0e8a9d6cacd11dda69df80e197f0d016b1e78b02a6770"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-core-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-core;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-core.sha256sum] = "812201b9a5d9b0204343f5f8d74cb0208366ec089abe433a022102488e5277a9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-disk-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-disk;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-disk.sha256sum] = "846fa6ce01b5015280a56cbe05991db520879db3323e75dcbc11589fb19d3a51"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-iscsi-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-iscsi;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-iscsi.sha256sum] = "df66bc9218d9eb2c9d8699de8a433692c12fb51e7c5d27c5ce11a6e09d5db586"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-logical-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-logical;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-logical.sha256sum] = "a6fdb0b818aef9459c0064364b229b3f7a162bc0c5b83f4c723453a7c882e30b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-mpath-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-mpath;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-mpath.sha256sum] = "825d23f2975875039e4773950de99488bfe2d8bd3e805df15222438100d8b232"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-rbd-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-rbd;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-rbd.sha256sum] = "0ab66f8772dd65ce6a6e536972dbbb7abd584d1f1db1bc1b0076da1c3fa2eb25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-scsi-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-scsi;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-scsi.sha256sum] = "5ef712b04d4e94c03ab9fa9941eb37506988657bb1b9af3b8be77b321b74a4b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-kvm-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-kvm;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-kvm.sha256sum] = "9e7a3004d683a5621bb8bfbc434724e2eb3a8c8139a931b213d85e416e591796"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-lock-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-lock;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-lock.sha256sum] = "16fd527f78e4f07fc1398caae02d0e9f8f6a4092bf1f9bd5cc3192df2e9de2fc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-log-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-log;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-log.sha256sum] = "1696162a9ea620cbec47d34bc2e04ad328fc375b5da8b12202dac7fcfc36bd45"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-plugin-lockd-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-plugin-lockd;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-plugin-lockd.sha256sum] = "6a8481bd8304c88b41c862148fadbe2f43583424358fe7305dc15f88051f722a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-daemon-plugin-sanlock-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-plugin-sanlock;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-plugin-sanlock.sha256sum] = "b9191a4a6c2ffc72fd818d211763734812005a9077c0f3c9fe69d938767c6548"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-proxy-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-proxy;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-proxy.sha256sum] = "425c3a52a29d3575fc79c2c5e8351943b1fb7b521cca1ccca7d8565757923b83"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-devel-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-devel;unpack=0"
SRC_URI[x86_64_v2_libvirt-devel.sha256sum] = "935e3f551782db77d89d5fa7ccf71093704bc453856df6f2e39aa4dbf90838d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-docs-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-docs;unpack=0"
SRC_URI[x86_64_v2_libvirt-docs.sha256sum] = "e93ab6b39fd55cad9ea61ce17c56be130a1943fb78049fe1064d571bce7c45e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-libs-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-libs;unpack=0"
SRC_URI[x86_64_v2_libvirt-libs.sha256sum] = "edf758193ee7ae8edab06d1186cb85e074750436829dd3c0f0437d013bf57033"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-nss-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-nss;unpack=0"
SRC_URI[x86_64_v2_libvirt-nss.sha256sum] = "5c219180342741caa9342d7e6240dff214ada6b0b725e0c4133628cbbe544a50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-ssh-proxy-12.5.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-ssh-proxy;unpack=0"
SRC_URI[x86_64_v2_libvirt-ssh-proxy.sha256sum] = "551631e04cfa8c4a8431a29e1d54868f20a504366789b919326ac282b01574c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt;unpack=0"
SRC_URI[aarch64_libvirt.sha256sum] = "d595896581a02bacaa2771b7d74018b95baa1387c66734c5057a41cb86f2ed46"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-client-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-client;unpack=0"
SRC_URI[aarch64_libvirt-client.sha256sum] = "35fd53522c4fdf65d97320caec10b561eb00392ec1b9d0c692e677d250ec6769"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-client-qemu-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-client-qemu;unpack=0"
SRC_URI[aarch64_libvirt-client-qemu.sha256sum] = "c3737ee909a43420444383ca7f22d47e274c5174fc79d209567a1e410c5d9922"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon;unpack=0"
SRC_URI[aarch64_libvirt-daemon.sha256sum] = "5daa44877d39672a155649721bba3e65d6ee097a5c132e01d19fd26c8c6e9da5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-common-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-common;unpack=0"
SRC_URI[aarch64_libvirt-daemon-common.sha256sum] = "48cac2e1fe939d0ad3674cb2b334bb18414dbb102e8a19c8ccce2005a5f93515"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-config-network-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-config-network;unpack=0"
SRC_URI[aarch64_libvirt-daemon-config-network.sha256sum] = "494f19c40158d7f93896a1b048074ae625d1a772369f9aa55661d4413e24e9b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-config-nwfilter-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-config-nwfilter;unpack=0"
SRC_URI[aarch64_libvirt-daemon-config-nwfilter.sha256sum] = "ce95fbfd9337e39cbd59b51528f751cac3a28c24d28092775045736e12e9b130"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-interface-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-interface;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-interface.sha256sum] = "fd51fc7526fc74c7eb8bd5632e35704e650a9fc57d7f78c46606ac43584469b5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-network-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-network;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-network.sha256sum] = "4363863a956fd8c3c661483430e5a2d32fd9cccb2d984488023ec8499bf7005e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-nodedev-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-nodedev;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-nodedev.sha256sum] = "56ce2418131da496ba23348f181f96227669afe37290614d9e5c0505f793480a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-nwfilter-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-nwfilter;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-nwfilter.sha256sum] = "480b445cc15e26ff83f69dd679550601bb5b981601a22c115f70928f4d486c59"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-qemu-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-qemu;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-qemu.sha256sum] = "d767602ccdd416e7389766bb81fd9a6edea137c4f5b9799a73d695776ca5e616"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-secret-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-secret;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-secret.sha256sum] = "1b976ac82352f235218a394c0a561629b6deb14e3bb3ee261d378fc533c64e41"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage.sha256sum] = "438c440e60013e257b5ee18bd3c0ea67780284c027fbe56669b0ba6707526b3d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-core-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-core;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage-core.sha256sum] = "d85dc54b626fb38395aa51970c3c535a5109f1c0270374c74999f3f942d7bb6a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-disk-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-disk;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage-disk.sha256sum] = "02d5cf70dc6121e30aff36bda068ccaa9fd0e4389382eb26328e025431db983e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-iscsi-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-iscsi;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage-iscsi.sha256sum] = "ce6d280608d1634aa64c173968aefbd982d6b67cf72ae8bc5dfb4767b0726d50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-logical-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-logical;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage-logical.sha256sum] = "6011e85ebc98daed08df4912e7007a045f03dac62ce4b8ed635140626be18044"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-mpath-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-mpath;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage-mpath.sha256sum] = "1e540e96f4d3f14ac05f53096c409864705fdde214f4d0e856a9e02dfeeb4003"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-rbd-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-rbd;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage-rbd.sha256sum] = "4883050bcda23cfe0d4da9f2769da5209f17ae71a5bbd378d59b65a7597655a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-scsi-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-scsi;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage-scsi.sha256sum] = "129dd5be22e199aa979d88fe5f286c64a42dbd539c8eedad229f6e045b185ff7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-kvm-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-kvm;unpack=0"
SRC_URI[aarch64_libvirt-daemon-kvm.sha256sum] = "8b0292f5fcb1537a9ccc89a8de29176cb88dd988edb66694bd0a832fda2cc367"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-lock-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-lock;unpack=0"
SRC_URI[aarch64_libvirt-daemon-lock.sha256sum] = "389e71d65cb9ceafd403873a8a6f860c5753989c9d2f882e9e60643ccb2b983d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-log-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-log;unpack=0"
SRC_URI[aarch64_libvirt-daemon-log.sha256sum] = "49857511f5ee1e4140213b3fa577ef25ff0a7f962b6035d442e05061415617f7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-plugin-lockd-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-plugin-lockd;unpack=0"
SRC_URI[aarch64_libvirt-daemon-plugin-lockd.sha256sum] = "c749886e9a9dfe7068642b8dde86b19df82927435df1d50c4ac76afb6f176b17"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-daemon-plugin-sanlock-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-plugin-sanlock;unpack=0"
SRC_URI[aarch64_libvirt-daemon-plugin-sanlock.sha256sum] = "b575d27d9b43eb3427fddc919d17c14401e73bcb5246f08f90f9fa00e4682967"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-proxy-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-proxy;unpack=0"
SRC_URI[aarch64_libvirt-daemon-proxy.sha256sum] = "68673f5040b82f1732a3f38b1c74710901a5310508515ef4514f927775dbf842"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-devel-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-devel;unpack=0"
SRC_URI[aarch64_libvirt-devel.sha256sum] = "b59218e5950eb995d2104f03a6bbdd12234c100146ad8f8cdf405bf27db79f6a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-docs-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-docs;unpack=0"
SRC_URI[aarch64_libvirt-docs.sha256sum] = "940277f34bbb1cb4b329541a3786627a71c79f59c0ade61fdb7f10053b9cf009"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-libs-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-libs;unpack=0"
SRC_URI[aarch64_libvirt-libs.sha256sum] = "4f4d81d88d8ad3c432ce051722541693c216bf472ba99b255822a17c24aa652b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-nss-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-nss;unpack=0"
SRC_URI[aarch64_libvirt-nss.sha256sum] = "b5a5659bc2a433be0254c38300dabb1797b3b10afd3753f0896393020daf4734"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-ssh-proxy-12.5.0-4.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-ssh-proxy;unpack=0"
SRC_URI[aarch64_libvirt-ssh-proxy.sha256sum] = "0c9ec4f805060775a268918cc7ba1684590906a887af0f847eb2e6b9b2905277"

RDEPENDS:libvirt = " \
 libvirt-client \
 libvirt-client-qemu \
 libvirt-daemon \
 libvirt-daemon-config-network \
 libvirt-daemon-config-nwfilter \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-libs \
 "
RDEPENDS:libvirt-client = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 libvirt-libs \
 libxml2 \
 readline \
 "
RDEPENDS:libvirt-client-qemu = " \
 libvirt-libs \
 python3 \
 python3-cryptography \
 python3-libvirt \
 python3-lxml \
 "
RDEPENDS:libvirt-daemon = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-proxy \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-common = " \
 bash \
 dbus \
 dmidecode \
 gettext \
 glib2 \
 glibc \
 iproute \
 iproute-tc \
 kmod \
 libacl \
 libgcc \
 libvirt-libs \
 polkit \
 readline \
 shadow-utils \
 systemd \
 "
RDEPENDS:libvirt-daemon-config-network = " \
 bash \
 libvirt-daemon-driver-network \
 "
RDEPENDS:libvirt-daemon-config-nwfilter = " \
 bash \
 libvirt-daemon-driver-nwfilter \
 "
RDEPENDS:libvirt-daemon-driver-interface = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 systemd-libs \
 "
RDEPENDS:libvirt-daemon-driver-network = " \
 bash \
 dnsmasq \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 nftables \
 "
RDEPENDS:libvirt-daemon-driver-nodedev = " \
 bash \
 glib2 \
 glibc \
 kmod \
 libgcc \
 libpciaccess \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 mdevctl \
 systemd \
 systemd-libs \
 "
RDEPENDS:libvirt-daemon-driver-nwfilter = " \
 bash \
 glib2 \
 glibc \
 iptables-nft \
 libgcc \
 libpcap \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-qemu = " \
 bash \
 bzip2 \
 glib2 \
 glibc \
 gnutls \
 gzip \
 libgcc \
 libnbd \
 libselinux \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-log \
 libvirt-libs \
 libxml2 \
 lzop \
 numad \
 qemu-img \
 swtpm-tools \
 systemd-container \
 xz \
 zstd \
 "
RDEPENDS:libvirt-daemon-driver-secret = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage = " \
 libvirt-daemon-driver-storage-core \
 libvirt-daemon-driver-storage-disk \
 libvirt-daemon-driver-storage-iscsi \
 libvirt-daemon-driver-storage-logical \
 libvirt-daemon-driver-storage-mpath \
 libvirt-daemon-driver-storage-rbd \
 libvirt-daemon-driver-storage-scsi \
 "
RDEPENDS:libvirt-daemon-driver-storage-core = " \
 bash \
 glib2 \
 glibc \
 libblkid \
 libgcc \
 libselinux \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 libxml2 \
 parted \
 qemu-img \
 scrub \
 util-linux \
 "
RDEPENDS:libvirt-daemon-driver-storage-disk = " \
 device-mapper \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 parted \
 "
RDEPENDS:libvirt-daemon-driver-storage-iscsi = " \
 glib2 \
 glibc \
 iscsi-initiator-utils \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-logical = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 lvm2 \
 "
RDEPENDS:libvirt-daemon-driver-storage-mpath = " \
 device-mapper \
 device-mapper-libs \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-rbd = " \
 glib2 \
 glibc \
 libgcc \
 librados2 \
 librbd1 \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-scsi = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-kvm = " \
 libvirt-daemon-common \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-proxy \
 libvirt-ssh-proxy \
 qemu-kvm \
 "
RDEPENDS:libvirt-daemon-lock = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-log = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-plugin-lockd = " \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-lock \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-plugin-sanlock = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-common \
 libvirt-libs \
 sanlock \
 sanlock-lib \
 "
RDEPENDS:libvirt-daemon-proxy = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-devel = " \
 libvirt-devel \
 libvirt-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:libvirt-docs = " \
 "
RDEPENDS:libvirt-libs = " \
 audit-libs \
 cyrus-sasl-gssapi \
 cyrus-sasl-lib \
 glib2 \
 glibc \
 gnutls \
 json-c \
 libacl \
 libcap-ng \
 libgcc \
 libnl3 \
 libselinux \
 libssh \
 libtirpc \
 libwsman1 \
 libxml2 \
 numactl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libvirt-nss = " \
 glibc \
 json-c \
 libgcc \
 libvirt-daemon-driver-network \
 "
RDEPENDS:libvirt-ssh-proxy = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-libs \
 libxml2 \
 "
