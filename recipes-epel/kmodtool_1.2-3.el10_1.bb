# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmodtool"
PV = "1.2"
PR = "3.el10_1"
PACKAGES = " \
 kmodtool \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmodtool-1.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4a33384b0b14b511472e50c7ad51045dbfae9af2335ac7c5a833a83d6f5591cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmodtool-1.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kmodtool;unpack=0"
SRC_URI[x86_64_v2_kmodtool.sha256sum] = "4d1253d07005ef47527c4dad65c6c513756631927067a350f98603c89fcdefbf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmodtool-1.2-3.el10_1.noarch.rpm;name=aarch64_kmodtool;unpack=0"
SRC_URI[aarch64_kmodtool.sha256sum] = "83df11a37a895ac90101fc3d79ddf4d90c4133eb5a6f6165da3056399a6780fa"

RDEPENDS:kmodtool = " \
 bash \
 "
