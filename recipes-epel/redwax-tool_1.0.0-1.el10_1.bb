# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "redwax-tool"
PV = "1.0.0"
PR = "1.el10_1"
PACKAGES = " \
 redwax-tool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/redwax-tool-1.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad0c90b69368f38945bf0cc9ea350b1621b950722f4e6c903a1a105f29e4e409"

URI_x86_64_v2_redwax-tool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/redwax-tool-1.0.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_redwax-tool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redwax-tool}"
SRC_URI[x86_64_v2_redwax-tool.sha256sum] = "cca0f6415cfd00d94554c5c3b515353acfa4c1abbf2a931c26c01dd92f9ec881"

URI_aarch64_redwax-tool = "${EPEL_MIRROR}/aarch64/Packages/r/redwax-tool-1.0.0-1.el10_1.aarch64.rpm;name=aarch64_redwax-tool;unpack=0"
SRC_URI:append = " ${URI_aarch64_redwax-tool}"
SRC_URI[aarch64_redwax-tool.sha256sum] = "c8125304c7eca60b78cada8dcfac1997ba6202ae17007ca83c67dbfc8d663ab3"

RDEPENDS:redwax-tool = " \
 apr \
 apr-util \
 glibc \
 ldns \
 libical \
 nspr \
 nss \
 openssl-libs \
 p11-kit \
 unbound-libs \
 "
