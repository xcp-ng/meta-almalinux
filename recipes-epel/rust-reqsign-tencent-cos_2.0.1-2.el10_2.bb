# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-tencent-cos"
PV = "2.0.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-reqsign-tencent-cos+default-devel \
 rust-reqsign-tencent-cos-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-tencent-cos-2.0.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81e8e800a9b667f91d134e17dd78d4a4a3e14198c65bdf05fe09895b1ef6acd4"

URI_x86_64_v2_rust-reqsign-tencent-cos+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-tencent-cos+default-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-tencent-cos+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-tencent-cos+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-tencent-cos+default-devel.sha256sum] = "63c501a73d6b1c85fdfe0aedae33153a9e9379f11e8df5ac04dc1341f3d89331"

URI_x86_64_v2_rust-reqsign-tencent-cos-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-tencent-cos-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-tencent-cos-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-tencent-cos-devel}"
SRC_URI[x86_64_v2_rust-reqsign-tencent-cos-devel.sha256sum] = "12ff45b607f3434957534d6a3a9835fb9758f19c407320a0b7a04221e45ffe74"

URI_aarch64_rust-reqsign-tencent-cos+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-tencent-cos+default-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-reqsign-tencent-cos+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-tencent-cos+default-devel}"
SRC_URI[aarch64_rust-reqsign-tencent-cos+default-devel.sha256sum] = "b1bf5e2e4ec4563f7af6e0844c303d1819052222138d56f5c900591329642cfb"

URI_aarch64_rust-reqsign-tencent-cos-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-tencent-cos-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-reqsign-tencent-cos-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-tencent-cos-devel}"
SRC_URI[aarch64_rust-reqsign-tencent-cos-devel.sha256sum] = "2df96c3f2ff371a6ebc0de658948cf992a071263a0232dd39d1715dd29a21765"

RDEPENDS:rust-reqsign-tencent-cos+default-devel = " \
 cargo \
 rust-reqsign-tencent-cos-devel \
 "
RDEPENDS:rust-reqsign-tencent-cos-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
