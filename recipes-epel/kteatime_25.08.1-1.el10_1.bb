# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kteatime"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kteatime \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kteatime-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcbf878cadc9de95317c267d949d794f6d925384827f2b163c7be3bc6af54332"

URI_x86_64_v2_kteatime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kteatime-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kteatime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kteatime}"
SRC_URI[x86_64_v2_kteatime.sha256sum] = "9f9acdefcf329e1d8b58efa00b11e5947db3a8f2bfc6ee39c9362b2dd4278580"

URI_aarch64_kteatime = "${EPEL_MIRROR}/aarch64/Packages/k/kteatime-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kteatime;unpack=0"
SRC_URI:append = " ${URI_aarch64_kteatime}"
SRC_URI[aarch64_kteatime.sha256sum] = "db4b41b6e1ecda61ef932234a145625313e54a17cf09e8305638ed23368c1bbf"

RDEPENDS:kteatime = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
