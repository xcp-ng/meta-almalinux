# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros0.22"
PV = "0.22.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyo3-macros0.22+default-devel \
 rust-pyo3-macros0.22+experimental-async-devel \
 rust-pyo3-macros0.22+gil-refs-devel \
 rust-pyo3-macros0.22+multiple-pymethods-devel \
 rust-pyo3-macros0.22-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros0.22-0.22.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae8f7ba80b25a719e9738cbdfe67cdce3b57cc00dde37fe2a8ec3e7980109a77"

URI_x86_64_v2_rust-pyo3-macros0.22+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.22+default-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.22+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.22+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.22+default-devel.sha256sum] = "9e8126245b1c0cf4cde906d9bfc31c46a37a2646a04a2965564064cb8f084071"

URI_x86_64_v2_rust-pyo3-macros0.22+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.22+experimental-async-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.22+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.22+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.22+experimental-async-devel.sha256sum] = "1e6bfbf3cdf71b08586c7c9680d7a5ddc7b083a79540cd3fbdf9443954cd49ec"

URI_x86_64_v2_rust-pyo3-macros0.22+gil-refs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.22+gil-refs-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.22+gil-refs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.22+gil-refs-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.22+gil-refs-devel.sha256sum] = "17df5c5e87b533ed7c57ab6aaaa0df1ef06826e0328fcf168dcd2c068700e41f"

URI_x86_64_v2_rust-pyo3-macros0.22+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.22+multiple-pymethods-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.22+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.22+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.22+multiple-pymethods-devel.sha256sum] = "e8d97a89ff65dae7496fd4d7569e62dcb20b3ffa75181ff2881cb43c1ae31565"

URI_x86_64_v2_rust-pyo3-macros0.22-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.22-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.22-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.22-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.22-devel.sha256sum] = "864dcbe949563880cf5fb749a1648062eef5fee9c96c31580c9baaa37967f028"

URI_aarch64_rust-pyo3-macros0.22+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.22+default-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros0.22+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.22+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.22+default-devel.sha256sum] = "0b653605a15e63358b20edcce25070657ad70c74214119773e12b78103a03962"

URI_aarch64_rust-pyo3-macros0.22+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.22+experimental-async-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros0.22+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.22+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.22+experimental-async-devel.sha256sum] = "43b676dd55b237e10671207da6f1abcf1fff184c9facaeccf5a44cd7b321473a"

URI_aarch64_rust-pyo3-macros0.22+gil-refs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.22+gil-refs-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros0.22+gil-refs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.22+gil-refs-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.22+gil-refs-devel.sha256sum] = "65a1a6e8bb7033a79e13bf025dc0e1b258501622fea1cca1e1313e93fdb437db"

URI_aarch64_rust-pyo3-macros0.22+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.22+multiple-pymethods-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros0.22+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.22+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.22+multiple-pymethods-devel.sha256sum] = "099705e186121fb5e83d4e9db74dea96d16b921825db71e49819f91bbe4c0fe8"

URI_aarch64_rust-pyo3-macros0.22-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.22-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros0.22-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.22-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.22-devel.sha256sum] = "521b48db13f6f94c70ae788dec2655396306eed5d31ce6ad7e4ad0cf405632c0"

RDEPENDS:rust-pyo3-macros0.22+default-devel = " \
 cargo \
 rust-pyo3-macros0.22-devel \
 "
RDEPENDS:rust-pyo3-macros0.22+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend0.22+experimental-async-devel \
 rust-pyo3-macros0.22-devel \
 "
RDEPENDS:rust-pyo3-macros0.22+gil-refs-devel = " \
 cargo \
 rust-pyo3-macros-backend0.22+gil-refs-devel \
 rust-pyo3-macros0.22-devel \
 "
RDEPENDS:rust-pyo3-macros0.22+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros0.22-devel \
 "
RDEPENDS:rust-pyo3-macros0.22-devel = " \
 cargo \
 rust-proc-macro2-devel \
 rust-pyo3-macros-backend0.22+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 "
