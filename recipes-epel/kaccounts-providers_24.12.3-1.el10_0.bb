# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kaccounts-providers"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kaccounts-providers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kaccounts-providers-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e404153a9de32bd5b94b19786408bf01cbac2b298430430304ac36ab2db1982b"

URI_x86_64_v2_kaccounts-providers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaccounts-providers-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaccounts-providers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaccounts-providers}"
SRC_URI[x86_64_v2_kaccounts-providers.sha256sum] = "30d499ee2eebc25b458903a6456519aaec3e23f7efd19d7545c1a9d5e933d096"

URI_aarch64_kaccounts-providers = "${EPEL_MIRROR}/aarch64/Packages/k/kaccounts-providers-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kaccounts-providers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaccounts-providers}"
SRC_URI[aarch64_kaccounts-providers.sha256sum] = "608d4b67c309d5fe5047656a310c4c7a8f5be96d5299b7cb0bb5df5f84ae056a"

RDEPENDS:kaccounts-providers = " \
 glibc \
 kaccounts-integration-qt6 \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kpackage \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 signon-plugin-oauth2 \
 signon-ui \
 "
