# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "systemd"
PV = "257"
PR = "23.el10_2.2.alma.1"
PACKAGES = " \
 systemd \
 systemd-boot-unsigned \
 systemd-container \
 systemd-devel \
 systemd-journal-remote \
 systemd-libs \
 systemd-oomd \
 systemd-pam \
 systemd-resolved \
 systemd-rpm-macros \
 systemd-udev \
 systemd-ukify \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/systemd-257-23.el10_2.2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c25f0deee804b5a7e6e34da9a99ee828a1fb4845963649eaed2347ece70025a"

URI_x86_64_v2_systemd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-257-23.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd}"
SRC_URI[x86_64_v2_systemd.sha256sum] = "9c7c2dd9542290b4d3eda4883390be582df2dd49e1f8a8d553ad4e30df4ea622"
RPROVIDES:systemd:x86_64_v2 = "virtual/group_dialout_ virtual/group_tty_ virtual/syslog"

URI_x86_64_v2_systemd-boot-unsigned = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-boot-unsigned-257-23.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-boot-unsigned;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-boot-unsigned}"
SRC_URI[x86_64_v2_systemd-boot-unsigned.sha256sum] = "3133081778aef1d0c0dc2a556591bdbef85f5de2fac84dd6ea2942636f030e40"

URI_x86_64_v2_systemd-container = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-container-257-23.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-container;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-container}"
SRC_URI[x86_64_v2_systemd-container.sha256sum] = "77b5c1af3b274e9347c9b7fc6a1c02e005de5306eef47d365bf7831bd13be625"

URI_x86_64_v2_systemd-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-devel-257-23.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-devel}"
SRC_URI[x86_64_v2_systemd-devel.sha256sum] = "7120bc5ae050396d8fca8a0e52c186d6e675624908196eb56bcb8b7b58425868"

URI_x86_64_v2_systemd-journal-remote = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-journal-remote-257-23.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-journal-remote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-journal-remote}"
SRC_URI[x86_64_v2_systemd-journal-remote.sha256sum] = "2385d9cda1b48cc53e3156f43322509e91fb647b5dccf6767afcaa2657ee8186"

URI_x86_64_v2_systemd-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-libs-257-23.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-libs}"
SRC_URI[x86_64_v2_systemd-libs.sha256sum] = "b98edb9ade1b741a888dad6d074a0e1f5aaac3e0c851753586df75719cf048f5"

URI_x86_64_v2_systemd-oomd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-oomd-257-23.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-oomd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-oomd}"
SRC_URI[x86_64_v2_systemd-oomd.sha256sum] = "8da4bfd20f6520d81e1d535700b130f2861b0744d271fa2b828134f3cb9dd42d"

URI_x86_64_v2_systemd-pam = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-pam-257-23.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-pam}"
SRC_URI[x86_64_v2_systemd-pam.sha256sum] = "1b88da3391fe7bebd09bce511e3e5fd2c0fbc7a85a82b873e7620d69cf9d3802"

URI_x86_64_v2_systemd-resolved = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-resolved-257-23.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-resolved;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-resolved}"
SRC_URI[x86_64_v2_systemd-resolved.sha256sum] = "d7b32d96845c198b98420f99fc21297b1df1a7e7ec3bf95056eb9cf015d5f9b3"

URI_x86_64_v2_systemd-rpm-macros = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-rpm-macros-257-23.el10_2.2.alma.1.noarch.rpm;name=x86_64_v2_systemd-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-rpm-macros}"
SRC_URI[x86_64_v2_systemd-rpm-macros.sha256sum] = "25a6ab6794dbe66dcaef12fe741c73df6fb52e85ec705973071b879d9a20cdcd"

URI_x86_64_v2_systemd-udev = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-udev-257-23.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-udev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-udev}"
SRC_URI[x86_64_v2_systemd-udev.sha256sum] = "e26e258c6622a68eeb5cae5b602d15093aef637a21c5f8e8cadc1e106eefa553"

URI_x86_64_v2_systemd-ukify = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-ukify-257-23.el10_2.2.alma.1.noarch.rpm;name=x86_64_v2_systemd-ukify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-ukify}"
SRC_URI[x86_64_v2_systemd-ukify.sha256sum] = "46133e35aced0445c40a30fb7ddc6b5d081bace313588ed3f7d3097a1a85c3f7"

URI_aarch64_systemd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-257-23.el10_2.2.alma.1.aarch64.rpm;name=aarch64_systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd}"
SRC_URI[aarch64_systemd.sha256sum] = "6892f1d0c22fe69f715f074af8f6aa3c2948ce3de99b2ac70ab4bb4a3868c0d2"
RPROVIDES:systemd:aarch64 = "virtual/group_dialout_ virtual/group_tty_ virtual/syslog"

URI_aarch64_systemd-boot-unsigned = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-boot-unsigned-257-23.el10_2.2.alma.1.aarch64.rpm;name=aarch64_systemd-boot-unsigned;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-boot-unsigned}"
SRC_URI[aarch64_systemd-boot-unsigned.sha256sum] = "e5fe69d02687b3031992b9360ebe0a8e5064e8fd99958d24ca782b686767724a"

URI_aarch64_systemd-container = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-container-257-23.el10_2.2.alma.1.aarch64.rpm;name=aarch64_systemd-container;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-container}"
SRC_URI[aarch64_systemd-container.sha256sum] = "37f827a10091a2670e33fce5488f70b4f6c575f5c69fffd32245f79887d207d4"

URI_aarch64_systemd-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-devel-257-23.el10_2.2.alma.1.aarch64.rpm;name=aarch64_systemd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-devel}"
SRC_URI[aarch64_systemd-devel.sha256sum] = "11a07d7ec68f33228abcfec001390478e788299f7b5b53383808d3fe21fa27f7"

URI_aarch64_systemd-journal-remote = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-journal-remote-257-23.el10_2.2.alma.1.aarch64.rpm;name=aarch64_systemd-journal-remote;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-journal-remote}"
SRC_URI[aarch64_systemd-journal-remote.sha256sum] = "8b50a4f41061dd1abf5ff659a30ab212fd509021cd190e5f985be67197f27606"

URI_aarch64_systemd-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-libs-257-23.el10_2.2.alma.1.aarch64.rpm;name=aarch64_systemd-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-libs}"
SRC_URI[aarch64_systemd-libs.sha256sum] = "ed54d45013b60571bd38b9a60e66307886a1e284c9098d86a716d36ed6760927"

URI_aarch64_systemd-oomd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-oomd-257-23.el10_2.2.alma.1.aarch64.rpm;name=aarch64_systemd-oomd;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-oomd}"
SRC_URI[aarch64_systemd-oomd.sha256sum] = "b3e57a71ff15f62b3ff0611a8c2204f33fed5c45ac1e79a2739b14d81ae07359"

URI_aarch64_systemd-pam = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-pam-257-23.el10_2.2.alma.1.aarch64.rpm;name=aarch64_systemd-pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-pam}"
SRC_URI[aarch64_systemd-pam.sha256sum] = "5a88a6c9d7067bb70330a4b3a3adff313b36a164c835bae3c7db5de1c20a83d4"

URI_aarch64_systemd-resolved = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-resolved-257-23.el10_2.2.alma.1.aarch64.rpm;name=aarch64_systemd-resolved;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-resolved}"
SRC_URI[aarch64_systemd-resolved.sha256sum] = "c504ba176d5d64d0d9e5ed121afc44d0c91692bb338e0969e228c57eb1256258"

URI_aarch64_systemd-rpm-macros = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-rpm-macros-257-23.el10_2.2.alma.1.noarch.rpm;name=aarch64_systemd-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-rpm-macros}"
SRC_URI[aarch64_systemd-rpm-macros.sha256sum] = "25a6ab6794dbe66dcaef12fe741c73df6fb52e85ec705973071b879d9a20cdcd"

URI_aarch64_systemd-udev = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-udev-257-23.el10_2.2.alma.1.aarch64.rpm;name=aarch64_systemd-udev;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-udev}"
SRC_URI[aarch64_systemd-udev.sha256sum] = "2822cef03293b07f1bfb06d7faf1de7c51ef55af70fdff1264205a36e5c9fbd7"

URI_aarch64_systemd-ukify = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-ukify-257-23.el10_2.2.alma.1.noarch.rpm;name=aarch64_systemd-ukify;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-ukify}"
SRC_URI[aarch64_systemd-ukify.sha256sum] = "46133e35aced0445c40a30fb7ddc6b5d081bace313588ed3f7d3097a1a85c3f7"

RDEPENDS:systemd = " \
 audit-libs \
 bash \
 bzip2-libs \
 dbus \
 glibc \
 grep \
 libacl \
 libblkid \
 libcap \
 libfdisk \
 libgcc \
 libmount \
 libseccomp \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 systemd-libs \
 systemd-pam \
 systemd-rpm-macros \
 virtual/coreutils \
 virtual/util-linux-core_or_util-linux \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:systemd-boot-unsigned = " \
 "
RDEPENDS:systemd-container = " \
 bzip2-libs \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:systemd-devel = " \
 systemd-libs \
 systemd-rpm-macros \
 "
RDEPENDS:systemd-journal-remote = " \
 bash \
 firewalld-filesystem \
 glibc \
 libgcc \
 libmicrohttpd \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:systemd-libs = " \
 glibc \
 libcap \
 libgcc \
 "
RDEPENDS:systemd-oomd = " \
 bash \
 glibc \
 libgcc \
 systemd \
 systemd-udev \
 "
RDEPENDS:systemd-pam = " \
 glibc \
 libcap \
 libgcc \
 pam-libs \
 systemd \
 "
RDEPENDS:systemd-resolved = " \
 bash \
 glibc \
 grep \
 libgcc \
 libidn2 \
 openssl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:systemd-rpm-macros = " \
 bash \
 "
RDEPENDS:systemd-udev = " \
 bash \
 cryptsetup-libs \
 glibc \
 grep \
 grubby \
 kbd \
 kmod \
 kmod-libs \
 libblkid \
 libfdisk \
 libgcc \
 openssl-libs \
 sdubby \
 systemd \
 "
RDEPENDS:systemd-ukify = " \
 python3 \
 python3-cryptography \
 python3-pefile \
 python3-zstandard \
 systemd \
 systemd-boot-unsigned \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/group_dialout_ rpm/virtual/group_tty_ rpm/virtual/syslog"

PROVIDES:append:aarch64 = " rpm/virtual/group_dialout_ rpm/virtual/group_tty_ rpm/virtual/syslog"
