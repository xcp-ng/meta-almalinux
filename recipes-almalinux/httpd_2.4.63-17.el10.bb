# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "httpd"
PV = "2.4.63"
PR = "17.el10"
PACKAGES = " \
 httpd \
 httpd-core \
 httpd-devel \
 httpd-filesystem \
 httpd-manual \
 httpd-tools \
 mod_ldap \
 mod_lua \
 mod_proxy_html \
 mod_session \
 mod_ssl \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/httpd-2.4.63-17.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7b6c04f673c523c0c75eb3994cc621202f1951a1e753811f818a74bd21c6c9a0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-2.4.63-17.el10.x86_64_v2.rpm;name=x86_64_v2_httpd;unpack=0"
SRC_URI[x86_64_v2_httpd.sha256sum] = "2a38de8f799b6988cff37432bb3ec6c0f9a71741bad4814d933f5f652448946c"
RPROVIDES:httpd:append:x86_64_v2 = " virtual/httpd_or_nginx virtual/webserver"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-core-2.4.63-17.el10.x86_64_v2.rpm;name=x86_64_v2_httpd-core;unpack=0"
SRC_URI[x86_64_v2_httpd-core.sha256sum] = "24f9aee4041feb5baea895bfa131629c95c7269046efff586b0e1052f2bbaefe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-devel-2.4.63-17.el10.x86_64_v2.rpm;name=x86_64_v2_httpd-devel;unpack=0"
SRC_URI[x86_64_v2_httpd-devel.sha256sum] = "2eec6ef3bf299c1e07277ea4070cbf3b35e39b9396a6dcd858c46838cb9766a0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-filesystem-2.4.63-17.el10.noarch.rpm;name=x86_64_v2_httpd-filesystem;unpack=0"
SRC_URI[x86_64_v2_httpd-filesystem.sha256sum] = "72a0fea4ed1cd4f49c0f70f98889e1acc4f1b03bc519af98a69d9a4248ac6226"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-manual-2.4.63-17.el10.noarch.rpm;name=x86_64_v2_httpd-manual;unpack=0"
SRC_URI[x86_64_v2_httpd-manual.sha256sum] = "a39aaf29e3148c4c551370d53a43a2c44cf4abe956bfca15fe3b109e7e038344"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-tools-2.4.63-17.el10.x86_64_v2.rpm;name=x86_64_v2_httpd-tools;unpack=0"
SRC_URI[x86_64_v2_httpd-tools.sha256sum] = "2d615d76a88863f61557a3b55abbf9852ca6e3565b6e79038a6fe7f30877c0e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_ldap-2.4.63-17.el10.x86_64_v2.rpm;name=x86_64_v2_mod_ldap;unpack=0"
SRC_URI[x86_64_v2_mod_ldap.sha256sum] = "63ed9744cb3e2e4e5c2eedf247b35f9502ad04b40907df2236b55aa2252c0e73"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_lua-2.4.63-17.el10.x86_64_v2.rpm;name=x86_64_v2_mod_lua;unpack=0"
SRC_URI[x86_64_v2_mod_lua.sha256sum] = "d27378f71d46f848eb738f09f29b44992a046ebff39f8ffd0042934b41d614d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_proxy_html-2.4.63-17.el10.x86_64_v2.rpm;name=x86_64_v2_mod_proxy_html;unpack=0"
SRC_URI[x86_64_v2_mod_proxy_html.sha256sum] = "b18456cb8c7891e43421e6130a40e4785b2e4a87ad8a9d6243d5751af7c4141f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_session-2.4.63-17.el10.x86_64_v2.rpm;name=x86_64_v2_mod_session;unpack=0"
SRC_URI[x86_64_v2_mod_session.sha256sum] = "93f3409c56da1e3ffc45318d4cdb5b115dccaff0c78225fae3fbfab6d030c5a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_ssl-2.4.63-17.el10.x86_64_v2.rpm;name=x86_64_v2_mod_ssl;unpack=0"
SRC_URI[x86_64_v2_mod_ssl.sha256sum] = "8211697bdfa01a369005fb0d974230076d48b1ae5a0e43ea4c349260927b1a99"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-2.4.63-17.el10.aarch64.rpm;name=aarch64_httpd;unpack=0"
SRC_URI[aarch64_httpd.sha256sum] = "c842d6e25b512d82e726a8fcd0ef0d47670a418d1996ce47fa141fc14a373acc"
RPROVIDES:httpd:append:aarch64 = " virtual/httpd_or_nginx virtual/webserver"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-core-2.4.63-17.el10.aarch64.rpm;name=aarch64_httpd-core;unpack=0"
SRC_URI[aarch64_httpd-core.sha256sum] = "a4a9937730d0e499fe065ec39e097dc894d23b05f7ddc0d61e7c00e74675bf55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-devel-2.4.63-17.el10.aarch64.rpm;name=aarch64_httpd-devel;unpack=0"
SRC_URI[aarch64_httpd-devel.sha256sum] = "2c3a821167091fd7d7c940927573f642b3c1abdf6861879b63d9d6295ccd4d65"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-filesystem-2.4.63-17.el10.noarch.rpm;name=aarch64_httpd-filesystem;unpack=0"
SRC_URI[aarch64_httpd-filesystem.sha256sum] = "72a0fea4ed1cd4f49c0f70f98889e1acc4f1b03bc519af98a69d9a4248ac6226"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-manual-2.4.63-17.el10.noarch.rpm;name=aarch64_httpd-manual;unpack=0"
SRC_URI[aarch64_httpd-manual.sha256sum] = "a39aaf29e3148c4c551370d53a43a2c44cf4abe956bfca15fe3b109e7e038344"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-tools-2.4.63-17.el10.aarch64.rpm;name=aarch64_httpd-tools;unpack=0"
SRC_URI[aarch64_httpd-tools.sha256sum] = "d711f1ce1c4ee8f340e723ede3f4c04b4085c50dfde13fba40329f79f245f507"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_ldap-2.4.63-17.el10.aarch64.rpm;name=aarch64_mod_ldap;unpack=0"
SRC_URI[aarch64_mod_ldap.sha256sum] = "21df27eb51be2e4f41352882125aa6c8186e9cee0da6d6fcef2ade5a1dbf023b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_lua-2.4.63-17.el10.aarch64.rpm;name=aarch64_mod_lua;unpack=0"
SRC_URI[aarch64_mod_lua.sha256sum] = "5c97a0011945f97ac608d7de2c939ae7801a29aa810caa41aa93b12fbe0177f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_proxy_html-2.4.63-17.el10.aarch64.rpm;name=aarch64_mod_proxy_html;unpack=0"
SRC_URI[aarch64_mod_proxy_html.sha256sum] = "7b09d85996dae3ad06476080c251ebb75ffd53e97b4438653bcadebf761668ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_session-2.4.63-17.el10.aarch64.rpm;name=aarch64_mod_session;unpack=0"
SRC_URI[aarch64_mod_session.sha256sum] = "77af6ccdfc5b9b399e7903517d5749c3ac81c6103402054a3d5ae54acd929036"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_ssl-2.4.63-17.el10.aarch64.rpm;name=aarch64_mod_ssl;unpack=0"
SRC_URI[aarch64_mod_ssl.sha256sum] = "b2ec7ae53a84ecbcab26537c175351412aea5d7aa3535c7b43e94e58d6162ed6"

RDEPENDS:httpd = " \
 almalinux-logos-httpd \
 bash \
 glibc \
 httpd-core \
 libbrotli \
 libselinux \
 systemd \
 systemd-libs \
 "
RDEPENDS:httpd-core = " \
 apr \
 apr-util \
 apr-util-lmdb \
 bash \
 glibc \
 httpd-filesystem \
 httpd-tools \
 mailcap \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:httpd-devel = " \
 apr-devel \
 apr-util-devel \
 bash \
 httpd-core \
 libtool \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:httpd-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:httpd-manual = " \
 httpd-core \
 "
RDEPENDS:httpd-tools = " \
 apr \
 apr-util \
 glibc \
 libxcrypt \
 openssl-libs \
 "
RDEPENDS:mod_ldap = " \
 apr-util-ldap \
 glibc \
 httpd-core \
 openldap \
 "
RDEPENDS:mod_lua = " \
 glibc \
 httpd-core \
 libxcrypt \
 lua-libs \
 "
RDEPENDS:mod_proxy_html = " \
 glibc \
 httpd-core \
 libxml2 \
 "
RDEPENDS:mod_session = " \
 glibc \
 httpd-core \
 "
RDEPENDS:mod_ssl = " \
 bash \
 glibc \
 hostname \
 httpd-core \
 httpd-filesystem \
 openssl-libs \
 sscg \
 "
