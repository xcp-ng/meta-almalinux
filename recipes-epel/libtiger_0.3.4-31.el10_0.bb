# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtiger"
PV = "0.3.4"
PR = "31.el10_0"
PACKAGES = " \
 libtiger \
 libtiger-devel \
 libtiger-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libtiger-0.3.4-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5399dbade1ec3d0c6a8ad329ae98098c14679d29729373c884aa0950f86e9d05"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtiger-0.3.4-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtiger;unpack=0"
SRC_URI[x86_64_v2_libtiger.sha256sum] = "179448d01561d41bc371fcedaba2eb9e4aa75d6951f9e877a2e704be4094ffc1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtiger-devel-0.3.4-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtiger-devel;unpack=0"
SRC_URI[x86_64_v2_libtiger-devel.sha256sum] = "616b280799fb581ee5dc67d9b8c9137380bd3e60c4efcdb57448d9cfecd51af4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtiger-doc-0.3.4-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libtiger-doc;unpack=0"
SRC_URI[x86_64_v2_libtiger-doc.sha256sum] = "fe46bfdf8f02d3bc9f088f86df7cb24479faba27fddcd33284706115092bf5e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libtiger-0.3.4-31.el10_0.aarch64.rpm;name=aarch64_libtiger;unpack=0"
SRC_URI[aarch64_libtiger.sha256sum] = "23bef33efc8083ea5e640a635a631303cc22bc3c5d86154cacef3dfebe3d7233"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libtiger-devel-0.3.4-31.el10_0.aarch64.rpm;name=aarch64_libtiger-devel;unpack=0"
SRC_URI[aarch64_libtiger-devel.sha256sum] = "a3ab29f263e8b63d4d6b2e6964a08a049a19ff47a7f475f1222643892c35e35d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libtiger-doc-0.3.4-31.el10_0.noarch.rpm;name=aarch64_libtiger-doc;unpack=0"
SRC_URI[aarch64_libtiger-doc.sha256sum] = "46c1955810904beb84f453965a9f26c0adae257d24cba5f05607f7e4174abcd2"

RDEPENDS:libtiger = " \
 cairo \
 glib2 \
 glibc \
 harfbuzz \
 libkate \
 pango \
 "
RDEPENDS:libtiger-devel = " \
 libkate-devel \
 libtiger \
 pango-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libtiger-doc = " \
 "
