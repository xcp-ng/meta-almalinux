# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-oracle"
PV = "3.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-oracle+default-devel \
 rust-reqsign-oracle-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-oracle-3.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a4a298e21fa999d7e264807d875dd1db3bbc643e744cb03d86da1263630492aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-oracle+default-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-oracle+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-oracle+default-devel.sha256sum] = "dedddb2d669b19cd4115e42de91a8a68561b02fba0fa813973a1f7d9e259b43c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-oracle-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-oracle-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-oracle-devel.sha256sum] = "44309297ef6eed29dc1fcd2ffc727f299298c3bded8f7d52be749f972c91f09c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-oracle+default-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-oracle+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-oracle+default-devel.sha256sum] = "d14d3ee874150a06c220deabff98807be2582898b63fea1c0bd868afca3ca754"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-oracle-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-oracle-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-oracle-devel.sha256sum] = "aa1c2453433d023f7735817adf808dd4914052d2a91b32e9fc0b1777987d27ec"

RDEPENDS:rust-reqsign-oracle+default-devel = " \
 cargo \
 rust-reqsign-oracle-devel \
 "
RDEPENDS:rust-reqsign-oracle-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-base64_0.22+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-reqsign-core+default-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-rust-ini+default-devel \
 "
