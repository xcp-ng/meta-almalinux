# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "codeblocks"
PV = "25.03"
PR = "1.el10_0"
PACKAGES = " \
 codeblocks \
 codeblocks-contrib \
 codeblocks-contrib-devel \
 codeblocks-contrib-libs \
 codeblocks-devel \
 codeblocks-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/codeblocks-25.03-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d1f2f99cc9ceec7a3ee0d3b70ad3001ec0cfd04034ee32add336d6b37e61bcf"

URI_x86_64_v2_codeblocks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codeblocks-25.03-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_codeblocks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codeblocks}"
SRC_URI[x86_64_v2_codeblocks.sha256sum] = "d33dd8bab5ec2b97f8dfdf5222568f0b7c619d925cef194ee1e00dc30a729e38"

URI_x86_64_v2_codeblocks-contrib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codeblocks-contrib-25.03-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_codeblocks-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codeblocks-contrib}"
SRC_URI[x86_64_v2_codeblocks-contrib.sha256sum] = "641c7c5859865ca17e584d6dcf89430e56157b25d2562a2a90bce7dd108d92c0"

URI_x86_64_v2_codeblocks-contrib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codeblocks-contrib-devel-25.03-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_codeblocks-contrib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codeblocks-contrib-devel}"
SRC_URI[x86_64_v2_codeblocks-contrib-devel.sha256sum] = "f6927166f54ee078e3523a3ad46ef38f2c161133ac07208252d718ef131d7a59"

URI_x86_64_v2_codeblocks-contrib-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codeblocks-contrib-libs-25.03-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_codeblocks-contrib-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codeblocks-contrib-libs}"
SRC_URI[x86_64_v2_codeblocks-contrib-libs.sha256sum] = "91991090517be7f8d3ddb230d46037d53e21687c16137912e50b2c74e6265ded"

URI_x86_64_v2_codeblocks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codeblocks-devel-25.03-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_codeblocks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codeblocks-devel}"
SRC_URI[x86_64_v2_codeblocks-devel.sha256sum] = "de3270560cbcb1b26c0662f09f26b3e7310007ac952edcb7b02810f5324ee759"

URI_x86_64_v2_codeblocks-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codeblocks-libs-25.03-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_codeblocks-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codeblocks-libs}"
SRC_URI[x86_64_v2_codeblocks-libs.sha256sum] = "96f9e707988b7e4a8626484103054a8cdf97bcb184e9d84043cbd9ce996ea3e8"

URI_aarch64_codeblocks = "${EPEL_MIRROR}/aarch64/Packages/c/codeblocks-25.03-1.el10_0.aarch64.rpm;name=aarch64_codeblocks;unpack=0"
SRC_URI:append = " ${URI_aarch64_codeblocks}"
SRC_URI[aarch64_codeblocks.sha256sum] = "f63194f5fdee90a5eeb3f437dac858c3f7d8475bd67049debd892d066d3ada01"

URI_aarch64_codeblocks-contrib = "${EPEL_MIRROR}/aarch64/Packages/c/codeblocks-contrib-25.03-1.el10_0.aarch64.rpm;name=aarch64_codeblocks-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_codeblocks-contrib}"
SRC_URI[aarch64_codeblocks-contrib.sha256sum] = "b80681633f2edf91e56143e7a460090c793e5164f5c3b2bd124c8b484540450d"

URI_aarch64_codeblocks-contrib-devel = "${EPEL_MIRROR}/aarch64/Packages/c/codeblocks-contrib-devel-25.03-1.el10_0.aarch64.rpm;name=aarch64_codeblocks-contrib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_codeblocks-contrib-devel}"
SRC_URI[aarch64_codeblocks-contrib-devel.sha256sum] = "e4daa26608bbed4125a40c331cfe8fca6e9b932c6ba7dff10b0e689b4d468e85"

URI_aarch64_codeblocks-contrib-libs = "${EPEL_MIRROR}/aarch64/Packages/c/codeblocks-contrib-libs-25.03-1.el10_0.aarch64.rpm;name=aarch64_codeblocks-contrib-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_codeblocks-contrib-libs}"
SRC_URI[aarch64_codeblocks-contrib-libs.sha256sum] = "62adeaa8c58a291baec4b9548957cef95818ea81ba42e1ad04e2130a90670f62"

URI_aarch64_codeblocks-devel = "${EPEL_MIRROR}/aarch64/Packages/c/codeblocks-devel-25.03-1.el10_0.aarch64.rpm;name=aarch64_codeblocks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_codeblocks-devel}"
SRC_URI[aarch64_codeblocks-devel.sha256sum] = "701c70f8de5ca5080101153a982c7419cf683c3659ea78731744939ffe9a688a"

URI_aarch64_codeblocks-libs = "${EPEL_MIRROR}/aarch64/Packages/c/codeblocks-libs-25.03-1.el10_0.aarch64.rpm;name=aarch64_codeblocks-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_codeblocks-libs}"
SRC_URI[aarch64_codeblocks-libs.sha256sum] = "518a5ee27543d3d21df9d7961925c62d221a212cb16cc6e3d96363d0ed62d9a4"

RDEPENDS:codeblocks = " \
 astyle \
 atk \
 cairo \
 cairo-gobject \
 codeblocks-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libgcc \
 libstdc++ \
 pango \
 shared-mime-info \
 tinyxml \
 wxBase \
 wxGTK \
 xterm \
 "
RDEPENDS:codeblocks-contrib = " \
 atk \
 boost-system \
 bzip2-libs \
 cairo \
 cairo-gobject \
 codeblocks \
 codeblocks-contrib-libs \
 codeblocks-libs \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 hunspell \
 libX11 \
 libgcc \
 libstdc++ \
 pango \
 tinyxml \
 wxBase \
 wxGTK \
 zlib-ng-compat \
 "
RDEPENDS:codeblocks-contrib-devel = " \
 codeblocks-contrib-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:codeblocks-contrib-libs = " \
 cairo \
 cairo-gobject \
 codeblocks-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libgcc \
 libstdc++ \
 pango \
 tinyxml \
 wxBase \
 wxGTK \
 "
RDEPENDS:codeblocks-devel = " \
 codeblocks-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:codeblocks-libs = " \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libgcc \
 libstdc++ \
 pango \
 tinyxml \
 wxBase \
 wxGTK \
 "
