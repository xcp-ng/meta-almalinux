# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkomparediff2"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 libkomparediff2 \
 libkomparediff2-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libkomparediff2-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f27eac500b8e613943e08b95094e6a655578a408bd549b71d705add952e4a4e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkomparediff2-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkomparediff2;unpack=0"
SRC_URI[x86_64_v2_libkomparediff2.sha256sum] = "cd878e5cf8a5a2688d16cfeec6bce84b566188b9b85d92b2709a40f971550b31"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkomparediff2-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkomparediff2-devel;unpack=0"
SRC_URI[x86_64_v2_libkomparediff2-devel.sha256sum] = "c206f619d77957fdf4f5b4d5ade27d7be0d0df78b1cdc97d537a1320114daf8a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkomparediff2-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkomparediff2;unpack=0"
SRC_URI[aarch64_libkomparediff2.sha256sum] = "e97ca520a2cbc6a793f4e7c6ad290067685f937e080309d5f1b3808cd6063925"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkomparediff2-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkomparediff2-devel;unpack=0"
SRC_URI[aarch64_libkomparediff2-devel.sha256sum] = "70ae80084d61538b49f61c603ad078faa413c5e3808adbaf1b34dc849fea7f1d"

RDEPENDS:libkomparediff2 = " \
 diffutils \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkomparediff2-devel = " \
 cmake \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kxmlgui-devel \
 libkomparediff2 \
 qt6-qtbase-devel \
 "
