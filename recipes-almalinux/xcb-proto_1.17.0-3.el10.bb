# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xcb-proto"
PV = "1.17.0"
PR = "3.el10"
PACKAGES = " \
 xcb-proto \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/xcb-proto-1.17.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e97c350d031689f5a031ac025801c2d58205dc392f5e0b91be4c866e4118ae7"

URI_x86_64_v2_xcb-proto = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xcb-proto-1.17.0-3.el10.noarch.rpm;name=x86_64_v2_xcb-proto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xcb-proto}"
SRC_URI[x86_64_v2_xcb-proto.sha256sum] = "5af6131f5c37d378aaed75fb15cc723b9a7b17a6df0c11490d03eb1cf1595cda"

URI_aarch64_xcb-proto = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xcb-proto-1.17.0-3.el10.noarch.rpm;name=aarch64_xcb-proto;unpack=0"
SRC_URI:append = " ${URI_aarch64_xcb-proto}"
SRC_URI[aarch64_xcb-proto.sha256sum] = "5af6131f5c37d378aaed75fb15cc723b9a7b17a6df0c11490d03eb1cf1595cda"

RDEPENDS:xcb-proto = " \
 pkgconf-pkg-config \
 python3 \
 "
