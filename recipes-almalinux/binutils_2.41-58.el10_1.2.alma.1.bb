# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "binutils"
PV = "2.41"
PR = "58.el10_1.2.alma.1"
PACKAGES = " \
 binutils \
 binutils-devel \
 binutils-gold \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/binutils-2.41-58.el10_1.2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d2ad0ff4468c734a03ce920330127dda3463f95645978da5289416e4a7fe957"

URI_x86_64_v2_binutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/binutils-2.41-58.el10_1.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils}"
SRC_URI[x86_64_v2_binutils.sha256sum] = "308b47d7a2017aa8892a4271cec23e7176a9b42cafa30c7dc5b6cd6c1d0f688b"
RPROVIDES:binutils:append:x86_64_v2 = " virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_ virtual/libsframe.so.1___64bit_"

URI_x86_64_v2_binutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/binutils-devel-2.41-58.el10_1.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-devel}"
SRC_URI[x86_64_v2_binutils-devel.sha256sum] = "da9b3a00734c4a98b8a8f9f521de4a30c1c3fd067959727be5b901c9217f4d21"

URI_x86_64_v2_binutils-gold = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/binutils-gold-2.41-58.el10_1.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils-gold;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-gold}"
SRC_URI[x86_64_v2_binutils-gold.sha256sum] = "c795b9a162ca36cb901c9da92baa1e413a08dbecf689814d215220d6ad16643a"

URI_aarch64_binutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/binutils-2.41-58.el10_1.2.alma.1.aarch64.rpm;name=aarch64_binutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils}"
SRC_URI[aarch64_binutils.sha256sum] = "4b1af9247023542d150dad246285e986f6b7e5cc16af0cff510f21bd57161f3f"
RPROVIDES:binutils:append:aarch64 = " virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_ virtual/libsframe.so.1___64bit_"

URI_aarch64_binutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/binutils-devel-2.41-58.el10_1.2.alma.1.aarch64.rpm;name=aarch64_binutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-devel}"
SRC_URI[aarch64_binutils-devel.sha256sum] = "7e1cba8fe9df5520f11d8302ab8f7c62f29043f8b8cb7b9e352541655f32dd62"

URI_aarch64_binutils-gold = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/binutils-gold-2.41-58.el10_1.2.alma.1.aarch64.rpm;name=aarch64_binutils-gold;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-gold}"
SRC_URI[aarch64_binutils-gold.sha256sum] = "8ad1cb032dfe2cdb01d3142603e58595af53db0740d718af238cb90e7f90eb30"

RDEPENDS:binutils = " \
 alternatives \
 bash \
 binutils-gold \
 elfutils-debuginfod-client \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:binutils-devel = " \
 binutils \
 virtual/coreutils \
 zlib-ng-compat-devel \
 "
RDEPENDS:binutils-gold = " \
 bash \
 binutils \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
