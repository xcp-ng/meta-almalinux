# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cordic"
PV = "0.1.5"
PR = "11.el10_1"
PACKAGES = " \
 rust-cordic+default-devel \
 rust-cordic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cordic-0.1.5-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c98f5a7e14c20a1121c54096062a5e27cb88610f1ffa66f70d2df7daf601ea83"

URI_x86_64_v2_rust-cordic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cordic+default-devel-0.1.5-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cordic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cordic+default-devel}"
SRC_URI[x86_64_v2_rust-cordic+default-devel.sha256sum] = "79df84275a37291d8eae3a8626d8c51203c65a2b0d41459ff48eee81008a83bf"

URI_x86_64_v2_rust-cordic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cordic-devel-0.1.5-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cordic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cordic-devel}"
SRC_URI[x86_64_v2_rust-cordic-devel.sha256sum] = "f9487b35b8c767690f8178a1e986eed9cb308759a775211e62b72d73356991cb"

URI_aarch64_rust-cordic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cordic+default-devel-0.1.5-11.el10_1.noarch.rpm;name=aarch64_rust-cordic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cordic+default-devel}"
SRC_URI[aarch64_rust-cordic+default-devel.sha256sum] = "87cb26e682f4da3cff74a29320b5ed49e7d4747ace3b38c05dea7487b0750193"

URI_aarch64_rust-cordic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cordic-devel-0.1.5-11.el10_1.noarch.rpm;name=aarch64_rust-cordic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cordic-devel}"
SRC_URI[aarch64_rust-cordic-devel.sha256sum] = "3b8ccb5480d025b225b70a283e9579f9a07b0052cb18b416db888a34a1311c13"

RDEPENDS:rust-cordic+default-devel = " \
 cargo \
 rust-cordic-devel \
 "
RDEPENDS:rust-cordic-devel = " \
 cargo \
 rust-fixed+default-devel \
 "
