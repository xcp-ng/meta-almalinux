# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-exr"
PV = "1.73.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-exr+default-devel \
 rust-exr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-exr-1.73.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fe6f43e8fa975f31899ab953709a90f88d31408d6db74d5b1951c492f01bc66"

URI_x86_64_v2_rust-exr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-exr+default-devel-1.73.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-exr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-exr+default-devel}"
SRC_URI[x86_64_v2_rust-exr+default-devel.sha256sum] = "e4538bb49d05ac3275e8b8285bdda0f49025287f4475df28031540569f1a31c0"

URI_x86_64_v2_rust-exr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-exr-devel-1.73.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-exr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-exr-devel}"
SRC_URI[x86_64_v2_rust-exr-devel.sha256sum] = "cb2c063d0184faf45d1cd608742e78e2bd207fee838876196d7f84851f15f5d3"

URI_aarch64_rust-exr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-exr+default-devel-1.73.0-1.el10_0.noarch.rpm;name=aarch64_rust-exr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-exr+default-devel}"
SRC_URI[aarch64_rust-exr+default-devel.sha256sum] = "718b276a72092ecbdc6c93e4f0c8fae0a48ff0ca6070527bfbdb70c87e1c0d69"

URI_aarch64_rust-exr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-exr-devel-1.73.0-1.el10_0.noarch.rpm;name=aarch64_rust-exr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-exr-devel}"
SRC_URI[aarch64_rust-exr-devel.sha256sum] = "5855180d8151bc84cb8e63e086aa0c60a8ffd542c8853071db1a239f01442668"

RDEPENDS:rust-exr+default-devel = " \
 cargo \
 rust-exr-devel \
 "
RDEPENDS:rust-exr-devel = " \
 cargo \
 rust \
 rust-bit_field+default-devel \
 rust-half+default-devel \
 rust-lebe+default-devel \
 rust-miniz_oxide+default-devel \
 rust-rayon-core+default-devel \
 rust-smallvec+default-devel \
 rust-zune-inflate+zlib-devel \
 rust-zune-inflate-devel \
 "
