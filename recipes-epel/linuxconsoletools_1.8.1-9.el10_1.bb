# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linuxconsoletools"
PV = "1.8.1"
PR = "9.el10_1"
PACKAGES = " \
 linuxconsoletools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/linuxconsoletools-1.8.1-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4947ea7a78eaa48107f3ba77e4dd76b8bfe7328e7427931157896e6aa68c1c9d"

URI_x86_64_v2_linuxconsoletools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/linuxconsoletools-1.8.1-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_linuxconsoletools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linuxconsoletools}"
SRC_URI[x86_64_v2_linuxconsoletools.sha256sum] = "27d3e7fa7790e865ecdd946a422985a362903ac5c1f16779fb5692b1fbe8422c"

URI_aarch64_linuxconsoletools = "${EPEL_MIRROR}/aarch64/Packages/l/linuxconsoletools-1.8.1-9.el10_1.aarch64.rpm;name=aarch64_linuxconsoletools;unpack=0"
SRC_URI:append = " ${URI_aarch64_linuxconsoletools}"
SRC_URI[aarch64_linuxconsoletools.sha256sum] = "aa952412a01f5b39502395c65f71e0b47f561e1cf0fe02912d9935b45441d49e"

RDEPENDS:linuxconsoletools = " \
 bash \
 gawk \
 glibc \
 sdl2-compat \
 "
