# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cgit"
PV = "1.2.3"
PR = "19.el10_0"
PACKAGES = " \
 cgit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cgit-1.2.3-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "baffb3645b87aad893bf5b4d28004756e892979636e94e4ee22e9b5b246f9e60"

URI_x86_64_v2_cgit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgit-1.2.3-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgit}"
SRC_URI[x86_64_v2_cgit.sha256sum] = "ff901399264ed5ae7c6b2866192afbdeafc233e3598b7021bf7cb622d49b8500"

URI_aarch64_cgit = "${EPEL_MIRROR}/aarch64/Packages/c/cgit-1.2.3-19.el10_0.aarch64.rpm;name=aarch64_cgit;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgit}"
SRC_URI[aarch64_cgit.sha256sum] = "98374b1f0cbec01fb9ac3e79d8b26973f73c79f649ed96954e746e695565ed5b"

RDEPENDS:cgit = " \
 bash \
 glibc \
 httpd-filesystem \
 lua-libs \
 python3 \
 virtual/webserver \
 zlib-ng-compat \
 "
