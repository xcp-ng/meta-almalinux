# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "slang"
PV = "2.3.3"
PR = "8.el10"
PACKAGES = " \
 slang \
 slang-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/slang-2.3.3-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2d22b2edee55a6730c932014e8ba5eb590908057af1ae09b260f64e11e2087d"

URI_x86_64_v2_slang = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/slang-2.3.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_slang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slang}"
SRC_URI[x86_64_v2_slang.sha256sum] = "e8de2cd931ca3c41d2929ffcb095c78664d6a15efe455fd08653ea976707c023"

URI_x86_64_v2_slang-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/slang-devel-2.3.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_slang-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slang-devel}"
SRC_URI[x86_64_v2_slang-devel.sha256sum] = "0556477ae5fe4850021b33134a572024e6d926a717567fd146e7dfaba4dcd95e"

URI_aarch64_slang = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/slang-2.3.3-8.el10.aarch64.rpm;name=aarch64_slang;unpack=0"
SRC_URI:append = " ${URI_aarch64_slang}"
SRC_URI[aarch64_slang.sha256sum] = "f1d35ec4a3d99fd52bfdf1d103b3528ca1385c1c664160132be7014f33bcc1df"

URI_aarch64_slang-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/slang-devel-2.3.3-8.el10.aarch64.rpm;name=aarch64_slang-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_slang-devel}"
SRC_URI[aarch64_slang-devel.sha256sum] = "75194b6a9128ba5f8f8383ee2838ed7096c47250a84f77e3b81387af9ef25ad7"

RDEPENDS:slang = " \
 glibc \
 "
RDEPENDS:slang-devel = " \
 pkgconf-pkg-config \
 slang \
 "
