# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "korganizer"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 korganizer \
 korganizer-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/korganizer-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f81e19d63b8e1c4ab6d5333b5d9e48c734a83680b38c1cc97e1c31d4beec22e2"

URI_x86_64_v2_korganizer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/korganizer-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_korganizer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_korganizer}"
SRC_URI[x86_64_v2_korganizer.sha256sum] = "fa887775a990d71223f3c3bc58664d9bfc65929eaee071882a0af3f2a1c8f920"

URI_x86_64_v2_korganizer-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/korganizer-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_korganizer-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_korganizer-libs}"
SRC_URI[x86_64_v2_korganizer-libs.sha256sum] = "1a3ee96106dd3d2d27715121d6069ed6540a1d5465fa821c56556a25713047c1"

URI_aarch64_korganizer = "${EPEL_MIRROR}/aarch64/Packages/k/korganizer-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_korganizer;unpack=0"
SRC_URI:append = " ${URI_aarch64_korganizer}"
SRC_URI[aarch64_korganizer.sha256sum] = "a112e222f21f8edd9078489d72be4bf7d550bdaff0d90c2b9a431d54c753487e"

URI_aarch64_korganizer-libs = "${EPEL_MIRROR}/aarch64/Packages/k/korganizer-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_korganizer-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_korganizer-libs}"
SRC_URI[aarch64_korganizer-libs.sha256sum] = "e9c4d85b9e1368f4f2789af554f6878825a45e5691e72af55c5ead3fe23413cc"

RDEPENDS:korganizer = " \
 akonadi-server \
 glibc \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kparts \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kontactinterface \
 korganizer-libs \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:korganizer-libs = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-server \
 calendarsupport \
 eventviews \
 glibc \
 incidenceeditor \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kmailtransport \
 kmime \
 kontactinterface \
 korganizer \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
