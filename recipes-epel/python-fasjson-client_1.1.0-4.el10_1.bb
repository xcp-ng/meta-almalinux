# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fasjson-client"
PV = "1.1.0"
PR = "4.el10_1"
PACKAGES = " \
 fasjson-client \
 python3-fasjson-client \
 python3-fasjson-client+cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fasjson-client-1.1.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dccb5d3af266e2a2e13690ba4d8d76e031f3f49b83f4dd28125017f375c43bc"

URI_x86_64_v2_fasjson-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fasjson-client-1.1.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fasjson-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fasjson-client}"
SRC_URI[x86_64_v2_fasjson-client.sha256sum] = "04d9d94dec5250513020e283e28e3a552887baa3e70891d4aac82430ab5e73d3"

URI_x86_64_v2_python3-fasjson-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fasjson-client-1.1.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fasjson-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fasjson-client}"
SRC_URI[x86_64_v2_python3-fasjson-client.sha256sum] = "7b965b7f2ea1b9dea16cd0b3b95c5f2ee0f5c6da98bd802c093d1f5ee8688722"

URI_x86_64_v2_python3-fasjson-client+cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fasjson-client+cli-1.1.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fasjson-client+cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fasjson-client+cli}"
SRC_URI[x86_64_v2_python3-fasjson-client+cli.sha256sum] = "616df6f79810e0f67b8deed2b2a603f78be6b0be6fc8f8ea7ae2764487056e62"

URI_aarch64_fasjson-client = "${EPEL_MIRROR}/aarch64/Packages/f/fasjson-client-1.1.0-4.el10_1.noarch.rpm;name=aarch64_fasjson-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_fasjson-client}"
SRC_URI[aarch64_fasjson-client.sha256sum] = "1d0fbc0cdad18b81b5c03a59e9b73da1cb7290d68276790fe46d12d67ef8bd23"

URI_aarch64_python3-fasjson-client = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fasjson-client-1.1.0-4.el10_1.noarch.rpm;name=aarch64_python3-fasjson-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fasjson-client}"
SRC_URI[aarch64_python3-fasjson-client.sha256sum] = "647d5be30d4d228c5fb082323d33a7c035572b6c911c95a36eea2e9524146663"

URI_aarch64_python3-fasjson-client+cli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fasjson-client+cli-1.1.0-4.el10_1.noarch.rpm;name=aarch64_python3-fasjson-client+cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fasjson-client+cli}"
SRC_URI[aarch64_python3-fasjson-client+cli.sha256sum] = "88196b7d20f8925c9034fd8bc69129741a9067a492b5e0e07a376a1208692062"

RDEPENDS:fasjson-client = " \
 python3 \
 python3-fasjson-client+cli \
 "
RDEPENDS:python3-fasjson-client = " \
 python3 \
 python3-bravado \
 python3-gssapi \
 python3-requests \
 python3-requests-gssapi \
 "
RDEPENDS:python3-fasjson-client+cli = " \
 python3 \
 python3-click \
 python3-cryptography \
 python3-fasjson-client \
 "
