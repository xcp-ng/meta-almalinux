# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plymouth-theme-hot-dog"
PV = "0.5"
PR = "28.el10_1"
PACKAGES = " \
 plymouth-theme-hot-dog \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plymouth-theme-hot-dog-0.5-28.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1088fc9bab2a8939653246428eab91ae8ead9dca4b7987eeb2873ff72ed87bc"

URI_x86_64_v2_plymouth-theme-hot-dog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plymouth-theme-hot-dog-0.5-28.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_plymouth-theme-hot-dog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-hot-dog}"
SRC_URI[x86_64_v2_plymouth-theme-hot-dog.sha256sum] = "79080891e531b25c09153a2630963cfee3a28ab8b87c0d377bb32b84b41b4d1c"

URI_aarch64_plymouth-theme-hot-dog = "${EPEL_MIRROR}/aarch64/Packages/p/plymouth-theme-hot-dog-0.5-28.el10_1.noarch.rpm;name=aarch64_plymouth-theme-hot-dog;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-hot-dog}"
SRC_URI[aarch64_plymouth-theme-hot-dog.sha256sum] = "d12be368e3ee3796ade23146029c6e9c4423479d7a5695b2b7cbc4cf0e32dbc9"

RDEPENDS:plymouth-theme-hot-dog = " \
 bash \
 plymouth-plugin-two-step \
 plymouth-scripts \
 "
