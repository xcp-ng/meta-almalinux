# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-software"
PV = "47.5"
PR = "1.el10"
PACKAGES = " \
 gnome-software \
 gnome-software-devel \
 gnome-software-fedora-langpacks \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-software-47.5-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de2b178e637dfc4086b4e2193276a97bd209957fa0f7f93982be20e0d70f8ddb"

URI_x86_64_v2_gnome-software = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-software-47.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-software;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-software}"
SRC_URI[x86_64_v2_gnome-software.sha256sum] = "4200b3e363fc54e145a5094effdd7ed8b23185023a264d7b75c48667ea101e46"

URI_x86_64_v2_gnome-software-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-software-devel-47.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-software-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-software-devel}"
SRC_URI[x86_64_v2_gnome-software-devel.sha256sum] = "eec8483b32d95e81a038bc4f496c87452d341badaf3de13ee5301c7a4195000a"

URI_x86_64_v2_gnome-software-fedora-langpacks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-software-fedora-langpacks-47.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-software-fedora-langpacks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-software-fedora-langpacks}"
SRC_URI[x86_64_v2_gnome-software-fedora-langpacks.sha256sum] = "79faf02818cf1b204c5bca4d47d20900d1c33e138f6965d7522d92a43bd377f8"

URI_aarch64_gnome-software = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-software-47.5-1.el10.aarch64.rpm;name=aarch64_gnome-software;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-software}"
SRC_URI[aarch64_gnome-software.sha256sum] = "acb5afa8697b3c676071aef279f612259cc8fed489c2a64de9c443d9ff909316"

URI_aarch64_gnome-software-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-software-devel-47.5-1.el10.aarch64.rpm;name=aarch64_gnome-software-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-software-devel}"
SRC_URI[aarch64_gnome-software-devel.sha256sum] = "0bb06da7fe64f0241aff8b289c52083d17f34ccec61d22872f99d81c70318d06"

URI_aarch64_gnome-software-fedora-langpacks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-software-fedora-langpacks-47.5-1.el10.aarch64.rpm;name=aarch64_gnome-software-fedora-langpacks;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-software-fedora-langpacks}"
SRC_URI[aarch64_gnome-software-fedora-langpacks.sha256sum] = "0d4b551594a9d90293041fd7a7b0585e89593edea5015493cfbf546760d27520"

RDEPENDS:gnome-software = " \
 PackageKit-glib \
 appstream \
 appstream-data \
 flatpak \
 flatpak-libs \
 fwupd \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-menus \
 gsettings-desktop-schemas \
 gtk4 \
 iso-codes \
 json-glib \
 libadwaita \
 libgcc \
 libgudev \
 librsvg2 \
 libsoup3 \
 libxmlb \
 ostree-libs \
 pango \
 polkit-libs \
 "
RDEPENDS:gnome-software-devel = " \
 appstream-devel \
 glib2-devel \
 gnome-software \
 gtk4-devel \
 json-glib-devel \
 libsoup3-devel \
 libxmlb-devel \
 pkgconf-pkg-config \
 polkit-devel \
 sysprof-capture-devel \
 "
RDEPENDS:gnome-software-fedora-langpacks = " \
 glib2 \
 glibc \
 gnome-software \
 libgcc \
 "
