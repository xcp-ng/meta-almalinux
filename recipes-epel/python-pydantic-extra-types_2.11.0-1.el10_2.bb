# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pydantic-extra-types"
PV = "2.11.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-pydantic-extra-types \
 python3-pydantic-extra-types+cron \
 python3-pydantic-extra-types+python_ulid \
 python3-pydantic-extra-types+semver \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-pydantic-extra-types-2.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ec6058fdabd66d3946bf8cc0f9c1a4c05b4dbad708453ca02ba4c5547f95c52b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-extra-types-2.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic-extra-types;unpack=0"
SRC_URI[x86_64_v2_python3-pydantic-extra-types.sha256sum] = "cb5eeedee831f5df1c17cd886568e911384ec0873b572970d07c7fb9569f0dd9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-extra-types+cron-2.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic-extra-types+cron;unpack=0"
SRC_URI[x86_64_v2_python3-pydantic-extra-types+cron.sha256sum] = "bf3162e671624d1d2c669306e1628f2ef72e2f4309da336feb48da2988b77b8a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-extra-types+python_ulid-2.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic-extra-types+python_ulid;unpack=0"
SRC_URI[x86_64_v2_python3-pydantic-extra-types+python_ulid.sha256sum] = "aa301995c8be125d52ceab0cfbcac716f3641ccdbece70bc5902fefb8e422cb2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-extra-types+semver-2.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic-extra-types+semver;unpack=0"
SRC_URI[x86_64_v2_python3-pydantic-extra-types+semver.sha256sum] = "a0e330f0e0cef2a899b592ff839c21794d444ea182daad66d6f750dac0f080e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-extra-types-2.11.0-1.el10_2.noarch.rpm;name=aarch64_python3-pydantic-extra-types;unpack=0"
SRC_URI[aarch64_python3-pydantic-extra-types.sha256sum] = "7e5b99774a63bfe52a4549f06e89e20c3f2270277aa21f5435e2b6ecb80c9d98"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-extra-types+cron-2.11.0-1.el10_2.noarch.rpm;name=aarch64_python3-pydantic-extra-types+cron;unpack=0"
SRC_URI[aarch64_python3-pydantic-extra-types+cron.sha256sum] = "ab8d7ca8c9aca7f70f485294a6f29e993aee6f900a7dcb43d92c29af2c973eb2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-extra-types+python_ulid-2.11.0-1.el10_2.noarch.rpm;name=aarch64_python3-pydantic-extra-types+python_ulid;unpack=0"
SRC_URI[aarch64_python3-pydantic-extra-types+python_ulid.sha256sum] = "1343d44466461fd6e92522d4b1b749d051bd80fa727246f904f384bb319b420d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-extra-types+semver-2.11.0-1.el10_2.noarch.rpm;name=aarch64_python3-pydantic-extra-types+semver;unpack=0"
SRC_URI[aarch64_python3-pydantic-extra-types+semver.sha256sum] = "dd335464c97e55c47dc6c0697d3958940af42e2528cade87461d701136b4a9c4"

RDEPENDS:python3-pydantic-extra-types = " \
 python3 \
 python3-pydantic \
 python3-typing-extensions \
 "
RDEPENDS:python3-pydantic-extra-types+cron = " \
 python3 \
 python3-cron-converter \
 python3-pydantic-extra-types \
 "
RDEPENDS:python3-pydantic-extra-types+python_ulid = " \
 python3 \
 python3-pydantic-extra-types \
 python3-python-ulid \
 "
RDEPENDS:python3-pydantic-extra-types+semver = " \
 python3 \
 python3-pydantic-extra-types \
 python3-semver \
 "
