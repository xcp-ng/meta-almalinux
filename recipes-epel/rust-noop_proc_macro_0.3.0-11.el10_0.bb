# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-noop_proc_macro"
PV = "0.3.0"
PR = "11.el10_0"
PACKAGES = " \
 rust-noop_proc_macro+default-devel \
 rust-noop_proc_macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-noop_proc_macro-0.3.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e949a5538aa93aa64e8b608106010592ce35f1b72e94ed31fba9a0004f35aeba"

URI_x86_64_v2_rust-noop_proc_macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-noop_proc_macro+default-devel-0.3.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-noop_proc_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-noop_proc_macro+default-devel}"
SRC_URI[x86_64_v2_rust-noop_proc_macro+default-devel.sha256sum] = "a457fe2143466fb8e2f53fae272535d895ea86a7c123e81a38dbac9fbfb54b35"

URI_x86_64_v2_rust-noop_proc_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-noop_proc_macro-devel-0.3.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-noop_proc_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-noop_proc_macro-devel}"
SRC_URI[x86_64_v2_rust-noop_proc_macro-devel.sha256sum] = "0756647bfeccbf4602567c92d308c28151504e431f67435717806149b61e1242"

URI_aarch64_rust-noop_proc_macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-noop_proc_macro+default-devel-0.3.0-11.el10_0.noarch.rpm;name=aarch64_rust-noop_proc_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-noop_proc_macro+default-devel}"
SRC_URI[aarch64_rust-noop_proc_macro+default-devel.sha256sum] = "ab6aa8460861647d87719e0be6050d899cdda103afcadd223055c4ff301bdf75"

URI_aarch64_rust-noop_proc_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-noop_proc_macro-devel-0.3.0-11.el10_0.noarch.rpm;name=aarch64_rust-noop_proc_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-noop_proc_macro-devel}"
SRC_URI[aarch64_rust-noop_proc_macro-devel.sha256sum] = "9dd75e6f7715a132408867ae715b1362ed80ac22df81606d454da1e1aeef820d"

RDEPENDS:rust-noop_proc_macro+default-devel = " \
 cargo \
 rust-noop_proc_macro-devel \
 "
RDEPENDS:rust-noop_proc_macro-devel = " \
 cargo \
 "
