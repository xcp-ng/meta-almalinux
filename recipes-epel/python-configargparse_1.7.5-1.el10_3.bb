# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-configargparse"
PV = "1.7.5"
PR = "1.el10_3"
PACKAGES = " \
 python3-configargparse \
 python3-configargparse+yaml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-configargparse-1.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc59bdb53dc78a850ae01255d30441b74f4a5f3af249135522cd4fbd436ba932"

URI_x86_64_v2_python3-configargparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-configargparse-1.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-configargparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-configargparse}"
SRC_URI[x86_64_v2_python3-configargparse.sha256sum] = "2a1b4601087d8b879bfbfe5ef09a4678b404c051106e75ad4ffe7c6948218e7c"

URI_x86_64_v2_python3-configargparse+yaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-configargparse+yaml-1.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-configargparse+yaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-configargparse+yaml}"
SRC_URI[x86_64_v2_python3-configargparse+yaml.sha256sum] = "b423531805977246ee1f3f4da15c3624761b8f51df480e3fe1f1e62c30256596"

URI_aarch64_python3-configargparse = "${EPEL_MIRROR}/aarch64/Packages/p/python3-configargparse-1.7.5-1.el10_3.noarch.rpm;name=aarch64_python3-configargparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-configargparse}"
SRC_URI[aarch64_python3-configargparse.sha256sum] = "b1087c05ac589176abca460f566bacc6a68ee397cf86d8c6990ba9e80c44a7b9"

URI_aarch64_python3-configargparse+yaml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-configargparse+yaml-1.7.5-1.el10_3.noarch.rpm;name=aarch64_python3-configargparse+yaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-configargparse+yaml}"
SRC_URI[aarch64_python3-configargparse+yaml.sha256sum] = "a22195a1a5341424f8312947f287a050eb6d74f9e2b4c43350e6305397806ce6"

RDEPENDS:python3-configargparse = " \
 python3 \
 "
RDEPENDS:python3-configargparse+yaml = " \
 python3 \
 python3-configargparse \
 python3-pyyaml \
 "
