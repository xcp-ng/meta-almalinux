# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-netlink-packet-route"
PV = "0.22.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-netlink-packet-route+default-devel \
 rust-netlink-packet-route+rich_nlas-devel \
 rust-netlink-packet-route-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-netlink-packet-route-0.22.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d4b9efc2ee4d35225fc84ff534bbb29702d038c3a0bf0bcd7ded3ecb91a2e6c"

URI_x86_64_v2_rust-netlink-packet-route+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-packet-route+default-devel-0.22.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-packet-route+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-packet-route+default-devel}"
SRC_URI[x86_64_v2_rust-netlink-packet-route+default-devel.sha256sum] = "bb327c5c1991ccf8f6086a7464bbc27304b12c4f70abd6c01c4591d81cdff0dc"

URI_x86_64_v2_rust-netlink-packet-route+rich_nlas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-packet-route+rich_nlas-devel-0.22.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-packet-route+rich_nlas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-packet-route+rich_nlas-devel}"
SRC_URI[x86_64_v2_rust-netlink-packet-route+rich_nlas-devel.sha256sum] = "e304f278217dd7597fbf715e51c9b3e27811498b7db8740da9764b034963da6c"

URI_x86_64_v2_rust-netlink-packet-route-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-packet-route-devel-0.22.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-packet-route-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-packet-route-devel}"
SRC_URI[x86_64_v2_rust-netlink-packet-route-devel.sha256sum] = "8904a8a94c6ec152ee97412eba733207a10a31c833e4d8b2b8d4be1fb7e02617"

URI_aarch64_rust-netlink-packet-route+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-packet-route+default-devel-0.22.0-2.el10_0.noarch.rpm;name=aarch64_rust-netlink-packet-route+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-packet-route+default-devel}"
SRC_URI[aarch64_rust-netlink-packet-route+default-devel.sha256sum] = "2e4e24a431245cf1580676de59f88f12a3efa96ea5f2c1c5aa26d84490a25b9d"

URI_aarch64_rust-netlink-packet-route+rich_nlas-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-packet-route+rich_nlas-devel-0.22.0-2.el10_0.noarch.rpm;name=aarch64_rust-netlink-packet-route+rich_nlas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-packet-route+rich_nlas-devel}"
SRC_URI[aarch64_rust-netlink-packet-route+rich_nlas-devel.sha256sum] = "55e0e9ba4f6b8a42327f6578a0b55a75af3ce25381623e87515c26a022a63f34"

URI_aarch64_rust-netlink-packet-route-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-packet-route-devel-0.22.0-2.el10_0.noarch.rpm;name=aarch64_rust-netlink-packet-route-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-packet-route-devel}"
SRC_URI[aarch64_rust-netlink-packet-route-devel.sha256sum] = "58a0f892e45485ec2c55fc059f4e2c0cb821f81aaf6c7450a865e9082c38c5c3"

RDEPENDS:rust-netlink-packet-route+default-devel = " \
 cargo \
 rust-netlink-packet-route-devel \
 "
RDEPENDS:rust-netlink-packet-route+rich_nlas-devel = " \
 cargo \
 rust-netlink-packet-route-devel \
 "
RDEPENDS:rust-netlink-packet-route-devel = " \
 bash \
 cargo \
 python3 \
 rust-anyhow+default-devel \
 rust-bitflags+default-devel \
 rust-byteorder+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-log+std-devel \
 rust-netlink-packet-core+default-devel \
 rust-netlink-packet-utils+default-devel \
 "
