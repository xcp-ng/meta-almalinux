# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-io"
PV = "0.18.1"
PR = "1.el10_0"
PACKAGES = " \
 aws-c-io \
 aws-c-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-io-0.18.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa62c28e33b108e7ecb0c0aafe0079db21e752d1a56d37ad5952c615eff33b0a"

URI_x86_64_v2_aws-c-io = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-io-0.18.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-io;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-io}"
SRC_URI[x86_64_v2_aws-c-io.sha256sum] = "33571031655d4e57b9c448457d882f5a49a9f718faabbe9ccbdd98a6d20cff94"

URI_x86_64_v2_aws-c-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-io-devel-0.18.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-io-devel}"
SRC_URI[x86_64_v2_aws-c-io-devel.sha256sum] = "5fc44f9e62c453fcd508dbfaef6305272c8c85be198472872d36610fea79bd0c"

URI_aarch64_aws-c-io = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-io-0.18.1-1.el10_0.aarch64.rpm;name=aarch64_aws-c-io;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-io}"
SRC_URI[aarch64_aws-c-io.sha256sum] = "f568ab88bb4268d65560309c722099680c289d09e2426a5498b587aba918b58f"

URI_aarch64_aws-c-io-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-io-devel-0.18.1-1.el10_0.aarch64.rpm;name=aarch64_aws-c-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-io-devel}"
SRC_URI[aarch64_aws-c-io-devel.sha256sum] = "1e4d96a0d98fe25a629354ece044c3aac444897c3471d3adedb2645d246147d8"

RDEPENDS:aws-c-io = " \
 aws-c-cal-libs \
 aws-c-common-libs \
 glibc \
 s2n-tls \
 "
RDEPENDS:aws-c-io-devel = " \
 aws-c-cal-devel \
 aws-c-common-devel \
 aws-c-io \
 cmake-filesystem \
 openssl-devel \
 s2n-tls-devel \
 "
