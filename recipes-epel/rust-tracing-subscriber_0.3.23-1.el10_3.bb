# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-subscriber"
PV = "0.3.23"
PR = "1.el10_3"
PACKAGES = " \
 rust-tracing-subscriber+alloc-devel \
 rust-tracing-subscriber+ansi-devel \
 rust-tracing-subscriber+chrono-devel \
 rust-tracing-subscriber+default-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+json-devel \
 rust-tracing-subscriber+local-time-devel \
 rust-tracing-subscriber+matchers-devel \
 rust-tracing-subscriber+nu-ansi-term-devel \
 rust-tracing-subscriber+once_cell-devel \
 rust-tracing-subscriber+parking_lot-devel \
 rust-tracing-subscriber+regex-devel \
 rust-tracing-subscriber+registry-devel \
 rust-tracing-subscriber+serde-devel \
 rust-tracing-subscriber+serde_json-devel \
 rust-tracing-subscriber+sharded-slab-devel \
 rust-tracing-subscriber+smallvec-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber+thread_local-devel \
 rust-tracing-subscriber+time-devel \
 rust-tracing-subscriber+tracing-devel \
 rust-tracing-subscriber+tracing-log-devel \
 rust-tracing-subscriber+tracing-serde-devel \
 rust-tracing-subscriber-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-subscriber-0.3.23-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9e9cfd760fdae3a54c5ef3d70411b691da2c4853a244d9be4aaf9ad03e3d5fa8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+alloc-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+alloc-devel.sha256sum] = "902fbc65b75f6cc18c8eb950b606d90e74349b85037e7ce32f42dea14339b49c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+ansi-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+ansi-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+ansi-devel.sha256sum] = "bb18c1a354924b34ec52f66cdfa53ccaa585e202143e7f67d047d6204c4fae29"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+chrono-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+chrono-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+chrono-devel.sha256sum] = "9415f88543ce4844e3b8c0d94cf65e0515365b57a5dd2b5b805b629661428993"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+default-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+default-devel.sha256sum] = "2da73a428eb94f1aff47bb52e2a149ec816d2d44fd282d9d63eb39267efac938"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+env-filter-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+env-filter-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+env-filter-devel.sha256sum] = "5d21f0b6881cd211f0ce22e0e902064f0ff9539246340c2894fba194728fae82"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+fmt-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+fmt-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+fmt-devel.sha256sum] = "0d1da9bc49450291b6d298a4a69e88145d60a4cd8496759f4ed3784dfdb063f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+json-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+json-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+json-devel.sha256sum] = "4b64d752544a452f5c6bcf458d34a55dcd4c5e8fc044be1f4311618cde3eacde"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+local-time-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+local-time-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+local-time-devel.sha256sum] = "4f04ea6f84abc768aa65107985b5d0bb6ad5bf5e7f65187841c0f5eff2039a94"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+matchers-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+matchers-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+matchers-devel.sha256sum] = "b947f6f10d30d7fd8dd400980a3e809094f688da7893f4b28ea24853ccafe9b4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+nu-ansi-term-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+nu-ansi-term-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+nu-ansi-term-devel.sha256sum] = "b463c66c134aaa906c0c03fd11b1cc1cecd9715bc393d914d45e8358c525bdec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+once_cell-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+once_cell-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+once_cell-devel.sha256sum] = "1f6a9a37899f5e8944b3baeaf323cde6f08cf349912d4ec5ef59b55ca385085e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+parking_lot-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+parking_lot-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+parking_lot-devel.sha256sum] = "e0a05122e27aa6c66855ce80f28b2dfbdd5a0f7c492d359eced95ca23da93a5f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+regex-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+regex-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+regex-devel.sha256sum] = "56f4b4929b110ccb1cbf1356e37f89dbb2656896d07de4359ab661e7410cbdd7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+registry-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+registry-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+registry-devel.sha256sum] = "e2e51d3e1bbe8380b17285e6a7d028042859a823bb9977ab18b4ee78555f2467"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+serde-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+serde-devel.sha256sum] = "27f49c0cde69282bee25e1823eee2437fed90f676338bbdc5c60d8182d409d13"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+serde_json-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+serde_json-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+serde_json-devel.sha256sum] = "452df363965b5728cd997fe001aac9756b08c544e6860b9ce8de33557a957a3f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+sharded-slab-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+sharded-slab-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+sharded-slab-devel.sha256sum] = "c0ad44d7caf199b37c961ade4739f16985be2d0964161c0f60b2f493763b6ecf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+smallvec-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+smallvec-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+smallvec-devel.sha256sum] = "34cd860f549805121614399095d663c17d664c30d84381c6a4f9f5e59accc8b9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+std-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+std-devel.sha256sum] = "53e416bb21891d4487b05498c9d8810e82cd1e117027c738fa2427b5fad62edc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+thread_local-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+thread_local-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+thread_local-devel.sha256sum] = "b1616f7074649657b26a56fe0a0ed8d14069571656e4b3947f057268b9a47391"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+time-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+time-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+time-devel.sha256sum] = "1c91c0174cf4c0cbbf3bf860d0e70c959f4fa4cce9fe200a2427eb5785184e81"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+tracing-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+tracing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+tracing-devel.sha256sum] = "165b28ee7521d6c4a79bebf50364d8043463295ac1174fc9fa988dd3a8de6c73"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+tracing-log-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+tracing-log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+tracing-log-devel.sha256sum] = "701f8e3776fe09f8368e0947d5a5e341493e8f3eaccd2306b0e998e02ff1ac93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+tracing-serde-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+tracing-serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber+tracing-serde-devel.sha256sum] = "ba1a684634023895b940e4cd7842db1d17d229e1b510a1b319a632fd31509f48"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber-devel-0.3.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tracing-subscriber-devel.sha256sum] = "0cf6d046156b6fc1c15cced18788989b28fb23d1af9cfe72b3f5eb3407e68fcf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+alloc-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+alloc-devel.sha256sum] = "5023cc7672bf365c1fb54ff719d176ecc0732f6e79bfa2a0bce27d72f23b3b12"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+ansi-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+ansi-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+ansi-devel.sha256sum] = "392cc900d2ed206f2bbe968180c41700c42eeb87d3d8b806a2495151be37cc61"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+chrono-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+chrono-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+chrono-devel.sha256sum] = "fd0fa53fb3b1adb0dd6fa5fd140859e5c88ceae682e2390b17f1198440d5cd2d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+default-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+default-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+default-devel.sha256sum] = "2fb459664957364de98264657bb65a6cfd3e4ff0ae416d5f8f682601b8f366eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+env-filter-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+env-filter-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+env-filter-devel.sha256sum] = "37bbff2ba1a71eafdd8fb71849392aa9ef28b948ac8eb93ee2387b0842c3d0b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+fmt-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+fmt-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+fmt-devel.sha256sum] = "5534c79975618f49b427fd370a5632e18bee06e9a4f5958bcf5c5e282d045bb5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+json-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+json-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+json-devel.sha256sum] = "8de9b1279ec7f18a0a284936ef1c4524e2699374ed6ab0a5deced817fa4ade9f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+local-time-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+local-time-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+local-time-devel.sha256sum] = "c9a60985784933ea920515ad614efd51a69beb79e9037d1e158961dd5625b3b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+matchers-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+matchers-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+matchers-devel.sha256sum] = "e786805478972a45d574f1dcd089053df8f584a1a647bcd21140d3bc11fb87d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+nu-ansi-term-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+nu-ansi-term-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+nu-ansi-term-devel.sha256sum] = "0d1483024cd35a32517df60bb78a4dbcba3c1840dde1cb24290037c21148b133"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+once_cell-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+once_cell-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+once_cell-devel.sha256sum] = "ff5b6ce50c6ae5d20bc32974e430578045de112d9d2b50f0407364987e63a80f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+parking_lot-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+parking_lot-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+parking_lot-devel.sha256sum] = "8f87b1fdf0a78d02a67973f1d60c089e72cbd697970ee9824ea16e5ee3abd265"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+regex-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+regex-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+regex-devel.sha256sum] = "0f36375b8a8e1778d6db57803217df0465506e10ceb7b3aff494fd1dad3db8d1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+registry-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+registry-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+registry-devel.sha256sum] = "8a0d7f1d2efa36cb7fc1384e453230f3cbfdc47285db93df34a28d80ce8274e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+serde-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+serde-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+serde-devel.sha256sum] = "a50f764e144f71e76c16e392241a6a6e654f0c6f29306d088e585d1c3bbf1821"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+serde_json-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+serde_json-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+serde_json-devel.sha256sum] = "3539600ca70a6c2b145f211114ecf44da2cd553e4f70d9562c8567ccf2669150"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+sharded-slab-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+sharded-slab-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+sharded-slab-devel.sha256sum] = "4e0a8525050ee6e7840dbe7b376899cf62339e04c424a37a229f558db01405a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+smallvec-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+smallvec-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+smallvec-devel.sha256sum] = "7534a4aabc8f646c12fc29c11a58251c9ede200be9ebabda54253a55baba7725"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+std-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+std-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+std-devel.sha256sum] = "ecaf6d75b54446d7eaf9d72f0c2d94154649d217151a4060bd45c6ade814efa6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+thread_local-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+thread_local-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+thread_local-devel.sha256sum] = "ceee14396420b15565f7ad6e61c451b550a2b2cb68b1b19bc1e01a950810ee11"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+time-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+time-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+time-devel.sha256sum] = "d6ae16ad01fb7f03f27f13e5c23ba81b0dacf6a34bb84dee0194e68f1eef69f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+tracing-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+tracing-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+tracing-devel.sha256sum] = "414b723cbe947533244781c0391e209a31e2255786fd0aa4c82073e3eece1866"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+tracing-log-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+tracing-log-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+tracing-log-devel.sha256sum] = "231ccb95882219bab4f7d5de7f73bfe37cc17bf5abd4feadcbf5e73f7072eeca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+tracing-serde-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber+tracing-serde-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber+tracing-serde-devel.sha256sum] = "4c08fd4e8ced4d5f0b20e3346c22ceade31870f2460def8854aaafe75095810e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber-devel-0.3.23-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-subscriber-devel;unpack=0"
SRC_URI[aarch64_rust-tracing-subscriber-devel.sha256sum] = "cc820136686f6fd98225cf3676c970dca0164057d65feb6e215beca3421fc0ae"

RDEPENDS:rust-tracing-subscriber+alloc-devel = " \
 cargo \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+ansi-devel = " \
 cargo \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+nu-ansi-term-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+default-devel = " \
 cargo \
 rust-tracing-subscriber+ansi-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+smallvec-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber+tracing-log-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+env-filter-devel = " \
 cargo \
 rust-regex-automata+std-devel \
 rust-regex-automata-devel \
 rust-tracing-subscriber+matchers-devel \
 rust-tracing-subscriber+once_cell-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber+thread_local-devel \
 rust-tracing-subscriber+tracing-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+fmt-devel = " \
 cargo \
 rust-tracing-subscriber+registry-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+json-devel = " \
 cargo \
 rust-tracing-subscriber+serde-devel \
 rust-tracing-subscriber+serde_json-devel \
 rust-tracing-subscriber+tracing-serde-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+local-time-devel = " \
 cargo \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+matchers-devel = " \
 cargo \
 rust-matchers+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+nu-ansi-term-devel = " \
 cargo \
 rust-nu-ansi-term+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+regex-devel = " \
 cargo \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+registry-devel = " \
 cargo \
 rust-tracing-subscriber+sharded-slab-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber+thread_local-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+sharded-slab-devel = " \
 cargo \
 rust-sharded-slab+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+smallvec-devel = " \
 cargo \
 rust-smallvec+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+std-devel = " \
 cargo \
 rust-tracing-core+std-devel \
 rust-tracing-subscriber+alloc-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+thread_local-devel = " \
 cargo \
 rust-thread_local+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+time-devel = " \
 cargo \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+tracing-devel = " \
 cargo \
 rust-tracing-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+tracing-log-devel = " \
 cargo \
 rust-tracing-log+log-tracer-devel \
 rust-tracing-log+std-devel \
 rust-tracing-log-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+tracing-serde-devel = " \
 cargo \
 rust-tracing-serde+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber-devel = " \
 cargo \
 rust \
 rust-tracing-core-devel \
 "
