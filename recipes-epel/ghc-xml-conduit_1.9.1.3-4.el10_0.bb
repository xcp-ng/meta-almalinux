# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-xml-conduit"
PV = "1.9.1.3"
PR = "4.el10_0"
PACKAGES = " \
 ghc-xml-conduit \
 ghc-xml-conduit-devel \
 ghc-xml-conduit-doc \
 ghc-xml-conduit-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-xml-conduit-1.9.1.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0269fd5f10767498bda797ed56cea14cae1cfbef15aabf42dd5e8e406d7f6248"

URI_x86_64_v2_ghc-xml-conduit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-conduit-1.9.1.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xml-conduit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-conduit}"
SRC_URI[x86_64_v2_ghc-xml-conduit.sha256sum] = "2672490db1b400d6a937c936ba7c1e4896d82784be75ad96566d242e1f613773"

URI_x86_64_v2_ghc-xml-conduit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-conduit-devel-1.9.1.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xml-conduit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-conduit-devel}"
SRC_URI[x86_64_v2_ghc-xml-conduit-devel.sha256sum] = "c9caf1283e4584c2c769822521842d58bc86574dd1739ffd16c30346581c8d12"

URI_x86_64_v2_ghc-xml-conduit-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-conduit-doc-1.9.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-xml-conduit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-conduit-doc}"
SRC_URI[x86_64_v2_ghc-xml-conduit-doc.sha256sum] = "968021aed52d8205197bfec48cca23448e2af23a78cb6a8387036a94f3cb09ac"

URI_x86_64_v2_ghc-xml-conduit-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-conduit-prof-1.9.1.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xml-conduit-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-conduit-prof}"
SRC_URI[x86_64_v2_ghc-xml-conduit-prof.sha256sum] = "37bb98fef8dac6b34dc4962121b669efebc50faa35afae67c118262bedea362e"

URI_aarch64_ghc-xml-conduit = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-conduit-1.9.1.3-4.el10_0.aarch64.rpm;name=aarch64_ghc-xml-conduit;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-conduit}"
SRC_URI[aarch64_ghc-xml-conduit.sha256sum] = "31e3964a00cfb91ea787a0207004482cf46a263dbbafb3b937f8980ec747eb00"

URI_aarch64_ghc-xml-conduit-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-conduit-devel-1.9.1.3-4.el10_0.aarch64.rpm;name=aarch64_ghc-xml-conduit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-conduit-devel}"
SRC_URI[aarch64_ghc-xml-conduit-devel.sha256sum] = "1bcd4f96a65cbb944d34e98a41e34b453c77be0e9a03ab9f3292b3ab7d7be402"

URI_aarch64_ghc-xml-conduit-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-conduit-doc-1.9.1.3-4.el10_0.noarch.rpm;name=aarch64_ghc-xml-conduit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-conduit-doc}"
SRC_URI[aarch64_ghc-xml-conduit-doc.sha256sum] = "f567914a450972c2b56edb36d926e22bd42cdc20309e946f822a3421a0535775"

URI_aarch64_ghc-xml-conduit-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-conduit-prof-1.9.1.3-4.el10_0.aarch64.rpm;name=aarch64_ghc-xml-conduit-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-conduit-prof}"
SRC_URI[aarch64_ghc-xml-conduit-prof.sha256sum] = "30f8e762fadc51427d0258d5f8aa3fb5287917df3ccd7ab91bb9c4a66971dfea"

RDEPENDS:ghc-xml-conduit = " \
 ghc-array \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-scientific \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-xml-types \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-xml-conduit-devel = " \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-blaze-html-devel \
 ghc-blaze-markup-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-conduit-extra-devel \
 ghc-containers-devel \
 ghc-data-default-class-devel \
 ghc-deepseq-devel \
 ghc-resourcet-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 ghc-xml-conduit \
 ghc-xml-types-devel \
 "
RDEPENDS:ghc-xml-conduit-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-xml-conduit-prof = " \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-blaze-html-prof \
 ghc-blaze-markup-prof \
 ghc-bytestring-prof \
 ghc-conduit-extra-prof \
 ghc-conduit-prof \
 ghc-containers-prof \
 ghc-data-default-class-prof \
 ghc-deepseq-prof \
 ghc-resourcet-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 ghc-xml-conduit-devel \
 ghc-xml-types-prof \
 "
