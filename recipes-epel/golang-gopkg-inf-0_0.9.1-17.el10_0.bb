# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-inf-0"
PV = "0.9.1"
PR = "17.el10_0"
PACKAGES = " \
 golang-gopkg-inf-0-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-inf-0-0.9.1-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3df9932a672ec60435b353db5b7b148bf6985441f816dfb55a570a76d5b4e53d"

URI_x86_64_v2_golang-gopkg-inf-0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-inf-0-devel-0.9.1-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-inf-0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gopkg-inf-0-devel}"
SRC_URI[x86_64_v2_golang-gopkg-inf-0-devel.sha256sum] = "be3122894cf22a283cdaf0dec7e18b51cb0acabee64112aa3f4946eeaa4b6dfc"

URI_aarch64_golang-gopkg-inf-0-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-inf-0-devel-0.9.1-17.el10_0.noarch.rpm;name=aarch64_golang-gopkg-inf-0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-inf-0-devel}"
SRC_URI[aarch64_golang-gopkg-inf-0-devel.sha256sum] = "8774529986778f73265744b3797dcc3d75176f40ccb9754b9fa6598047dfcb30"

RDEPENDS:golang-gopkg-inf-0-devel = " \
 go-filesystem \
 "
