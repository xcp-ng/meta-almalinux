# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xhost"
PV = "1.0.9"
PR = "9.el10"
PACKAGES = " \
 xhost \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xhost-1.0.9-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2d9b7c6185382e5d5a962f5f1d60926249240a6d599f70807ecb2251a9f0507b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xhost-1.0.9-9.el10.x86_64_v2.rpm;name=x86_64_v2_xhost;unpack=0"
SRC_URI[x86_64_v2_xhost.sha256sum] = "c0331c43fd421372f303723ba1e01b598cd2eb6762b654db054320d62663a678"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xhost-1.0.9-9.el10.aarch64.rpm;name=aarch64_xhost;unpack=0"
SRC_URI[aarch64_xhost.sha256sum] = "f208a73f89031b80f662f0269501f21c51c429b4fa43c9b9115c399fc81254c0"

RDEPENDS:xhost = " \
 glibc \
 libX11 \
 libXmu \
 "
