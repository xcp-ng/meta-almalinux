# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xalan-c"
PV = "1.12.0"
PR = "49.el10_0"
PACKAGES = " \
 xalan-c \
 xalan-c-devel \
 xalan-c-doc \
 xalan-c-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xalan-c-1.12.0-49.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c287c7cec53abf391231dbf4f124a712e4cc58ada7be8d62cdca1e9a0a0fecef"

URI_x86_64_v2_xalan-c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xalan-c-1.12.0-49.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xalan-c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xalan-c}"
SRC_URI[x86_64_v2_xalan-c.sha256sum] = "2e356d77cc98021416674bce9e4487aafd4a240405de1df1f4589f97249db9cb"

URI_x86_64_v2_xalan-c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xalan-c-devel-1.12.0-49.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xalan-c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xalan-c-devel}"
SRC_URI[x86_64_v2_xalan-c-devel.sha256sum] = "77ec4ba505b487945340cc9ae59ec3d400199e029495161743f1cc9e084e0591"

URI_x86_64_v2_xalan-c-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xalan-c-doc-1.12.0-49.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_xalan-c-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xalan-c-doc}"
SRC_URI[x86_64_v2_xalan-c-doc.sha256sum] = "29c1de1f69e3f4a6b9ac4973023decbd748be002c7bf316c78c3612e056ca449"

URI_x86_64_v2_xalan-c-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xalan-c-libs-1.12.0-49.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xalan-c-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xalan-c-libs}"
SRC_URI[x86_64_v2_xalan-c-libs.sha256sum] = "b3bd36028dca927e73881efb3a14affe35570dd2535932237673766738799f89"

URI_aarch64_xalan-c = "${EPEL_MIRROR}/aarch64/Packages/x/xalan-c-1.12.0-49.el10_0.aarch64.rpm;name=aarch64_xalan-c;unpack=0"
SRC_URI:append = " ${URI_aarch64_xalan-c}"
SRC_URI[aarch64_xalan-c.sha256sum] = "aa4d02ad68ea75d9858a310888fd1d070e8e4d3c7305552d5a9dcfffbf89ca2c"

URI_aarch64_xalan-c-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xalan-c-devel-1.12.0-49.el10_0.aarch64.rpm;name=aarch64_xalan-c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xalan-c-devel}"
SRC_URI[aarch64_xalan-c-devel.sha256sum] = "bfe174135a67616d296d4db59cabbde59a6cb434d18301718044ff7c1624dbce"

URI_aarch64_xalan-c-doc = "${EPEL_MIRROR}/aarch64/Packages/x/xalan-c-doc-1.12.0-49.el10_0.noarch.rpm;name=aarch64_xalan-c-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_xalan-c-doc}"
SRC_URI[aarch64_xalan-c-doc.sha256sum] = "5c2a88c1a71389a3cfdb1446d16176c1b9ff0083a84db7a641d6425cbfadf8be"

URI_aarch64_xalan-c-libs = "${EPEL_MIRROR}/aarch64/Packages/x/xalan-c-libs-1.12.0-49.el10_0.aarch64.rpm;name=aarch64_xalan-c-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xalan-c-libs}"
SRC_URI[aarch64_xalan-c-libs.sha256sum] = "ab092c7e97626a1b4f48ef6f4c19e25a11d537d2a1ec2201d8e4e5808b60ec75"

RDEPENDS:xalan-c = " \
 glibc \
 libgcc \
 libstdc++ \
 xalan-c-libs \
 xerces-c \
 "
RDEPENDS:xalan-c-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 xalan-c-libs \
 "
RDEPENDS:xalan-c-doc = " \
 "
RDEPENDS:xalan-c-libs = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 xerces-c \
 "
