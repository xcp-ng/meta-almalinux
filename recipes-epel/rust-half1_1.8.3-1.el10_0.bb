# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-half1"
PV = "1.8.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-half1+alloc-devel \
 rust-half1+bytemuck-devel \
 rust-half1+default-devel \
 rust-half1+num-traits-devel \
 rust-half1+serde-devel \
 rust-half1+serialize-devel \
 rust-half1+std-devel \
 rust-half1+use-intrinsics-devel \
 rust-half1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-half1-1.8.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a808c83e9004ff6559118f06e37524d56f8fd672e00f3e32d23d0e04bf8267a"

URI_x86_64_v2_rust-half1+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half1+alloc-devel-1.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half1+alloc-devel}"
SRC_URI[x86_64_v2_rust-half1+alloc-devel.sha256sum] = "06724818b6340354be84417335f1021bcbb394afefbfa83a6d96b1fa40d84277"

URI_x86_64_v2_rust-half1+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half1+bytemuck-devel-1.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half1+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half1+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-half1+bytemuck-devel.sha256sum] = "e7b8214bdf9080be891cc19f34016af877161c8d9017ad5bb6c58ce1664b65af"

URI_x86_64_v2_rust-half1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half1+default-devel-1.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half1+default-devel}"
SRC_URI[x86_64_v2_rust-half1+default-devel.sha256sum] = "603d9a1449fdaa9377443612418a3c56c70b6017c269bbd742da7aa9d5604f92"

URI_x86_64_v2_rust-half1+num-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half1+num-traits-devel-1.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half1+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half1+num-traits-devel}"
SRC_URI[x86_64_v2_rust-half1+num-traits-devel.sha256sum] = "266d96e9861b9a4af55743dd16f16515a3b0cadc3b574f5c3d3884e057740f68"

URI_x86_64_v2_rust-half1+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half1+serde-devel-1.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half1+serde-devel}"
SRC_URI[x86_64_v2_rust-half1+serde-devel.sha256sum] = "6a528b55938591b7d9dfb3129d874ba241a4c6d065e2c9d21cf399cf90743181"

URI_x86_64_v2_rust-half1+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half1+serialize-devel-1.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half1+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half1+serialize-devel}"
SRC_URI[x86_64_v2_rust-half1+serialize-devel.sha256sum] = "04b8d287482d7d9a8edfc1f72e4af81bfee761e78a5f7575510a7561ca25b7b1"

URI_x86_64_v2_rust-half1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half1+std-devel-1.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half1+std-devel}"
SRC_URI[x86_64_v2_rust-half1+std-devel.sha256sum] = "ef4e30d29f9ff4f9ac49286b7bd6a3a94652069cd0f94f109d4ffe630b9ce5a8"

URI_x86_64_v2_rust-half1+use-intrinsics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half1+use-intrinsics-devel-1.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half1+use-intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half1+use-intrinsics-devel}"
SRC_URI[x86_64_v2_rust-half1+use-intrinsics-devel.sha256sum] = "75c4765d9d2be5d57da4765b4d2c8bfea8199773f15713f95eed4e8b0e8c9fcc"

URI_x86_64_v2_rust-half1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half1-devel-1.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half1-devel}"
SRC_URI[x86_64_v2_rust-half1-devel.sha256sum] = "525aa4002e9ccc1ea14cf496903de27d782edb8e21aabc0de47a0d9e4a80f89e"
RPROVIDES:rust-half1-devel:append:x86_64_v2 = " virtual/crate_half__ge_1.8.0_with_crate_half__lt_3.0.0~"

URI_aarch64_rust-half1+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half1+alloc-devel-1.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-half1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half1+alloc-devel}"
SRC_URI[aarch64_rust-half1+alloc-devel.sha256sum] = "3afbb7b56a4cb2b18488d23f1b5666fad6eb75889c1a85cd1806598fc1356063"

URI_aarch64_rust-half1+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half1+bytemuck-devel-1.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-half1+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half1+bytemuck-devel}"
SRC_URI[aarch64_rust-half1+bytemuck-devel.sha256sum] = "e6c16ad3effeade76600842a148cbe909e84d512a20f5bb813717fef85d50d88"

URI_aarch64_rust-half1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half1+default-devel-1.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-half1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half1+default-devel}"
SRC_URI[aarch64_rust-half1+default-devel.sha256sum] = "409ab8e035730f5ebbf94b4f44cb59fb323fbc77dd9f9ef797e85e311a6f8894"

URI_aarch64_rust-half1+num-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half1+num-traits-devel-1.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-half1+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half1+num-traits-devel}"
SRC_URI[aarch64_rust-half1+num-traits-devel.sha256sum] = "a3714b722aa739c0595eaaeba1464176e8fa9d4fc3695d15444722dbf8e42068"

URI_aarch64_rust-half1+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half1+serde-devel-1.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-half1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half1+serde-devel}"
SRC_URI[aarch64_rust-half1+serde-devel.sha256sum] = "f03a43af40029fafc4e7999800a0a8d7a5d070f805885f6d425a5496a23ddb16"

URI_aarch64_rust-half1+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half1+serialize-devel-1.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-half1+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half1+serialize-devel}"
SRC_URI[aarch64_rust-half1+serialize-devel.sha256sum] = "81faa9d28e8dbe3a9b0dd7b9958dccf1628ff32d361afc0bc873372267c0f014"

URI_aarch64_rust-half1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half1+std-devel-1.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-half1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half1+std-devel}"
SRC_URI[aarch64_rust-half1+std-devel.sha256sum] = "787b4e1ac3142560be6b3d8ae74e06ceadafdbe5d19c72b40df34a24cf122b25"

URI_aarch64_rust-half1+use-intrinsics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half1+use-intrinsics-devel-1.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-half1+use-intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half1+use-intrinsics-devel}"
SRC_URI[aarch64_rust-half1+use-intrinsics-devel.sha256sum] = "185359138579f63be44a767c25ba64669db306940d2fd06f9a0a0540fb40b8cc"

URI_aarch64_rust-half1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half1-devel-1.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-half1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half1-devel}"
SRC_URI[aarch64_rust-half1-devel.sha256sum] = "4fff69158b20f88609e14e56c7b142e6aa41a13c2d461fbbde40df5d67b4609e"
RPROVIDES:rust-half1-devel:append:aarch64 = " virtual/crate_half__ge_1.8.0_with_crate_half__lt_3.0.0~"

RDEPENDS:rust-half1+alloc-devel = " \
 cargo \
 rust-half1-devel \
 "
RDEPENDS:rust-half1+bytemuck-devel = " \
 cargo \
 rust-bytemuck+derive-devel \
 rust-bytemuck-devel \
 rust-half1-devel \
 "
RDEPENDS:rust-half1+default-devel = " \
 cargo \
 rust-half1-devel \
 "
RDEPENDS:rust-half1+num-traits-devel = " \
 cargo \
 rust-half1-devel \
 rust-num-traits+libm-devel \
 rust-num-traits-devel \
 "
RDEPENDS:rust-half1+serde-devel = " \
 cargo \
 rust-half1-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-half1+serialize-devel = " \
 cargo \
 rust-half1+serde-devel \
 rust-half1-devel \
 "
RDEPENDS:rust-half1+std-devel = " \
 cargo \
 rust-half1+alloc-devel \
 rust-half1-devel \
 "
RDEPENDS:rust-half1+use-intrinsics-devel = " \
 cargo \
 rust-half1-devel \
 "
RDEPENDS:rust-half1-devel = " \
 cargo \
 "
