# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cramjam"
PV = "2.12.1"
PR = "1.el10_3"
PACKAGES = " \
 python3-cramjam \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-cramjam-2.12.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2f8df26f8cdd680a191167bf0c2d84196994c4f45ffabb18a661d96b2e1395fe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cramjam-2.12.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-cramjam;unpack=0"
SRC_URI[x86_64_v2_python3-cramjam.sha256sum] = "5d6002369ce834539d0844e2a0d8a0d463e6f03373a183baf33f482ee2eb3e87"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-cramjam-2.12.1-1.el10_3.aarch64.rpm;name=aarch64_python3-cramjam;unpack=0"
SRC_URI[aarch64_python3-cramjam.sha256sum] = "168c2fb344ed22d17f80c7cc87e2562128f14390dce323d7ea0bf8b3eb03c2eb"

RDEPENDS:python3-cramjam = " \
 glibc \
 libgcc \
 libzstd \
 lz4-libs \
 python3 \
 xz-libs \
 "
