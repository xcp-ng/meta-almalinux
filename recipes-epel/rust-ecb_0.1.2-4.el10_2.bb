# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ecb"
PV = "0.1.2"
PR = "4.el10_2"
PACKAGES = " \
 rust-ecb+alloc-devel \
 rust-ecb+block-padding-devel \
 rust-ecb+default-devel \
 rust-ecb+std-devel \
 rust-ecb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ecb-0.1.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48cfa5cb1c3eeedda5ea4cf7677b9a9c5afe9304ae68df0c91e01c37b726e770"

URI_x86_64_v2_rust-ecb+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb+alloc-devel-0.1.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb+alloc-devel}"
SRC_URI[x86_64_v2_rust-ecb+alloc-devel.sha256sum] = "559c8bf3d339c3054cb5b69bb46b175cfcf1639712699f70f55ccfe131c74ddf"

URI_x86_64_v2_rust-ecb+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb+block-padding-devel-0.1.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb+block-padding-devel}"
SRC_URI[x86_64_v2_rust-ecb+block-padding-devel.sha256sum] = "fff2d79dec477e4d6958761eb232768adbf17bad49d0500268ac58d0e14c329b"

URI_x86_64_v2_rust-ecb+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb+default-devel-0.1.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb+default-devel}"
SRC_URI[x86_64_v2_rust-ecb+default-devel.sha256sum] = "79d595d6124d0174c0cc133bf5ac15951d9f25fcfcd180241e6e95fe847418c0"

URI_x86_64_v2_rust-ecb+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb+std-devel-0.1.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb+std-devel}"
SRC_URI[x86_64_v2_rust-ecb+std-devel.sha256sum] = "445537245587877657581e52ede86705d68de493e07795ae170e146b230edc21"

URI_x86_64_v2_rust-ecb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb-devel-0.1.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb-devel}"
SRC_URI[x86_64_v2_rust-ecb-devel.sha256sum] = "bc449af049fc1a35601ebd8f623431d6ec6ab53e5ef7d83cebd0cd4c45a37abe"

URI_aarch64_rust-ecb+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb+alloc-devel-0.1.2-4.el10_2.noarch.rpm;name=aarch64_rust-ecb+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb+alloc-devel}"
SRC_URI[aarch64_rust-ecb+alloc-devel.sha256sum] = "1d6b354c74dd89d8712194444d738efe9b205a2801ba5b11fb989b9ba6e8999d"

URI_aarch64_rust-ecb+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb+block-padding-devel-0.1.2-4.el10_2.noarch.rpm;name=aarch64_rust-ecb+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb+block-padding-devel}"
SRC_URI[aarch64_rust-ecb+block-padding-devel.sha256sum] = "efe6b588b6d681b6cf194a600909be7f84c92eaa36cfb2ac43b850b16f7aa9ff"

URI_aarch64_rust-ecb+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb+default-devel-0.1.2-4.el10_2.noarch.rpm;name=aarch64_rust-ecb+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb+default-devel}"
SRC_URI[aarch64_rust-ecb+default-devel.sha256sum] = "a7699d7702ed3b26e4969b178aa39468c668a2211135f427eeebeb3732718473"

URI_aarch64_rust-ecb+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb+std-devel-0.1.2-4.el10_2.noarch.rpm;name=aarch64_rust-ecb+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb+std-devel}"
SRC_URI[aarch64_rust-ecb+std-devel.sha256sum] = "c62bd08105c256f176b10bc6a6e0a00d5b4b8683cd08ed7e7107fd83f0da93c0"

URI_aarch64_rust-ecb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb-devel-0.1.2-4.el10_2.noarch.rpm;name=aarch64_rust-ecb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb-devel}"
SRC_URI[aarch64_rust-ecb-devel.sha256sum] = "7eb7206481a144e63a91dbf116eab77a3738c5227bc3dd0b5e88d1805a701937"

RDEPENDS:rust-ecb+alloc-devel = " \
 cargo \
 rust-cipher0.4+alloc-devel \
 rust-ecb-devel \
 "
RDEPENDS:rust-ecb+block-padding-devel = " \
 cargo \
 rust-cipher0.4+block-padding-devel \
 rust-ecb-devel \
 "
RDEPENDS:rust-ecb+default-devel = " \
 cargo \
 rust-ecb+block-padding-devel \
 rust-ecb-devel \
 "
RDEPENDS:rust-ecb+std-devel = " \
 cargo \
 rust-cipher0.4+std-devel \
 rust-ecb+alloc-devel \
 rust-ecb-devel \
 "
RDEPENDS:rust-ecb-devel = " \
 cargo \
 rust \
 rust-cipher0.4+default-devel \
 "
