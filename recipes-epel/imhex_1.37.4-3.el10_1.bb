# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "imhex"
PV = "1.37.4"
PR = "3.el10_1"
PACKAGES = " \
 imhex \
 imhex-devel \
 imhex-patterns \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/imhex-1.37.4-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5945fcddcb76b85ddd8fbeff6d67bad8f62f648df5c0facf8586a98d2c894af"

URI_x86_64_v2_imhex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/imhex-1.37.4-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_imhex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_imhex}"
SRC_URI[x86_64_v2_imhex.sha256sum] = "b3b0b05c0175d336dbd2b08d6c16ad8499f466c65fa22ae06d3ca569853b415b"

URI_x86_64_v2_imhex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/imhex-devel-1.37.4-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_imhex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_imhex-devel}"
SRC_URI[x86_64_v2_imhex-devel.sha256sum] = "bec0e4751cf27073cc7b13ec426e78d5c015138eb5f23783c4919fef2a8ef3a9"

URI_x86_64_v2_imhex-patterns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/imhex-patterns-1.37.4-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_imhex-patterns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_imhex-patterns}"
SRC_URI[x86_64_v2_imhex-patterns.sha256sum] = "38abf82244207992ed57ef5683f3a6d986d4fc05bb7bf59c95815528991da0a7"

URI_aarch64_imhex = "${EPEL_MIRROR}/aarch64/Packages/i/imhex-1.37.4-3.el10_1.aarch64.rpm;name=aarch64_imhex;unpack=0"
SRC_URI:append = " ${URI_aarch64_imhex}"
SRC_URI[aarch64_imhex.sha256sum] = "ea35dfc05ef546e87126010b2100f0227ae523920b2489481bd72935b8bd0129"

URI_aarch64_imhex-devel = "${EPEL_MIRROR}/aarch64/Packages/i/imhex-devel-1.37.4-3.el10_1.aarch64.rpm;name=aarch64_imhex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_imhex-devel}"
SRC_URI[aarch64_imhex-devel.sha256sum] = "712d8795dbbceda916ce794a6d875da71a22a5910ec5b8fd641cb48b95d29f56"

URI_aarch64_imhex-patterns = "${EPEL_MIRROR}/aarch64/Packages/i/imhex-patterns-1.37.4-3.el10_1.aarch64.rpm;name=aarch64_imhex-patterns;unpack=0"
SRC_URI:append = " ${URI_aarch64_imhex-patterns}"
SRC_URI[aarch64_imhex-patterns.sha256sum] = "c17918a97fab8362fa60167e847114c0bc898c36fe8fc7bf1ee8e60f8e93767d"

RDEPENDS:imhex = " \
 bzip2-libs \
 capstone \
 file-libs \
 fmt \
 fontconfig \
 freetype \
 glfw \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lunasvg \
 lz4-libs \
 mbedtls \
 nativefiledialog-extended \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 yara \
 zlib-ng-compat \
 "
RDEPENDS:imhex-devel = " \
 imhex \
 "
RDEPENDS:imhex-patterns = " \
 imhex \
 "
