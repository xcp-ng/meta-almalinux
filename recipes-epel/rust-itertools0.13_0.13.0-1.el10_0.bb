# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-itertools0.13"
PV = "0.13.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-itertools0.13+default-devel \
 rust-itertools0.13+use_alloc-devel \
 rust-itertools0.13+use_std-devel \
 rust-itertools0.13-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-itertools0.13-0.13.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52f1c5d702e09f799897e715d126063b1a1b9f91f3da030abe7d32ca6def6c61"

URI_x86_64_v2_rust-itertools0.13+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools0.13+default-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools0.13+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools0.13+default-devel}"
SRC_URI[x86_64_v2_rust-itertools0.13+default-devel.sha256sum] = "d1ce0930a448b3cdac50f9c6d34be21755be4f07bf95830d479c38e7cfd4c8e4"
RPROVIDES:rust-itertools0.13+default-devel:x86_64_v2 = "virtual/crate_itertools/default__ge_0.10.1_with_crate_itertools/default__lt_0.15.0~ virtual/crate_itertools/default__ge_0.13.0_with_crate_itertools/default__lt_0.15.0~"

URI_x86_64_v2_rust-itertools0.13+use_alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools0.13+use_alloc-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools0.13+use_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools0.13+use_alloc-devel}"
SRC_URI[x86_64_v2_rust-itertools0.13+use_alloc-devel.sha256sum] = "aedf8ac4bccd24ff116526b1cf91b2100dc3c23d9d75fc4e1477c73da4cb552a"

URI_x86_64_v2_rust-itertools0.13+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools0.13+use_std-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools0.13+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools0.13+use_std-devel}"
SRC_URI[x86_64_v2_rust-itertools0.13+use_std-devel.sha256sum] = "43b3e22b4b2e0469a74840d1f0fdcb3f7a2ccaed29c8d4d65030c293fc23faf7"

URI_x86_64_v2_rust-itertools0.13-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools0.13-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools0.13-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools0.13-devel}"
SRC_URI[x86_64_v2_rust-itertools0.13-devel.sha256sum] = "d69cc1b4b257b8b79bafa86178d0ef8521fd5ded1aebf12841e41a74d73e45b3"
RPROVIDES:rust-itertools0.13-devel:x86_64_v2 = "virtual/crate_itertools__ge_0.10.0_with_crate_itertools__lt_0.14.0~"

URI_aarch64_rust-itertools0.13+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools0.13+default-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-itertools0.13+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools0.13+default-devel}"
SRC_URI[aarch64_rust-itertools0.13+default-devel.sha256sum] = "244ec4d6e05bed5a1042c48e33a68d779aac1e014a20614ebd7a87864bc8311c"
RPROVIDES:rust-itertools0.13+default-devel:aarch64 = "virtual/crate_itertools/default__ge_0.10.1_with_crate_itertools/default__lt_0.15.0~ virtual/crate_itertools/default__ge_0.13.0_with_crate_itertools/default__lt_0.15.0~"

URI_aarch64_rust-itertools0.13+use_alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools0.13+use_alloc-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-itertools0.13+use_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools0.13+use_alloc-devel}"
SRC_URI[aarch64_rust-itertools0.13+use_alloc-devel.sha256sum] = "2bc4c7081daa17632240b2a96250c535aa32c03e60c16a698db0f8b7b1f81580"

URI_aarch64_rust-itertools0.13+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools0.13+use_std-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-itertools0.13+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools0.13+use_std-devel}"
SRC_URI[aarch64_rust-itertools0.13+use_std-devel.sha256sum] = "795852778d181381de906730b96447924647430ced24a0937fe67e604c6cf565"

URI_aarch64_rust-itertools0.13-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools0.13-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-itertools0.13-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools0.13-devel}"
SRC_URI[aarch64_rust-itertools0.13-devel.sha256sum] = "57d4181c02baf1871560ca35f67bcd82461d612af3d9374fd4868529fc4f07a9"
RPROVIDES:rust-itertools0.13-devel:aarch64 = "virtual/crate_itertools__ge_0.10.0_with_crate_itertools__lt_0.14.0~"

RDEPENDS:rust-itertools0.13+default-devel = " \
 cargo \
 rust-itertools0.13+use_std-devel \
 rust-itertools0.13-devel \
 "
RDEPENDS:rust-itertools0.13+use_alloc-devel = " \
 cargo \
 rust-itertools0.13-devel \
 "
RDEPENDS:rust-itertools0.13+use_std-devel = " \
 cargo \
 rust-either+use_std-devel \
 rust-itertools0.13+use_alloc-devel \
 rust-itertools0.13-devel \
 "
RDEPENDS:rust-itertools0.13-devel = " \
 cargo \
 rust \
 rust-either-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_itertools/default__ge_0.10.1_with_crate_itertools/default__lt_0.15.0~ rpm/virtual/crate_itertools/default__ge_0.13.0_with_crate_itertools/default__lt_0.15.0~ rpm/virtual/crate_itertools__ge_0.10.0_with_crate_itertools__lt_0.14.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_itertools/default__ge_0.10.1_with_crate_itertools/default__lt_0.15.0~ rpm/virtual/crate_itertools/default__ge_0.13.0_with_crate_itertools/default__lt_0.15.0~ rpm/virtual/crate_itertools__ge_0.10.0_with_crate_itertools__lt_0.14.0~"
