# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "colord-kde"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 colord-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/colord-kde-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bb6f9c34236345cb7cc3ae1adac7c744d76c4dc63b123f7c2a6d7a99529cd74"

URI_x86_64_v2_colord-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/colord-kde-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_colord-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colord-kde}"
SRC_URI[x86_64_v2_colord-kde.sha256sum] = "68dd43a786f92b2fc291438858fa66a160095473d64320dd372be46192b17fed"

URI_aarch64_colord-kde = "${EPEL_MIRROR}/aarch64/Packages/c/colord-kde-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_colord-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_colord-kde}"
SRC_URI[aarch64_colord-kde.sha256sum] = "eaf8386c2c0d9a086d20d87a1a0491e98b7bb3de93dfb93da2199ce280a23789"

RDEPENDS:colord-kde = " \
 colord \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami-addons \
 kf6-kwidgetsaddons \
 lcms2 \
 libX11 \
 libXrandr \
 libstdc++ \
 plasma-systemsettings \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
