# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-configparser"
PV = "3.1.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-configparser+async-std-devel \
 rust-configparser+default-devel \
 rust-configparser+indexmap-devel \
 rust-configparser+tokio-devel \
 rust-configparser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-configparser-3.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "583c714c0cfed86392b627c2bd6d046bce938d789ddef72d8f155d5153f0e83c"

URI_x86_64_v2_rust-configparser+async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-configparser+async-std-devel-3.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-configparser+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-configparser+async-std-devel}"
SRC_URI[x86_64_v2_rust-configparser+async-std-devel.sha256sum] = "7d94e5f32807b11ef0efab8ff971708903f0e7c631e69ff168bdefa718362a1e"

URI_x86_64_v2_rust-configparser+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-configparser+default-devel-3.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-configparser+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-configparser+default-devel}"
SRC_URI[x86_64_v2_rust-configparser+default-devel.sha256sum] = "385d2f112de539a61b59df095fcfdd174ded64a53597ae263fcc7e4147d48e1d"

URI_x86_64_v2_rust-configparser+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-configparser+indexmap-devel-3.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-configparser+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-configparser+indexmap-devel}"
SRC_URI[x86_64_v2_rust-configparser+indexmap-devel.sha256sum] = "4145f02ef39498091999ce76e04bea047597667637ac9817aa1fc89a49ca109b"

URI_x86_64_v2_rust-configparser+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-configparser+tokio-devel-3.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-configparser+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-configparser+tokio-devel}"
SRC_URI[x86_64_v2_rust-configparser+tokio-devel.sha256sum] = "a4ba45c036e66ba8b7e30d322c760f2ad8f13d8479895562652c558b744fda81"

URI_x86_64_v2_rust-configparser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-configparser-devel-3.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-configparser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-configparser-devel}"
SRC_URI[x86_64_v2_rust-configparser-devel.sha256sum] = "deb26a3e9645b19737229fd2cae1ccc7659d219591464024ce6d6026115a4957"

URI_aarch64_rust-configparser+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-configparser+async-std-devel-3.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-configparser+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-configparser+async-std-devel}"
SRC_URI[aarch64_rust-configparser+async-std-devel.sha256sum] = "16814c2fa87a1f5d805a7870a4892aa2fa7353fbcf22727bcb2b9647ef44222f"

URI_aarch64_rust-configparser+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-configparser+default-devel-3.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-configparser+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-configparser+default-devel}"
SRC_URI[aarch64_rust-configparser+default-devel.sha256sum] = "d272290e238cd8764ce6880ee2d034da585c8b11677fe229c4b449efd14d51ce"

URI_aarch64_rust-configparser+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-configparser+indexmap-devel-3.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-configparser+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-configparser+indexmap-devel}"
SRC_URI[aarch64_rust-configparser+indexmap-devel.sha256sum] = "40f43aec5572a4d5969b7d4fcc32733b6f3749ba841c94f00090d2236b623f67"

URI_aarch64_rust-configparser+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-configparser+tokio-devel-3.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-configparser+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-configparser+tokio-devel}"
SRC_URI[aarch64_rust-configparser+tokio-devel.sha256sum] = "7713ee918abd9fa30245fd08f6afdf77d0b9702ed052a2c5daeaf2937895dc36"

URI_aarch64_rust-configparser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-configparser-devel-3.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-configparser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-configparser-devel}"
SRC_URI[aarch64_rust-configparser-devel.sha256sum] = "0189a93d11997188dee0aff43c98d6b5579740daf75d4c8e7a384251a6a2e506"

RDEPENDS:rust-configparser+async-std-devel = " \
 cargo \
 rust-configparser+tokio-devel \
 rust-configparser-devel \
 "
RDEPENDS:rust-configparser+default-devel = " \
 cargo \
 rust-configparser-devel \
 "
RDEPENDS:rust-configparser+indexmap-devel = " \
 cargo \
 rust-configparser-devel \
 rust-indexmap+default-devel \
 "
RDEPENDS:rust-configparser+tokio-devel = " \
 cargo \
 rust-configparser-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 "
RDEPENDS:rust-configparser-devel = " \
 cargo \
 "
