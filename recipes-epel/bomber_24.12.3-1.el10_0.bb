# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bomber"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 bomber \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bomber-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "461991f83995f6ebdbe1bdc4e4274e289c0f774d288270ed0e00b64451a2455d"

URI_x86_64_v2_bomber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bomber-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bomber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bomber}"
SRC_URI[x86_64_v2_bomber.sha256sum] = "37c083aff9f544953dc62eb09835284671777fa274d0e83880481c88873a7723"

URI_aarch64_bomber = "${EPEL_MIRROR}/aarch64/Packages/b/bomber-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_bomber;unpack=0"
SRC_URI:append = " ${URI_aarch64_bomber}"
SRC_URI[aarch64_bomber.sha256sum] = "fb16142039b117d6580b5fa809d890bf0c8d5753351e6f5c53e3fef8b15dda97"

RDEPENDS:bomber = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
