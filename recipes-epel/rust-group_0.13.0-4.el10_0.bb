# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-group"
PV = "0.13.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-group+alloc-devel \
 rust-group+default-devel \
 rust-group+rand-devel \
 rust-group+rand_xorshift-devel \
 rust-group+tests-devel \
 rust-group-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-group-0.13.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90783b74b306b38be610ea4fe7e6febc4e5e79620b63d64a70fc9b1df53449b9"

URI_x86_64_v2_rust-group+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group+alloc-devel-0.13.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group+alloc-devel}"
SRC_URI[x86_64_v2_rust-group+alloc-devel.sha256sum] = "22ec64b6242f54aa62e9ca0c637598758fa3e1fcd6fecc89903a2e15aaf2a32d"

URI_x86_64_v2_rust-group+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group+default-devel-0.13.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group+default-devel}"
SRC_URI[x86_64_v2_rust-group+default-devel.sha256sum] = "9595fa00aaf415b11e900962b12b60a3490a49eb19c7d38dc700bd2ff13e1108"

URI_x86_64_v2_rust-group+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group+rand-devel-0.13.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group+rand-devel}"
SRC_URI[x86_64_v2_rust-group+rand-devel.sha256sum] = "817cb1bde97a2f74d89bc4427ce0e53d2ffdd51c8182376736a487d1c25232ff"

URI_x86_64_v2_rust-group+rand_xorshift-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group+rand_xorshift-devel-0.13.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group+rand_xorshift-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group+rand_xorshift-devel}"
SRC_URI[x86_64_v2_rust-group+rand_xorshift-devel.sha256sum] = "bb584501e034c7a6558adaaedfd13326c18a4e3083a0e4f560637270de9234ef"

URI_x86_64_v2_rust-group+tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group+tests-devel-0.13.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group+tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group+tests-devel}"
SRC_URI[x86_64_v2_rust-group+tests-devel.sha256sum] = "c7cd784afb3768d60c8ccdffaeba4ccc134b391b77c1f02aeee48c72ee689be4"

URI_x86_64_v2_rust-group-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group-devel-0.13.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group-devel}"
SRC_URI[x86_64_v2_rust-group-devel.sha256sum] = "93660c566100d9a809c251a0f0d9242a3e3a3e8e7feabde19f55db7835d4aa2a"

URI_aarch64_rust-group+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group+alloc-devel-0.13.0-4.el10_0.noarch.rpm;name=aarch64_rust-group+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group+alloc-devel}"
SRC_URI[aarch64_rust-group+alloc-devel.sha256sum] = "b4a035b909fae337ef285a9054194498ad19ac111a78a44fa4279537e7423639"

URI_aarch64_rust-group+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group+default-devel-0.13.0-4.el10_0.noarch.rpm;name=aarch64_rust-group+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group+default-devel}"
SRC_URI[aarch64_rust-group+default-devel.sha256sum] = "b8e59e0a3e43f0c62b743495c9ced0dd95850ea2edc34b6e275a6ede5da796a0"

URI_aarch64_rust-group+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group+rand-devel-0.13.0-4.el10_0.noarch.rpm;name=aarch64_rust-group+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group+rand-devel}"
SRC_URI[aarch64_rust-group+rand-devel.sha256sum] = "5f4f1631178cea8eb4bef16fb28c8aacb8ae164e8041f4faab881663db8a8905"

URI_aarch64_rust-group+rand_xorshift-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group+rand_xorshift-devel-0.13.0-4.el10_0.noarch.rpm;name=aarch64_rust-group+rand_xorshift-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group+rand_xorshift-devel}"
SRC_URI[aarch64_rust-group+rand_xorshift-devel.sha256sum] = "39ee6c985c29a5c6c89c9581fc902f802dc8edb96db1b74059dca8c6a73cc8f3"

URI_aarch64_rust-group+tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group+tests-devel-0.13.0-4.el10_0.noarch.rpm;name=aarch64_rust-group+tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group+tests-devel}"
SRC_URI[aarch64_rust-group+tests-devel.sha256sum] = "268dfddb35813fc955fa194e60a8b64055c1f40cf4765f625f8dab098f06f65d"

URI_aarch64_rust-group-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group-devel-0.13.0-4.el10_0.noarch.rpm;name=aarch64_rust-group-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group-devel}"
SRC_URI[aarch64_rust-group-devel.sha256sum] = "ea07dd41cd072cbf22298c02ac422c0806f38ad154ef083fa7e02ee348e4a001"

RDEPENDS:rust-group+alloc-devel = " \
 cargo \
 rust-group-devel \
 "
RDEPENDS:rust-group+default-devel = " \
 cargo \
 rust-group+alloc-devel \
 rust-group-devel \
 "
RDEPENDS:rust-group+rand-devel = " \
 cargo \
 rust-group-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-group+rand_xorshift-devel = " \
 cargo \
 rust-group-devel \
 rust-rand_xorshift+default-devel \
 "
RDEPENDS:rust-group+tests-devel = " \
 cargo \
 rust-group+alloc-devel \
 rust-group+rand-devel \
 rust-group+rand_xorshift-devel \
 rust-group-devel \
 "
RDEPENDS:rust-group-devel = " \
 cargo \
 rust-ff-devel \
 rust-rand_core0.6-devel \
 rust-subtle-devel \
 "
