# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "juk"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 juk \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/juk-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2bf32652614ae8c127b20f567c0b288dbdda46c0ca649d2317a154ebd37baaca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/juk-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_juk;unpack=0"
SRC_URI[x86_64_v2_juk.sha256sum] = "3a279e97dd1eae03efd1040870cd045ca8b3c8231a216de05fa0cc88b0302eaf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/juk-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_juk;unpack=0"
SRC_URI[aarch64_juk.sha256sum] = "96b2fe14bc513c7e99f4f1dc3c3ff4c853182f22dfb386486c43303b3f55821a"

RDEPENDS:juk = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 taglib \
 "
