# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qmlkonsole"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 qmlkonsole \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qmlkonsole-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "32daab4822f8230bd0a0ef3f1d04225c3b7e752b4aa0dfc6c6f1c56cf2ec07a6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qmlkonsole-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qmlkonsole;unpack=0"
SRC_URI[x86_64_v2_qmlkonsole.sha256sum] = "e4a8ba29acd87659996560a5b4e147c887a26fbb96eecd14b46cd561f19ec5fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qmlkonsole-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_qmlkonsole;unpack=0"
SRC_URI[aarch64_qmlkonsole.sha256sum] = "0a11a7f36e60773f3ec1604b1fced3625386dd87362c50d7ebb9b101d18bc22f"

RDEPENDS:qmlkonsole = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kpty \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
