# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-influxdata-influxdb1-client"
PV = "0"
PR = "17.20210109gitb269163.el10_0"
PACKAGES = " \
 golang-github-influxdata-influxdb1-client-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-influxdata-influxdb1-client-0-17.20210109gitb269163.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "895be24dd033021537557c43fe72fb9e14f0a9bdb1ee3e60ab47d30ce1eafab5"

URI_aarch64_golang-github-influxdata-influxdb1-client-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-influxdata-influxdb1-client-devel-0-17.20210109gitb269163.el10_0.noarch.rpm;name=aarch64_golang-github-influxdata-influxdb1-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-influxdata-influxdb1-client-devel}"
SRC_URI[aarch64_golang-github-influxdata-influxdb1-client-devel.sha256sum] = "49534fcfd9694cd9940eceec110896c4509244a18dc4b95065012445b1a171c7"

RDEPENDS:golang-github-influxdata-influxdb1-client-devel = " \
 go-filesystem \
 "
