# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kshisen"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kshisen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kshisen-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cca56882f015ecd9de5e64993bc7e817a1a024eae975a35a09a62034e00a6012"

URI_x86_64_v2_kshisen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kshisen-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kshisen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kshisen}"
SRC_URI[x86_64_v2_kshisen.sha256sum] = "8d6075bb9bf6da0c9c4e212aa6192bde5dc15eb48c7b57329b614389ebb731b7"

URI_aarch64_kshisen = "${EPEL_MIRROR}/aarch64/Packages/k/kshisen-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kshisen;unpack=0"
SRC_URI:append = " ${URI_aarch64_kshisen}"
SRC_URI[aarch64_kshisen.sha256sum] = "b97359efdef11d4a0fcda4079b81de5b505719005458717beede196875105389"

RDEPENDS:kshisen = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libkmahjongg \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
