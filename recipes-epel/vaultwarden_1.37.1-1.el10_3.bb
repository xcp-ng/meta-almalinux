# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vaultwarden"
PV = "1.37.1"
PR = "1.el10_3"
PACKAGES = " \
 vaultwarden \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vaultwarden-1.37.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9125f56a95d5db8987bc6e2ca67282fc2a14a85903e9d46f0540f7ed61ae4959"

URI_x86_64_v2_vaultwarden = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vaultwarden-1.37.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vaultwarden;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vaultwarden}"
SRC_URI[x86_64_v2_vaultwarden.sha256sum] = "5d620738c671efc12c95589439e375d28a901aaa07ef6baf131c113378bc474f"

URI_aarch64_vaultwarden = "${EPEL_MIRROR}/aarch64/Packages/v/vaultwarden-1.37.1-1.el10_3.aarch64.rpm;name=aarch64_vaultwarden;unpack=0"
SRC_URI:append = " ${URI_aarch64_vaultwarden}"
SRC_URI[aarch64_vaultwarden.sha256sum] = "debd2fa98bec427c883c704341228b83962bac7b2f7b40fdd9e24b2d86fcc83a"

RDEPENDS:vaultwarden = " \
 bash \
 glibc \
 libgcc \
 libpq \
 mariadb-connector-c \
 openssl-libs \
 shadow-utils \
 vaultwarden-web \
 "
