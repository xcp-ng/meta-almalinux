# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-relative-path"
PV = "1.9.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-relative-path+default-devel \
 rust-relative-path+serde-devel \
 rust-relative-path-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-relative-path-1.9.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f595b52eda85b9795d3fcbaec1f39fb4927a0aac55a2c1a3ade9d474db392d06"

URI_x86_64_v2_rust-relative-path+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-relative-path+default-devel-1.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-relative-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-relative-path+default-devel}"
SRC_URI[x86_64_v2_rust-relative-path+default-devel.sha256sum] = "2b61b3c4b7f3af21220eab7bb71d43d50735acf69ca61f4783556fc3cb9a438d"

URI_x86_64_v2_rust-relative-path+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-relative-path+serde-devel-1.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-relative-path+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-relative-path+serde-devel}"
SRC_URI[x86_64_v2_rust-relative-path+serde-devel.sha256sum] = "8c7f78e085c6e349e4abaa901493da4180ec2f41ec7b8f1f65ef1fa9ea8fa619"

URI_x86_64_v2_rust-relative-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-relative-path-devel-1.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-relative-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-relative-path-devel}"
SRC_URI[x86_64_v2_rust-relative-path-devel.sha256sum] = "406758264d106524cc810e2577d4fdb8befbafeec59a0ba6aebd0b969a1e6bad"

URI_aarch64_rust-relative-path+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-relative-path+default-devel-1.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-relative-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-relative-path+default-devel}"
SRC_URI[aarch64_rust-relative-path+default-devel.sha256sum] = "64d681bfcbd849f7fbf40dc8205b5527a159c05914c30e76d04a85e6c2539593"

URI_aarch64_rust-relative-path+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-relative-path+serde-devel-1.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-relative-path+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-relative-path+serde-devel}"
SRC_URI[aarch64_rust-relative-path+serde-devel.sha256sum] = "6997da7dcec9ee0033049db574e6743ce49c58979d48e488222bfe211231eb7d"

URI_aarch64_rust-relative-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-relative-path-devel-1.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-relative-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-relative-path-devel}"
SRC_URI[aarch64_rust-relative-path-devel.sha256sum] = "c5f959d883f177612a45d56c21c672b050d9412482f38202caadfb203aca8f22"

RDEPENDS:rust-relative-path+default-devel = " \
 cargo \
 rust-relative-path-devel \
 "
RDEPENDS:rust-relative-path+serde-devel = " \
 cargo \
 rust-relative-path-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-relative-path-devel = " \
 cargo \
 rust \
 "
