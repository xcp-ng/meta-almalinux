# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mstflint"
PV = "4.34.0"
PR = "1.el10"
PACKAGES = " \
 mstflint \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mstflint-4.34.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5571825614d7f8419ce2d1f2d95357015b260c02fb6139891c48a3fd731275c3"

URI_x86_64_v2_mstflint = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mstflint-4.34.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_mstflint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mstflint}"
SRC_URI[x86_64_v2_mstflint.sha256sum] = "9db4898ceff3e60a4ab0a8cd29474db62488a6bc3a66d16cde4babe89c9dce3c"

URI_aarch64_mstflint = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mstflint-4.34.0-1.el10.aarch64.rpm;name=aarch64_mstflint;unpack=0"
SRC_URI:append = " ${URI_aarch64_mstflint}"
SRC_URI[aarch64_mstflint.sha256sum] = "2188ffe995fff6f0aca1e23b99a5b9dfe7e6da6f5a9a10fb5e83c25425b75b50"

RDEPENDS:mstflint = " \
 bash \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 openssl-libs \
 python3 \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
