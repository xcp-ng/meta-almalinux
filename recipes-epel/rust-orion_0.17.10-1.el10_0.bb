# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-orion"
PV = "0.17.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-orion+alloc-devel \
 rust-orion+ct-codecs-devel \
 rust-orion+default-devel \
 rust-orion+experimental-devel \
 rust-orion+getrandom-devel \
 rust-orion+safe_api-devel \
 rust-orion+serde-devel \
 rust-orion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-orion-0.17.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0aaf268cecc2feda30057327931db26a4f17714f355124e086736a26d2b87ac8"

URI_x86_64_v2_rust-orion+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+alloc-devel-0.17.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+alloc-devel}"
SRC_URI[x86_64_v2_rust-orion+alloc-devel.sha256sum] = "9e8e2bd77c2bb5ca077e6ee685767932674894c3355f053fdf36423ade42277f"

URI_x86_64_v2_rust-orion+ct-codecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+ct-codecs-devel-0.17.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+ct-codecs-devel}"
SRC_URI[x86_64_v2_rust-orion+ct-codecs-devel.sha256sum] = "ea00f95fb4a10a9576b572ba19897f158f1b7ee21473d89438f7f41c6730c470"

URI_x86_64_v2_rust-orion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+default-devel-0.17.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+default-devel}"
SRC_URI[x86_64_v2_rust-orion+default-devel.sha256sum] = "34da9d25f8458caa3831bb137840e4eead7fdbd09ccbf467c36625966c04fdf3"

URI_x86_64_v2_rust-orion+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+experimental-devel-0.17.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+experimental-devel}"
SRC_URI[x86_64_v2_rust-orion+experimental-devel.sha256sum] = "7b6610ac251ff052cf25f0388b6591e0fee7a1604c9012ba06e9d2b5be0cd0a4"

URI_x86_64_v2_rust-orion+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+getrandom-devel-0.17.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+getrandom-devel}"
SRC_URI[x86_64_v2_rust-orion+getrandom-devel.sha256sum] = "032e98e899a4081bd532515bafed7c2da3e8eca05eed130480222c605149df88"

URI_x86_64_v2_rust-orion+safe_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+safe_api-devel-0.17.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+safe_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+safe_api-devel}"
SRC_URI[x86_64_v2_rust-orion+safe_api-devel.sha256sum] = "e413c01c72bb846fefb200fc6625571ffaab7ec5d2373eaee3adc41551fdaddc"

URI_x86_64_v2_rust-orion+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+serde-devel-0.17.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+serde-devel}"
SRC_URI[x86_64_v2_rust-orion+serde-devel.sha256sum] = "c36dfe64226196da15c7e1f94d379a64899aaf79e7141038ecc85dd59b7f1a21"

URI_x86_64_v2_rust-orion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion-devel-0.17.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion-devel}"
SRC_URI[x86_64_v2_rust-orion-devel.sha256sum] = "c96a1d4f8b72244e5c7e1706cb90e54ea7450254de35658dd23fcbea53ff6939"

URI_aarch64_rust-orion+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+alloc-devel-0.17.10-1.el10_0.noarch.rpm;name=aarch64_rust-orion+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+alloc-devel}"
SRC_URI[aarch64_rust-orion+alloc-devel.sha256sum] = "bb6ca771916b28fab4efd9735907f7858daf2bf00ffbf3bcf40c6f8c48c247b3"

URI_aarch64_rust-orion+ct-codecs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+ct-codecs-devel-0.17.10-1.el10_0.noarch.rpm;name=aarch64_rust-orion+ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+ct-codecs-devel}"
SRC_URI[aarch64_rust-orion+ct-codecs-devel.sha256sum] = "bce64678d08a125dc92709c2d9919d5b86b779aa936088c89cfb089f9e2643fb"

URI_aarch64_rust-orion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+default-devel-0.17.10-1.el10_0.noarch.rpm;name=aarch64_rust-orion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+default-devel}"
SRC_URI[aarch64_rust-orion+default-devel.sha256sum] = "21e252b0423b2ba5095926d966ac62e80f935ac8ec026f65a7131556ee10044a"

URI_aarch64_rust-orion+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+experimental-devel-0.17.10-1.el10_0.noarch.rpm;name=aarch64_rust-orion+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+experimental-devel}"
SRC_URI[aarch64_rust-orion+experimental-devel.sha256sum] = "cab57fcb819f96a5d0234e85e8d9c58a06ecbb4e21b98ffd335a9081a4b8afa3"

URI_aarch64_rust-orion+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+getrandom-devel-0.17.10-1.el10_0.noarch.rpm;name=aarch64_rust-orion+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+getrandom-devel}"
SRC_URI[aarch64_rust-orion+getrandom-devel.sha256sum] = "7d2862c5236ab119effd0c04ad68331dcf57d4f842b48fc5cd8a6127fa605dc9"

URI_aarch64_rust-orion+safe_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+safe_api-devel-0.17.10-1.el10_0.noarch.rpm;name=aarch64_rust-orion+safe_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+safe_api-devel}"
SRC_URI[aarch64_rust-orion+safe_api-devel.sha256sum] = "3225a23960e7769f5661b550b50204d44c68d85af9f2a484f1ea15886d09436b"

URI_aarch64_rust-orion+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+serde-devel-0.17.10-1.el10_0.noarch.rpm;name=aarch64_rust-orion+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+serde-devel}"
SRC_URI[aarch64_rust-orion+serde-devel.sha256sum] = "b3127c83f1483961f3a6f0b7cb3e279dcad80e989e72beaf9c594bea94721abe"

URI_aarch64_rust-orion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion-devel-0.17.10-1.el10_0.noarch.rpm;name=aarch64_rust-orion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion-devel}"
SRC_URI[aarch64_rust-orion-devel.sha256sum] = "c89681f774b0e656515ff0d3e8930d6ad106e94640ecfce838461fa970f80acc"

RDEPENDS:rust-orion+alloc-devel = " \
 cargo \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+ct-codecs-devel = " \
 cargo \
 rust-ct-codecs+default-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+default-devel = " \
 cargo \
 rust-orion+safe_api-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+experimental-devel = " \
 cargo \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+safe_api-devel = " \
 cargo \
 rust-orion+ct-codecs-devel \
 rust-orion+getrandom-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+serde-devel = " \
 cargo \
 rust-orion-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-orion-devel = " \
 cargo \
 rust \
 rust-fiat-crypto-devel \
 rust-subtle-devel \
 rust-zeroize-devel \
 "
