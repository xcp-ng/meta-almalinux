# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-regex"
PV = "0.1.13"
PR = "1.el10_0"
PACKAGES = " \
 rust-grep-regex+default-devel \
 rust-grep-regex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-regex-0.1.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17c0dbdf1eab4fc02fc52b284582247e5313d2a0e2c8f38ae421946b899dae6c"

URI_x86_64_v2_rust-grep-regex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-regex+default-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-regex+default-devel}"
SRC_URI[x86_64_v2_rust-grep-regex+default-devel.sha256sum] = "cdf114d15927c4d164cf0af9ac7757c617db3b145ec15a6d4c001f32327e0b4b"

URI_x86_64_v2_rust-grep-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-regex-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-regex-devel}"
SRC_URI[x86_64_v2_rust-grep-regex-devel.sha256sum] = "7d3865f99e603389a63c5318a43619eb88b2f7b04e9f64f67713af30baf7021f"

URI_aarch64_rust-grep-regex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-regex+default-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-grep-regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-regex+default-devel}"
SRC_URI[aarch64_rust-grep-regex+default-devel.sha256sum] = "21e47e3b457842fa9d315fb689a3481bf29b211a6fccf232e3ffae8b85cfaeb8"

URI_aarch64_rust-grep-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-regex-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-grep-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-regex-devel}"
SRC_URI[aarch64_rust-grep-regex-devel.sha256sum] = "d6b30ef42a28ec514d01974dbc26cf06e283d5b10165991158e0c8ab5a40ea0b"

RDEPENDS:rust-grep-regex+default-devel = " \
 cargo \
 rust-grep-regex-devel \
 "
RDEPENDS:rust-grep-regex-devel = " \
 cargo \
 rust-bstr+default-devel \
 rust-grep-matcher+default-devel \
 rust-log+default-devel \
 rust-regex-automata+default-devel \
 rust-regex-syntax+default-devel \
 "
