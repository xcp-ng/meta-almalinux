# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scan_fmt"
PV = "0.2.6"
PR = "10.el10_0"
PACKAGES = " \
 rust-scan_fmt+default-devel \
 rust-scan_fmt+regex-devel \
 rust-scan_fmt+std-devel \
 rust-scan_fmt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scan_fmt-0.2.6-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e437bf9b7044c74946d5b48ae8e309c4a675288036ef6601659daaf597713c13"

URI_x86_64_v2_rust-scan_fmt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scan_fmt+default-devel-0.2.6-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scan_fmt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scan_fmt+default-devel}"
SRC_URI[x86_64_v2_rust-scan_fmt+default-devel.sha256sum] = "090a5aa68250943d9faa5039e13db4f34ed130916c1cd4b694bd4e2052de1b93"

URI_x86_64_v2_rust-scan_fmt+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scan_fmt+regex-devel-0.2.6-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scan_fmt+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scan_fmt+regex-devel}"
SRC_URI[x86_64_v2_rust-scan_fmt+regex-devel.sha256sum] = "023c1c0810a277f8ca062ffc12a43143a98c5de0a00220248dab285912a9bce6"

URI_x86_64_v2_rust-scan_fmt+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scan_fmt+std-devel-0.2.6-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scan_fmt+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scan_fmt+std-devel}"
SRC_URI[x86_64_v2_rust-scan_fmt+std-devel.sha256sum] = "210b1001daeb4dc63790d7e75b9f4a749db54ed9bf7fce5ab17ed6e1234c83eb"

URI_x86_64_v2_rust-scan_fmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scan_fmt-devel-0.2.6-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scan_fmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scan_fmt-devel}"
SRC_URI[x86_64_v2_rust-scan_fmt-devel.sha256sum] = "f974b0bc6701200c3a7753b317b67b4314123caa9e2122a3cadadf970d68a5d3"

URI_aarch64_rust-scan_fmt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scan_fmt+default-devel-0.2.6-10.el10_0.noarch.rpm;name=aarch64_rust-scan_fmt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scan_fmt+default-devel}"
SRC_URI[aarch64_rust-scan_fmt+default-devel.sha256sum] = "6e2aca8f2db81c0418725466478b52240d581e205c2d40eef66b9a15e211fbbe"

URI_aarch64_rust-scan_fmt+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scan_fmt+regex-devel-0.2.6-10.el10_0.noarch.rpm;name=aarch64_rust-scan_fmt+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scan_fmt+regex-devel}"
SRC_URI[aarch64_rust-scan_fmt+regex-devel.sha256sum] = "911c9686f1a0255e2de3fca3a09873e0733a41097e13da9e2ab1869b0e8fe92e"

URI_aarch64_rust-scan_fmt+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scan_fmt+std-devel-0.2.6-10.el10_0.noarch.rpm;name=aarch64_rust-scan_fmt+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scan_fmt+std-devel}"
SRC_URI[aarch64_rust-scan_fmt+std-devel.sha256sum] = "1dcaa63693212b3994af9606bbdfca51dc3ac3e9f7fd890ec64cce66ef4221c8"

URI_aarch64_rust-scan_fmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scan_fmt-devel-0.2.6-10.el10_0.noarch.rpm;name=aarch64_rust-scan_fmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scan_fmt-devel}"
SRC_URI[aarch64_rust-scan_fmt-devel.sha256sum] = "dce8934505fcbca0c7acca1516cd9c632e5003f6803cbb441be7af70231922d7"

RDEPENDS:rust-scan_fmt+default-devel = " \
 cargo \
 rust-scan_fmt+regex-devel \
 rust-scan_fmt+std-devel \
 rust-scan_fmt-devel \
 "
RDEPENDS:rust-scan_fmt+regex-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-scan_fmt-devel \
 "
RDEPENDS:rust-scan_fmt+std-devel = " \
 cargo \
 rust-scan_fmt-devel \
 "
RDEPENDS:rust-scan_fmt-devel = " \
 cargo \
 "
