# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tinystr"
PV = "0.8.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-tinystr+alloc-devel \
 rust-tinystr+databake-devel \
 rust-tinystr+default-devel \
 rust-tinystr+serde-devel \
 rust-tinystr+std-devel \
 rust-tinystr+zerovec-devel \
 rust-tinystr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tinystr-0.8.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffb3b21ec11fd601be2b69f76d9288ead645af1680ab647bd6cb72673377a662"

URI_x86_64_v2_rust-tinystr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+alloc-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+alloc-devel}"
SRC_URI[x86_64_v2_rust-tinystr+alloc-devel.sha256sum] = "93d6b7a21ee24e7da9328a89e1afd755c4c466b674e702c537de5980ffb9e8bb"

URI_x86_64_v2_rust-tinystr+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+databake-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+databake-devel}"
SRC_URI[x86_64_v2_rust-tinystr+databake-devel.sha256sum] = "15a3b17bd7d401c1515227738d7454977ac410e4605be7f7f4ba43c36e66dcf3"

URI_x86_64_v2_rust-tinystr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+default-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+default-devel}"
SRC_URI[x86_64_v2_rust-tinystr+default-devel.sha256sum] = "45a10723941942eab1fdc9e9af5fec2755a21ea0692fd47b069b77733899b478"

URI_x86_64_v2_rust-tinystr+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+serde-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+serde-devel}"
SRC_URI[x86_64_v2_rust-tinystr+serde-devel.sha256sum] = "996977fcdeb8418319f9c360a03c764a975b97cde9ed6082b665abc80f475df7"

URI_x86_64_v2_rust-tinystr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+std-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+std-devel}"
SRC_URI[x86_64_v2_rust-tinystr+std-devel.sha256sum] = "621c0cf9f1f9845b7e41c699c9fba2cde3ce7e429ab73dd71c62ee67114fc09d"

URI_x86_64_v2_rust-tinystr+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+zerovec-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+zerovec-devel}"
SRC_URI[x86_64_v2_rust-tinystr+zerovec-devel.sha256sum] = "a4dee5cefa23868d13d9b223d51368bbd194dacbb458494eb674d338194af044"

URI_x86_64_v2_rust-tinystr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr-devel}"
SRC_URI[x86_64_v2_rust-tinystr-devel.sha256sum] = "c41005f2b26a2a6d4609a5e89c6b6f4abf6f1da69dc3ea3309c76bdc283c6662"

URI_aarch64_rust-tinystr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+alloc-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-tinystr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+alloc-devel}"
SRC_URI[aarch64_rust-tinystr+alloc-devel.sha256sum] = "d68a9351679631f6090f26482cedbd263b2f68a7aa9d3f704574ba57fdbb35dd"

URI_aarch64_rust-tinystr+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+databake-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-tinystr+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+databake-devel}"
SRC_URI[aarch64_rust-tinystr+databake-devel.sha256sum] = "69c7c1b9a7a5f0c46497cf43ae179f49f5283ffade2dbe888ed6569bce1903b2"

URI_aarch64_rust-tinystr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+default-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-tinystr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+default-devel}"
SRC_URI[aarch64_rust-tinystr+default-devel.sha256sum] = "df1834d50ed42df6fa760a33f3e1ba01d278199730eaa96c52bb624d45ad4733"

URI_aarch64_rust-tinystr+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+serde-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-tinystr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+serde-devel}"
SRC_URI[aarch64_rust-tinystr+serde-devel.sha256sum] = "246af3b13f446aad0b02ef6bc828bafacffd05822ece93f4e308c77fe9dd6eb3"

URI_aarch64_rust-tinystr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+std-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-tinystr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+std-devel}"
SRC_URI[aarch64_rust-tinystr+std-devel.sha256sum] = "fe56e570cddcf29268cea49c84f5614bf1707871cc1bb7c3429d2614651902e1"

URI_aarch64_rust-tinystr+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+zerovec-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-tinystr+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+zerovec-devel}"
SRC_URI[aarch64_rust-tinystr+zerovec-devel.sha256sum] = "418d7c26746849bff08bb0f9bf22881c08e81a504adfb29129c206c67de890ed"

URI_aarch64_rust-tinystr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-tinystr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr-devel}"
SRC_URI[aarch64_rust-tinystr-devel.sha256sum] = "4a50a14c172f8f9c978e28ef678a6f1b877b0b4533db831abab6dcb845ea8750"

RDEPENDS:rust-tinystr+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-tinystr-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-tinystr+databake-devel = " \
 cargo \
 rust-databake-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+default-devel = " \
 cargo \
 rust-tinystr+alloc-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+std-devel = " \
 cargo \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+zerovec-devel = " \
 cargo \
 rust-tinystr-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-tinystr-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 "
