# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nextcloud"
PV = "34.0.2"
PR = "1.el10_3"
PACKAGES = " \
 nextcloud \
 nextcloud-httpd \
 nextcloud-mysql \
 nextcloud-nginx \
 nextcloud-postgresql \
 nextcloud-sqlite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nextcloud-34.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d64d89da477318108a346bafc04086e8471ebd7e204a9f28e27deeeab8ffd0f5"

URI_x86_64_v2_nextcloud = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-34.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud}"
SRC_URI[x86_64_v2_nextcloud.sha256sum] = "d49da93fc6e90553e4be49f4f2d74a3e7b1b8bbfe82d842e91dae3179aa21023"

URI_x86_64_v2_nextcloud-httpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-httpd-34.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-httpd}"
SRC_URI[x86_64_v2_nextcloud-httpd.sha256sum] = "68a552f0ede3c840d16141d8483b9980046405122351746508a5ca53dace2f13"
RPROVIDES:nextcloud-httpd:x86_64_v2 = "virtual/nextcloud-webserver_eq_34.0.2-1.el10_3.alma_altarch"

URI_x86_64_v2_nextcloud-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-mysql-34.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-mysql}"
SRC_URI[x86_64_v2_nextcloud-mysql.sha256sum] = "f7dcb2a4c94d1acc70399dbb4a42df44c0509d40baee59f0c2b0020b4b392aa1"
RPROVIDES:nextcloud-mysql:x86_64_v2 = "virtual/nextcloud-database_eq_34.0.2-1.el10_3.alma_altarch"

URI_x86_64_v2_nextcloud-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-nginx-34.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-nginx}"
SRC_URI[x86_64_v2_nextcloud-nginx.sha256sum] = "72ec692e9fe9f142683d1f00b84c7681f12afb884d2f81cd216514bf94e9d7e3"
RPROVIDES:nextcloud-nginx:x86_64_v2 = "virtual/nextcloud-webserver_eq_34.0.2-1.el10_3.alma_altarch"

URI_x86_64_v2_nextcloud-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-postgresql-34.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-postgresql}"
SRC_URI[x86_64_v2_nextcloud-postgresql.sha256sum] = "a58e357d26f50c5cb34f73a162fe41a124320268b62f8089002ea57809107a93"
RPROVIDES:nextcloud-postgresql:x86_64_v2 = "virtual/nextcloud-database_eq_34.0.2-1.el10_3.alma_altarch"

URI_x86_64_v2_nextcloud-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-sqlite-34.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-sqlite}"
SRC_URI[x86_64_v2_nextcloud-sqlite.sha256sum] = "4f9dd3bde91f62671b15b31f42c8809cc9100016eba412bb49da95b34d0b36d7"
RPROVIDES:nextcloud-sqlite:x86_64_v2 = "virtual/nextcloud-database_eq_34.0.2-1.el10_3.alma_altarch"

URI_aarch64_nextcloud = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-34.0.2-1.el10_3.noarch.rpm;name=aarch64_nextcloud;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud}"
SRC_URI[aarch64_nextcloud.sha256sum] = "6cd64dff041fdd0024cd04ef4c84a043be4604193eed8471216ac9c3e51a0a4d"

URI_aarch64_nextcloud-httpd = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-httpd-34.0.2-1.el10_3.noarch.rpm;name=aarch64_nextcloud-httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-httpd}"
SRC_URI[aarch64_nextcloud-httpd.sha256sum] = "fa4501bc26e833f6a859337b5d16c63c3ed19dbf62d2cafca0d9a8dbdeeccdaa"
RPROVIDES:nextcloud-httpd:aarch64 = "virtual/nextcloud-webserver_eq_34.0.2-1.el10_3"

URI_aarch64_nextcloud-mysql = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-mysql-34.0.2-1.el10_3.noarch.rpm;name=aarch64_nextcloud-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-mysql}"
SRC_URI[aarch64_nextcloud-mysql.sha256sum] = "1c3d1f2513f4654753be0a7d3d67cc24e4cc03b105a6726b98f238a315c142d9"
RPROVIDES:nextcloud-mysql:aarch64 = "virtual/nextcloud-database_eq_34.0.2-1.el10_3"

URI_aarch64_nextcloud-nginx = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-nginx-34.0.2-1.el10_3.noarch.rpm;name=aarch64_nextcloud-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-nginx}"
SRC_URI[aarch64_nextcloud-nginx.sha256sum] = "0cfef86cda99ca110e221c300a699a81aaf7796b8558321aea2da43ddbc24943"
RPROVIDES:nextcloud-nginx:aarch64 = "virtual/nextcloud-webserver_eq_34.0.2-1.el10_3"

URI_aarch64_nextcloud-postgresql = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-postgresql-34.0.2-1.el10_3.noarch.rpm;name=aarch64_nextcloud-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-postgresql}"
SRC_URI[aarch64_nextcloud-postgresql.sha256sum] = "5ec480d1b87f226f3e30ed535ed6631537966adc525aea9f0db3536da133a28e"
RPROVIDES:nextcloud-postgresql:aarch64 = "virtual/nextcloud-database_eq_34.0.2-1.el10_3"

URI_aarch64_nextcloud-sqlite = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-sqlite-34.0.2-1.el10_3.noarch.rpm;name=aarch64_nextcloud-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-sqlite}"
SRC_URI[aarch64_nextcloud-sqlite.sha256sum] = "d0898e970f5c3b901d172b6c8ce1df73f7e3abebc73960ced48b257ec306c220"
RPROVIDES:nextcloud-sqlite:aarch64 = "virtual/nextcloud-database_eq_34.0.2-1.el10_3"

RDEPENDS:nextcloud:x86_64_v2 = " \
 bash \
 ca-certificates \
 php-pecl-imagick \
 php-pecl-memcached \
 php-smbclient \
 systemd \
 virtual//usr/bin/php \
 virtual/nextcloud-database_eq_34.0.2-1.el10_3.alma_altarch \
 virtual/nextcloud-webserver_eq_34.0.2-1.el10_3.alma_altarch \
 virtual/php-bcmath \
 virtual/php-cli \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-gmp \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-mbstring \
 virtual/php-opcache \
 virtual/php-openssl \
 virtual/php-pcre \
 virtual/php-pdo \
 virtual/php-pecl-apcu \
 virtual/php-pecl-redis6_or_php-pecl-redis5 \
 virtual/php-process \
 virtual/php-session \
 virtual/php-simplexml \
 virtual/php-spl \
 virtual/php-xmlwriter \
 virtual/php-zip \
"
RDEPENDS:nextcloud:aarch64 = " \
 bash \
 ca-certificates \
 php-pecl-imagick \
 php-pecl-memcached \
 php-smbclient \
 systemd \
 virtual//usr/bin/php \
 virtual/nextcloud-database_eq_34.0.2-1.el10_3 \
 virtual/nextcloud-webserver_eq_34.0.2-1.el10_3 \
 virtual/php-bcmath \
 virtual/php-cli \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-gmp \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-mbstring \
 virtual/php-opcache \
 virtual/php-openssl \
 virtual/php-pcre \
 virtual/php-pdo \
 virtual/php-pecl-apcu \
 virtual/php-pecl-redis6_or_php-pecl-redis5 \
 virtual/php-process \
 virtual/php-session \
 virtual/php-simplexml \
 virtual/php-spl \
 virtual/php-xmlwriter \
 virtual/php-zip \
"
RDEPENDS:nextcloud-httpd = " \
 bash \
 httpd \
 nextcloud \
 virtual/php-fpm \
 "
RDEPENDS:nextcloud-mysql = " \
 nextcloud \
 virtual/php-mysqlnd \
 "
RDEPENDS:nextcloud-nginx = " \
 bash \
 nextcloud \
 nginx \
 virtual/php-fpm \
 "
RDEPENDS:nextcloud-postgresql = " \
 nextcloud \
 virtual/php-pgsql \
 "
RDEPENDS:nextcloud-sqlite = " \
 nextcloud \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/nextcloud-database_eq_34.0.2-1.el10_3.alma_altarch rpm/virtual/nextcloud-webserver_eq_34.0.2-1.el10_3.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/nextcloud-database_eq_34.0.2-1.el10_3 rpm/virtual/nextcloud-webserver_eq_34.0.2-1.el10_3"
