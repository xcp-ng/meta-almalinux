# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xfontsel"
PV = "1.1.1"
PR = "4.el10_0"
PACKAGES = " \
 xfontsel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xfontsel-1.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "143fe7b744dcd1e37ad5cb68a2f13333f1860bf3b93fe11d8684abdc964f4e35"

URI_x86_64_v2_xfontsel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xfontsel-1.1.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xfontsel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfontsel}"
SRC_URI[x86_64_v2_xfontsel.sha256sum] = "5f80d3ab975118fd17ccea81d682635308444abf0cd82d5207001454573cbc7f"

URI_aarch64_xfontsel = "${EPEL_MIRROR}/aarch64/Packages/x/xfontsel-1.1.1-4.el10_0.aarch64.rpm;name=aarch64_xfontsel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfontsel}"
SRC_URI[aarch64_xfontsel.sha256sum] = "2d8e77afdc1eec1f8e99bfa00101dec99775971753b6a5e455698f2af5430239"

RDEPENDS:xfontsel = " \
 glibc \
 libX11 \
 libXaw \
 libXmu \
 libXt \
 "
