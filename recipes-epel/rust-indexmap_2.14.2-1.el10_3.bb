# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indexmap"
PV = "2.14.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-indexmap+arbitrary-devel \
 rust-indexmap+default-devel \
 rust-indexmap+quickcheck-devel \
 rust-indexmap+rayon-devel \
 rust-indexmap+serde-devel \
 rust-indexmap+std-devel \
 rust-indexmap+test_debug-devel \
 rust-indexmap-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-indexmap-2.14.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b698dce73f7dd7247e90000a8dca3f6a2082ce2375b912db92c178648e01415f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+arbitrary-devel-2.14.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-indexmap+arbitrary-devel.sha256sum] = "151d8befc0d31de9794299e67492a8abadae94617412d8d197c249877000c0b9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+default-devel-2.14.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-indexmap+default-devel.sha256sum] = "ee1818f42ff62415377730da1b630c0609d0de019a93889d87c378ae28bfd00f"
RPROVIDES:rust-indexmap+default-devel:append:x86_64_v2 = " virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+quickcheck-devel-2.14.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+quickcheck-devel;unpack=0"
SRC_URI[x86_64_v2_rust-indexmap+quickcheck-devel.sha256sum] = "9e261474c1ced1430d18f42b122f82b8c7ab7319b7f7e09b53e3e3c201cc3e93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+rayon-devel-2.14.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+rayon-devel;unpack=0"
SRC_URI[x86_64_v2_rust-indexmap+rayon-devel.sha256sum] = "c20a498d911ad01f1d848e3c12ca3941817563ed55dff0fad8f700bdb399519a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+serde-devel-2.14.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-indexmap+serde-devel.sha256sum] = "7186d6bad584dbd1ea49ee2ea4fbbe98a0c891d2572a462b9381a0f07a154efe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+std-devel-2.14.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-indexmap+std-devel.sha256sum] = "0f8c7f25fee3430d096f6635319fea30467db16c85c918c41cae532290c87b43"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+test_debug-devel-2.14.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+test_debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-indexmap+test_debug-devel.sha256sum] = "267ba6ea0943ffaa9234f7cb0c0770246e5ed8885dabefc4a1ed9269ec5f4fa4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap-devel-2.14.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-indexmap-devel.sha256sum] = "2a38d51674cb00c8c3d5727d44c131437f1153836f4afd919a403d8997e68f5a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+arbitrary-devel-2.14.2-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-indexmap+arbitrary-devel.sha256sum] = "193cbb484c2af9ac164a720e0ada5a04526a6e7fded2a088d885afbcea2bb0da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+default-devel-2.14.2-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap+default-devel;unpack=0"
SRC_URI[aarch64_rust-indexmap+default-devel.sha256sum] = "a4763df2386e84ac7e226c28a934619ccaed3d9141344784a3ff88333ee82c24"
RPROVIDES:rust-indexmap+default-devel:append:aarch64 = " virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+quickcheck-devel-2.14.2-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap+quickcheck-devel;unpack=0"
SRC_URI[aarch64_rust-indexmap+quickcheck-devel.sha256sum] = "83f6b6edec7f4bf5b5c4752d402e501dfe2f1567189eeea17d5b8716ad7dca9d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+rayon-devel-2.14.2-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap+rayon-devel;unpack=0"
SRC_URI[aarch64_rust-indexmap+rayon-devel.sha256sum] = "f71d7a1f0babe5ae288fb776f48b23b638db7db004a99bf72050d4b3486c8ae7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+serde-devel-2.14.2-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap+serde-devel;unpack=0"
SRC_URI[aarch64_rust-indexmap+serde-devel.sha256sum] = "ccb9bcd7a09ef41a3bc3449f3b38a4e6d42e28131c6133f23fa4cacf66b88b73"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+std-devel-2.14.2-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap+std-devel;unpack=0"
SRC_URI[aarch64_rust-indexmap+std-devel.sha256sum] = "307ff91d80de15ca91a9da76c472631f7028b9fbcbbc7a87254e4d85002d7cc3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+test_debug-devel-2.14.2-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap+test_debug-devel;unpack=0"
SRC_URI[aarch64_rust-indexmap+test_debug-devel.sha256sum] = "770dd6731889eac96df15f0004c4ec5af2508d4572b8408b1357689e8eb98ff7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap-devel-2.14.2-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap-devel;unpack=0"
SRC_URI[aarch64_rust-indexmap-devel.sha256sum] = "3d095696ac663c3f24c2488b343f0c758c82326a7e04a40951dcc33c8594d9f0"

RDEPENDS:rust-indexmap+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+default-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+quickcheck-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-indexmap+rayon-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-indexmap+serde-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-indexmap+std-devel = " \
 cargo \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+test_debug-devel = " \
 cargo \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap-devel = " \
 cargo \
 rust \
 rust-equivalent-devel \
 rust-hashbrown-devel \
 "
