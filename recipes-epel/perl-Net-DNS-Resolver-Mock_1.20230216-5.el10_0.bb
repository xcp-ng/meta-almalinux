# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-DNS-Resolver-Mock"
PV = "1.20230216"
PR = "5.el10_0"
PACKAGES = " \
 perl-Net-DNS-Resolver-Mock \
 perl-Net-DNS-Resolver-Mock-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-DNS-Resolver-Mock-1.20230216-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce411af6013800db47476cae302aea42916941db6ac08d947ac7e9deb70e319f"

URI_x86_64_v2_perl-Net-DNS-Resolver-Mock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-DNS-Resolver-Mock-1.20230216-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-DNS-Resolver-Mock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-DNS-Resolver-Mock}"
SRC_URI[x86_64_v2_perl-Net-DNS-Resolver-Mock.sha256sum] = "71e46955aa2f487065d3660d7767e77c7f7857ac5cb5ba762829e02b91d2e8f1"

URI_x86_64_v2_perl-Net-DNS-Resolver-Mock-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-DNS-Resolver-Mock-tests-1.20230216-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-DNS-Resolver-Mock-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-DNS-Resolver-Mock-tests}"
SRC_URI[x86_64_v2_perl-Net-DNS-Resolver-Mock-tests.sha256sum] = "e6e53dcd1ecd2a471b37a04fa475928629e920ebc54a9abae3298c31ef047358"

URI_aarch64_perl-Net-DNS-Resolver-Mock = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-DNS-Resolver-Mock-1.20230216-5.el10_0.noarch.rpm;name=aarch64_perl-Net-DNS-Resolver-Mock;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-DNS-Resolver-Mock}"
SRC_URI[aarch64_perl-Net-DNS-Resolver-Mock.sha256sum] = "1b84e77f3570bd2c265b407bdaa9b179ab47e853327480aa1999d9d40a0f9cf3"

URI_aarch64_perl-Net-DNS-Resolver-Mock-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-DNS-Resolver-Mock-tests-1.20230216-5.el10_0.noarch.rpm;name=aarch64_perl-Net-DNS-Resolver-Mock-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-DNS-Resolver-Mock-tests}"
SRC_URI[aarch64_perl-Net-DNS-Resolver-Mock-tests.sha256sum] = "cbfd5d3cc4b7fbee16e16f9063db0722ca7c89ba1cccae3b10fe48d3baf7bbfc"

RDEPENDS:perl-Net-DNS-Resolver-Mock = " \
 perl-Net-DNS \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-Net-DNS-Resolver-Mock-tests = " \
 bash \
 perl-Net-DNS-Resolver-Mock \
 perl-Test-Exception \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
