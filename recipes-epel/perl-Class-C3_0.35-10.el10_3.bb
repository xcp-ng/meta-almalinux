# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-C3"
PV = "0.35"
PR = "10.el10_3"
PACKAGES = " \
 perl-Class-C3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-C3-0.35-10.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7154b6443f7e8626b26b367bb554c8e9599daa3fdddb663d47fe5207e8224fd"

URI_x86_64_v2_perl-Class-C3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-C3-0.35-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-C3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-C3}"
SRC_URI[x86_64_v2_perl-Class-C3.sha256sum] = "c19f9091914cd6ac5c07896833b84c9b6a7d5253882cff811b1dad24b9a84987"

URI_aarch64_perl-Class-C3 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-C3-0.35-10.el10_3.noarch.rpm;name=aarch64_perl-Class-C3;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-C3}"
SRC_URI[aarch64_perl-Class-C3.sha256sum] = "b0381757dc7e900011bbcac66bbfe31469bbb09ec2e80b9746ca2bbd15120dca"

RDEPENDS:perl-Class-C3 = " \
 perl-Algorithm-C3 \
 perl-Class-C3 \
 perl-Scalar-List-Utils \
 perl-libs \
 "
