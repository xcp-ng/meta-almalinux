# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-osc-placement"
PV = "4.8.0"
PR = "1.el10_2"
PACKAGES = " \
 python-osc-placement-docs \
 python3-osc-placement \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-osc-placement-4.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df9e2010a9f057d70424d2bc24c3f494185791b1756ee7696aa59bfbcdf53730"

URI_x86_64_v2_python-osc-placement-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-osc-placement-docs-4.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-osc-placement-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-osc-placement-docs}"
SRC_URI[x86_64_v2_python-osc-placement-docs.sha256sum] = "c3c0b8ed0c98b703f36994b5f872117078ef0ec8db02555fad705c3f9be9c0e7"

URI_x86_64_v2_python3-osc-placement = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-osc-placement-4.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-osc-placement;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-osc-placement}"
SRC_URI[x86_64_v2_python3-osc-placement.sha256sum] = "3c0e3032eb7b51599a4b83abbdfa44dffa9274d514d3b7ead7897a584c89d1a8"

URI_aarch64_python-osc-placement-docs = "${EPEL_MIRROR}/aarch64/Packages/p/python-osc-placement-docs-4.8.0-1.el10_2.noarch.rpm;name=aarch64_python-osc-placement-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-osc-placement-docs}"
SRC_URI[aarch64_python-osc-placement-docs.sha256sum] = "87ec1fd5d4535c99a6d0e1dd4fec50ae1c339ef1eda10dd9ec37efea45196183"

URI_aarch64_python3-osc-placement = "${EPEL_MIRROR}/aarch64/Packages/p/python3-osc-placement-4.8.0-1.el10_2.noarch.rpm;name=aarch64_python3-osc-placement;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-osc-placement}"
SRC_URI[aarch64_python3-osc-placement.sha256sum] = "ae5f40fd5434c278d41ee6bfa15a36e6feb51c2f7a8c5cf1e417634c91acc14d"

RDEPENDS:python-osc-placement-docs = " \
 python3-osc-placement \
 "
RDEPENDS:python3-osc-placement = " \
 python3 \
 python3-keystoneauth1 \
 python3-osc-lib \
 python3-oslo-utils \
 python3-pbr \
 "
