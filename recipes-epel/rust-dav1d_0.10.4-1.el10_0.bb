# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dav1d"
PV = "0.10.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-dav1d+default-devel \
 rust-dav1d-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dav1d-0.10.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "536f5ae30aedb6cb6fe422253e725c5fdd5c99519319eed791478b195799a7e6"

URI_x86_64_v2_rust-dav1d+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dav1d+default-devel-0.10.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dav1d+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dav1d+default-devel}"
SRC_URI[x86_64_v2_rust-dav1d+default-devel.sha256sum] = "6af43ff0da40f8b37606b82a98bd1c7ff0a979ea131964e4fdc0ef3ee7e87b96"

URI_x86_64_v2_rust-dav1d-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dav1d-devel-0.10.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dav1d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dav1d-devel}"
SRC_URI[x86_64_v2_rust-dav1d-devel.sha256sum] = "f923d0d79d9fe0de1d9c2ae465c88d7185a0f78318c85ae76f541e9f20f074b8"

URI_aarch64_rust-dav1d+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dav1d+default-devel-0.10.4-1.el10_0.noarch.rpm;name=aarch64_rust-dav1d+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dav1d+default-devel}"
SRC_URI[aarch64_rust-dav1d+default-devel.sha256sum] = "0fe046360470d7915fd3ac67dd619e731b5cb73e26fd6ccc6e43e9aebb0e3fd3"

URI_aarch64_rust-dav1d-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dav1d-devel-0.10.4-1.el10_0.noarch.rpm;name=aarch64_rust-dav1d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dav1d-devel}"
SRC_URI[aarch64_rust-dav1d-devel.sha256sum] = "7e115a7b78c356eb02479619ffb0fcee7d1076a3ae342516a4d6784bfe0e45c1"

RDEPENDS:rust-dav1d+default-devel = " \
 cargo \
 rust-dav1d-devel \
 "
RDEPENDS:rust-dav1d-devel = " \
 cargo \
 rust-av-data+default-devel \
 rust-bitflags+default-devel \
 rust-dav1d-sys+default-devel \
 rust-static_assertions+default-devel \
 "
