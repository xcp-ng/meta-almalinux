# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkmahjongg"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 libkmahjongg \
 libkmahjongg-data \
 libkmahjongg-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libkmahjongg-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2dc18fc5638ebbfa1f107e3779865b57356bd8f30e6cab067aa4631b717881ab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkmahjongg-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkmahjongg;unpack=0"
SRC_URI[x86_64_v2_libkmahjongg.sha256sum] = "84e0e3ffcd825d44d8da0408c3e88bb87cc22277dfce966f4d2ecf04d4d97f64"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkmahjongg-data-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libkmahjongg-data;unpack=0"
SRC_URI[x86_64_v2_libkmahjongg-data.sha256sum] = "19399c480ffa04eac92db109a6a4b215bf809ea8427d84e03c0dd7ffdfaefe02"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkmahjongg-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkmahjongg-devel;unpack=0"
SRC_URI[x86_64_v2_libkmahjongg-devel.sha256sum] = "b6a4d494b09efee9cd61f0dfdc23da883babfc2bc845c9fd7abfb917824e57dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkmahjongg-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkmahjongg;unpack=0"
SRC_URI[aarch64_libkmahjongg.sha256sum] = "248bbfa7f855b134bb97c47240dd95229f66db082b3e2f6ab6de313fd170f3d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkmahjongg-data-26.08.1-1.el10_3.noarch.rpm;name=aarch64_libkmahjongg-data;unpack=0"
SRC_URI[aarch64_libkmahjongg-data.sha256sum] = "7115ed1198d69b842d8f658124bbb28871059d3fca051f1cba5e1b1809cafb5e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkmahjongg-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkmahjongg-devel;unpack=0"
SRC_URI[aarch64_libkmahjongg-devel.sha256sum] = "b61a692aff6df8e788b9e4dfe2757be65fba101a2dd8af1accbe2b880dafedd0"

RDEPENDS:libkmahjongg = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libkmahjongg-data \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:libkmahjongg-data = " \
 "
RDEPENDS:libkmahjongg-devel = " \
 cmake-filesystem \
 kf6-kconfigwidgets-devel \
 libkmahjongg \
 qt6-qtbase-devel \
 "
