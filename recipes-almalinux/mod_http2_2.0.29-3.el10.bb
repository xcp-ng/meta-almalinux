# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_http2"
PV = "2.0.29"
PR = "3.el10"
PACKAGES = " \
 mod_http2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_http2-2.0.29-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ca7254f889522f312bba3d9d25b9791bc354f8c0be1856f15931d6d183cc4ad"

URI_x86_64_v2_mod_http2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_http2-2.0.29-3.el10.x86_64_v2.rpm;name=x86_64_v2_mod_http2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_http2}"
SRC_URI[x86_64_v2_mod_http2.sha256sum] = "f21772d4c40457864a21900efbc861be1865bf3c61f14af7011f5972a49bf712"

URI_aarch64_mod_http2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_http2-2.0.29-3.el10.aarch64.rpm;name=aarch64_mod_http2;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_http2}"
SRC_URI[aarch64_mod_http2.sha256sum] = "42d762255bea7ecc78677ba3852d0a6e8c914166e926f3c88d175a58bb207fd0"

RDEPENDS:mod_http2 = " \
 glibc \
 httpd-core \
 libnghttp2 \
 openssl-libs \
 "
