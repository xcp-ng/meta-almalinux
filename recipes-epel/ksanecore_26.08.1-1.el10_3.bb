# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksanecore"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ksanecore \
 ksanecore-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ksanecore-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0d82d8343ad01361888b7f33fc94c7bdc40b2610b595f677de0906b8f959dba2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksanecore-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksanecore;unpack=0"
SRC_URI[x86_64_v2_ksanecore.sha256sum] = "bf3ecb22587550dc906815577950683ef241c474a043edecda60e716e38772d7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksanecore-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksanecore-devel;unpack=0"
SRC_URI[x86_64_v2_ksanecore-devel.sha256sum] = "5899372e56eb6dbe9b607987e216b67e55635051d30e766b04b8d8d6d6621756"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ksanecore-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ksanecore;unpack=0"
SRC_URI[aarch64_ksanecore.sha256sum] = "b0028aa9203307bbe566e8ee600253c1c7a87bbacf1280e3300a3e22ab4657d2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ksanecore-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ksanecore-devel;unpack=0"
SRC_URI[aarch64_ksanecore-devel.sha256sum] = "c4af380b6607aa3c0ba206a06e6703791e2c7ec39fe5e8b66033bfe4203bca95"

RDEPENDS:ksanecore = " \
 glibc \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 sane-backends-libs \
 "
RDEPENDS:ksanecore-devel = " \
 cmake-filesystem \
 ksanecore \
 qt6-qtbase-devel \
 "
