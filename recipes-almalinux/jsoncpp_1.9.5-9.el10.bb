# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jsoncpp"
PV = "1.9.5"
PR = "9.el10"
PACKAGES = " \
 jsoncpp \
 jsoncpp-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jsoncpp-1.9.5-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a61eac8b648cfba2501e3c6b1fee0a3291ce9b5356082148d8440c473c802eef"

URI_x86_64_v2_jsoncpp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jsoncpp-1.9.5-9.el10.x86_64_v2.rpm;name=x86_64_v2_jsoncpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsoncpp}"
SRC_URI[x86_64_v2_jsoncpp.sha256sum] = "76c1c5602a9ab4b6b05a19200c49ce15f4889a5746b01b928f974dc7e2fd1254"

URI_x86_64_v2_jsoncpp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jsoncpp-devel-1.9.5-9.el10.x86_64_v2.rpm;name=x86_64_v2_jsoncpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsoncpp-devel}"
SRC_URI[x86_64_v2_jsoncpp-devel.sha256sum] = "3b0b2da8e0f09d9bad8a00d2a702620ec557c075e1168ae84d20b0cab737921d"

URI_aarch64_jsoncpp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jsoncpp-1.9.5-9.el10.aarch64.rpm;name=aarch64_jsoncpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsoncpp}"
SRC_URI[aarch64_jsoncpp.sha256sum] = "f8846c73fd59c7f6279646dd0f765900bae94bdd192c53d72d3ee1d049af6801"

URI_aarch64_jsoncpp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jsoncpp-devel-1.9.5-9.el10.aarch64.rpm;name=aarch64_jsoncpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsoncpp-devel}"
SRC_URI[aarch64_jsoncpp-devel.sha256sum] = "f591481548234bf5d4b241fa8c5107ca25204f81d1fc806b0dfc9ae926ec10d7"

RDEPENDS:jsoncpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:jsoncpp-devel = " \
 cmake-filesystem \
 jsoncpp \
 pkgconf-pkg-config \
 "
