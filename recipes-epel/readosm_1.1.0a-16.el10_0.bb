# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "readosm"
PV = "1.1.0a"
PR = "16.el10_0"
PACKAGES = " \
 readosm \
 readosm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/readosm-1.1.0a-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bb3caa162ec49813dd3660b55124698c651c9376bb9abf1595527a2b5b0a7d2"

URI_x86_64_v2_readosm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/readosm-1.1.0a-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_readosm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_readosm}"
SRC_URI[x86_64_v2_readosm.sha256sum] = "953fa72204268001a93ea55eecc59a7cc8c48577fdfd56799398be7a70697e1c"

URI_x86_64_v2_readosm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/readosm-devel-1.1.0a-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_readosm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_readosm-devel}"
SRC_URI[x86_64_v2_readosm-devel.sha256sum] = "d5a6e5cb138a4f9be3eb079fac3a3c6f5b11a890936bf74512c29537a90cd3fa"

URI_aarch64_readosm = "${EPEL_MIRROR}/aarch64/Packages/r/readosm-1.1.0a-16.el10_0.aarch64.rpm;name=aarch64_readosm;unpack=0"
SRC_URI:append = " ${URI_aarch64_readosm}"
SRC_URI[aarch64_readosm.sha256sum] = "edfe23916a745503d52dda7fac07dddfb87454c2c677f1b233c7fb46b56d27c9"

URI_aarch64_readosm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/readosm-devel-1.1.0a-16.el10_0.aarch64.rpm;name=aarch64_readosm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_readosm-devel}"
SRC_URI[aarch64_readosm-devel.sha256sum] = "6011339b337bc8e036cb239dc3c0724a1bdae4e96360d8ceb6dd8d124e8c4db1"

RDEPENDS:readosm = " \
 expat \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:readosm-devel = " \
 pkgconf-pkg-config \
 readosm \
 "
