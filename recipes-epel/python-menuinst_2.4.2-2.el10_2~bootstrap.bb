# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-menuinst"
PV = "2.4.2"
PR = "2.el10_2~bootstrap"
PACKAGES = " \
 python3-menuinst \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-menuinst-2.4.2-2.el10_2~bootstrap.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d0d2712d9cd43ad86e3dd389b81c96a0dcc991b9784557a2a26fb56b2371255"

URI_aarch64_python3-menuinst = "${EPEL_MIRROR}/aarch64/Packages/p/python3-menuinst-2.4.2-2.el10_2~bootstrap.noarch.rpm;name=aarch64_python3-menuinst;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-menuinst}"
SRC_URI[aarch64_python3-menuinst.sha256sum] = "6cab2a0f0c7d48bd20b9e0eb56b99cafe49aee5e555bfe7d719eba788d653ec0"

RDEPENDS:python3-menuinst = " \
 python3 \
 "
