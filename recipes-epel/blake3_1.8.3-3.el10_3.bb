# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "blake3"
PV = "1.8.3"
PR = "3.el10_3"
PACKAGES = " \
 blake3 \
 blake3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/blake3-1.8.3-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7197a0cc97968fa8e2d9a6c49543a22c00dfec7a8051ec7d879933d1528a1df9"

URI_x86_64_v2_blake3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blake3-1.8.3-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blake3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blake3}"
SRC_URI[x86_64_v2_blake3.sha256sum] = "b03238c5159c626eed11bec280861d5eedd996167e210bac55e1add0abc8148f"

URI_x86_64_v2_blake3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blake3-devel-1.8.3-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blake3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blake3-devel}"
SRC_URI[x86_64_v2_blake3-devel.sha256sum] = "fc906938e48111ec3b67f57641305d383782e7882215a132e3a421dfdbe9d894"

URI_aarch64_blake3 = "${EPEL_MIRROR}/aarch64/Packages/b/blake3-1.8.3-3.el10_3.aarch64.rpm;name=aarch64_blake3;unpack=0"
SRC_URI:append = " ${URI_aarch64_blake3}"
SRC_URI[aarch64_blake3.sha256sum] = "72785e77728c49db8725bb1caedced2bd754a399246a9f5f31b7aaf7547e04d6"

URI_aarch64_blake3-devel = "${EPEL_MIRROR}/aarch64/Packages/b/blake3-devel-1.8.3-3.el10_3.aarch64.rpm;name=aarch64_blake3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_blake3-devel}"
SRC_URI[aarch64_blake3-devel.sha256sum] = "f15ce0390d611438fcef7c1914f74e40ec87e633c2b84d124092da5e5bc68231"

RDEPENDS:blake3 = " \
 glibc \
 libstdc++ \
 tbb \
 "
RDEPENDS:blake3-devel = " \
 blake3 \
 cmake-filesystem \
 pkgconf-pkg-config \
 tbb-devel \
 "
