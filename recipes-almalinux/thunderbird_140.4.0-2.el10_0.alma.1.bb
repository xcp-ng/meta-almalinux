# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "thunderbird"
PV = "140.4.0"
PR = "2.el10_0.alma.1"
PACKAGES = " \
 thunderbird \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/thunderbird-140.4.0-2.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5aa96174a9803f3e61ec03671085647f444898c2166710b64aa28c935049e33a"

URI_x86_64_v2_thunderbird = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/thunderbird-140.4.0-2.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_thunderbird;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_thunderbird}"
SRC_URI[x86_64_v2_thunderbird.sha256sum] = "df3c4bc7fb27bb5eeda333bfd1a235a22c4bbbbab51a4634920b17cc7b35770c"

URI_aarch64_thunderbird = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/thunderbird-140.4.0-2.el10_0.alma.1.aarch64.rpm;name=aarch64_thunderbird;unpack=0"
SRC_URI:append = " ${URI_aarch64_thunderbird}"
SRC_URI[aarch64_thunderbird.sha256sum] = "093e21107cce8d69bb4932a25a1af6ddbd68d47113b10f6017644efba78138e7"

RDEPENDS:thunderbird = " \
 alsa-lib \
 atk \
 bash \
 cairo \
 cairo-gobject \
 dbus-libs \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libX11 \
 libX11-xcb \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXrandr \
 libXrender \
 libffi \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 libxcb \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 p11-kit-trust \
 pango \
 pciutils-libs \
 zlib-ng-compat \
 "
