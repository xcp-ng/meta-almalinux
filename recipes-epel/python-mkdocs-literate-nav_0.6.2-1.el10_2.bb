# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-literate-nav"
PV = "0.6.2"
PR = "1.el10_2"
PACKAGES = " \
 python3-mkdocs-literate-nav \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-literate-nav-0.6.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9e03dc942b57fdd61d392cee83d30324db498335030d6962bb88799499208f8"

URI_x86_64_v2_python3-mkdocs-literate-nav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-literate-nav-0.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-literate-nav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-literate-nav}"
SRC_URI[x86_64_v2_python3-mkdocs-literate-nav.sha256sum] = "014bc309be708aa2bc15a87a35255c7bbf80fe308261b7b2b88cd1515aee3620"

URI_aarch64_python3-mkdocs-literate-nav = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-literate-nav-0.6.2-1.el10_2.noarch.rpm;name=aarch64_python3-mkdocs-literate-nav;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-literate-nav}"
SRC_URI[aarch64_python3-mkdocs-literate-nav.sha256sum] = "eac02d48899e18f721cc16c34865a413fae85da6a379d48f5fe8957839d9e606"

RDEPENDS:python3-mkdocs-literate-nav = " \
 mkdocs \
 python3 \
 "
