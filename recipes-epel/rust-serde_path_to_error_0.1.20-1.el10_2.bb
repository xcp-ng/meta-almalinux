# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_path_to_error"
PV = "0.1.20"
PR = "1.el10_2"
PACKAGES = " \
 rust-serde_path_to_error+default-devel \
 rust-serde_path_to_error-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_path_to_error-0.1.20-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46794673e0c82deaf6bdf817a77e24f01c27b383e489aa23b4ef2e88f441905a"

URI_x86_64_v2_rust-serde_path_to_error+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_path_to_error+default-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_path_to_error+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_path_to_error+default-devel}"
SRC_URI[x86_64_v2_rust-serde_path_to_error+default-devel.sha256sum] = "6f46343f3a563e35262d476e83634881f0940aa875c9ab7cb24c586af0aa38b1"

URI_x86_64_v2_rust-serde_path_to_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_path_to_error-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_path_to_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_path_to_error-devel}"
SRC_URI[x86_64_v2_rust-serde_path_to_error-devel.sha256sum] = "eafcd35ead1b11becf948365ab9f3fe0685af41cae55c914b08f5abd5911de83"

URI_aarch64_rust-serde_path_to_error+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_path_to_error+default-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-serde_path_to_error+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_path_to_error+default-devel}"
SRC_URI[aarch64_rust-serde_path_to_error+default-devel.sha256sum] = "44664e4b0209ea16c11b516f14a8f15af5a565e445d597418dd0b0805d58f2f7"

URI_aarch64_rust-serde_path_to_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_path_to_error-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-serde_path_to_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_path_to_error-devel}"
SRC_URI[aarch64_rust-serde_path_to_error-devel.sha256sum] = "7b37dd666c2414785f9e63f6d9cf74e5849d23d2e14e0c70b1ab2b6812d6576b"

RDEPENDS:rust-serde_path_to_error+default-devel = " \
 cargo \
 rust-serde_path_to_error-devel \
 "
RDEPENDS:rust-serde_path_to_error-devel = " \
 cargo \
 rust \
 rust-itoa+default-devel \
 rust-serde-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
