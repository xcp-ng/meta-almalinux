# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kscreen"
PE = "1"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kscreen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kscreen-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b87c29ec1b97f1a7961e841a680360250957be7685d7a917dcbf8380e845986"

URI_x86_64_v2_kscreen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreen-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kscreen}"
SRC_URI[x86_64_v2_kscreen.sha256sum] = "39544f54678b0a98f9ebe4c1c2680ee0c889535ba64508dab3d3f880d2365d33"

URI_aarch64_kscreen = "${EPEL_MIRROR}/aarch64/Packages/k/kscreen-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kscreen;unpack=0"
SRC_URI:append = " ${URI_aarch64_kscreen}"
SRC_URI[aarch64_kscreen.sha256sum] = "78ee3b14da83829dbf567496137b9e7bf10201262c1c21e9101096e4d7b52eb0"

RDEPENDS:kscreen = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kwindowsystem \
 layer-shell-qt \
 libX11 \
 libXi \
 libkscreen \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma5support \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
