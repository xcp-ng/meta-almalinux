# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtbase"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtbase \
 qt5-qtbase-common \
 qt5-qtbase-devel \
 qt5-qtbase-examples \
 qt5-qtbase-gui \
 qt5-qtbase-mysql \
 qt5-qtbase-odbc \
 qt5-qtbase-postgresql \
 qt5-qtbase-private-devel \
 qt5-qtbase-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtbase-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd8271918d12f6561d0824ecb515671bf0dbf5dcc8099e1bc7e05d4b36bdbaa8"

URI_x86_64_v2_qt5-qtbase = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase}"
SRC_URI[x86_64_v2_qt5-qtbase.sha256sum] = "c1c75411b6f711e4cf11caa59ba831271349758551c433e02c922e2bbffbe94e"

URI_x86_64_v2_qt5-qtbase-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-common-5.15.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtbase-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-common}"
SRC_URI[x86_64_v2_qt5-qtbase-common.sha256sum] = "c2e856927c75f03edc0db52f35f8148261fcb6a551e78c825fe17788935cfda8"

URI_x86_64_v2_qt5-qtbase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-devel}"
SRC_URI[x86_64_v2_qt5-qtbase-devel.sha256sum] = "8fe4715d9f3e37694444d9c478a63386d04136ee927f08c271c13c96853c898b"

URI_x86_64_v2_qt5-qtbase-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-examples}"
SRC_URI[x86_64_v2_qt5-qtbase-examples.sha256sum] = "5925e617a898b3ec3fa9aba0124b9ab1050dd6d416c3c9c35cda264790c2f982"

URI_x86_64_v2_qt5-qtbase-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-gui-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-gui}"
SRC_URI[x86_64_v2_qt5-qtbase-gui.sha256sum] = "0b8ee7964629ad13854a1ef0bc7c8a0619588dee8e08a40f645470a4a35b07de"

URI_x86_64_v2_qt5-qtbase-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-mysql-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-mysql}"
SRC_URI[x86_64_v2_qt5-qtbase-mysql.sha256sum] = "ef202255083543e082e5a8287a7f595c256dbf14ac0a8cc8cd1f5e364bfb83e2"

URI_x86_64_v2_qt5-qtbase-odbc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-odbc-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-odbc}"
SRC_URI[x86_64_v2_qt5-qtbase-odbc.sha256sum] = "8fa9b4349fc80d9619414bf430f04e30a59aa28ca4cb7ca8826f14d7d39aeabb"

URI_x86_64_v2_qt5-qtbase-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-postgresql-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-postgresql}"
SRC_URI[x86_64_v2_qt5-qtbase-postgresql.sha256sum] = "413d3d07908621117f53b583b33c609f1d318f68cd3145c4a2d6dadd58a515c6"

URI_x86_64_v2_qt5-qtbase-private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-private-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-private-devel}"
SRC_URI[x86_64_v2_qt5-qtbase-private-devel.sha256sum] = "98498990aa52808cd8396db8c1e30d720120e70e663c1151da51f9ec36032f32"

URI_x86_64_v2_qt5-qtbase-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-static-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-static}"
SRC_URI[x86_64_v2_qt5-qtbase-static.sha256sum] = "fb921026d947b80e0b586c75ca0db3c615adbe105d153604a3140ae1ba050e04"

URI_aarch64_qt5-qtbase = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtbase;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase}"
SRC_URI[aarch64_qt5-qtbase.sha256sum] = "fa82083fe67b87018fb424fa7ea0d8e64174ec7ad4728424a1e14613645b65e9"

URI_aarch64_qt5-qtbase-common = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-common-5.15.18-1.el10_2.noarch.rpm;name=aarch64_qt5-qtbase-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-common}"
SRC_URI[aarch64_qt5-qtbase-common.sha256sum] = "d326a28a8a2364e740d0e7010b5a6634cfc2c88ee1e55f2513ffc1fcea23ac58"

URI_aarch64_qt5-qtbase-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtbase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-devel}"
SRC_URI[aarch64_qt5-qtbase-devel.sha256sum] = "49b0d5e118e3ecd4f67db7fa0d227ae061453dd25ee92a1039e7f96d92970555"

URI_aarch64_qt5-qtbase-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtbase-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-examples}"
SRC_URI[aarch64_qt5-qtbase-examples.sha256sum] = "6662b0aef3614dd14415003a17c84f17ba5703183cdd5dc6e4cadf107584e01a"

URI_aarch64_qt5-qtbase-gui = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-gui-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtbase-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-gui}"
SRC_URI[aarch64_qt5-qtbase-gui.sha256sum] = "b237cab04ee6dae75b547f5ac0ebe8212cde1bef8c0c02fd77e6c9a7b002cb90"

URI_aarch64_qt5-qtbase-mysql = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-mysql-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtbase-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-mysql}"
SRC_URI[aarch64_qt5-qtbase-mysql.sha256sum] = "bcc720826c4e3384656a434a8cf8cf352fea541548145dab0474495651f78e8f"

URI_aarch64_qt5-qtbase-odbc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-odbc-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtbase-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-odbc}"
SRC_URI[aarch64_qt5-qtbase-odbc.sha256sum] = "8fb8f8f11f0046583eaf70d0e22254fc3353970f59e78383ebb2e6f95f2216f3"

URI_aarch64_qt5-qtbase-postgresql = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-postgresql-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtbase-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-postgresql}"
SRC_URI[aarch64_qt5-qtbase-postgresql.sha256sum] = "5cae5c4381e817a5cdb8011660430461e0c0a1748258c6235b5858e5c4eb40a9"

URI_aarch64_qt5-qtbase-private-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-private-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtbase-private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-private-devel}"
SRC_URI[aarch64_qt5-qtbase-private-devel.sha256sum] = "807721a7eac5ce4144225a1aeb9fbe1213a09207daa2687d15bdee472268ca61"

URI_aarch64_qt5-qtbase-static = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-static-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtbase-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-static}"
SRC_URI[aarch64_qt5-qtbase-static.sha256sum] = "b49c9ca3308d710eee226041a9226f6bcc292521ba2d059e0782a1a70331e4ab"

RDEPENDS:qt5-qtbase = " \
 alternatives \
 bash \
 dbus-libs \
 double-conversion \
 glib2 \
 glibc \
 krb5-libs \
 libgcc \
 libicu \
 libproxy \
 libstdc++ \
 libzstd \
 openssl-libs \
 pcre2-utf16 \
 qt5-filesystem \
 qt5-qtbase-common \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtbase-common = " \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtbase-devel = " \
 bash \
 cmake-filesystem \
 glibc \
 libgcc \
 libglvnd-devel \
 libstdc++ \
 libzstd \
 perl-English \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-IO \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 python3 \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtbase-gui \
 qt5-rpm-macros \
 vulkan-loader-devel \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtbase-examples = " \
 glibc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:qt5-qtbase-gui = " \
 bash \
 cups-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 glx-utils \
 harfbuzz \
 libICE \
 libSM \
 libX11 \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libglvnd-glx \
 libinput \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libxcb \
 libxkbcommon \
 libxkbcommon-x11 \
 mesa-libgbm \
 qt5-qtbase \
 systemd-libs \
 xcb-util-image \
 xcb-util-keysyms \
 xcb-util-renderutil \
 xcb-util-wm \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtbase-mysql = " \
 glibc \
 libstdc++ \
 mariadb-connector-c \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtbase-odbc = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 unixODBC \
 "
RDEPENDS:qt5-qtbase-postgresql = " \
 glibc \
 libpq \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtbase-private-devel = " \
 cups-devel \
 qt5-qtbase-devel \
 "
RDEPENDS:qt5-qtbase-static = " \
 cmake-filesystem \
 fontconfig-devel \
 glib2-devel \
 libinput-devel \
 libxkbcommon-devel \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 zlib-ng-compat-devel \
 "
