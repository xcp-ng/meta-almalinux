# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_md"
PE = "1"
PV = "2.4.26"
PR = "6.el10"
PACKAGES = " \
 mod_md \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_md-2.4.26-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d68e9c362da6aa029435686b3789a5857bb5372d41e2de28491e7ebd76434ddd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_md-2.4.26-6.el10.x86_64_v2.rpm;name=x86_64_v2_mod_md;unpack=0"
SRC_URI[x86_64_v2_mod_md.sha256sum] = "15a33e629599a41247c0a815fa19363a2a5b9592b3e8380ceb3db17c7be753bf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_md-2.4.26-6.el10.aarch64.rpm;name=aarch64_mod_md;unpack=0"
SRC_URI[aarch64_mod_md.sha256sum] = "b6db9197714962491e9ed008f71e14413df7dc9c78ec41ea69ab144995a605a3"

RDEPENDS:mod_md = " \
 apr \
 apr-util \
 glibc \
 httpd-core \
 jansson \
 mod_ssl \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
