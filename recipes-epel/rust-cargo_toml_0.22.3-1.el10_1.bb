# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_toml"
PV = "0.22.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-cargo_toml+default-devel \
 rust-cargo_toml+features-devel \
 rust-cargo_toml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_toml-0.22.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ad71771ace265c00e0b3fc2589244c63f757ca7b31cf100d70c56bf495bfb12"

URI_x86_64_v2_rust-cargo_toml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_toml+default-devel-0.22.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_toml+default-devel}"
SRC_URI[x86_64_v2_rust-cargo_toml+default-devel.sha256sum] = "1a86bc222507b14224bd7f1a17d6aaefd0eebb98e2a350be48838c24d46efbe9"

URI_x86_64_v2_rust-cargo_toml+features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_toml+features-devel-0.22.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_toml+features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_toml+features-devel}"
SRC_URI[x86_64_v2_rust-cargo_toml+features-devel.sha256sum] = "abbe8ac115ced7d2cd0993535ee11358bde09ceb5fadaad3b80a6f2754304a6b"

URI_x86_64_v2_rust-cargo_toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_toml-devel-0.22.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_toml-devel}"
SRC_URI[x86_64_v2_rust-cargo_toml-devel.sha256sum] = "4092b14e8708fc4fc5e7cd1951c41d82a915c04a13857a07904d6da234f0c736"

URI_aarch64_rust-cargo_toml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_toml+default-devel-0.22.3-1.el10_1.noarch.rpm;name=aarch64_rust-cargo_toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_toml+default-devel}"
SRC_URI[aarch64_rust-cargo_toml+default-devel.sha256sum] = "80b65669a0a21c96763f9de9732f10ae891c02b91839a7f5957ae423f4823354"

URI_aarch64_rust-cargo_toml+features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_toml+features-devel-0.22.3-1.el10_1.noarch.rpm;name=aarch64_rust-cargo_toml+features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_toml+features-devel}"
SRC_URI[aarch64_rust-cargo_toml+features-devel.sha256sum] = "504a7c8c8b99f8d761f91bfbdc8d610293d8d9464287240b0358d3811dc080e1"

URI_aarch64_rust-cargo_toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_toml-devel-0.22.3-1.el10_1.noarch.rpm;name=aarch64_rust-cargo_toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_toml-devel}"
SRC_URI[aarch64_rust-cargo_toml-devel.sha256sum] = "8518e0a156431c2a604838add4032fa3939bfadb3a9c5b66ee641f3e2632f063"

RDEPENDS:rust-cargo_toml+default-devel = " \
 cargo \
 rust-cargo_toml-devel \
 "
RDEPENDS:rust-cargo_toml+features-devel = " \
 cargo \
 rust-cargo_toml-devel \
 "
RDEPENDS:rust-cargo_toml-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-toml+default-devel \
 "
