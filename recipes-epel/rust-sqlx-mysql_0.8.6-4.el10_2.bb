# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sqlx-mysql"
PV = "0.8.6"
PR = "4.el10_2"
PACKAGES = " \
 rust-sqlx-mysql+any-devel \
 rust-sqlx-mysql+bigdecimal-devel \
 rust-sqlx-mysql+chrono-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+json-devel \
 rust-sqlx-mysql+migrate-devel \
 rust-sqlx-mysql+offline-devel \
 rust-sqlx-mysql+rust_decimal-devel \
 rust-sqlx-mysql+serde-devel \
 rust-sqlx-mysql+time-devel \
 rust-sqlx-mysql+uuid-devel \
 rust-sqlx-mysql-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sqlx-mysql-0.8.6-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26b3768760ad259f5ffa028d29950bb48ef0b916d7d6cdc89aaaac1de972bbac"

URI_x86_64_v2_rust-sqlx-mysql+any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+any-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+any-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+any-devel.sha256sum] = "0d0f95e2d0babfbf95d92b6162dc0a1321cc3a5b29077b80f2aa7beabc220440"

URI_x86_64_v2_rust-sqlx-mysql+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+bigdecimal-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+bigdecimal-devel.sha256sum] = "becd943f683df0b64f15630df5d4e3c8de1c2b40f9f70ad5c73bad7e5cbe8de0"

URI_x86_64_v2_rust-sqlx-mysql+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+chrono-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+chrono-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+chrono-devel.sha256sum] = "cc27105c94e121b34358525b26666cdd87a5bc52d209c4d7c660ced427c8b593"

URI_x86_64_v2_rust-sqlx-mysql+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+default-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+default-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+default-devel.sha256sum] = "3ffd805b5e73daa27be3efc08fd7da8ae7f8d0942ae8a146a059b9a1bea94250"

URI_x86_64_v2_rust-sqlx-mysql+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+json-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+json-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+json-devel.sha256sum] = "9059b6f81429a1ac168d3321854f5b7110ab08befc59d52e9b751a345e72ea12"

URI_x86_64_v2_rust-sqlx-mysql+migrate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+migrate-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+migrate-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+migrate-devel.sha256sum] = "fb3ca0c7e08f0927e363c1916989d06cd20df674289da0994d5773ff4fcb01fe"

URI_x86_64_v2_rust-sqlx-mysql+offline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+offline-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+offline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+offline-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+offline-devel.sha256sum] = "c24ad5e16f835c40c47685ba848094a51e5dddc729243a2b4f74962eb2036d8d"

URI_x86_64_v2_rust-sqlx-mysql+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+rust_decimal-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+rust_decimal-devel.sha256sum] = "0d0f82c27ecb25f65eda0c12448b61dddf93ad6c4705b5b85bc6a1166247bb72"

URI_x86_64_v2_rust-sqlx-mysql+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+serde-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+serde-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+serde-devel.sha256sum] = "ac439f77bb8aec580cb0a5f655319b4e7361c15b753b89ad388694e6c0f5e2b8"

URI_x86_64_v2_rust-sqlx-mysql+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+time-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+time-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+time-devel.sha256sum] = "43baa57d88b33ae7769dfd3e75980177027058ea39b027fbbf2418dfe1cc9ccf"

URI_x86_64_v2_rust-sqlx-mysql+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+uuid-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+uuid-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+uuid-devel.sha256sum] = "a505baf43c9954ada844b4d11477d51ceb07766f5a1c56fc7394a42287811a26"

URI_x86_64_v2_rust-sqlx-mysql-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql-devel.sha256sum] = "af8f22c20bc38dabe57bb06bb545b5ccd6322c7befd3f5348a151d43d95b176c"

URI_aarch64_rust-sqlx-mysql+any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+any-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-mysql+any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+any-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+any-devel.sha256sum] = "4ca855242e37b0a15db29cd0d45761e8dd996444fe59596b314c53c0e3b94f08"

URI_aarch64_rust-sqlx-mysql+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+bigdecimal-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-mysql+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+bigdecimal-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+bigdecimal-devel.sha256sum] = "ac5f24bce8decf445e4cabc5c4d0d054903de580e751453b210cfb65a04c2b3c"

URI_aarch64_rust-sqlx-mysql+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+chrono-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-mysql+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+chrono-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+chrono-devel.sha256sum] = "4c89f1d51ec9d51174a2da72d6887118ce9ae5b00f14a891620253bedbb450c8"

URI_aarch64_rust-sqlx-mysql+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+default-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-mysql+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+default-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+default-devel.sha256sum] = "86a97b424ee778cb2947a0ca6161ebcdc057914a6d5b6ec006dd603d5d1f5171"

URI_aarch64_rust-sqlx-mysql+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+json-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-mysql+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+json-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+json-devel.sha256sum] = "0be6d5148a9c8ad9611df54e8b464ea0e131eb9e1be782d5fd881251dba34553"

URI_aarch64_rust-sqlx-mysql+migrate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+migrate-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-mysql+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+migrate-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+migrate-devel.sha256sum] = "cc12288faba77593dbbe93431555be45c499a3c54ecdaf13366b231c6a9d4b03"

URI_aarch64_rust-sqlx-mysql+offline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+offline-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-mysql+offline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+offline-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+offline-devel.sha256sum] = "c14d85211b492550a0b4eb114b7256418be70643f6cd79e62f4b040706b7a23e"

URI_aarch64_rust-sqlx-mysql+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+rust_decimal-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-mysql+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+rust_decimal-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+rust_decimal-devel.sha256sum] = "049df583af6a2a59899825d398e6cb3c2581e18d4e91610940c1975cf231c40e"

URI_aarch64_rust-sqlx-mysql+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+serde-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-mysql+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+serde-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+serde-devel.sha256sum] = "f9355a53940f5870ba0b585b46e614248d5737a27ef9f13344c4332c8d42b7ef"

URI_aarch64_rust-sqlx-mysql+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+time-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-mysql+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+time-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+time-devel.sha256sum] = "90773be31f98f3ebe430efd15939c6b07a6df18a29cba836baf936930caf8fac"

URI_aarch64_rust-sqlx-mysql+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+uuid-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-mysql+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+uuid-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+uuid-devel.sha256sum] = "e5f250ed05838f8fb1dc0a980a3e1f51efccab36fbf62f71ec185cfd82b46f03"

URI_aarch64_rust-sqlx-mysql-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-mysql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql-devel}"
SRC_URI[aarch64_rust-sqlx-mysql-devel.sha256sum] = "b5ed6b1a0997f3171d7c9cbce0c7b55bed5f260bef487ab94978c90a55ce3644"

RDEPENDS:rust-sqlx-mysql+any-devel = " \
 cargo \
 rust-sqlx-core+any-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+bigdecimal-devel = " \
 cargo \
 rust-bigdecimal+default-devel \
 rust-sqlx-core+bigdecimal-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-sqlx-core+chrono-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+default-devel = " \
 cargo \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+json-devel = " \
 cargo \
 rust-sqlx-core+json-devel \
 rust-sqlx-mysql+serde-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+migrate-devel = " \
 cargo \
 rust-sqlx-core+migrate-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+offline-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-sqlx-core+offline-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+rust_decimal-devel = " \
 cargo \
 rust-rust_decimal+maths-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 rust-sqlx-core+rust_decimal-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+time-devel = " \
 cargo \
 rust-sqlx-core+time-devel \
 rust-sqlx-mysql-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-sqlx-mysql+uuid-devel = " \
 cargo \
 rust-sqlx-core+uuid-devel \
 rust-sqlx-mysql-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-sqlx-mysql-devel = " \
 cargo \
 rust-atoi+default-devel \
 rust-base64+std-devel \
 rust-base64-devel \
 rust-bitflags+serde-devel \
 rust-bitflags-devel \
 rust-byteorder+std-devel \
 rust-byteorder-devel \
 rust-bytes+default-devel \
 rust-crc+default-devel \
 rust-digest+std-devel \
 rust-digest-devel \
 rust-dotenvy+default-devel \
 rust-either+default-devel \
 rust-futures-channel+alloc-devel \
 rust-futures-channel+sink-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-core-devel \
 rust-futures-io+default-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util+io-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 rust-generic-array-devel \
 rust-hex+default-devel \
 rust-hkdf+default-devel \
 rust-hmac-devel \
 rust-itoa+default-devel \
 rust-log+default-devel \
 rust-md-5-devel \
 rust-memchr-devel \
 rust-once_cell+default-devel \
 rust-percent-encoding+default-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 rust-rsa+default-devel \
 rust-sha1-devel \
 rust-sha2-devel \
 rust-smallvec+default-devel \
 rust-sqlx-core+default-devel \
 rust-stringprep+default-devel \
 rust-thiserror+default-devel \
 rust-tracing+default-devel \
 rust-tracing+log-devel \
 "
