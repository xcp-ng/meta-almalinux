# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-model"
PV = "0.9.0"
PR = "4.el10_3"
PACKAGES = " \
 rust-below-model+default-devel \
 rust-below-model-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-model-0.9.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "882aeb16389335c51d8b48d4331888faf26b5631d8b3fdc0815bce826d888cd8"

URI_x86_64_v2_rust-below-model+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-model+default-devel-0.9.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-model+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-model+default-devel}"
SRC_URI[x86_64_v2_rust-below-model+default-devel.sha256sum] = "6c5b2d47c2449ff17f47ff9cc3af24fe3f469857feb69a1afedb6a7495f69b8d"

URI_x86_64_v2_rust-below-model-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-model-devel-0.9.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-model-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-model-devel}"
SRC_URI[x86_64_v2_rust-below-model-devel.sha256sum] = "c49a1269314909320579936abaeb06f4eef54b2adaa1bc1af81356ce35fc0e08"

URI_aarch64_rust-below-model+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-model+default-devel-0.9.0-4.el10_3.noarch.rpm;name=aarch64_rust-below-model+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-model+default-devel}"
SRC_URI[aarch64_rust-below-model+default-devel.sha256sum] = "4a94780b69756eae9e043be2f51c958ca3ea28610528400aa16c3a2a99223c8f"

URI_aarch64_rust-below-model-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-model-devel-0.9.0-4.el10_3.noarch.rpm;name=aarch64_rust-below-model-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-model-devel}"
SRC_URI[aarch64_rust-below-model-devel.sha256sum] = "f3326302829db44852d8b4dd6eb5cb2705645d3f91480775ea54f8d7dcc67f69"

RDEPENDS:rust-below-model+default-devel = " \
 cargo \
 rust-below-model-devel \
 "
RDEPENDS:rust-below-model-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-below-btrfs+default-devel \
 rust-below-common+default-devel \
 rust-below-ethtool+default-devel \
 rust-below-gpu-stats+default-devel \
 rust-below-tc+default-devel \
 rust-below_derive+default-devel \
 rust-cgroupfs+default-devel \
 rust-enum-iterator+default-devel \
 rust-fb_procfs+default-devel \
 rust-hostname+default-devel \
 rust-os_info+default-devel \
 rust-regex+default-devel \
 rust-resctrlfs+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde_json+default-devel \
 rust-serde_json+float_roundtrip-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-slog+default-devel \
 rust-slog+max_level_trace-devel \
 rust-slog+nested-values-devel \
 "
