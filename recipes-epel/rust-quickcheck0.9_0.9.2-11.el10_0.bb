# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quickcheck0.9"
PV = "0.9.2"
PR = "11.el10_0"
PACKAGES = " \
 rust-quickcheck0.9+default-devel \
 rust-quickcheck0.9+env_logger-devel \
 rust-quickcheck0.9+log-devel \
 rust-quickcheck0.9+regex-devel \
 rust-quickcheck0.9+unstable-devel \
 rust-quickcheck0.9+use_logging-devel \
 rust-quickcheck0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quickcheck0.9-0.9.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3aa6457064b53dc9eb236a8417b31bf6d0b60ed1a16f125822be489fa5ce1692"

URI_x86_64_v2_rust-quickcheck0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck0.9+default-devel-0.9.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck0.9+default-devel}"
SRC_URI[x86_64_v2_rust-quickcheck0.9+default-devel.sha256sum] = "0beb155bab0cba3fb2e3017509ead5a3dba59600baa4cf9397e3b4f71059f2e3"

URI_x86_64_v2_rust-quickcheck0.9+env_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck0.9+env_logger-devel-0.9.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck0.9+env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck0.9+env_logger-devel}"
SRC_URI[x86_64_v2_rust-quickcheck0.9+env_logger-devel.sha256sum] = "45e6357faf07938017e9e9ac1ef23558dc724b332f9f43c0c954d073df059b08"

URI_x86_64_v2_rust-quickcheck0.9+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck0.9+log-devel-0.9.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck0.9+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck0.9+log-devel}"
SRC_URI[x86_64_v2_rust-quickcheck0.9+log-devel.sha256sum] = "d96d0ade2eac54111c1e710c0ff89dc75e00c9a7b83683ff30d6f5fea9df993f"

URI_x86_64_v2_rust-quickcheck0.9+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck0.9+regex-devel-0.9.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck0.9+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck0.9+regex-devel}"
SRC_URI[x86_64_v2_rust-quickcheck0.9+regex-devel.sha256sum] = "d2b9af7c79e03a50d5619116e8b3480cc17cc3937b038686252c891b64fe2747"

URI_x86_64_v2_rust-quickcheck0.9+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck0.9+unstable-devel-0.9.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck0.9+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck0.9+unstable-devel}"
SRC_URI[x86_64_v2_rust-quickcheck0.9+unstable-devel.sha256sum] = "5942d2187897da705131ebfc045448f9e51e18a73dfbcde3b20eb3e755cc3791"

URI_x86_64_v2_rust-quickcheck0.9+use_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck0.9+use_logging-devel-0.9.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck0.9+use_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck0.9+use_logging-devel}"
SRC_URI[x86_64_v2_rust-quickcheck0.9+use_logging-devel.sha256sum] = "9879926b5716910283a70b825c01c9cbb3887d690c125c1b6ff7d08f68976782"

URI_x86_64_v2_rust-quickcheck0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck0.9-devel-0.9.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck0.9-devel}"
SRC_URI[x86_64_v2_rust-quickcheck0.9-devel.sha256sum] = "4e9886cadd72ec48c1312401d93bbac6fa6b55e0f1f76196c6f43f981c6d56a2"

URI_aarch64_rust-quickcheck0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck0.9+default-devel-0.9.2-11.el10_0.noarch.rpm;name=aarch64_rust-quickcheck0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck0.9+default-devel}"
SRC_URI[aarch64_rust-quickcheck0.9+default-devel.sha256sum] = "2a9d8bba448498e1fab03715cc59a233fc92c6a5b5385a8752ac8e421553b0d9"

URI_aarch64_rust-quickcheck0.9+env_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck0.9+env_logger-devel-0.9.2-11.el10_0.noarch.rpm;name=aarch64_rust-quickcheck0.9+env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck0.9+env_logger-devel}"
SRC_URI[aarch64_rust-quickcheck0.9+env_logger-devel.sha256sum] = "4cf9f250f5effaa77b35d0f304388de15669657c7e9001022dc8be18036e0b1d"

URI_aarch64_rust-quickcheck0.9+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck0.9+log-devel-0.9.2-11.el10_0.noarch.rpm;name=aarch64_rust-quickcheck0.9+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck0.9+log-devel}"
SRC_URI[aarch64_rust-quickcheck0.9+log-devel.sha256sum] = "71cc218b7be219bbeee582edde1a2d1e1437b4e6cfaeb0bb929b7c0aa3a524d1"

URI_aarch64_rust-quickcheck0.9+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck0.9+regex-devel-0.9.2-11.el10_0.noarch.rpm;name=aarch64_rust-quickcheck0.9+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck0.9+regex-devel}"
SRC_URI[aarch64_rust-quickcheck0.9+regex-devel.sha256sum] = "8c48394aca33505b4a9f73df1e3e8e6ed40845435eed335eeeff424b1fc3941a"

URI_aarch64_rust-quickcheck0.9+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck0.9+unstable-devel-0.9.2-11.el10_0.noarch.rpm;name=aarch64_rust-quickcheck0.9+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck0.9+unstable-devel}"
SRC_URI[aarch64_rust-quickcheck0.9+unstable-devel.sha256sum] = "ca866d611d3cccc15ec21b78e461e8abf845620f3964a794d50180a8f3598a8c"

URI_aarch64_rust-quickcheck0.9+use_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck0.9+use_logging-devel-0.9.2-11.el10_0.noarch.rpm;name=aarch64_rust-quickcheck0.9+use_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck0.9+use_logging-devel}"
SRC_URI[aarch64_rust-quickcheck0.9+use_logging-devel.sha256sum] = "34193c24ff2d4891169964866b3a9be852812c50d685f1bd3a301d1e1d2d96bd"

URI_aarch64_rust-quickcheck0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck0.9-devel-0.9.2-11.el10_0.noarch.rpm;name=aarch64_rust-quickcheck0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck0.9-devel}"
SRC_URI[aarch64_rust-quickcheck0.9-devel.sha256sum] = "6dc2442c5f0a7727e97e9e2882e017702d99d413a527031dee4bd98820321faa"

RDEPENDS:rust-quickcheck0.9+default-devel = " \
 cargo \
 rust-quickcheck0.9+regex-devel \
 rust-quickcheck0.9+use_logging-devel \
 rust-quickcheck0.9-devel \
 "
RDEPENDS:rust-quickcheck0.9+env_logger-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 rust-quickcheck0.9-devel \
 "
RDEPENDS:rust-quickcheck0.9+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-quickcheck0.9-devel \
 "
RDEPENDS:rust-quickcheck0.9+regex-devel = " \
 cargo \
 rust-env_logger0.8+regex-devel \
 rust-env_logger0.8-devel \
 rust-quickcheck0.9-devel \
 "
RDEPENDS:rust-quickcheck0.9+unstable-devel = " \
 cargo \
 rust-quickcheck0.9-devel \
 "
RDEPENDS:rust-quickcheck0.9+use_logging-devel = " \
 cargo \
 rust-quickcheck0.9+env_logger-devel \
 rust-quickcheck0.9+log-devel \
 rust-quickcheck0.9-devel \
 "
RDEPENDS:rust-quickcheck0.9-devel = " \
 cargo \
 rust-rand0.7+default-devel \
 rust-rand_core0.5+default-devel \
 "
