# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ccache"
PV = "4.10.2"
PR = "1.el10_0"
PACKAGES = " \
 ccache \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/ccache-4.10.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "299891002fa7a87eacd7559a7e6b1fa624c8955bc250a75199a9793fa47c69fc"

URI_x86_64_v2_ccache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ccache-4.10.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ccache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ccache}"
SRC_URI[x86_64_v2_ccache.sha256sum] = "4a351dca02f9c682627bcc9740f201c64dd57393e36a367413d79eb5e2300ead"

URI_aarch64_ccache = "${EPEL_MIRROR}/aarch64/Packages/c/ccache-4.10.2-1.el10_0.aarch64.rpm;name=aarch64_ccache;unpack=0"
SRC_URI:append = " ${URI_aarch64_ccache}"
SRC_URI[aarch64_ccache.sha256sum] = "877a2b2c9e57a340b3745ab68f129a6955741006acf80d56e0bc2d804d33080f"

RDEPENDS:ccache = " \
 bash \
 fmt \
 glibc \
 hiredis \
 libgcc \
 libstdc++ \
 libzstd \
 shadow-utils \
 virtual/coreutils \
 xxhash-libs \
 "
