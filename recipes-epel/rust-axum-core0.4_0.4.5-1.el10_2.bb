# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-axum-core0.4"
PV = "0.4.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-axum-core0.4+default-devel \
 rust-axum-core0.4+tracing-devel \
 rust-axum-core0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-axum-core0.4-0.4.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de02b7c3163864c953476f667bb0e48bb531d8b8bcaeca678a397a51de47e1ff"

URI_x86_64_v2_rust-axum-core0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-core0.4+default-devel-0.4.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-core0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-core0.4+default-devel}"
SRC_URI[x86_64_v2_rust-axum-core0.4+default-devel.sha256sum] = "0272da31af87b8dbac6899a517a57dc248808cbe2cc218d2270f2939346e9bb5"

URI_x86_64_v2_rust-axum-core0.4+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-core0.4+tracing-devel-0.4.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-core0.4+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-core0.4+tracing-devel}"
SRC_URI[x86_64_v2_rust-axum-core0.4+tracing-devel.sha256sum] = "c86952d0a77d0bf00ca3ec839fa06bd2e21b66479eea6a3f946ca48f952acf40"

URI_x86_64_v2_rust-axum-core0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-core0.4-devel-0.4.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-core0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-core0.4-devel}"
SRC_URI[x86_64_v2_rust-axum-core0.4-devel.sha256sum] = "d3ab31a725c09c74589cdf5da3aafc938b2bed128dbdd7fb3f71b0c800597b4a"

URI_aarch64_rust-axum-core0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-core0.4+default-devel-0.4.5-1.el10_2.noarch.rpm;name=aarch64_rust-axum-core0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-core0.4+default-devel}"
SRC_URI[aarch64_rust-axum-core0.4+default-devel.sha256sum] = "ca90c746d7ad2cadd32c36568afee850b223b7089c5a754fc581f2a0768db7d6"

URI_aarch64_rust-axum-core0.4+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-core0.4+tracing-devel-0.4.5-1.el10_2.noarch.rpm;name=aarch64_rust-axum-core0.4+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-core0.4+tracing-devel}"
SRC_URI[aarch64_rust-axum-core0.4+tracing-devel.sha256sum] = "05f87e849b7e913d9fd3e1386a451fce45299503ff2785ed3a94a118b825996e"

URI_aarch64_rust-axum-core0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-core0.4-devel-0.4.5-1.el10_2.noarch.rpm;name=aarch64_rust-axum-core0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-core0.4-devel}"
SRC_URI[aarch64_rust-axum-core0.4-devel.sha256sum] = "7a0f9d3228111e477d590746977c0d7f73878231bcf07210afa963f88ad28790"

RDEPENDS:rust-axum-core0.4+default-devel = " \
 cargo \
 rust-axum-core0.4-devel \
 "
RDEPENDS:rust-axum-core0.4+tracing-devel = " \
 cargo \
 rust-axum-core0.4-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-axum-core0.4-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-bytes+default-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-mime+default-devel \
 rust-pin-project-lite+default-devel \
 rust-rustversion+default-devel \
 rust-sync_wrapper+default-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
