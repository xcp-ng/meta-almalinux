# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spectacle"
PE = "1"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 spectacle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spectacle-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0799bccc39e4421cdc216564f240ff1659ca1474111054d8de0ce2a0cc269d69"

URI_x86_64_v2_spectacle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spectacle-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spectacle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spectacle}"
SRC_URI[x86_64_v2_spectacle.sha256sum] = "de84151c51fecf0e66a1fe58689e39c65e2e4dad815844151696208e0ea215c6"

URI_aarch64_spectacle = "${EPEL_MIRROR}/aarch64/Packages/s/spectacle-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_spectacle;unpack=0"
SRC_URI:append = " ${URI_aarch64_spectacle}"
SRC_URI[aarch64_spectacle.sha256sum] = "d592b2a243d26c5d115b7231332bec1ec0279bccc1c6dc6e1cf308aad6d2eb1a"

RDEPENDS:spectacle = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-prison \
 kf6-purpose \
 kpipewire \
 kquickimageeditor-qt6 \
 layer-shell-qt \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 opencv-core \
 opencv-imgproc \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 tesseract \
 xcb-util \
 xcb-util-cursor \
 xcb-util-image \
 "
