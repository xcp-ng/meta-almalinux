# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-qqc2-desktop-style"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-qqc2-desktop-style \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-qqc2-desktop-style-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "546c806c7d1615cb65a3fc3a2550b5ee795546c5e858b6338667882b33c24fdb"

URI_x86_64_v2_kf6-qqc2-desktop-style = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-qqc2-desktop-style-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-qqc2-desktop-style;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-qqc2-desktop-style}"
SRC_URI[x86_64_v2_kf6-qqc2-desktop-style.sha256sum] = "7dc3d3b305999a825bfdf68bf1784d50048409cd8ea91f8a9d7f3da3b4b006d8"

URI_aarch64_kf6-qqc2-desktop-style = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-qqc2-desktop-style-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-qqc2-desktop-style;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-qqc2-desktop-style}"
SRC_URI[aarch64_kf6-qqc2-desktop-style.sha256sum] = "f809d0eb4a645de894df3289267a4984d99e770525f058ccc0a596c3c84e0d01"

RDEPENDS:kf6-qqc2-desktop-style = " \
 cmake-filesystem \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
