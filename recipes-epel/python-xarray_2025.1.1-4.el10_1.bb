# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-xarray"
PV = "2025.1.1"
PR = "4.el10_1"
PACKAGES = " \
 python3-xarray \
 python3-xarray+io \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-xarray-2025.1.1-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "939fa7aa569573171dba6f41ca4dad46ae0d3fb8305fed56445a9ce5245913ef"

URI_x86_64_v2_python3-xarray = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-xarray-2025.1.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-xarray;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-xarray}"
SRC_URI[x86_64_v2_python3-xarray.sha256sum] = "ce7a8dccfd5fd658bab163dfe9db25b687ec06ead8f5e0a12bb7ad58641f8af3"

URI_x86_64_v2_python3-xarray+io = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-xarray+io-2025.1.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-xarray+io;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-xarray+io}"
SRC_URI[x86_64_v2_python3-xarray+io.sha256sum] = "ce43c0f31267e0982ee02c4a52536ebdf1cffca3111766f9a837126b86dfebeb"

URI_aarch64_python3-xarray = "${EPEL_MIRROR}/aarch64/Packages/p/python3-xarray-2025.1.1-4.el10_1.noarch.rpm;name=aarch64_python3-xarray;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-xarray}"
SRC_URI[aarch64_python3-xarray.sha256sum] = "3347bd74f2df3d430296521fe8b3edc19b6b953a10e5ec2f03ee6c11a743a02b"

URI_aarch64_python3-xarray+io = "${EPEL_MIRROR}/aarch64/Packages/p/python3-xarray+io-2025.1.1-4.el10_1.noarch.rpm;name=aarch64_python3-xarray+io;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-xarray+io}"
SRC_URI[aarch64_python3-xarray+io.sha256sum] = "b7015ba1e67b58776fd44c709116d57a9fea430b38a04e51951c60b48e36e3d8"

RDEPENDS:python3-xarray = " \
 python3 \
 python3-numpy \
 python3-packaging \
 python3-pandas \
 "
RDEPENDS:python3-xarray+io = " \
 python3 \
 python3-cftime \
 python3-fsspec \
 python3-h5netcdf \
 python3-netcdf4 \
 python3-pooch \
 python3-scipy \
 python3-xarray \
 python3-zarr \
 "
