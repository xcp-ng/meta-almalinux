# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-truncate"
PV = "2.0.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-unicode-truncate+default-devel \
 rust-unicode-truncate+std-devel \
 rust-unicode-truncate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-truncate-2.0.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6432f614709cc2f186655ef7ab2a35bbb6ed19b864cdae600db38f030ef8f13"

URI_x86_64_v2_rust-unicode-truncate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-truncate+default-devel-2.0.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-truncate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-truncate+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-truncate+default-devel.sha256sum] = "d7cf6a745f6a469724742f3507afeb9e591d0278bfa2d452bec62d13415d503c"

URI_x86_64_v2_rust-unicode-truncate+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-truncate+std-devel-2.0.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-truncate+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-truncate+std-devel}"
SRC_URI[x86_64_v2_rust-unicode-truncate+std-devel.sha256sum] = "88c8b7b1f2cba18890e2821cca436dd82f13e1f14b7cf87e876ce3987c4bd587"

URI_x86_64_v2_rust-unicode-truncate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-truncate-devel-2.0.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-truncate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-truncate-devel}"
SRC_URI[x86_64_v2_rust-unicode-truncate-devel.sha256sum] = "a6241bee7662fe174aec29daa5571cbedf41e8011e31c7ba6f4a2e3bee6db612"

URI_aarch64_rust-unicode-truncate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-truncate+default-devel-2.0.0-2.el10_1.noarch.rpm;name=aarch64_rust-unicode-truncate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-truncate+default-devel}"
SRC_URI[aarch64_rust-unicode-truncate+default-devel.sha256sum] = "67afdbb670f381c14530e764bd8346b1393d11734ef1066b285da1812e09e37f"

URI_aarch64_rust-unicode-truncate+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-truncate+std-devel-2.0.0-2.el10_1.noarch.rpm;name=aarch64_rust-unicode-truncate+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-truncate+std-devel}"
SRC_URI[aarch64_rust-unicode-truncate+std-devel.sha256sum] = "837d54d3f288cadf2a8d9064d1c789502b77a8acb26b5779c29a60c879a169a0"

URI_aarch64_rust-unicode-truncate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-truncate-devel-2.0.0-2.el10_1.noarch.rpm;name=aarch64_rust-unicode-truncate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-truncate-devel}"
SRC_URI[aarch64_rust-unicode-truncate-devel.sha256sum] = "37deba1bc0ebbf27c1b6e6873e3a4c6dd2faa2087fa92b1f97b68171bbe007ec"

RDEPENDS:rust-unicode-truncate+default-devel = " \
 cargo \
 rust-unicode-truncate+std-devel \
 rust-unicode-truncate-devel \
 "
RDEPENDS:rust-unicode-truncate+std-devel = " \
 cargo \
 rust-unicode-truncate-devel \
 "
RDEPENDS:rust-unicode-truncate-devel = " \
 cargo \
 rust \
 rust-itertools0.13-devel \
 rust-unicode-segmentation-devel \
 rust-unicode-width+default-devel \
 "
