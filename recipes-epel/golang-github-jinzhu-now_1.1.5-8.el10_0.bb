# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-jinzhu-now"
PV = "1.1.5"
PR = "8.el10_0"
PACKAGES = " \
 golang-github-jinzhu-now-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-jinzhu-now-1.1.5-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55b90350352f91698577a0affc1b27b6c6535037ba111d04c4472fd4f9ea0af4"

URI_x86_64_v2_golang-github-jinzhu-now-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-jinzhu-now-devel-1.1.5-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-jinzhu-now-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-jinzhu-now-devel}"
SRC_URI[x86_64_v2_golang-github-jinzhu-now-devel.sha256sum] = "2f30d316046df55ac4e6de7d535908711fa67bc7aea02dce61e1188c26cc651c"

URI_aarch64_golang-github-jinzhu-now-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jinzhu-now-devel-1.1.5-8.el10_0.noarch.rpm;name=aarch64_golang-github-jinzhu-now-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-jinzhu-now-devel}"
SRC_URI[aarch64_golang-github-jinzhu-now-devel.sha256sum] = "785ac0799aa5729c34ebee96ce977a6809e956e07befcc1d9c47ac1acc759189"

RDEPENDS:golang-github-jinzhu-now-devel = " \
 go-filesystem \
 "
