# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-base64-simd"
PV = "0.8.0"
PR = "3.el10_3"
PACKAGES = " \
 rust-base64-simd+alloc-devel \
 rust-base64-simd+default-devel \
 rust-base64-simd+detect-devel \
 rust-base64-simd+std-devel \
 rust-base64-simd+unstable-devel \
 rust-base64-simd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-base64-simd-0.8.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cd550341be800f6917b1f98d4f2d5c7a03f71cec73dcc49772564ec386be407"

URI_x86_64_v2_rust-base64-simd+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64-simd+alloc-devel-0.8.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64-simd+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64-simd+alloc-devel}"
SRC_URI[x86_64_v2_rust-base64-simd+alloc-devel.sha256sum] = "c77d58ab3dbf71f2a0f9229b59b6a5ab330454f19d78d700c8aa7f01a14c6a08"

URI_x86_64_v2_rust-base64-simd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64-simd+default-devel-0.8.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64-simd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64-simd+default-devel}"
SRC_URI[x86_64_v2_rust-base64-simd+default-devel.sha256sum] = "99ad49a6dee33be5c24ff1bb8894658858ca8be1bf0312a4a287ff1f17a14690"

URI_x86_64_v2_rust-base64-simd+detect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64-simd+detect-devel-0.8.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64-simd+detect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64-simd+detect-devel}"
SRC_URI[x86_64_v2_rust-base64-simd+detect-devel.sha256sum] = "80cd81980d35bb5a72695c0fcbfabaa6bfbef2795ec7a47330d69eaf358b9cc3"

URI_x86_64_v2_rust-base64-simd+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64-simd+std-devel-0.8.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64-simd+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64-simd+std-devel}"
SRC_URI[x86_64_v2_rust-base64-simd+std-devel.sha256sum] = "a72ff219c971c84f64c321146b97fd496ec844e2c1956d50aabd369d050f00cf"

URI_x86_64_v2_rust-base64-simd+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64-simd+unstable-devel-0.8.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64-simd+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64-simd+unstable-devel}"
SRC_URI[x86_64_v2_rust-base64-simd+unstable-devel.sha256sum] = "86113465414449003af35df846d8d6e6c9717cbda8310423b733e6db02d2c0c7"

URI_x86_64_v2_rust-base64-simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64-simd-devel-0.8.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64-simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64-simd-devel}"
SRC_URI[x86_64_v2_rust-base64-simd-devel.sha256sum] = "a2d48a14dc4f6560a3202dbe926a8e2a4099200f89b3dbb4dd5c530fd0f20b50"

URI_aarch64_rust-base64-simd+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64-simd+alloc-devel-0.8.0-3.el10_3.noarch.rpm;name=aarch64_rust-base64-simd+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64-simd+alloc-devel}"
SRC_URI[aarch64_rust-base64-simd+alloc-devel.sha256sum] = "21a6f2fcb331fb3f72c0ab341fc60d003261c271d34bda4eda14df1b4c2b341b"

URI_aarch64_rust-base64-simd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64-simd+default-devel-0.8.0-3.el10_3.noarch.rpm;name=aarch64_rust-base64-simd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64-simd+default-devel}"
SRC_URI[aarch64_rust-base64-simd+default-devel.sha256sum] = "f622b47142477bd3ea25437276a81ae1e6d843a99f87ad521f2a6d1c14b5088d"

URI_aarch64_rust-base64-simd+detect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64-simd+detect-devel-0.8.0-3.el10_3.noarch.rpm;name=aarch64_rust-base64-simd+detect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64-simd+detect-devel}"
SRC_URI[aarch64_rust-base64-simd+detect-devel.sha256sum] = "02fdd041f620e1a4eb8fd6fe32f4f1a48761c23fa24971a4432551c49e47b8e5"

URI_aarch64_rust-base64-simd+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64-simd+std-devel-0.8.0-3.el10_3.noarch.rpm;name=aarch64_rust-base64-simd+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64-simd+std-devel}"
SRC_URI[aarch64_rust-base64-simd+std-devel.sha256sum] = "ecbe69cb39b3410310ff13c20b0dc4aba5273025cc2793cc27ced430682c2f8e"

URI_aarch64_rust-base64-simd+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64-simd+unstable-devel-0.8.0-3.el10_3.noarch.rpm;name=aarch64_rust-base64-simd+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64-simd+unstable-devel}"
SRC_URI[aarch64_rust-base64-simd+unstable-devel.sha256sum] = "d6acc150393abf53e394ad1d4c91fc1f442e93f697ed1aad7ffe7c4c135d6902"

URI_aarch64_rust-base64-simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64-simd-devel-0.8.0-3.el10_3.noarch.rpm;name=aarch64_rust-base64-simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64-simd-devel}"
SRC_URI[aarch64_rust-base64-simd-devel.sha256sum] = "41840c40343fff95c9c82f32e0c951f0d58528165cd334be4066f3ec86f4ce17"

RDEPENDS:rust-base64-simd+alloc-devel = " \
 cargo \
 rust-base64-simd-devel \
 rust-vsimd+alloc-devel \
 "
RDEPENDS:rust-base64-simd+default-devel = " \
 cargo \
 rust-base64-simd+detect-devel \
 rust-base64-simd+std-devel \
 rust-base64-simd-devel \
 "
RDEPENDS:rust-base64-simd+detect-devel = " \
 cargo \
 rust-base64-simd-devel \
 rust-vsimd+detect-devel \
 "
RDEPENDS:rust-base64-simd+std-devel = " \
 cargo \
 rust-base64-simd+alloc-devel \
 rust-base64-simd-devel \
 rust-vsimd+std-devel \
 "
RDEPENDS:rust-base64-simd+unstable-devel = " \
 cargo \
 rust-base64-simd-devel \
 rust-vsimd+unstable-devel \
 "
RDEPENDS:rust-base64-simd-devel = " \
 cargo \
 rust \
 rust-outref+default-devel \
 rust-vsimd+default-devel \
 "
