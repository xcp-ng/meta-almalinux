# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memo-map"
PV = "0.3.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-memo-map+default-devel \
 rust-memo-map-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-memo-map-0.3.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7878d7bf838c29b826e8721ff26703fefb6b9f24986f2eb2d4e6e8d384a68694"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memo-map+default-devel-0.3.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memo-map+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-memo-map+default-devel.sha256sum] = "35227471c1942ef08b1aef4a41f274c5483648265ee037621951e38da5e55c88"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memo-map-devel-0.3.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memo-map-devel;unpack=0"
SRC_URI[x86_64_v2_rust-memo-map-devel.sha256sum] = "5e84e42a4c8a25053aee68855fcb49426200cec6fecf7afef767c837b2be2284"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-memo-map+default-devel-0.3.4-1.el10_3.noarch.rpm;name=aarch64_rust-memo-map+default-devel;unpack=0"
SRC_URI[aarch64_rust-memo-map+default-devel.sha256sum] = "d524675178dbd918fb2c6168ddbfa64caa79e1716faf5cde335fdf8e0ea4167f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-memo-map-devel-0.3.4-1.el10_3.noarch.rpm;name=aarch64_rust-memo-map-devel;unpack=0"
SRC_URI[aarch64_rust-memo-map-devel.sha256sum] = "d332e289f0f8f3f3cf43bff1014d7d7a5263abbc1e28f2e7e2975f1a1c3aa816"

RDEPENDS:rust-memo-map+default-devel = " \
 cargo \
 rust-memo-map-devel \
 "
RDEPENDS:rust-memo-map-devel = " \
 cargo \
 rust \
 "
