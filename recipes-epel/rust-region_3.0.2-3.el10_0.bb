# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-region"
PV = "3.0.2"
PR = "3.el10_0"
PACKAGES = " \
 rust-region+default-devel \
 rust-region-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-region-3.0.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a52b0f16d79dc24e1ca1a26bebdd82407ca4992caaf3bb8e1bf9f7a5ca1d96b"

URI_x86_64_v2_rust-region+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-region+default-devel-3.0.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-region+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-region+default-devel}"
SRC_URI[x86_64_v2_rust-region+default-devel.sha256sum] = "458d91c0ed93afa9ac1e1d74b010d79e2e782cc563fcde1d1b65b132ed16036b"

URI_x86_64_v2_rust-region-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-region-devel-3.0.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-region-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-region-devel}"
SRC_URI[x86_64_v2_rust-region-devel.sha256sum] = "0906808bf816ec981134bf0bd393083553ec9c94b1eab8a3be23a87a3721193c"

URI_aarch64_rust-region+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-region+default-devel-3.0.2-3.el10_0.noarch.rpm;name=aarch64_rust-region+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-region+default-devel}"
SRC_URI[aarch64_rust-region+default-devel.sha256sum] = "de2f185c501a8e42f56066cfb1178861ac803e9ef11555ba083f86b41553e77f"

URI_aarch64_rust-region-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-region-devel-3.0.2-3.el10_0.noarch.rpm;name=aarch64_rust-region-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-region-devel}"
SRC_URI[aarch64_rust-region-devel.sha256sum] = "69cb7a69889cfa2842ee583bc76ed4555a944fe78da138f20f7df0104078bc99"

RDEPENDS:rust-region+default-devel = " \
 cargo \
 rust-region-devel \
 "
RDEPENDS:rust-region-devel = " \
 cargo \
 rust-bitflags1+default-devel \
 rust-libc+default-devel \
 "
