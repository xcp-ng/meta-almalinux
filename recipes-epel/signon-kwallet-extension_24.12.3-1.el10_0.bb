# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "signon-kwallet-extension"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 signon-kwallet-extension \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/signon-kwallet-extension-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5313204dcc32ee48f22018244a027f4c553a1699e6c43d82bc0c3a6b92d5d8e8"

URI_x86_64_v2_signon-kwallet-extension = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-kwallet-extension-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signon-kwallet-extension;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signon-kwallet-extension}"
SRC_URI[x86_64_v2_signon-kwallet-extension.sha256sum] = "5b1fdc3e7c40eacf8f2c4483541d4c6a5d212599de13263f96188b5236a37349"

URI_aarch64_signon-kwallet-extension = "${EPEL_MIRROR}/aarch64/Packages/s/signon-kwallet-extension-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_signon-kwallet-extension;unpack=0"
SRC_URI:append = " ${URI_aarch64_signon-kwallet-extension}"
SRC_URI[aarch64_signon-kwallet-extension.sha256sum] = "4111183823e178d767dd98ad76d2ee87db24936b9672ec40edc87b9aa6c74e79"

RDEPENDS:signon-kwallet-extension = " \
 glibc \
 kf6-kwallet-libs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 signon \
 "
