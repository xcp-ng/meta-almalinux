# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdiff3"
PV = "1.12.3"
PR = "3.el10_2"
PACKAGES = " \
 kdiff3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdiff3-1.12.3-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5f7d44127555ebf42bc39765d2dc4a0c2fe998d49ba5dc92ce73e2dad78bfd9"

URI_x86_64_v2_kdiff3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdiff3-1.12.3-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdiff3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdiff3}"
SRC_URI[x86_64_v2_kdiff3.sha256sum] = "baa603df05712939eb4afeebea7687d6aa1f5ec8d8d36ec741f3a99bf1429162"

URI_aarch64_kdiff3 = "${EPEL_MIRROR}/aarch64/Packages/k/kdiff3-1.12.3-3.el10_2.aarch64.rpm;name=aarch64_kdiff3;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdiff3}"
SRC_URI[aarch64_kdiff3.sha256sum] = "4dd788a451c4429daa961bb8d99cc757410cfcd609f783d2a770749c73ebcd57"

RDEPENDS:kdiff3 = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libicu \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
