# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uuid"
PV = "1.24.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uuid+arbitrary-devel \
 rust-uuid+atomic-devel \
 rust-uuid+bytemuck-devel \
 rust-uuid+default-devel \
 rust-uuid+fast-rng-devel \
 rust-uuid+md5-devel \
 rust-uuid+rng-devel \
 rust-uuid+rng-getrandom-devel \
 rust-uuid+rng-rand-devel \
 rust-uuid+serde-devel \
 rust-uuid+sha1-devel \
 rust-uuid+slog-devel \
 rust-uuid+std-devel \
 rust-uuid+v1-devel \
 rust-uuid+v3-devel \
 rust-uuid+v4-devel \
 rust-uuid+v5-devel \
 rust-uuid+v6-devel \
 rust-uuid+v7-devel \
 rust-uuid+v8-devel \
 rust-uuid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uuid-1.24.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68aed72360d0307d38f423682d83566bf5c21550e9051ba558633513a6c340c7"

URI_x86_64_v2_rust-uuid+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+arbitrary-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-uuid+arbitrary-devel.sha256sum] = "670c48740d8f3a1004f87477f14b63298b6b5310803e8721ffd6d074db0ef4c6"

URI_x86_64_v2_rust-uuid+atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+atomic-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+atomic-devel}"
SRC_URI[x86_64_v2_rust-uuid+atomic-devel.sha256sum] = "bcb75a87ab6ecdc446328dd4cbc50e6a9d4afcc0cd251baf408f2ec4ab91bc5c"

URI_x86_64_v2_rust-uuid+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+bytemuck-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-uuid+bytemuck-devel.sha256sum] = "443727f10dc203792e473cfa75ca28a59581a8bdd6cbc5b111cfe94ecb40e9a8"

URI_x86_64_v2_rust-uuid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+default-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+default-devel}"
SRC_URI[x86_64_v2_rust-uuid+default-devel.sha256sum] = "6c9e67de1cb6ed65fd470bdd48cfd234d012486aa0dea7e61af1030d9cdbae52"

URI_x86_64_v2_rust-uuid+fast-rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+fast-rng-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+fast-rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+fast-rng-devel}"
SRC_URI[x86_64_v2_rust-uuid+fast-rng-devel.sha256sum] = "7d356c59baf67de3c4920575324aa838f6c3284f11c97b66e1f80fefcccf4851"

URI_x86_64_v2_rust-uuid+md5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+md5-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+md5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+md5-devel}"
SRC_URI[x86_64_v2_rust-uuid+md5-devel.sha256sum] = "836bf14d9bc09d751798ade43557fb5de164a5a08aaaebd80be7444ebfd95293"

URI_x86_64_v2_rust-uuid+rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+rng-devel}"
SRC_URI[x86_64_v2_rust-uuid+rng-devel.sha256sum] = "957dba4c820e7620c5e70da79e49eb3818f8f9c47d014f743ead1c3b5ba258f3"

URI_x86_64_v2_rust-uuid+rng-getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-getrandom-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+rng-getrandom-devel}"
SRC_URI[x86_64_v2_rust-uuid+rng-getrandom-devel.sha256sum] = "63955d870bf1a7adb0f4058babf7680e1707620ee442f36e64fedc3a955c587d"

URI_x86_64_v2_rust-uuid+rng-rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-rand-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+rng-rand-devel}"
SRC_URI[x86_64_v2_rust-uuid+rng-rand-devel.sha256sum] = "85062d6dedf5e9718febf3f903c8e06668e763b99d2af4bf006794beb5706a54"

URI_x86_64_v2_rust-uuid+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+serde-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+serde-devel}"
SRC_URI[x86_64_v2_rust-uuid+serde-devel.sha256sum] = "47f8c91cd060745b844b6866ddef38b710b7d6885b298389f001a621bb42c92f"

URI_x86_64_v2_rust-uuid+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+sha1-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+sha1-devel}"
SRC_URI[x86_64_v2_rust-uuid+sha1-devel.sha256sum] = "f35413f1ae9ace4c3c4c98132c2585b934e2fdd3ef054bef187f350b5773582b"

URI_x86_64_v2_rust-uuid+slog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+slog-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+slog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+slog-devel}"
SRC_URI[x86_64_v2_rust-uuid+slog-devel.sha256sum] = "ab43a335c0c4b3ea109c111209ed37a983e30ab3f547eefd419ed0e9ff15b8fd"

URI_x86_64_v2_rust-uuid+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+std-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+std-devel}"
SRC_URI[x86_64_v2_rust-uuid+std-devel.sha256sum] = "53182de4fa034f6b7c16f052126dded9fdd13c4346a9c91368db12174dc2fc25"

URI_x86_64_v2_rust-uuid+v1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v1-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v1-devel}"
SRC_URI[x86_64_v2_rust-uuid+v1-devel.sha256sum] = "444db113cd39148f8545433e46c970ffb554447b7a32ecbef9e871c615ca79cc"

URI_x86_64_v2_rust-uuid+v3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v3-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v3-devel}"
SRC_URI[x86_64_v2_rust-uuid+v3-devel.sha256sum] = "a36bd74a92e3a49b37fee7bd0f4b75222ff72115307e29dd181453930143f286"

URI_x86_64_v2_rust-uuid+v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v4-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v4-devel}"
SRC_URI[x86_64_v2_rust-uuid+v4-devel.sha256sum] = "ebcc8f223d3486c74655215b455cfd0ef5f7ad76c9f2b1a3d16da855355f3aad"

URI_x86_64_v2_rust-uuid+v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v5-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v5-devel}"
SRC_URI[x86_64_v2_rust-uuid+v5-devel.sha256sum] = "289a21735986a33e7e58a0f67cd41554f382fbab22304991e40e92b495f2cde8"

URI_x86_64_v2_rust-uuid+v6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v6-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v6-devel}"
SRC_URI[x86_64_v2_rust-uuid+v6-devel.sha256sum] = "6535dca7379d0ecd5746e34e01511617511a60e03d79df67ea91df03b7c72b14"

URI_x86_64_v2_rust-uuid+v7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v7-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v7-devel}"
SRC_URI[x86_64_v2_rust-uuid+v7-devel.sha256sum] = "990ce1771aacef0b81e4aefdabf8d05e9e4f5b7c4a6dca80b5ac426225de1ff3"

URI_x86_64_v2_rust-uuid+v8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v8-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v8-devel}"
SRC_URI[x86_64_v2_rust-uuid+v8-devel.sha256sum] = "55caa1297bf25c860b20ded8793ae18f2855817d4555d9a880b08a4c1b35ddb1"

URI_x86_64_v2_rust-uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid-devel-1.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid-devel}"
SRC_URI[x86_64_v2_rust-uuid-devel.sha256sum] = "b5231b5516cfd3a4a40682d1793836760722e74fc880abf8baa030ac7ad92453"

URI_aarch64_rust-uuid+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+arbitrary-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+arbitrary-devel}"
SRC_URI[aarch64_rust-uuid+arbitrary-devel.sha256sum] = "febf4b886512653c8920f7c20477620b795e1b09a9d8ada84c2c65c0f480f22b"

URI_aarch64_rust-uuid+atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+atomic-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+atomic-devel}"
SRC_URI[aarch64_rust-uuid+atomic-devel.sha256sum] = "843e529d927d3996c6c3248d745a07b89e8ae6ea0ff8f7ea87c28a78593323f0"

URI_aarch64_rust-uuid+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+bytemuck-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+bytemuck-devel}"
SRC_URI[aarch64_rust-uuid+bytemuck-devel.sha256sum] = "f84265cefeb593a78dd71abe7b1d8028068925a9efbcaa2426ea8f18607f0e87"

URI_aarch64_rust-uuid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+default-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+default-devel}"
SRC_URI[aarch64_rust-uuid+default-devel.sha256sum] = "e45c3f438940d2bb8befdddaacd9e79a4cd811d635f1fe5dc2bdd922768cdcd7"

URI_aarch64_rust-uuid+fast-rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+fast-rng-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+fast-rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+fast-rng-devel}"
SRC_URI[aarch64_rust-uuid+fast-rng-devel.sha256sum] = "c7fd06aa0d5c5b36322d3d07eef9e0e8abfaaddc1d9cd7d2cf2cfecc3ae17057"

URI_aarch64_rust-uuid+md5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+md5-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+md5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+md5-devel}"
SRC_URI[aarch64_rust-uuid+md5-devel.sha256sum] = "6ffc3df222d710e08e67451f2ae9bd07edcc5bf41b91abe6da3a92f43f6008cb"

URI_aarch64_rust-uuid+rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+rng-devel}"
SRC_URI[aarch64_rust-uuid+rng-devel.sha256sum] = "524427561ca06eaf5e8a856c67495d6b2c5232fea0170036e6a282b45afe5d5e"

URI_aarch64_rust-uuid+rng-getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-getrandom-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+rng-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+rng-getrandom-devel}"
SRC_URI[aarch64_rust-uuid+rng-getrandom-devel.sha256sum] = "be9f0c109f3303eb8539328d6bf3e4c61088ec69c740967b8c7b13976ecd814f"

URI_aarch64_rust-uuid+rng-rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-rand-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+rng-rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+rng-rand-devel}"
SRC_URI[aarch64_rust-uuid+rng-rand-devel.sha256sum] = "bee6e51542b3830b29fa30dff2689ba31e553f98abaa1c273858eb4850deb7e4"

URI_aarch64_rust-uuid+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+serde-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+serde-devel}"
SRC_URI[aarch64_rust-uuid+serde-devel.sha256sum] = "09150657d89fbac5d93b3e6296b1521ae01b45eca3f89be81675fe0d2785786e"

URI_aarch64_rust-uuid+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+sha1-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+sha1-devel}"
SRC_URI[aarch64_rust-uuid+sha1-devel.sha256sum] = "6aa28579f6bbbc2ac22bf09e504e1be9fce58f17d5bab84451111a3711768e17"

URI_aarch64_rust-uuid+slog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+slog-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+slog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+slog-devel}"
SRC_URI[aarch64_rust-uuid+slog-devel.sha256sum] = "24ab9b232ff38dd9f8a83dd710bb5cefbe96325906df97925cde669df1ac4ed9"

URI_aarch64_rust-uuid+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+std-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+std-devel}"
SRC_URI[aarch64_rust-uuid+std-devel.sha256sum] = "898ba2cb2a79e8d73f76270a9bd881000588ee499d2bffc0fc5d6f1dc18d3740"

URI_aarch64_rust-uuid+v1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v1-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+v1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v1-devel}"
SRC_URI[aarch64_rust-uuid+v1-devel.sha256sum] = "4b3329dd8418cc5c8869bf8d947c1b93d0581f6b74414dbf620fd3279fdbc14f"

URI_aarch64_rust-uuid+v3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v3-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+v3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v3-devel}"
SRC_URI[aarch64_rust-uuid+v3-devel.sha256sum] = "8f2ad88e332fb525a7b4ae0ff45f5d8eb9d1a23262db4491355475f57e0cec2c"

URI_aarch64_rust-uuid+v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v4-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v4-devel}"
SRC_URI[aarch64_rust-uuid+v4-devel.sha256sum] = "809830b1bff5e121b8366666d1be5a9fff7f87af650f51392e744411c5fa21bc"

URI_aarch64_rust-uuid+v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v5-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v5-devel}"
SRC_URI[aarch64_rust-uuid+v5-devel.sha256sum] = "62dfae3348dbbf95924aa7ab2551f2d2d145ea9ac7637bbcb30f1cb7c8d14b3d"

URI_aarch64_rust-uuid+v6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v6-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+v6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v6-devel}"
SRC_URI[aarch64_rust-uuid+v6-devel.sha256sum] = "86bb391a9989b6b0a93ddf38889404551f372da6f74e87fb18d41c0f11d4ff53"

URI_aarch64_rust-uuid+v7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v7-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+v7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v7-devel}"
SRC_URI[aarch64_rust-uuid+v7-devel.sha256sum] = "0a3b72e5724e1159f6fa7dc573a22d8c35f1fabe36a25a31e97ffdb23fa02d05"

URI_aarch64_rust-uuid+v8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v8-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+v8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v8-devel}"
SRC_URI[aarch64_rust-uuid+v8-devel.sha256sum] = "2c6f62f811b5b87dea929c15577ceb2f58ccc94b40d11d4c841e9822faa9d28b"

URI_aarch64_rust-uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid-devel-1.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid-devel}"
SRC_URI[aarch64_rust-uuid-devel.sha256sum] = "f42519b96b30697ae2c909250cdec91980514d22db624b8a180fd4cf6ec2a308"

RDEPENDS:rust-uuid+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+atomic-devel = " \
 cargo \
 rust-atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-bytemuck+derive-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+default-devel = " \
 cargo \
 rust-uuid+std-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+fast-rng-devel = " \
 cargo \
 rust-rand+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+md5-devel = " \
 cargo \
 rust-md-5_0.10-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-rand-devel = " \
 cargo \
 rust-rand+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+sha1-devel = " \
 cargo \
 rust-sha1_smol-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+slog-devel = " \
 cargo \
 rust-slog+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+std-devel = " \
 cargo \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v1-devel = " \
 cargo \
 rust-uuid+atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v3-devel = " \
 cargo \
 rust-uuid+md5-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v4-devel = " \
 cargo \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v5-devel = " \
 cargo \
 rust-uuid+sha1-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v6-devel = " \
 cargo \
 rust-uuid+atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v7-devel = " \
 cargo \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v8-devel = " \
 cargo \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid-devel = " \
 cargo \
 rust \
 "
