# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-etcetera"
PV = "0.8.0"
PR = "8.el10_0"
PACKAGES = " \
 rust-etcetera+default-devel \
 rust-etcetera-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-etcetera-0.8.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ddb05dc58d7c14c34d885bb7e34781f3df3d2dbc9cd0e96f9f66c87949d8370"

URI_x86_64_v2_rust-etcetera+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-etcetera+default-devel-0.8.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-etcetera+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-etcetera+default-devel}"
SRC_URI[x86_64_v2_rust-etcetera+default-devel.sha256sum] = "4d321e391a88af11d14e8c3661eb05d7512a95e4c549e5e78df7cd8e0c6c86eb"

URI_x86_64_v2_rust-etcetera-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-etcetera-devel-0.8.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-etcetera-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-etcetera-devel}"
SRC_URI[x86_64_v2_rust-etcetera-devel.sha256sum] = "94ddc8f2f09c8b9bc2c5f308ad0379060a48f255537f7e50df1f13fdf88b227d"

URI_aarch64_rust-etcetera+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-etcetera+default-devel-0.8.0-8.el10_0.noarch.rpm;name=aarch64_rust-etcetera+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-etcetera+default-devel}"
SRC_URI[aarch64_rust-etcetera+default-devel.sha256sum] = "5d2a08e632d86fac750bb8e8f9170425b7bfea4deab81db90df84de900abb1b9"

URI_aarch64_rust-etcetera-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-etcetera-devel-0.8.0-8.el10_0.noarch.rpm;name=aarch64_rust-etcetera-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-etcetera-devel}"
SRC_URI[aarch64_rust-etcetera-devel.sha256sum] = "52ca85e6b6804d5c5be11ab2ce442564c448cda0b752f6dafaaa83ba0db68d97"

RDEPENDS:rust-etcetera+default-devel = " \
 cargo \
 rust-etcetera-devel \
 "
RDEPENDS:rust-etcetera-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-home+default-devel \
 "
