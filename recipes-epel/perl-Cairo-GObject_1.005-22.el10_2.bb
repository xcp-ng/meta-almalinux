# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cairo-GObject"
PV = "1.005"
PR = "22.el10_2"
PACKAGES = " \
 perl-Cairo-GObject \
 perl-Cairo-GObject-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Cairo-GObject-1.005-22.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0e4941d31fc31db0e9dd945611dd85b68e8139de0adf38b36ca1a8b7168b0d1"

URI_x86_64_v2_perl-Cairo-GObject = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cairo-GObject-1.005-22.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Cairo-GObject;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cairo-GObject}"
SRC_URI[x86_64_v2_perl-Cairo-GObject.sha256sum] = "4e040ff9e3fad79018a1390b6ba34320153844635f1ed966a43d3d2347af343f"

URI_x86_64_v2_perl-Cairo-GObject-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cairo-GObject-tests-1.005-22.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Cairo-GObject-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cairo-GObject-tests}"
SRC_URI[x86_64_v2_perl-Cairo-GObject-tests.sha256sum] = "b0d5234873a1dd24bd6efc17b3a91ee8750300d766f01280aa4b2fcc18d7395a"

URI_aarch64_perl-Cairo-GObject = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cairo-GObject-1.005-22.el10_2.aarch64.rpm;name=aarch64_perl-Cairo-GObject;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cairo-GObject}"
SRC_URI[aarch64_perl-Cairo-GObject.sha256sum] = "7c031508d41b3208f832e10e2340f2b8126a36c7477a3ed6d1bda1040c6316f4"

URI_aarch64_perl-Cairo-GObject-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cairo-GObject-tests-1.005-22.el10_2.noarch.rpm;name=aarch64_perl-Cairo-GObject-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cairo-GObject-tests}"
SRC_URI[aarch64_perl-Cairo-GObject-tests.sha256sum] = "646d5953fbb7d1a295ad2c3768ba8bca92ab2c0182a9860f0bf5e5cf2283220a"

RDEPENDS:perl-Cairo-GObject = " \
 cairo \
 cairo-gobject \
 glib2 \
 glibc \
 perl-Cairo \
 perl-Glib \
 perl-libs \
 "
RDEPENDS:perl-Cairo-GObject-tests = " \
 bash \
 perl-Cairo-GObject \
 perl-Glib \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
