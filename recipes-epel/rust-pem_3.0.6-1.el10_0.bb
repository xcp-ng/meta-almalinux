# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pem"
PV = "3.0.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-pem+default-devel \
 rust-pem+serde-devel \
 rust-pem+std-devel \
 rust-pem-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pem-3.0.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b35a2da6a936960411ccd32b50bd6d0f1c58992daaeca59b46b369818ce66c6c"

URI_x86_64_v2_rust-pem+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem+default-devel-3.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem+default-devel}"
SRC_URI[x86_64_v2_rust-pem+default-devel.sha256sum] = "74cb2e360381aaeaa1357848e138b2483edf8c5261c61939361af69d93fb7c39"

URI_x86_64_v2_rust-pem+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem+serde-devel-3.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem+serde-devel}"
SRC_URI[x86_64_v2_rust-pem+serde-devel.sha256sum] = "aac46ecf16ac842185500f77c2bb247f0fa38eaab9b0587361aed4791f7ac1bd"

URI_x86_64_v2_rust-pem+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem+std-devel-3.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem+std-devel}"
SRC_URI[x86_64_v2_rust-pem+std-devel.sha256sum] = "6590bd02cdb1abf1f9179087d38ebd8fdc2f162302abbed17f17c977d39e4d9f"

URI_x86_64_v2_rust-pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-devel-3.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-devel}"
SRC_URI[x86_64_v2_rust-pem-devel.sha256sum] = "f55180ed2d935026150da8e73ee4dc9754ebc7f53fd0a85a2f99374297863ead"

URI_aarch64_rust-pem+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem+default-devel-3.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-pem+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem+default-devel}"
SRC_URI[aarch64_rust-pem+default-devel.sha256sum] = "da07b8991a8327c92073f3bd871f93440791fed9963416c41a2683bc739ddf87"

URI_aarch64_rust-pem+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem+serde-devel-3.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-pem+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem+serde-devel}"
SRC_URI[aarch64_rust-pem+serde-devel.sha256sum] = "6e9666839b57070a3ab4fe676f7570c0033492bd0ddf392076ad6c6e7889c0fc"

URI_aarch64_rust-pem+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem+std-devel-3.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-pem+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem+std-devel}"
SRC_URI[aarch64_rust-pem+std-devel.sha256sum] = "5151060a8dfeafefb3bd43399220f3ef9d04e160113043f0070faaaf31891e49"

URI_aarch64_rust-pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-devel-3.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-devel}"
SRC_URI[aarch64_rust-pem-devel.sha256sum] = "09256735708315eb28704b299a5a0ac4d23939def2c4027773d17a3fcfbf616e"

RDEPENDS:rust-pem+default-devel = " \
 cargo \
 rust-pem+std-devel \
 rust-pem-devel \
 "
RDEPENDS:rust-pem+serde-devel = " \
 cargo \
 rust-pem-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-pem+std-devel = " \
 cargo \
 rust-base64+std-devel \
 rust-pem-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-pem-devel = " \
 cargo \
 rust \
 rust-base64+alloc-devel \
 rust-base64-devel \
 "
