# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libica"
PV = "4.4.0"
PR = "1.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libica-4.4.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3ea79ba81dc18bad7557c76641da899fbcd1d6617b6ffffbfac1b10399a2eed"

