# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yelp-tools"
PV = "42.1"
PR = "8.el10"
PACKAGES = " \
 yelp-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yelp-tools-42.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e034169247dc0ea7921753b260589a4847aeb03e702dffed4c03a9dc5b672a67"

URI_x86_64_v2_yelp-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yelp-tools-42.1-8.el10.noarch.rpm;name=x86_64_v2_yelp-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yelp-tools}"
SRC_URI[x86_64_v2_yelp-tools.sha256sum] = "9b287fb96b0ed67e7a4679224facaa816060fceeab7e473230a50b3ac67f163f"

URI_aarch64_yelp-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yelp-tools-42.1-8.el10.noarch.rpm;name=aarch64_yelp-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_yelp-tools}"
SRC_URI[aarch64_yelp-tools.sha256sum] = "9b287fb96b0ed67e7a4679224facaa816060fceeab7e473230a50b3ac67f163f"

RDEPENDS:yelp-tools = " \
 itstool \
 libxml2 \
 libxslt \
 mallard-rng \
 python3 \
 python3-lxml \
 yelp-xsl \
 "
