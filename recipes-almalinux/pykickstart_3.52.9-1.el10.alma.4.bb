# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pykickstart"
PV = "3.52.9"
PR = "1.el10.alma.4"
PACKAGES = " \
 pykickstart \
 python3-kickstart \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pykickstart-3.52.9-1.el10.alma.4.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8338d4d59a4155ef56409d79577d212feb987463f8971ddbdbdd35910c07cec2"

URI_x86_64_v2_pykickstart = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pykickstart-3.52.9-1.el10.alma.4.noarch.rpm;name=x86_64_v2_pykickstart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pykickstart}"
SRC_URI[x86_64_v2_pykickstart.sha256sum] = "9c11a93bdcb429aed821bc3dca7365ff78f8413dde8289a903ac6ee54ff9b9bf"

URI_x86_64_v2_python3-kickstart = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-kickstart-3.52.9-1.el10.alma.4.noarch.rpm;name=x86_64_v2_python3-kickstart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kickstart}"
SRC_URI[x86_64_v2_python3-kickstart.sha256sum] = "5bcd48bb4b6317f6c4fc7c4428e407f1518e2b0d06895b634ea13199f6bb20da"

URI_aarch64_pykickstart = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pykickstart-3.52.9-1.el10.alma.4.noarch.rpm;name=aarch64_pykickstart;unpack=0"
SRC_URI:append = " ${URI_aarch64_pykickstart}"
SRC_URI[aarch64_pykickstart.sha256sum] = "9c11a93bdcb429aed821bc3dca7365ff78f8413dde8289a903ac6ee54ff9b9bf"

URI_aarch64_python3-kickstart = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-kickstart-3.52.9-1.el10.alma.4.noarch.rpm;name=aarch64_python3-kickstart;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kickstart}"
SRC_URI[aarch64_python3-kickstart.sha256sum] = "5bcd48bb4b6317f6c4fc7c4428e407f1518e2b0d06895b634ea13199f6bb20da"

RDEPENDS:pykickstart = " \
 python3 \
 python3-kickstart \
 "
RDEPENDS:python3-kickstart = " \
 python3 \
 python3-requests \
 "
