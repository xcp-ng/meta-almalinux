# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xq"
PV = "1.4.0"
PR = "2.el10_3"
PACKAGES = " \
 xq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xq-1.4.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae55a7f1c6e5de2afc60263cbe7224f1cb56b045f822ea4abb7629b5bd380607"

URI_x86_64_v2_xq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xq-1.4.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xq}"
SRC_URI[x86_64_v2_xq.sha256sum] = "cee4b0c15ef5ba49a7313d8bae1d0651f848201aa2ef06cf14735ffb41544833"

URI_aarch64_xq = "${EPEL_MIRROR}/aarch64/Packages/x/xq-1.4.0-2.el10_3.aarch64.rpm;name=aarch64_xq;unpack=0"
SRC_URI:append = " ${URI_aarch64_xq}"
SRC_URI[aarch64_xq.sha256sum] = "5674a2e27055b6f46d08a85268a4e8a88eae8739d0d0a347cc84097d9f390a81"

RDEPENDS:xq = " \
 glibc \
 "
