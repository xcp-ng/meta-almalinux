# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-submodule"
PV = "0.22.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-submodule+default-devel \
 rust-gix-submodule-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-submodule-0.22.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "156c1e6a235bd347566f6517c1bfb887f838d3151f3e7f141f97082d2f02e076"

URI_x86_64_v2_rust-gix-submodule+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-submodule+default-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-submodule+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-submodule+default-devel}"
SRC_URI[x86_64_v2_rust-gix-submodule+default-devel.sha256sum] = "d1c7548a8029e1b498bee1cb5b6f3038907df481d63e5b24125b788ebed8f7ff"

URI_x86_64_v2_rust-gix-submodule-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-submodule-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-submodule-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-submodule-devel}"
SRC_URI[x86_64_v2_rust-gix-submodule-devel.sha256sum] = "f1ea2bfde9ac8fc81a70203112bf62d9eaf3fecc66d44efc8186f6cec502f3c3"

URI_aarch64_rust-gix-submodule+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-submodule+default-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-submodule+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-submodule+default-devel}"
SRC_URI[aarch64_rust-gix-submodule+default-devel.sha256sum] = "484abafec17beffd980b2ecb8e29567313c0aae94eb4bd886e41b56c56397ae2"

URI_aarch64_rust-gix-submodule-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-submodule-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-submodule-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-submodule-devel}"
SRC_URI[aarch64_rust-gix-submodule-devel.sha256sum] = "35a678021bd9f57ea7d039b5c53f9411070beda827efee40958ab9e34dd5ec01"

RDEPENDS:rust-gix-submodule+default-devel = " \
 cargo \
 rust-gix-submodule-devel \
 "
RDEPENDS:rust-gix-submodule-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-config+default-devel \
 rust-gix-path+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-refspec+default-devel \
 rust-gix-url+default-devel \
 rust-thiserror+default-devel \
 "
