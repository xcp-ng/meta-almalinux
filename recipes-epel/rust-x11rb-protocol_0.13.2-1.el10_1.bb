# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-x11rb-protocol"
PV = "0.13.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-x11rb-protocol+all-extensions-devel \
 rust-x11rb-protocol+composite-devel \
 rust-x11rb-protocol+damage-devel \
 rust-x11rb-protocol+dbe-devel \
 rust-x11rb-protocol+default-devel \
 rust-x11rb-protocol+dpms-devel \
 rust-x11rb-protocol+dri2-devel \
 rust-x11rb-protocol+dri3-devel \
 rust-x11rb-protocol+extra-traits-devel \
 rust-x11rb-protocol+glx-devel \
 rust-x11rb-protocol+present-devel \
 rust-x11rb-protocol+randr-devel \
 rust-x11rb-protocol+record-devel \
 rust-x11rb-protocol+render-devel \
 rust-x11rb-protocol+request-parsing-devel \
 rust-x11rb-protocol+res-devel \
 rust-x11rb-protocol+resource_manager-devel \
 rust-x11rb-protocol+screensaver-devel \
 rust-x11rb-protocol+serde-devel \
 rust-x11rb-protocol+shape-devel \
 rust-x11rb-protocol+shm-devel \
 rust-x11rb-protocol+std-devel \
 rust-x11rb-protocol+sync-devel \
 rust-x11rb-protocol+xevie-devel \
 rust-x11rb-protocol+xf86dri-devel \
 rust-x11rb-protocol+xf86vidmode-devel \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol+xinerama-devel \
 rust-x11rb-protocol+xinput-devel \
 rust-x11rb-protocol+xkb-devel \
 rust-x11rb-protocol+xprint-devel \
 rust-x11rb-protocol+xselinux-devel \
 rust-x11rb-protocol+xtest-devel \
 rust-x11rb-protocol+xv-devel \
 rust-x11rb-protocol+xvmc-devel \
 rust-x11rb-protocol-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-x11rb-protocol-0.13.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57b0b5e4b40151f21aac3250b5b05d832192a8ca8ad9d44d4963302a1ee7f27e"

URI_x86_64_v2_rust-x11rb-protocol+all-extensions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+all-extensions-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+all-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+all-extensions-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+all-extensions-devel.sha256sum] = "7589afd1a640892a2881d4c5668c76770e9402819200a5b5acc9923365a33871"

URI_x86_64_v2_rust-x11rb-protocol+composite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+composite-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+composite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+composite-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+composite-devel.sha256sum] = "2c1f34be5995107f68e2077a5b7a485bc477678ea6de9273e71910537d81ff56"

URI_x86_64_v2_rust-x11rb-protocol+damage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+damage-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+damage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+damage-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+damage-devel.sha256sum] = "3a5197f156a5f0dcb59ec6229f8590ef0b8c3a01ce0ec0e67007969a12d7e46f"

URI_x86_64_v2_rust-x11rb-protocol+dbe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+dbe-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+dbe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+dbe-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+dbe-devel.sha256sum] = "3b75f8a2a08b92da4138f1dd9fe07b4d6fcf9cefff4f2079e44f5b2dfb3037f0"

URI_x86_64_v2_rust-x11rb-protocol+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+default-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+default-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+default-devel.sha256sum] = "b3ebfe4da11c628c9553622951acb3b2d5b4a083006bb6b50de771dcabce9255"

URI_x86_64_v2_rust-x11rb-protocol+dpms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+dpms-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+dpms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+dpms-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+dpms-devel.sha256sum] = "11d6a81d7be0022de35ba5ba0f84391523c8f6e41ed38938e626fb17f8adc887"

URI_x86_64_v2_rust-x11rb-protocol+dri2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+dri2-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+dri2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+dri2-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+dri2-devel.sha256sum] = "a80e406d4b879753964f7bcf8666e16862ea234fc3bebd37bb83863aaa440a6b"

URI_x86_64_v2_rust-x11rb-protocol+dri3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+dri3-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+dri3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+dri3-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+dri3-devel.sha256sum] = "be9c0fe5c4fa8d5ffa93207dd250cb11bd826ce4c9e92dfcfab9eccab9012192"

URI_x86_64_v2_rust-x11rb-protocol+extra-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+extra-traits-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+extra-traits-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+extra-traits-devel.sha256sum] = "62ca6d4e826dc3ac44e57604eb3d9d80db5bfb4328645016c140d11fb6ce1e3f"

URI_x86_64_v2_rust-x11rb-protocol+glx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+glx-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+glx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+glx-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+glx-devel.sha256sum] = "eaa11508d45cf2b47dec9af67b52ceab7da0823b19c40ce75870e983a84a4cb5"

URI_x86_64_v2_rust-x11rb-protocol+present-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+present-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+present-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+present-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+present-devel.sha256sum] = "632eebbe1cbc0006c461d426fd2e7da45ab41397fe4ca2bc6db5a86869c54d1e"

URI_x86_64_v2_rust-x11rb-protocol+randr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+randr-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+randr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+randr-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+randr-devel.sha256sum] = "499f1d633ca0cdf88558dc5dde8327812590e1e61538f182b22bac92ef5e1018"

URI_x86_64_v2_rust-x11rb-protocol+record-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+record-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+record-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+record-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+record-devel.sha256sum] = "d527e863ffb5c086b4dbd28da81584ff172b9fde7b470aecf2c3c3543e0029c5"

URI_x86_64_v2_rust-x11rb-protocol+render-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+render-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+render-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+render-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+render-devel.sha256sum] = "ffdb595ea944ab38248daa2132745218c396631bd50e35ced44739e7c4c13dca"

URI_x86_64_v2_rust-x11rb-protocol+request-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+request-parsing-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+request-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+request-parsing-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+request-parsing-devel.sha256sum] = "00aab3de1d4dd8dbf897159ffb05a5c72388037c3aff4a9e3e99471a60ae7588"

URI_x86_64_v2_rust-x11rb-protocol+res-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+res-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+res-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+res-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+res-devel.sha256sum] = "8e67844280f0f83c460a5b0f3c444da610be0a5f90680ef7fa6c84cf5055aff7"

URI_x86_64_v2_rust-x11rb-protocol+resource_manager-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+resource_manager-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+resource_manager-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+resource_manager-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+resource_manager-devel.sha256sum] = "5dde685e8b88cf48de20c668e6c21c31ff2e416541da4cfb90746269ff900159"

URI_x86_64_v2_rust-x11rb-protocol+screensaver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+screensaver-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+screensaver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+screensaver-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+screensaver-devel.sha256sum] = "93efced052e5ca87b42e5e9179f96b1639c87a0c783058a7a64513c5ff430c49"

URI_x86_64_v2_rust-x11rb-protocol+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+serde-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+serde-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+serde-devel.sha256sum] = "cb352cade6c971e8f33df00c7888d25e7ad3bcaafa5256e01ad16c6685574692"

URI_x86_64_v2_rust-x11rb-protocol+shape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+shape-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+shape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+shape-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+shape-devel.sha256sum] = "cb17b4b4d18e5e36934e554d201a201fd1f3224625309861a7ff4788b84723fb"

URI_x86_64_v2_rust-x11rb-protocol+shm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+shm-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+shm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+shm-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+shm-devel.sha256sum] = "634d539bb153bec67b6907483b7bcc85db68859fe5ff7dc39fc2f0ff2beb3943"

URI_x86_64_v2_rust-x11rb-protocol+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+std-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+std-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+std-devel.sha256sum] = "f6cc203e6a48b1687b9da495e7e8f10795d71284d5c1913780384f9237d02f40"

URI_x86_64_v2_rust-x11rb-protocol+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+sync-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+sync-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+sync-devel.sha256sum] = "89a42f40568d367aca3205a1f808233a6651bb4bca749bbdd2fdd14d8509d184"

URI_x86_64_v2_rust-x11rb-protocol+xevie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xevie-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xevie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xevie-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xevie-devel.sha256sum] = "49437e3574ec2c7a3bd3aca8cbaad441b592322f6bae53f1c81331a928170679"

URI_x86_64_v2_rust-x11rb-protocol+xf86dri-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xf86dri-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xf86dri-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xf86dri-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xf86dri-devel.sha256sum] = "c05dccefdfa379a5ab0f26416fb23e8d65ba579e05d83c02bc7a82cf9a4b0985"

URI_x86_64_v2_rust-x11rb-protocol+xf86vidmode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xf86vidmode-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xf86vidmode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xf86vidmode-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xf86vidmode-devel.sha256sum] = "d7bcf2cebb87e25a8fd62f1772f3ac88ca686731137d2b351ad61e66410f31c6"

URI_x86_64_v2_rust-x11rb-protocol+xfixes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xfixes-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xfixes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xfixes-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xfixes-devel.sha256sum] = "3931799758dfa777de4199e3e0bbff801a4a99f4f7882d05377eeba8c4b0ecb2"

URI_x86_64_v2_rust-x11rb-protocol+xinerama-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xinerama-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xinerama-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xinerama-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xinerama-devel.sha256sum] = "d9bb5480fa7e0dcc16738341ee981584772e4a499923ccee489124033546aa20"

URI_x86_64_v2_rust-x11rb-protocol+xinput-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xinput-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xinput-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xinput-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xinput-devel.sha256sum] = "fe04904fd480c87a48446754fef827aca908854bd27ae98802386fc22b16f0a9"

URI_x86_64_v2_rust-x11rb-protocol+xkb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xkb-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xkb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xkb-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xkb-devel.sha256sum] = "e7dae4185c9cc0a3f89084f8058fc3fdcc821589a7752a9a749bae5e7b2ac498"

URI_x86_64_v2_rust-x11rb-protocol+xprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xprint-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xprint-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xprint-devel.sha256sum] = "21a3836242c58a2fbd9c378831016176727d415822074041f88b0dffdf5cb090"

URI_x86_64_v2_rust-x11rb-protocol+xselinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xselinux-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xselinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xselinux-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xselinux-devel.sha256sum] = "5daa2db2fd039220cd728e709dac567ab2b40cd2b0a1b3dd94ff7819281bbf12"

URI_x86_64_v2_rust-x11rb-protocol+xtest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xtest-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xtest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xtest-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xtest-devel.sha256sum] = "39fbc91c0d623a2b30d520f020ae71f2b8141f720481ebbc6335bbe9c1a9ab67"

URI_x86_64_v2_rust-x11rb-protocol+xv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xv-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xv-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xv-devel.sha256sum] = "0aa0610b8bc12a45d5538210fe0ec546e24150d6b31fb44c6938e1430f4b0e45"

URI_x86_64_v2_rust-x11rb-protocol+xvmc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xvmc-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xvmc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xvmc-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xvmc-devel.sha256sum] = "45e35ae66dc1c9a94d41abd18758010fdeac4ac46c0f245e534c78fd6a2d427b"

URI_x86_64_v2_rust-x11rb-protocol-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol-devel.sha256sum] = "4b0bf2e9ffd8256826492ef1f44f777b93d5c8d5855390b773546255d0737810"

URI_aarch64_rust-x11rb-protocol+all-extensions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+all-extensions-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+all-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+all-extensions-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+all-extensions-devel.sha256sum] = "ed5c07eeda58954dd2a0194f103a885039d83959d32a7d7711e45b24d904c4b7"

URI_aarch64_rust-x11rb-protocol+composite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+composite-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+composite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+composite-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+composite-devel.sha256sum] = "738ed7fb9713e55720028414328e718bae5cddab9dcf96fe0103674140daa788"

URI_aarch64_rust-x11rb-protocol+damage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+damage-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+damage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+damage-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+damage-devel.sha256sum] = "c75363aed1b80bccb5e1f7e5e6edaa3d94d6c3b5bd44c250384d4dc445986a26"

URI_aarch64_rust-x11rb-protocol+dbe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+dbe-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+dbe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+dbe-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+dbe-devel.sha256sum] = "d9390fc97b4f8a8d756cf3073d24800cd72ab0d7cc1a0cfdcd5e64cbb81267d8"

URI_aarch64_rust-x11rb-protocol+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+default-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+default-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+default-devel.sha256sum] = "715ace6e3942881541bb76c7035cbadc17c7cd2ff242b64e80f8e07f36d8cc25"

URI_aarch64_rust-x11rb-protocol+dpms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+dpms-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+dpms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+dpms-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+dpms-devel.sha256sum] = "5fd3e6b0f2019087ebefb9653be89bd89f6a5b3f8ce41e3be2f6f9591c8c678e"

URI_aarch64_rust-x11rb-protocol+dri2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+dri2-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+dri2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+dri2-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+dri2-devel.sha256sum] = "d110370f041b17d4467d50cd5f84ad32b93f228ae9be41689721f58cafa7e01e"

URI_aarch64_rust-x11rb-protocol+dri3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+dri3-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+dri3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+dri3-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+dri3-devel.sha256sum] = "42e9aea1edbd0742533ac51868731537ef61483fa026484a516520ccf5303f8c"

URI_aarch64_rust-x11rb-protocol+extra-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+extra-traits-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+extra-traits-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+extra-traits-devel.sha256sum] = "d1a0a65a496c8d0782b85bbef517e5ea67921becfcc147b3e74700eec2ca039a"

URI_aarch64_rust-x11rb-protocol+glx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+glx-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+glx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+glx-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+glx-devel.sha256sum] = "96605a89cc9bd8b4697ae40de22be3259f0fb25c205d14f4f0a92c89e99e8d63"

URI_aarch64_rust-x11rb-protocol+present-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+present-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+present-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+present-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+present-devel.sha256sum] = "f178e0904230d893fbe6dba3ddb4cbef601a1d8e22c758dc252524276a13175b"

URI_aarch64_rust-x11rb-protocol+randr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+randr-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+randr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+randr-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+randr-devel.sha256sum] = "b4fefc25d36f42cbb2e8b0d109230523d2c01daafe102203518b1fc378e18736"

URI_aarch64_rust-x11rb-protocol+record-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+record-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+record-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+record-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+record-devel.sha256sum] = "e7e626c421cfed7ffeb13339e05a98f06a013f15ffab28f86824f0c4385099fa"

URI_aarch64_rust-x11rb-protocol+render-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+render-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+render-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+render-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+render-devel.sha256sum] = "59a7c032d2575ca0074f6819ee732e6ee6896d558bc1e920e9ec0b2881f9c565"

URI_aarch64_rust-x11rb-protocol+request-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+request-parsing-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+request-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+request-parsing-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+request-parsing-devel.sha256sum] = "3c2ea78d171a66aa7177055fb6feb081fb2a2faa5ce2a7c10f45d0d301630222"

URI_aarch64_rust-x11rb-protocol+res-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+res-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+res-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+res-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+res-devel.sha256sum] = "8502cc6d4c0c5ff0fdbcb96c3c63a6c60d448f053ee859bcd0eaea772fb39b21"

URI_aarch64_rust-x11rb-protocol+resource_manager-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+resource_manager-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+resource_manager-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+resource_manager-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+resource_manager-devel.sha256sum] = "230727adfe993fd8a83ca1c02dafecddfbdd39369487f36424b0d986e358d722"

URI_aarch64_rust-x11rb-protocol+screensaver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+screensaver-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+screensaver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+screensaver-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+screensaver-devel.sha256sum] = "ae941616123334aef1ce7c464349f6aa73effbab60bc4675dd0ae9c8642ee9d3"

URI_aarch64_rust-x11rb-protocol+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+serde-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+serde-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+serde-devel.sha256sum] = "9f6f5a3aab6d106d7b73e7828710e82e964b86069238921569289d5ba423d835"

URI_aarch64_rust-x11rb-protocol+shape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+shape-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+shape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+shape-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+shape-devel.sha256sum] = "62dfaa5e8bfaaff0ccf93cdd4f2baeeee006f33f735f95492a72f7ed774574e4"

URI_aarch64_rust-x11rb-protocol+shm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+shm-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+shm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+shm-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+shm-devel.sha256sum] = "fe49ec4b08d608130695b8e3a72a4a4d87b93e06e10d6a74d8bd858c3f02e8e6"

URI_aarch64_rust-x11rb-protocol+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+std-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+std-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+std-devel.sha256sum] = "b49086c2bebbdc8c8d67cdf1e74782e69e5ecb47be951dd9a9164677530dd76c"

URI_aarch64_rust-x11rb-protocol+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+sync-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+sync-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+sync-devel.sha256sum] = "f00eb3e3ddaf65cfcee646faced52ab0fe54ec38f76ee5b01ac5b73598a58900"

URI_aarch64_rust-x11rb-protocol+xevie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xevie-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+xevie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xevie-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xevie-devel.sha256sum] = "d4e6f3f13ad86789e8b208a971d820a5d6848aff41bc9dade5d7839101c6ad63"

URI_aarch64_rust-x11rb-protocol+xf86dri-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xf86dri-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+xf86dri-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xf86dri-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xf86dri-devel.sha256sum] = "445c9f228a5b20145be9a056d12163d2294566d6f27145227f650daaffb18327"

URI_aarch64_rust-x11rb-protocol+xf86vidmode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xf86vidmode-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+xf86vidmode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xf86vidmode-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xf86vidmode-devel.sha256sum] = "40c875ace7cca8ea1aba8b5d12bd9edbc190a75712d6fecb84bf34e6d67979e9"

URI_aarch64_rust-x11rb-protocol+xfixes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xfixes-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+xfixes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xfixes-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xfixes-devel.sha256sum] = "f54fb96e286d691c03233d0efd2a5a1f42a55aaccbb29f86d564799a7f64021c"

URI_aarch64_rust-x11rb-protocol+xinerama-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xinerama-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+xinerama-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xinerama-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xinerama-devel.sha256sum] = "83a14c1431b9c51e7427145bf5a6061731756bc193aabd06299270888ea34072"

URI_aarch64_rust-x11rb-protocol+xinput-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xinput-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+xinput-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xinput-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xinput-devel.sha256sum] = "868146e527815493af70b3afa0d82a6c81ab295f31a680045b11174bdd0b18dd"

URI_aarch64_rust-x11rb-protocol+xkb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xkb-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+xkb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xkb-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xkb-devel.sha256sum] = "88b1713980748cdc15f78e2b8e620e3ecc0eb519fba63765e0e7de1edf4a7d3e"

URI_aarch64_rust-x11rb-protocol+xprint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xprint-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+xprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xprint-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xprint-devel.sha256sum] = "c970660725b3e5040c6156a1043019f7ea246a77c0141284b0131cbc9f97d796"

URI_aarch64_rust-x11rb-protocol+xselinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xselinux-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+xselinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xselinux-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xselinux-devel.sha256sum] = "440ed688f3381b1fab3da3579a950587c6c5ec50cbe25c02b7ae18edd0a4c4ee"

URI_aarch64_rust-x11rb-protocol+xtest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xtest-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+xtest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xtest-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xtest-devel.sha256sum] = "f1bae3f8f647d782ee4ee9c661e693705e8a89017e3536ea0d3b518f89f144a3"

URI_aarch64_rust-x11rb-protocol+xv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xv-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+xv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xv-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xv-devel.sha256sum] = "2aa652b1f0604b3e16d3b612b0566f5066c6868cc8893e588e129a1976f53ab5"

URI_aarch64_rust-x11rb-protocol+xvmc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xvmc-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol+xvmc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xvmc-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xvmc-devel.sha256sum] = "f2e4c4fa70b0acf59e4760319dd82394549757e4177a0f909d5210ef5d7aa4c5"

URI_aarch64_rust-x11rb-protocol-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol-devel}"
SRC_URI[aarch64_rust-x11rb-protocol-devel.sha256sum] = "8ad6beacdf46a34c25ac50d8f4c9d9a7a29aa216bf13c5332742d9592ca110e1"

RDEPENDS:rust-x11rb-protocol+all-extensions-devel = " \
 cargo \
 rust-x11rb-protocol+composite-devel \
 rust-x11rb-protocol+damage-devel \
 rust-x11rb-protocol+dbe-devel \
 rust-x11rb-protocol+dpms-devel \
 rust-x11rb-protocol+dri2-devel \
 rust-x11rb-protocol+dri3-devel \
 rust-x11rb-protocol+glx-devel \
 rust-x11rb-protocol+present-devel \
 rust-x11rb-protocol+randr-devel \
 rust-x11rb-protocol+record-devel \
 rust-x11rb-protocol+render-devel \
 rust-x11rb-protocol+res-devel \
 rust-x11rb-protocol+screensaver-devel \
 rust-x11rb-protocol+shape-devel \
 rust-x11rb-protocol+shm-devel \
 rust-x11rb-protocol+sync-devel \
 rust-x11rb-protocol+xevie-devel \
 rust-x11rb-protocol+xf86dri-devel \
 rust-x11rb-protocol+xf86vidmode-devel \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol+xinerama-devel \
 rust-x11rb-protocol+xinput-devel \
 rust-x11rb-protocol+xkb-devel \
 rust-x11rb-protocol+xprint-devel \
 rust-x11rb-protocol+xselinux-devel \
 rust-x11rb-protocol+xtest-devel \
 rust-x11rb-protocol+xv-devel \
 rust-x11rb-protocol+xvmc-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+composite-devel = " \
 cargo \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+damage-devel = " \
 cargo \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+dbe-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+default-devel = " \
 cargo \
 rust-x11rb-protocol+std-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+dpms-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+dri2-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+dri3-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+extra-traits-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+glx-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+present-devel = " \
 cargo \
 rust-x11rb-protocol+dri3-devel \
 rust-x11rb-protocol+randr-devel \
 rust-x11rb-protocol+sync-devel \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+randr-devel = " \
 cargo \
 rust-x11rb-protocol+render-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+record-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+render-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+request-parsing-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+res-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+resource_manager-devel = " \
 cargo \
 rust-x11rb-protocol+std-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+screensaver-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+shape-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+shm-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+std-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+sync-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xevie-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xf86dri-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xf86vidmode-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xfixes-devel = " \
 cargo \
 rust-x11rb-protocol+render-devel \
 rust-x11rb-protocol+shape-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xinerama-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xinput-devel = " \
 cargo \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xkb-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xprint-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xselinux-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xtest-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xv-devel = " \
 cargo \
 rust-x11rb-protocol+shm-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xvmc-devel = " \
 cargo \
 rust-x11rb-protocol+xv-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol-devel = " \
 cargo \
 rust \
 "
