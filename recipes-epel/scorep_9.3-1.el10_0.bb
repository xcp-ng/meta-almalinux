# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scorep"
PV = "9.3"
PR = "1.el10_0"
PACKAGES = " \
 scorep \
 scorep-config \
 scorep-doc \
 scorep-libs \
 scorep-mpich \
 scorep-mpich-config \
 scorep-mpich-libs \
 scorep-openmpi \
 scorep-openmpi-config \
 scorep-openmpi-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scorep-9.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f347e173b6825b215570efb40270cb4385c392e74ffb0040dd428e3d5086b0cc"

URI_x86_64_v2_scorep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-9.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep}"
SRC_URI[x86_64_v2_scorep.sha256sum] = "152d9ba54b14ae15780710a58819d9da3e58c2c36d64e0cf020c342be53c5383"

URI_x86_64_v2_scorep-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-config-9.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-config}"
SRC_URI[x86_64_v2_scorep-config.sha256sum] = "7d2cc791aaeab7149fa78bfaa6602248bac2a71de5b7b147ff529f9fb6a090d7"

URI_x86_64_v2_scorep-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-doc-9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_scorep-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-doc}"
SRC_URI[x86_64_v2_scorep-doc.sha256sum] = "74f456a1d0be8e6ba70dfe09cbd275fd8e2bd210a86e00cdf1795dfc38c44dd4"

URI_x86_64_v2_scorep-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-libs-9.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-libs}"
SRC_URI[x86_64_v2_scorep-libs.sha256sum] = "2e3eafbdcf8cea30ec1d74ad5bb7899f4a0aa537079ec5ecfb3137601f6d5306"

URI_x86_64_v2_scorep-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-mpich-9.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-mpich}"
SRC_URI[x86_64_v2_scorep-mpich.sha256sum] = "7940f4bfd08a646f61c03a0b62debb488be44d345514cb3e66cad64adee70f9b"

URI_x86_64_v2_scorep-mpich-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-mpich-config-9.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-mpich-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-mpich-config}"
SRC_URI[x86_64_v2_scorep-mpich-config.sha256sum] = "b396f0ffd9934fb0851055989ca2b11557befb8dfa87db2ff163ae8778396d57"

URI_x86_64_v2_scorep-mpich-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-mpich-libs-9.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-mpich-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-mpich-libs}"
SRC_URI[x86_64_v2_scorep-mpich-libs.sha256sum] = "2a9444c1fe535bc3b0faf2640ef2d6c9728d7af7c6c559f2019d56b733f58fe0"

URI_x86_64_v2_scorep-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-openmpi-9.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-openmpi}"
SRC_URI[x86_64_v2_scorep-openmpi.sha256sum] = "77d59c913388cbb9868b6cf365e57022c8110a6d3aa4e1db8d582c3d22e54c39"

URI_x86_64_v2_scorep-openmpi-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-openmpi-config-9.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-openmpi-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-openmpi-config}"
SRC_URI[x86_64_v2_scorep-openmpi-config.sha256sum] = "2a8ad601a04e8f432bc51c93f96073c2d7f0ea7acb915cc851aac957c4e3164e"

URI_x86_64_v2_scorep-openmpi-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-openmpi-libs-9.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-openmpi-libs}"
SRC_URI[x86_64_v2_scorep-openmpi-libs.sha256sum] = "3fe983db26d3e89fc3725111cae3abc167fe65f6183fed664b70e119ce4b33dc"

URI_aarch64_scorep = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-9.3-1.el10_0.aarch64.rpm;name=aarch64_scorep;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep}"
SRC_URI[aarch64_scorep.sha256sum] = "5d4d683bd60dc0f1f324d737b2fc0580d283755b5cd0eb5cd5317b153a6d3002"

URI_aarch64_scorep-config = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-config-9.3-1.el10_0.aarch64.rpm;name=aarch64_scorep-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-config}"
SRC_URI[aarch64_scorep-config.sha256sum] = "e5bbf7b837ccdffb7b816bf1e492c02568c8cd51d86089a6e6c8a6b488258a24"

URI_aarch64_scorep-doc = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-doc-9.3-1.el10_0.noarch.rpm;name=aarch64_scorep-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-doc}"
SRC_URI[aarch64_scorep-doc.sha256sum] = "e4623025d77b41efc2ad9560b85a20fe5313878d7fa68cc6c6bb5798d928a19f"

URI_aarch64_scorep-libs = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-libs-9.3-1.el10_0.aarch64.rpm;name=aarch64_scorep-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-libs}"
SRC_URI[aarch64_scorep-libs.sha256sum] = "8be25272dcb5f85b96c20facbff982b2bd8f4688dc838e3e22b3a6b96ef73a76"

URI_aarch64_scorep-mpich = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-mpich-9.3-1.el10_0.aarch64.rpm;name=aarch64_scorep-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-mpich}"
SRC_URI[aarch64_scorep-mpich.sha256sum] = "edbedb171ede0d51893a5d095e058cb6a8c2317b0cf6344a659976f78a008857"

URI_aarch64_scorep-mpich-config = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-mpich-config-9.3-1.el10_0.aarch64.rpm;name=aarch64_scorep-mpich-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-mpich-config}"
SRC_URI[aarch64_scorep-mpich-config.sha256sum] = "1348763d34d51dee1921f3acb4f521cd846db4e0812edaf77629cc74545792f8"

URI_aarch64_scorep-mpich-libs = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-mpich-libs-9.3-1.el10_0.aarch64.rpm;name=aarch64_scorep-mpich-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-mpich-libs}"
SRC_URI[aarch64_scorep-mpich-libs.sha256sum] = "25a277e1fc0b1ab4636b7df31c4c9e2811139edfd160c5e55e60152e001df012"

URI_aarch64_scorep-openmpi = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-openmpi-9.3-1.el10_0.aarch64.rpm;name=aarch64_scorep-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-openmpi}"
SRC_URI[aarch64_scorep-openmpi.sha256sum] = "0a3ed59bd0a70a8524e9fd8fb97a2712864f516bd09053a188ad564f05772497"

URI_aarch64_scorep-openmpi-config = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-openmpi-config-9.3-1.el10_0.aarch64.rpm;name=aarch64_scorep-openmpi-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-openmpi-config}"
SRC_URI[aarch64_scorep-openmpi-config.sha256sum] = "b03013172d92b54a3f74acc786545f635daf871d7addf57b63af1b5885bb0cf4"

URI_aarch64_scorep-openmpi-libs = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-openmpi-libs-9.3-1.el10_0.aarch64.rpm;name=aarch64_scorep-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-openmpi-libs}"
SRC_URI[aarch64_scorep-openmpi-libs.sha256sum] = "bfdbf7410161e81b7e13f18edac824f49f661f482c585c22a1771d6c0672a3a8"

RDEPENDS:scorep = " \
 bash \
 binutils-devel \
 clang-libs \
 cube-libs \
 cube-libs-devel \
 glibc \
 gotcha-devel \
 libgcc \
 libstdc++ \
 libunwind-devel \
 ocl-icd-devel \
 opari2 \
 otf2-devel \
 papi-devel \
 scorep-libs \
 "
RDEPENDS:scorep-config = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:scorep-doc = " \
 "
RDEPENDS:scorep-libs = " \
 scorep-config \
 "
RDEPENDS:scorep-mpich = " \
 bash \
 cube-libs \
 cube-libs-devel \
 glibc \
 libgcc \
 libstdc++ \
 otf2-devel \
 papi-devel \
 scorep-mpich-libs \
 "
RDEPENDS:scorep-mpich-config = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:scorep-mpich-libs = " \
 scorep-mpich-config \
 "
RDEPENDS:scorep-openmpi = " \
 bash \
 cube-libs \
 cube-libs-devel \
 glibc \
 libgcc \
 libstdc++ \
 otf2-devel \
 papi-devel \
 scorep-openmpi-libs \
 "
RDEPENDS:scorep-openmpi-config = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:scorep-openmpi-libs = " \
 scorep-openmpi-config \
 "
