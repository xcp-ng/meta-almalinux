# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kldap"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kldap \
 kldap-devel \
 kldap-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kldap-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "921a35c5fe15594be258c63b5dd79a24d19e43a5c4bab29fccc3de4129aa316a"

URI_x86_64_v2_kldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kldap}"
SRC_URI[x86_64_v2_kldap.sha256sum] = "1b51560eb293d79f93ea13baf7569c0ce14ef76883bb6cef07356312b2d2b212"

URI_x86_64_v2_kldap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kldap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kldap-devel}"
SRC_URI[x86_64_v2_kldap-devel.sha256sum] = "380f2ba65b3910863255301bedb08f2494a721efd24ea071f7c997e2f7470276"

URI_x86_64_v2_kldap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kldap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kldap-doc}"
SRC_URI[x86_64_v2_kldap-doc.sha256sum] = "d4ae3a02a1591d270cfcd4dc5f2eb5941ff4358645e595bc7935e9218f32a0cb"

URI_aarch64_kldap = "${EPEL_MIRROR}/aarch64/Packages/k/kldap-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_kldap}"
SRC_URI[aarch64_kldap.sha256sum] = "455a7003146b8e36e0f24e9da2ceeea17d0443acbff139bef93064fa9531745f"

URI_aarch64_kldap-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kldap-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kldap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kldap-devel}"
SRC_URI[aarch64_kldap-devel.sha256sum] = "90c9033f84980046a1e66a1b348fabfd93919121884d4c40ed3287df7b488c46"

URI_aarch64_kldap-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kldap-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kldap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kldap-doc}"
SRC_URI[aarch64_kldap-doc.sha256sum] = "acf6cf671cf3e8337d06035cfcc663262bac29e515fba577d906786259961e7b"

RDEPENDS:kldap = " \
 cyrus-sasl-lib \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 libstdc++ \
 openldap \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:kldap-devel = " \
 cmake-filesystem \
 cyrus-sasl-devel \
 kldap \
 openldap-devel \
 "
RDEPENDS:kldap-doc = " \
 "
