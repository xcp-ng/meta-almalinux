# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "francis"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 francis \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/francis-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "49e597ffb0da332692f57adf56e6be6c0ad6ed4df075a7cb042275bd6105b1ae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/francis-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_francis;unpack=0"
SRC_URI[x86_64_v2_francis.sha256sum] = "677473607aa4a0073afb0e81a76d944f23f24905b44ba80bad07b9e087c546f2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/francis-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_francis;unpack=0"
SRC_URI[aarch64_francis.sha256sum] = "e8581a4d4bb1fa5c0e6eeb60d83457225114c55cd62c75f96b9c8a69e1ae0c28"

RDEPENDS:francis = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
