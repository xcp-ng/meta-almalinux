# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "environment-modules"
PV = "5.6.1"
PR = "3.el10"
PACKAGES = " \
 environment-modules \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/environment-modules-5.6.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b91a41427fc05a41f422ac5a4f059bb744149cb424a40af2c1d6b13d8f9d6c9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/environment-modules-5.6.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_environment-modules;unpack=0"
SRC_URI[x86_64_v2_environment-modules.sha256sum] = "d7698ded417e3eda2421ff483e5c002222173e9a35f1d3c41bf4ae7e6bf622b5"
RPROVIDES:environment-modules:append:x86_64_v2 = " virtual/environment_modules_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/environment-modules-5.6.1-3.el10.aarch64.rpm;name=aarch64_environment-modules;unpack=0"
SRC_URI[aarch64_environment-modules.sha256sum] = "de9633373a847d6aeb47544fbe0c9aa02f9c02c0a8bdf73273c73d33bf456cc0"
RPROVIDES:environment-modules:append:aarch64 = " virtual/environment_modules_"

RDEPENDS:environment-modules = " \
 alternatives \
 bash \
 emacs-filesystem \
 glibc \
 less \
 man-db \
 procps-ng \
 sed \
 tcl \
 util-linux-core \
 vim-filesystem \
 virtual/coreutils \
 "
