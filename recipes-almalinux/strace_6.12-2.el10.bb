# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "strace"
PV = "6.12"
PR = "2.el10"
PACKAGES = " \
 strace \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/strace-6.12-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7f4854f50a5faf47d119d90e47ff2363ac0899127d55f3f6ef761cdbf3f418d"

URI_x86_64_v2_strace = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/strace-6.12-2.el10.x86_64_v2.rpm;name=x86_64_v2_strace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_strace}"
SRC_URI[x86_64_v2_strace.sha256sum] = "6fbd2a2cb75c58cb3ae7161967fa0968137f1379523d20d202ee8da720912226"

URI_aarch64_strace = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/strace-6.12-2.el10.aarch64.rpm;name=aarch64_strace;unpack=0"
SRC_URI:append = " ${URI_aarch64_strace}"
SRC_URI[aarch64_strace.sha256sum] = "023c963c1e732332d6dac92fc5e060917f33a74b517523aa35025a86a984e4c1"

RDEPENDS:strace = " \
 bash \
 elfutils-libs \
 glibc \
 libselinux \
 "
