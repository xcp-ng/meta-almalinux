# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kjournald"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kjournald \
 kjournald-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kjournald-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a53c95eb737f90794fc86219f4c1a529588c00dff81b87fb49e7a3f46eae54a0"

URI_x86_64_v2_kjournald = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjournald-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjournald;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kjournald}"
SRC_URI[x86_64_v2_kjournald.sha256sum] = "8e3ca107d668031a0170aff502125070ffe4e1c2fb6023f11c6f3a752ccca555"

URI_x86_64_v2_kjournald-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjournald-libs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjournald-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kjournald-libs}"
SRC_URI[x86_64_v2_kjournald-libs.sha256sum] = "d065414a1530fdce23ae90228206b917ab4685896b5dee5f067eeb681189c849"

URI_aarch64_kjournald = "${EPEL_MIRROR}/aarch64/Packages/k/kjournald-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kjournald;unpack=0"
SRC_URI:append = " ${URI_aarch64_kjournald}"
SRC_URI[aarch64_kjournald.sha256sum] = "aa2060bf0291abe9b2271b459740f6f5d12af78003402113f4d2f12708d810eb"

URI_aarch64_kjournald-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kjournald-libs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kjournald-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kjournald-libs}"
SRC_URI[aarch64_kjournald-libs.sha256sum] = "3035f9742d59c7599f2ae405f08c236d227e3bd92af1de9491810f50f74ca15f"

RDEPENDS:kjournald = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kjournald-libs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kjournald-libs = " \
 glibc \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 systemd-libs \
 "
