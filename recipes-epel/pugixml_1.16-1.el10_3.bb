# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pugixml"
PV = "1.16"
PR = "1.el10_3"
PACKAGES = " \
 pugixml \
 pugixml-devel \
 pugixml-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pugixml-1.16-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49f39389f39ca6702da7eb0661d0a6391a665d9eeed3e50ad32b40dc4e0be90b"

URI_x86_64_v2_pugixml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pugixml-1.16-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pugixml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pugixml}"
SRC_URI[x86_64_v2_pugixml.sha256sum] = "53b21aa035ea27d2ad49a47a40170652bd594716ae3d3839003aea6fa17d1d6a"

URI_x86_64_v2_pugixml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pugixml-devel-1.16-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pugixml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pugixml-devel}"
SRC_URI[x86_64_v2_pugixml-devel.sha256sum] = "50c4a2da8baf3fa4556f22aade76696aab8f6e38de237429fec4099e0ef53368"

URI_x86_64_v2_pugixml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pugixml-doc-1.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pugixml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pugixml-doc}"
SRC_URI[x86_64_v2_pugixml-doc.sha256sum] = "39f7d3fa75e013df1d59b115d88d51115ea81c44035fe3730431d4e44a7dd1f7"

URI_aarch64_pugixml = "${EPEL_MIRROR}/aarch64/Packages/p/pugixml-1.16-1.el10_3.aarch64.rpm;name=aarch64_pugixml;unpack=0"
SRC_URI:append = " ${URI_aarch64_pugixml}"
SRC_URI[aarch64_pugixml.sha256sum] = "717125d9bff20e8c75c8ffb19d0e5e11bd3fa49a7ac9d3521dc8eabaa8b62589"

URI_aarch64_pugixml-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pugixml-devel-1.16-1.el10_3.aarch64.rpm;name=aarch64_pugixml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pugixml-devel}"
SRC_URI[aarch64_pugixml-devel.sha256sum] = "ce5069f2cebedf21343edf6d5cd180ead0cbc3aa9ec54d16f923c2f88daec445"

URI_aarch64_pugixml-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pugixml-doc-1.16-1.el10_3.noarch.rpm;name=aarch64_pugixml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pugixml-doc}"
SRC_URI[aarch64_pugixml-doc.sha256sum] = "75fcd83811e7432733e7d50dd7daa5de8cb7402d5ab5308a081c4490be906c09"

RDEPENDS:pugixml = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:pugixml-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pugixml \
 "
RDEPENDS:pugixml-doc = " \
 pugixml \
 "
