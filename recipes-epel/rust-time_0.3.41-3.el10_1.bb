# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-time"
PV = "0.3.41"
PR = "3.el10_1"
PACKAGES = " \
 rust-time+alloc-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+large-dates-devel \
 rust-time+local-offset-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 rust-time+quickcheck-devel \
 rust-time+rand-devel \
 rust-time+serde-devel \
 rust-time+serde-human-readable-devel \
 rust-time+serde-well-known-devel \
 rust-time+std-devel \
 rust-time-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-time-0.3.41-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb6e040b08a0fb512dce199488f0ef362bedae0d5c216c7c046b07a5f80a183a"

URI_x86_64_v2_rust-time+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+alloc-devel-0.3.41-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+alloc-devel}"
SRC_URI[x86_64_v2_rust-time+alloc-devel.sha256sum] = "9930ccbca3ca78f6fb7b0df040659c87726a7b0db7cccf11f814a9c924d7c68b"

URI_x86_64_v2_rust-time+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+default-devel-0.3.41-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+default-devel}"
SRC_URI[x86_64_v2_rust-time+default-devel.sha256sum] = "46f7442df344c18bbba176e30b22c7e6321ab19048d24e4dc4c5c57d63406f05"

URI_x86_64_v2_rust-time+formatting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+formatting-devel-0.3.41-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+formatting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+formatting-devel}"
SRC_URI[x86_64_v2_rust-time+formatting-devel.sha256sum] = "9503737159ccc5b5692cf85c1c05a2478269d6f1a5ac6c06f8b18411ef222c59"

URI_x86_64_v2_rust-time+large-dates-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+large-dates-devel-0.3.41-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+large-dates-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+large-dates-devel}"
SRC_URI[x86_64_v2_rust-time+large-dates-devel.sha256sum] = "3d09bf782c89c6d1bce668e9e154184b48901fe6a59266bc1126e964a415642a"

URI_x86_64_v2_rust-time+local-offset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+local-offset-devel-0.3.41-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+local-offset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+local-offset-devel}"
SRC_URI[x86_64_v2_rust-time+local-offset-devel.sha256sum] = "aa9aca29e6baa977d08f6d8ca37285412508d7a99cca3b7ee0f64ca5a16da9f1"

URI_x86_64_v2_rust-time+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+macros-devel-0.3.41-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+macros-devel}"
SRC_URI[x86_64_v2_rust-time+macros-devel.sha256sum] = "14ec5f5f4fe13b3a5221c51d9d0d7eff801eddf4e0517eb3a15e0b028c21132b"

URI_x86_64_v2_rust-time+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+parsing-devel-0.3.41-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+parsing-devel}"
SRC_URI[x86_64_v2_rust-time+parsing-devel.sha256sum] = "93f90dacedad253b886df4d836e3bc07c227b054d2ec83fd9b25962147914432"

URI_x86_64_v2_rust-time+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+quickcheck-devel-0.3.41-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-time+quickcheck-devel.sha256sum] = "7b327b0556b84d0e53ffbeff957f69ac2c3de2bbacfbbf847d5b95dc3d1c5034"

URI_x86_64_v2_rust-time+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+rand-devel-0.3.41-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+rand-devel}"
SRC_URI[x86_64_v2_rust-time+rand-devel.sha256sum] = "95c67de716dee17a5f53ec8c9c74bbdb9fe56fef97556b280cce72b932bd3874"

URI_x86_64_v2_rust-time+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+serde-devel-0.3.41-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+serde-devel}"
SRC_URI[x86_64_v2_rust-time+serde-devel.sha256sum] = "8c3be0c0d9112e0cc4c7c2bcb6075d5997d5dd2819d2a910030e0c3b8e345962"

URI_x86_64_v2_rust-time+serde-human-readable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+serde-human-readable-devel-0.3.41-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+serde-human-readable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+serde-human-readable-devel}"
SRC_URI[x86_64_v2_rust-time+serde-human-readable-devel.sha256sum] = "aa0995e5903be983fdc912a01a5e587edbd7fb6e53ea5fcafde2e579000517c7"

URI_x86_64_v2_rust-time+serde-well-known-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+serde-well-known-devel-0.3.41-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+serde-well-known-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+serde-well-known-devel}"
SRC_URI[x86_64_v2_rust-time+serde-well-known-devel.sha256sum] = "c28bcdb8905bacba09bebed7e406051600958733ada3928014bffbd3c67d733b"

URI_x86_64_v2_rust-time+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+std-devel-0.3.41-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+std-devel}"
SRC_URI[x86_64_v2_rust-time+std-devel.sha256sum] = "422afb0e2c0530a14dac2367b26b522e2cc1df6ecbefb6aa60c93940161827c4"

URI_x86_64_v2_rust-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-devel-0.3.41-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-devel}"
SRC_URI[x86_64_v2_rust-time-devel.sha256sum] = "801959c03f0118975a1f527599cadc6b802008513138c5628d652d3dc5293842"

URI_aarch64_rust-time+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+alloc-devel-0.3.41-3.el10_1.noarch.rpm;name=aarch64_rust-time+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+alloc-devel}"
SRC_URI[aarch64_rust-time+alloc-devel.sha256sum] = "cd6912190c6d99ccf84c7e6d9a8ce14cec538b14e23fd162151dbb8f21ae170e"

URI_aarch64_rust-time+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+default-devel-0.3.41-3.el10_1.noarch.rpm;name=aarch64_rust-time+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+default-devel}"
SRC_URI[aarch64_rust-time+default-devel.sha256sum] = "d468f8f4181820a32154f8e4d892a44e96ed4925610c6008c1ee195b2220d46a"

URI_aarch64_rust-time+formatting-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+formatting-devel-0.3.41-3.el10_1.noarch.rpm;name=aarch64_rust-time+formatting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+formatting-devel}"
SRC_URI[aarch64_rust-time+formatting-devel.sha256sum] = "e219d096b14aefe70b1d44149c36dd44022f84902c4782bf7d5e2c3ddc5106ef"

URI_aarch64_rust-time+large-dates-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+large-dates-devel-0.3.41-3.el10_1.noarch.rpm;name=aarch64_rust-time+large-dates-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+large-dates-devel}"
SRC_URI[aarch64_rust-time+large-dates-devel.sha256sum] = "93522003ff4343c67687de5ca94467bee643ca7206b093d2b76e5c982984ab7d"

URI_aarch64_rust-time+local-offset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+local-offset-devel-0.3.41-3.el10_1.noarch.rpm;name=aarch64_rust-time+local-offset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+local-offset-devel}"
SRC_URI[aarch64_rust-time+local-offset-devel.sha256sum] = "db18fbd151261dee7cd5449e271aae88cdc60ddd644d91e06ce1abf3c5495675"

URI_aarch64_rust-time+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+macros-devel-0.3.41-3.el10_1.noarch.rpm;name=aarch64_rust-time+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+macros-devel}"
SRC_URI[aarch64_rust-time+macros-devel.sha256sum] = "c0b4de22c3b7b89b45c98e99ffa6d2e71af8451c41b74cb2a9c3c69bedf4d367"

URI_aarch64_rust-time+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+parsing-devel-0.3.41-3.el10_1.noarch.rpm;name=aarch64_rust-time+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+parsing-devel}"
SRC_URI[aarch64_rust-time+parsing-devel.sha256sum] = "83041843a62b030ef5f4ac259158103fc98dccd3754f5253b5146c3d9119f141"

URI_aarch64_rust-time+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+quickcheck-devel-0.3.41-3.el10_1.noarch.rpm;name=aarch64_rust-time+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+quickcheck-devel}"
SRC_URI[aarch64_rust-time+quickcheck-devel.sha256sum] = "b7bb5edf906f31f468845d465993251982a18fb2185482b5bdfa91806788edc7"

URI_aarch64_rust-time+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+rand-devel-0.3.41-3.el10_1.noarch.rpm;name=aarch64_rust-time+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+rand-devel}"
SRC_URI[aarch64_rust-time+rand-devel.sha256sum] = "42c1a6b8d11222f6d2ae1c132209333e961086ed4fb00c29c50b9c7b485c80bc"

URI_aarch64_rust-time+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+serde-devel-0.3.41-3.el10_1.noarch.rpm;name=aarch64_rust-time+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+serde-devel}"
SRC_URI[aarch64_rust-time+serde-devel.sha256sum] = "8acec25909580cdb75472cdf628bb93a2e70273d28ea50db6cedc1109deb091c"

URI_aarch64_rust-time+serde-human-readable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+serde-human-readable-devel-0.3.41-3.el10_1.noarch.rpm;name=aarch64_rust-time+serde-human-readable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+serde-human-readable-devel}"
SRC_URI[aarch64_rust-time+serde-human-readable-devel.sha256sum] = "5fa72d90c375b914a75b9d6b024cfb84d298017ef17d7ce8c7281f4ea7506239"

URI_aarch64_rust-time+serde-well-known-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+serde-well-known-devel-0.3.41-3.el10_1.noarch.rpm;name=aarch64_rust-time+serde-well-known-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+serde-well-known-devel}"
SRC_URI[aarch64_rust-time+serde-well-known-devel.sha256sum] = "d27d1c24165c03ea696f70279c7cbabea055db63e0fdb362674faeab02b5e3c3"

URI_aarch64_rust-time+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+std-devel-0.3.41-3.el10_1.noarch.rpm;name=aarch64_rust-time+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+std-devel}"
SRC_URI[aarch64_rust-time+std-devel.sha256sum] = "753a1cc687e28c2462bf8e189847fd603dadbcc753972976275726c74035478e"

URI_aarch64_rust-time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-devel-0.3.41-3.el10_1.noarch.rpm;name=aarch64_rust-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-devel}"
SRC_URI[aarch64_rust-time-devel.sha256sum] = "695f6afb4e5063e2e514a1ccf4098a8bf6e864fcf1dadcd81640b037396fa774"

RDEPENDS:rust-time+alloc-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+default-devel = " \
 cargo \
 rust-time+std-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+formatting-devel = " \
 cargo \
 rust-itoa+default-devel \
 rust-time+std-devel \
 rust-time-devel \
 rust-time-macros+default-devel \
 rust-time-macros+formatting-devel \
 "
RDEPENDS:rust-time+large-dates-devel = " \
 cargo \
 rust-time-devel \
 rust-time-macros+default-devel \
 rust-time-macros+large-dates-devel \
 "
RDEPENDS:rust-time+local-offset-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-num_threads+default-devel \
 rust-time+std-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+macros-devel = " \
 cargo \
 rust-time-devel \
 rust-time-macros+default-devel \
 "
RDEPENDS:rust-time+parsing-devel = " \
 cargo \
 rust-time-devel \
 rust-time-macros+default-devel \
 rust-time-macros+parsing-devel \
 "
RDEPENDS:rust-time+quickcheck-devel = " \
 cargo \
 rust-deranged+quickcheck-devel \
 rust-quickcheck-devel \
 rust-time+alloc-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+rand-devel = " \
 cargo \
 rust-deranged+rand-devel \
 rust-rand0.8-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+serde-devel = " \
 cargo \
 rust-deranged+serde-devel \
 rust-serde-devel \
 rust-time-devel \
 rust-time-macros+default-devel \
 rust-time-macros+serde-devel \
 "
RDEPENDS:rust-time+serde-human-readable-devel = " \
 cargo \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time+serde-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+serde-well-known-devel = " \
 cargo \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time+serde-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+std-devel = " \
 cargo \
 rust-deranged+std-devel \
 rust-time+alloc-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time-devel = " \
 cargo \
 rust \
 rust-deranged+powerfmt-devel \
 rust-deranged-devel \
 rust-num-conv+default-devel \
 rust-powerfmt-devel \
 rust-time-core+default-devel \
 "
