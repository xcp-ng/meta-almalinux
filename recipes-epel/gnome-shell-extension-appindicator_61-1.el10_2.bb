# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-appindicator"
PV = "61"
PR = "1.el10_2"
PACKAGES = " \
 gnome-shell-extension-appindicator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-shell-extension-appindicator-61-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "457a07914cca474ab38ba09b4e2e2da8f57d6ba48bd385c5993788c75dc568c1"

URI_x86_64_v2_gnome-shell-extension-appindicator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-shell-extension-appindicator-61-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-shell-extension-appindicator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-appindicator}"
SRC_URI[x86_64_v2_gnome-shell-extension-appindicator.sha256sum] = "1c40d4d1ca4af32a0d06fbd2b9cbd88a98e3d650cb14d3af65433f5cc8217e42"

URI_aarch64_gnome-shell-extension-appindicator = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-shell-extension-appindicator-61-1.el10_2.noarch.rpm;name=aarch64_gnome-shell-extension-appindicator;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-appindicator}"
SRC_URI[aarch64_gnome-shell-extension-appindicator.sha256sum] = "c5704e6b1c71d28124b7fda73239aa8af9de8e2ea0e878ae6acdd06c335a2b99"

RDEPENDS:gnome-shell-extension-appindicator = " \
 gnome-shell \
 libappindicator-gtk3 \
 "
