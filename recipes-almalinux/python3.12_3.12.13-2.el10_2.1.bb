# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.12"
PV = "3.12.13"
PR = "2.el10_2.1"
PACKAGES = " \
 python-unversioned-command \
 python3 \
 python3-debug \
 python3-devel \
 python3-idle \
 python3-libs \
 python3-test \
 python3-tkinter \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python3.12-3.12.13-2.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bb698c4ba53d4da56f94b30c935d8bae7ebfe74ea6f0f06f36623f8eab10ad8"

URI_x86_64_v2_python-unversioned-command = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-unversioned-command-3.12.13-2.el10_2.1.noarch.rpm;name=x86_64_v2_python-unversioned-command;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-unversioned-command}"
SRC_URI[x86_64_v2_python-unversioned-command.sha256sum] = "01fd0cfaa34357b582559770297e93d57c2b9e0ffb6f529c89ba4cd34d50ce96"

URI_x86_64_v2_python3 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-3.12.13-2.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3}"
SRC_URI[x86_64_v2_python3.sha256sum] = "be88b3844a5dec6912ad0b5cff5bd6bb5d35505a3fcffa482893afb4f48ed71e"

URI_x86_64_v2_python3-debug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-debug-3.12.13-2.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-debug}"
SRC_URI[x86_64_v2_python3-debug.sha256sum] = "66d9da8af67ae76d278aba64abaabdc9bc70d979d64deb391fdd245a297c64c1"

URI_x86_64_v2_python3-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-devel-3.12.13-2.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-devel}"
SRC_URI[x86_64_v2_python3-devel.sha256sum] = "a666629529d0714d232dc7eaae7e936e85b45e2c7c79bf3ce0c09b010ff32ef3"

URI_x86_64_v2_python3-idle = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-idle-3.12.13-2.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-idle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-idle}"
SRC_URI[x86_64_v2_python3-idle.sha256sum] = "19af374edefa471f7a5cf6b15586dee3b6d8d4a875e54a2d661be29272a19dfc"

URI_x86_64_v2_python3-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libs-3.12.13-2.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libs}"
SRC_URI[x86_64_v2_python3-libs.sha256sum] = "e91c79b43c04b58e732eefdd67537237c78ad1b4a50437ec9643ed0ee846f3e3"

URI_x86_64_v2_python3-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-test-3.12.13-2.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-test}"
SRC_URI[x86_64_v2_python3-test.sha256sum] = "3b520c4948b3a4d0842745e0274543321b74db9d3e940dfe70b55c7a7d022aef"

URI_x86_64_v2_python3-tkinter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tkinter-3.12.13-2.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-tkinter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tkinter}"
SRC_URI[x86_64_v2_python3-tkinter.sha256sum] = "d6a8f03da143bb04f00805b27de2fdf8ba19d61e6b9e41262a3f5dd52812823b"

URI_aarch64_python-unversioned-command = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-unversioned-command-3.12.13-2.el10_2.1.noarch.rpm;name=aarch64_python-unversioned-command;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-unversioned-command}"
SRC_URI[aarch64_python-unversioned-command.sha256sum] = "01fd0cfaa34357b582559770297e93d57c2b9e0ffb6f529c89ba4cd34d50ce96"

URI_aarch64_python3 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-3.12.13-2.el10_2.1.aarch64.rpm;name=aarch64_python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3}"
SRC_URI[aarch64_python3.sha256sum] = "c55199a8b9ea3b4645a862b9b9e9ec4585eee2a69c5b06b6b91fa0a16fdc2547"

URI_aarch64_python3-debug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-debug-3.12.13-2.el10_2.1.aarch64.rpm;name=aarch64_python3-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-debug}"
SRC_URI[aarch64_python3-debug.sha256sum] = "2ebe4099644a5ed0979b282f94682a52e9f4d734480e3868306091eb43dd35f7"

URI_aarch64_python3-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-devel-3.12.13-2.el10_2.1.aarch64.rpm;name=aarch64_python3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-devel}"
SRC_URI[aarch64_python3-devel.sha256sum] = "ed8a8701c338c112455e98c703504b0ed135f7286938d08f4cbca5f048686730"

URI_aarch64_python3-idle = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-idle-3.12.13-2.el10_2.1.aarch64.rpm;name=aarch64_python3-idle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-idle}"
SRC_URI[aarch64_python3-idle.sha256sum] = "9f5f89b45fe7b93a10d445808355261a2acaac852e9745dcaba24db1d22810a6"

URI_aarch64_python3-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libs-3.12.13-2.el10_2.1.aarch64.rpm;name=aarch64_python3-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libs}"
SRC_URI[aarch64_python3-libs.sha256sum] = "363c94caea62240dc3e95707b225c6372af9e307a3b2e1cd3f842178568a45fa"

URI_aarch64_python3-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-test-3.12.13-2.el10_2.1.aarch64.rpm;name=aarch64_python3-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-test}"
SRC_URI[aarch64_python3-test.sha256sum] = "2df8fd7e090e9838af30348e1f88ef33f8c611bdfeea97d5289a30baff8f629b"

URI_aarch64_python3-tkinter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tkinter-3.12.13-2.el10_2.1.aarch64.rpm;name=aarch64_python3-tkinter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tkinter}"
SRC_URI[aarch64_python3-tkinter.sha256sum] = "e9ceedf025b6e0828fd8c1e368cd0ef68d20f0dcde9e48fd643a1d66796d8e09"

RDEPENDS:python-unversioned-command = " \
 python3 \
 "
RDEPENDS:python3 = " \
 glibc \
 python3-libs \
 "
RDEPENDS:python3-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libxcrypt \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3 \
 python3-devel \
 python3-idle \
 python3-libs \
 python3-test \
 python3-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-devel = " \
 bash \
 pkgconf-pkg-config \
 python-rpm-macros \
 python3 \
 python3-libs \
 python3-rpm-generators \
 python3-rpm-macros \
 "
RDEPENDS:python3-idle = " \
 python3 \
 python3-tkinter \
 "
RDEPENDS:python3-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libxcrypt \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-test = " \
 bash \
 glibc \
 python3 \
 python3-libs \
 python3-setuptools-wheel \
 python3-wheel-wheel \
 "
RDEPENDS:python3-tkinter = " \
 glibc \
 python3 \
 tcl \
 tk \
 "
