# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radsecproxy"
PV = "1.11.4"
PR = "1.el10_3"
PACKAGES = " \
 radsecproxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/radsecproxy-1.11.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b12eb35a3028b19793890be5c749f27c27cc50165fe6e67f9dd0467530952c5a"

URI_x86_64_v2_radsecproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radsecproxy-1.11.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radsecproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radsecproxy}"
SRC_URI[x86_64_v2_radsecproxy.sha256sum] = "f5969f536b8fc890acccfbacad6af2db572c0ad4c0fcf3f860ac53ead9a90ffc"

URI_aarch64_radsecproxy = "${EPEL_MIRROR}/aarch64/Packages/r/radsecproxy-1.11.4-1.el10_3.aarch64.rpm;name=aarch64_radsecproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_radsecproxy}"
SRC_URI[aarch64_radsecproxy.sha256sum] = "7ba0b8cc6f1bdccaef060b6e27e7f836a8868f253c3dca9a10c6c0631ce944dd"

RDEPENDS:radsecproxy = " \
 bash \
 glibc \
 logrotate \
 nettle \
 openssl-libs \
 shadow-utils \
 systemd \
 "
