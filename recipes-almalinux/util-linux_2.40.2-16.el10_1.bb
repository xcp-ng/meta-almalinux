# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "util-linux"
PV = "2.40.2"
PR = "16.el10_1"
PACKAGES = " \
 libblkid \
 libblkid-devel \
 libfdisk \
 libfdisk-devel \
 libmount \
 libmount-devel \
 libsmartcols \
 libsmartcols-devel \
 libuuid \
 libuuid-devel \
 python3-libmount \
 util-linux \
 util-linux-core \
 uuidd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/util-linux-2.40.2-16.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44366e296cbcae25eff985cfea1a5e283299b3b80c3c8fe0c2a57fd281098b4f"

URI_x86_64_v2_libblkid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libblkid-2.40.2-16.el10_1.x86_64_v2.rpm;name=x86_64_v2_libblkid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblkid}"
SRC_URI[x86_64_v2_libblkid.sha256sum] = "4ee6eda95fc23a2c47c5931aaa1ca3e051d2f16e74fe8a8db4957b3a35af2351"

URI_x86_64_v2_libblkid-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblkid-devel-2.40.2-16.el10_1.x86_64_v2.rpm;name=x86_64_v2_libblkid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblkid-devel}"
SRC_URI[x86_64_v2_libblkid-devel.sha256sum] = "9b6ca8f884cc61ba27c120e63b14b35623fdb2112bef180b5ce463476d7027b9"

URI_x86_64_v2_libfdisk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libfdisk-2.40.2-16.el10_1.x86_64_v2.rpm;name=x86_64_v2_libfdisk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfdisk}"
SRC_URI[x86_64_v2_libfdisk.sha256sum] = "ec6f122092998f189797d01c6210b6d5cf9253b435c628ccf27113b17208ddd4"

URI_x86_64_v2_libfdisk-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libfdisk-devel-2.40.2-16.el10_1.x86_64_v2.rpm;name=x86_64_v2_libfdisk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfdisk-devel}"
SRC_URI[x86_64_v2_libfdisk-devel.sha256sum] = "721ff83c79b0d89f2391288d36672688582c99d98c89be1af79b5c565caff822"

URI_x86_64_v2_libmount = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libmount-2.40.2-16.el10_1.x86_64_v2.rpm;name=x86_64_v2_libmount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmount}"
SRC_URI[x86_64_v2_libmount.sha256sum] = "9c4c564a581741165939d97f284817f5873bf65e84d9c93288a9932a6f3a72e0"

URI_x86_64_v2_libmount-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libmount-devel-2.40.2-16.el10_1.x86_64_v2.rpm;name=x86_64_v2_libmount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmount-devel}"
SRC_URI[x86_64_v2_libmount-devel.sha256sum] = "fc24b6f67809db1e6eb6accec6be4390f8da601d4fd6c56e08a4705f77dc5f1d"

URI_x86_64_v2_libsmartcols = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsmartcols-2.40.2-16.el10_1.x86_64_v2.rpm;name=x86_64_v2_libsmartcols;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmartcols}"
SRC_URI[x86_64_v2_libsmartcols.sha256sum] = "6b834e4b18f53980e59f43b0bb395d00e631650ae07205b0aae21eb0c7b7aa2e"

URI_x86_64_v2_libsmartcols-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsmartcols-devel-2.40.2-16.el10_1.x86_64_v2.rpm;name=x86_64_v2_libsmartcols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmartcols-devel}"
SRC_URI[x86_64_v2_libsmartcols-devel.sha256sum] = "39ef25e727292b6e7c784224bd120f389a5752e40b8d149f37be7051c3dd68f8"

URI_x86_64_v2_libuuid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libuuid-2.40.2-16.el10_1.x86_64_v2.rpm;name=x86_64_v2_libuuid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuuid}"
SRC_URI[x86_64_v2_libuuid.sha256sum] = "af52e7e6dacf62f942970d0d186db0407e83cd62b44122b96986e80187374528"

URI_x86_64_v2_libuuid-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libuuid-devel-2.40.2-16.el10_1.x86_64_v2.rpm;name=x86_64_v2_libuuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuuid-devel}"
SRC_URI[x86_64_v2_libuuid-devel.sha256sum] = "adab22ab646191f4418b669562b1745ce8034bdde2d453c618801a59a74ac0e5"

URI_x86_64_v2_python3-libmount = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libmount-2.40.2-16.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-libmount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libmount}"
SRC_URI[x86_64_v2_python3-libmount.sha256sum] = "861baee4325a16666785d74cd99282f4d2874c9ec7fe712b356e61462a710963"

URI_x86_64_v2_util-linux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/util-linux-2.40.2-16.el10_1.x86_64_v2.rpm;name=x86_64_v2_util-linux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_util-linux}"
SRC_URI[x86_64_v2_util-linux.sha256sum] = "b55ad4e12db2071ee88015180e7ee0f47347cd143b6fe481729473a150580d2a"
RPROVIDES:util-linux:append:x86_64_v2 = " virtual/util-linux-core_or_util-linux"

URI_x86_64_v2_util-linux-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/util-linux-core-2.40.2-16.el10_1.x86_64_v2.rpm;name=x86_64_v2_util-linux-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_util-linux-core}"
SRC_URI[x86_64_v2_util-linux-core.sha256sum] = "3e6c2d831735ae4f2e3c96b34a568b6ecd9ea93fce171e807c057add689d7b73"
RPROVIDES:util-linux-core:append:x86_64_v2 = " virtual/util-linux-core_or_util-linux"

URI_x86_64_v2_uuidd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/uuidd-2.40.2-16.el10_1.x86_64_v2.rpm;name=x86_64_v2_uuidd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uuidd}"
SRC_URI[x86_64_v2_uuidd.sha256sum] = "eb1a8f1c1cf4b14432cec526a060979ffef8d6ee5d2f1ece55a655c5ffae089e"

URI_aarch64_libblkid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libblkid-2.40.2-16.el10_1.aarch64.rpm;name=aarch64_libblkid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblkid}"
SRC_URI[aarch64_libblkid.sha256sum] = "96d2f9cdeef5ddffeeeb9f09572633afba260b6cb8e9ca7ef0636dff03cd0686"

URI_aarch64_libblkid-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblkid-devel-2.40.2-16.el10_1.aarch64.rpm;name=aarch64_libblkid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblkid-devel}"
SRC_URI[aarch64_libblkid-devel.sha256sum] = "e3a034f280acfed899b71e37c22204331b42c79eeb7f6ec4d97e8a12c1df4deb"

URI_aarch64_libfdisk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libfdisk-2.40.2-16.el10_1.aarch64.rpm;name=aarch64_libfdisk;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfdisk}"
SRC_URI[aarch64_libfdisk.sha256sum] = "e70bf50876f0ea6c1612e6bc9b3ea43fb630f35407415e880e14d8401e8c9ffb"

URI_aarch64_libfdisk-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfdisk-devel-2.40.2-16.el10_1.aarch64.rpm;name=aarch64_libfdisk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfdisk-devel}"
SRC_URI[aarch64_libfdisk-devel.sha256sum] = "32016e036e2e3b3d7ef1012c4b9a76afed61c28e5113bb2b436a3a3d87f334a5"

URI_aarch64_libmount = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libmount-2.40.2-16.el10_1.aarch64.rpm;name=aarch64_libmount;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmount}"
SRC_URI[aarch64_libmount.sha256sum] = "d958687fb1d4278396b09ae2d64dc6b8eb0e9981bbcdd60ffe5dde26aca8b8a8"

URI_aarch64_libmount-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libmount-devel-2.40.2-16.el10_1.aarch64.rpm;name=aarch64_libmount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmount-devel}"
SRC_URI[aarch64_libmount-devel.sha256sum] = "57e584499be1f78c565f901546fa6ddf348a49e70fbc81a038263e124c93c6b2"

URI_aarch64_libsmartcols = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsmartcols-2.40.2-16.el10_1.aarch64.rpm;name=aarch64_libsmartcols;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmartcols}"
SRC_URI[aarch64_libsmartcols.sha256sum] = "3760e42a3e09cacc8c8310fa10847a0acb96eebef57c1a2992f9a16b365c02f8"

URI_aarch64_libsmartcols-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsmartcols-devel-2.40.2-16.el10_1.aarch64.rpm;name=aarch64_libsmartcols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmartcols-devel}"
SRC_URI[aarch64_libsmartcols-devel.sha256sum] = "ba53d25e963d6c5535a716b9822c4c93eb995f34b147938ca6ea04e444dc5db3"

URI_aarch64_libuuid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libuuid-2.40.2-16.el10_1.aarch64.rpm;name=aarch64_libuuid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuuid}"
SRC_URI[aarch64_libuuid.sha256sum] = "2b886f0ce7c4defa267e645962e4f41f4b4383d000182f8f0e4784ea0aada73f"

URI_aarch64_libuuid-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libuuid-devel-2.40.2-16.el10_1.aarch64.rpm;name=aarch64_libuuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuuid-devel}"
SRC_URI[aarch64_libuuid-devel.sha256sum] = "b8eb9af0dc1fc2b79c5d5faca5c47f34dabd7d0cef8f0b141d8e39357c8fbf7c"

URI_aarch64_python3-libmount = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libmount-2.40.2-16.el10_1.aarch64.rpm;name=aarch64_python3-libmount;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libmount}"
SRC_URI[aarch64_python3-libmount.sha256sum] = "d8b87820f52fa99c99d508f46fcb83352962ee373df969496a70b412e78f4381"

URI_aarch64_util-linux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/util-linux-2.40.2-16.el10_1.aarch64.rpm;name=aarch64_util-linux;unpack=0"
SRC_URI:append = " ${URI_aarch64_util-linux}"
SRC_URI[aarch64_util-linux.sha256sum] = "521b2e9e71ad31062926bad2c02abaab844e3afbbfd96c27db26bf409a28bfec"
RPROVIDES:util-linux:append:aarch64 = " virtual/util-linux-core_or_util-linux"

URI_aarch64_util-linux-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/util-linux-core-2.40.2-16.el10_1.aarch64.rpm;name=aarch64_util-linux-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_util-linux-core}"
SRC_URI[aarch64_util-linux-core.sha256sum] = "43ebd81163110fa3eb84f0a8d08e642c74e9b28fdbd97d7bc68da3afd7f479b2"
RPROVIDES:util-linux-core:append:aarch64 = " virtual/util-linux-core_or_util-linux"

URI_aarch64_uuidd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/uuidd-2.40.2-16.el10_1.aarch64.rpm;name=aarch64_uuidd;unpack=0"
SRC_URI:append = " ${URI_aarch64_uuidd}"
SRC_URI[aarch64_uuidd.sha256sum] = "9c24f209f1612ff36108081451b9d54fa6bac5abb1b172b844947821e3e7602e"

RDEPENDS:libblkid = " \
 glibc \
 libuuid \
 "
RDEPENDS:libblkid-devel = " \
 libblkid \
 pkgconf-pkg-config \
 "
RDEPENDS:libfdisk = " \
 glibc \
 libblkid \
 libuuid \
 "
RDEPENDS:libfdisk-devel = " \
 libblkid-devel \
 libfdisk \
 libuuid-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libmount = " \
 glibc \
 libblkid \
 libselinux \
 libuuid \
 "
RDEPENDS:libmount-devel = " \
 libblkid-devel \
 libmount \
 libselinux-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libsmartcols = " \
 glibc \
 "
RDEPENDS:libsmartcols-devel = " \
 libsmartcols \
 pkgconf-pkg-config \
 "
RDEPENDS:libuuid = " \
 glibc \
 "
RDEPENDS:libuuid-devel = " \
 libuuid \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libmount = " \
 glibc \
 libblkid \
 libmount \
 libselinux \
 python3 \
 "
RDEPENDS:util-linux = " \
 audit-libs \
 authselect-libs \
 bash \
 glibc \
 libblkid \
 libcap-ng \
 libfdisk \
 libmount \
 libselinux \
 libsmartcols \
 libutempter \
 libuuid \
 ncurses-libs \
 pam \
 pam-libs \
 readline \
 systemd-libs \
 util-linux-core \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:util-linux-core = " \
 glibc \
 libblkid \
 libmount \
 libselinux \
 libsmartcols \
 libuuid \
 libxcrypt \
 ncurses-libs \
 systemd-libs \
 "
RDEPENDS:uuidd = " \
 bash \
 glibc \
 libuuid \
 shadow-utils \
 systemd-libs \
 "
