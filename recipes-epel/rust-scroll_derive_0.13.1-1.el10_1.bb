# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scroll_derive"
PV = "0.13.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-scroll_derive+default-devel \
 rust-scroll_derive-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-scroll_derive-0.13.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d41cc64431d559ec7e041d12f876916c1f57d2d97bf85244d3a385ed2f0d2d6c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll_derive+default-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll_derive+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-scroll_derive+default-devel.sha256sum] = "2071a7356a75dbc672b933e54126826cc3a6817f1891563ebafd36ae9c7ee9db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll_derive-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll_derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-scroll_derive-devel.sha256sum] = "7f04ab78ddc4fae79db0a1869176388de8b47a18e8ed456c5c51efbf23ab4470"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll_derive+default-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-scroll_derive+default-devel;unpack=0"
SRC_URI[aarch64_rust-scroll_derive+default-devel.sha256sum] = "74fe99ffaf4bf226ee96466cff4281a3b37961c8cd5a83f63934505eee940ec7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll_derive-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-scroll_derive-devel;unpack=0"
SRC_URI[aarch64_rust-scroll_derive-devel.sha256sum] = "0860e4061a989872f9ae33ac09ec1fbc7f9834f60315558421d3d2a3acb46a2a"

RDEPENDS:rust-scroll_derive+default-devel = " \
 cargo \
 rust-scroll_derive-devel \
 "
RDEPENDS:rust-scroll_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
