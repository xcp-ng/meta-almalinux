# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-char-range"
PV = "0.9.0"
PR = "17.el10_0"
PACKAGES = " \
 rust-unic-char-range+default-devel \
 rust-unic-char-range+exact-size-is-empty-devel \
 rust-unic-char-range+fused-devel \
 rust-unic-char-range+rayon-devel \
 rust-unic-char-range+std-devel \
 rust-unic-char-range+trusted-len-devel \
 rust-unic-char-range+unstable-devel \
 rust-unic-char-range-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-char-range-0.9.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f818261850fadf2a3f541953b0d1cc621cf0cb949fd6336486863ef3ea8bb666"

URI_x86_64_v2_rust-unic-char-range+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-char-range+default-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-char-range+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-char-range+default-devel}"
SRC_URI[x86_64_v2_rust-unic-char-range+default-devel.sha256sum] = "b9760c0f74438453161b47910620e24e8510d92b5e2a801bbd1826c4a4523878"

URI_x86_64_v2_rust-unic-char-range+exact-size-is-empty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-char-range+exact-size-is-empty-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-char-range+exact-size-is-empty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-char-range+exact-size-is-empty-devel}"
SRC_URI[x86_64_v2_rust-unic-char-range+exact-size-is-empty-devel.sha256sum] = "4e7300196b5e03b12951ad13f3cd37e60face21170f1920c62522b19551c5081"

URI_x86_64_v2_rust-unic-char-range+fused-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-char-range+fused-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-char-range+fused-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-char-range+fused-devel}"
SRC_URI[x86_64_v2_rust-unic-char-range+fused-devel.sha256sum] = "75a7349dfd4122b1e00338c1bc5e9031b8907adab4fcbb3301f9c92585dd4a78"

URI_x86_64_v2_rust-unic-char-range+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-char-range+rayon-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-char-range+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-char-range+rayon-devel}"
SRC_URI[x86_64_v2_rust-unic-char-range+rayon-devel.sha256sum] = "c30fb19bc76f982a1e9cbed34884c4d2c5e4a729e709e628c68d65f9e3fff941"

URI_x86_64_v2_rust-unic-char-range+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-char-range+std-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-char-range+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-char-range+std-devel}"
SRC_URI[x86_64_v2_rust-unic-char-range+std-devel.sha256sum] = "bbf1a4154d69a16fcae3ab4a0787205d57a7916a337353d2003bd86ee0df96a0"

URI_x86_64_v2_rust-unic-char-range+trusted-len-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-char-range+trusted-len-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-char-range+trusted-len-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-char-range+trusted-len-devel}"
SRC_URI[x86_64_v2_rust-unic-char-range+trusted-len-devel.sha256sum] = "280cfbe9521c6b1dafac1a3ac50c01803abe53d997d4d7b5b90557938bec8bdc"

URI_x86_64_v2_rust-unic-char-range+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-char-range+unstable-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-char-range+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-char-range+unstable-devel}"
SRC_URI[x86_64_v2_rust-unic-char-range+unstable-devel.sha256sum] = "a01c7ab3ca260b7f89caa78d5a99b000066f57df4a71d67e9d6f6b758a00830f"

URI_x86_64_v2_rust-unic-char-range-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-char-range-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-char-range-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-char-range-devel}"
SRC_URI[x86_64_v2_rust-unic-char-range-devel.sha256sum] = "34fc7ffd42a921bc50fad99ded16651868e1c821fe6ccbd014dcd7a42db5067a"

URI_aarch64_rust-unic-char-range+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-char-range+default-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-char-range+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-char-range+default-devel}"
SRC_URI[aarch64_rust-unic-char-range+default-devel.sha256sum] = "b302aa2dcfff62c2e8c5f92020d1eec359dc765798039c339c1c1674495f6735"

URI_aarch64_rust-unic-char-range+exact-size-is-empty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-char-range+exact-size-is-empty-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-char-range+exact-size-is-empty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-char-range+exact-size-is-empty-devel}"
SRC_URI[aarch64_rust-unic-char-range+exact-size-is-empty-devel.sha256sum] = "38efaa476506344871957aa2454fc8e25276f86880d98cb5268c405e65da5619"

URI_aarch64_rust-unic-char-range+fused-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-char-range+fused-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-char-range+fused-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-char-range+fused-devel}"
SRC_URI[aarch64_rust-unic-char-range+fused-devel.sha256sum] = "6615d7c655423d8d5c5843fce042f566fef206b7dee3c56643ccaa3db0f834b1"

URI_aarch64_rust-unic-char-range+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-char-range+rayon-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-char-range+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-char-range+rayon-devel}"
SRC_URI[aarch64_rust-unic-char-range+rayon-devel.sha256sum] = "c01869ade661c8d4e3301d5d2e71ef4c4d56cd6d0218ce589119cf6f73175f90"

URI_aarch64_rust-unic-char-range+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-char-range+std-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-char-range+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-char-range+std-devel}"
SRC_URI[aarch64_rust-unic-char-range+std-devel.sha256sum] = "efdc4a2b18f7da89c9e1281bc36424991d2b0f16273c59a953edc71140032854"

URI_aarch64_rust-unic-char-range+trusted-len-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-char-range+trusted-len-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-char-range+trusted-len-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-char-range+trusted-len-devel}"
SRC_URI[aarch64_rust-unic-char-range+trusted-len-devel.sha256sum] = "404a757d63c0632da192b54b0a23fbf036dbe29f715b7e18d45cf94a51e06991"

URI_aarch64_rust-unic-char-range+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-char-range+unstable-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-char-range+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-char-range+unstable-devel}"
SRC_URI[aarch64_rust-unic-char-range+unstable-devel.sha256sum] = "d6ed75359d666c796aa4d3f242d0833b10ddf793021db08a8562eea845052b8d"

URI_aarch64_rust-unic-char-range-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-char-range-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-char-range-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-char-range-devel}"
SRC_URI[aarch64_rust-unic-char-range-devel.sha256sum] = "817db4bf9461d86a03eb11fc3e03efc31582aed917d299b4b186a89fedba4e17"

RDEPENDS:rust-unic-char-range+default-devel = " \
 cargo \
 rust-unic-char-range-devel \
 "
RDEPENDS:rust-unic-char-range+exact-size-is-empty-devel = " \
 cargo \
 rust-unic-char-range-devel \
 "
RDEPENDS:rust-unic-char-range+fused-devel = " \
 cargo \
 rust-unic-char-range-devel \
 "
RDEPENDS:rust-unic-char-range+rayon-devel = " \
 cargo \
 rust-rayon+default-devel \
 rust-unic-char-range-devel \
 "
RDEPENDS:rust-unic-char-range+std-devel = " \
 cargo \
 rust-unic-char-range-devel \
 "
RDEPENDS:rust-unic-char-range+trusted-len-devel = " \
 cargo \
 rust-unic-char-range-devel \
 "
RDEPENDS:rust-unic-char-range+unstable-devel = " \
 cargo \
 rust-unic-char-range+exact-size-is-empty-devel \
 rust-unic-char-range+fused-devel \
 rust-unic-char-range+trusted-len-devel \
 rust-unic-char-range-devel \
 "
RDEPENDS:rust-unic-char-range-devel = " \
 cargo \
 "
