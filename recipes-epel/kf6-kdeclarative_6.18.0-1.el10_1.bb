# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdeclarative"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kdeclarative \
 kf6-kdeclarative-devel \
 kf6-kdeclarative-doc \
 kf6-kdeclarative-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdeclarative-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc14afc326001f8259f717d1a6b22cc4c4a1059fd1f9c64db4acf5e8de9ee0db"

URI_x86_64_v2_kf6-kdeclarative = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdeclarative;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative}"
SRC_URI[x86_64_v2_kf6-kdeclarative.sha256sum] = "5116677cf94be90ed7609f1f9d786b2c2d50397d669ab09757dc05bcd95a7b33"

URI_x86_64_v2_kf6-kdeclarative-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative-devel}"
SRC_URI[x86_64_v2_kf6-kdeclarative-devel.sha256sum] = "4963e71295928053354ade47fa950840158481db12af20a58c66f244327cfec5"

URI_x86_64_v2_kf6-kdeclarative-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdeclarative-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative-doc}"
SRC_URI[x86_64_v2_kf6-kdeclarative-doc.sha256sum] = "a35427e585ee0e9c29b52cf4aa5733c9f6157741c8f8edf60dba2e91e4aa1b0b"

URI_x86_64_v2_kf6-kdeclarative-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdeclarative-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative-html}"
SRC_URI[x86_64_v2_kf6-kdeclarative-html.sha256sum] = "9f1783d70da599533828c8fa2a2f560225ae9709afae7b71829498d23eadd45c"

URI_aarch64_kf6-kdeclarative = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kdeclarative;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative}"
SRC_URI[aarch64_kf6-kdeclarative.sha256sum] = "9260328004a93798ee171041aa624d1804877d778a8e16f7ba63c86436e39aa1"

URI_aarch64_kf6-kdeclarative-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative-devel}"
SRC_URI[aarch64_kf6-kdeclarative-devel.sha256sum] = "645df604b7a861051bd118d554a8d94f1c1e0b3f2cfdb9c5d2718aea2ffdc047"

URI_aarch64_kf6-kdeclarative-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kdeclarative-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative-doc}"
SRC_URI[aarch64_kf6-kdeclarative-doc.sha256sum] = "58a7b0a32954dce711616717ebac6af2db524612e5fc9ecfa5767bec2289dc7e"

URI_aarch64_kf6-kdeclarative-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kdeclarative-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative-html}"
SRC_URI[aarch64_kf6-kdeclarative-html.sha256sum] = "7bcee3716a79459571f3d4edc5e558d2f26c59ae17081e78f21e0848cffabf86"

RDEPENDS:kf6-kdeclarative = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kdeclarative-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kdeclarative \
 kf6-kpackage-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kdeclarative-doc = " \
 "
RDEPENDS:kf6-kdeclarative-html = " \
 "
