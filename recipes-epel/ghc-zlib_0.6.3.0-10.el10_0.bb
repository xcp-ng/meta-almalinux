# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-zlib"
PV = "0.6.3.0"
PR = "10.el10_0"
PACKAGES = " \
 ghc-zlib \
 ghc-zlib-devel \
 ghc-zlib-doc \
 ghc-zlib-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-zlib-0.6.3.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97dd41aa2a6c9d90648d5171de5254d57c6f4ccbd664843d538dd13d109b52db"

URI_x86_64_v2_ghc-zlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-zlib-0.6.3.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-zlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-zlib}"
SRC_URI[x86_64_v2_ghc-zlib.sha256sum] = "4eb287e07f1ec22cb1318bcdf332f2a16e250e52ba00c6ae9b1a6d382cb53e34"

URI_x86_64_v2_ghc-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-zlib-devel-0.6.3.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-zlib-devel}"
SRC_URI[x86_64_v2_ghc-zlib-devel.sha256sum] = "f7ba57dc93e311ef85beac07659cd1d686e2664ecf87cb6ecb5effa2c3cb8151"

URI_x86_64_v2_ghc-zlib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-zlib-doc-0.6.3.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-zlib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-zlib-doc}"
SRC_URI[x86_64_v2_ghc-zlib-doc.sha256sum] = "a4b3192d173d0f7cd6a9c1ae33855aee6ed9434ceee0ab8b4890c8c73e8f40cc"

URI_x86_64_v2_ghc-zlib-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-zlib-prof-0.6.3.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-zlib-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-zlib-prof}"
SRC_URI[x86_64_v2_ghc-zlib-prof.sha256sum] = "1a6d17d2c6a896ac36496a2af4ac6918caefa25dbc2bdc48b450c635083d0d44"

URI_aarch64_ghc-zlib = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-zlib-0.6.3.0-10.el10_0.aarch64.rpm;name=aarch64_ghc-zlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-zlib}"
SRC_URI[aarch64_ghc-zlib.sha256sum] = "4ff97d74db925f277aae5563de06f1585c3643593b58dbc7132a7e294a80e4f5"

URI_aarch64_ghc-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-zlib-devel-0.6.3.0-10.el10_0.aarch64.rpm;name=aarch64_ghc-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-zlib-devel}"
SRC_URI[aarch64_ghc-zlib-devel.sha256sum] = "2c8b278d45d6d37f9902d59ba1cd6e9f249f086ae84ef0d00357191add978b80"

URI_aarch64_ghc-zlib-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-zlib-doc-0.6.3.0-10.el10_0.noarch.rpm;name=aarch64_ghc-zlib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-zlib-doc}"
SRC_URI[aarch64_ghc-zlib-doc.sha256sum] = "ebc07cc7d0d5aa1b3076259e067ff6c9b2f98bfbf1f26d8dd235c736d748038f"

URI_aarch64_ghc-zlib-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-zlib-prof-0.6.3.0-10.el10_0.aarch64.rpm;name=aarch64_ghc-zlib-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-zlib-prof}"
SRC_URI[aarch64_ghc-zlib-prof.sha256sum] = "944325053c781a44bd9b283a59f555b677e5f647625b06bad06c4ae3f409f86f"

RDEPENDS:ghc-zlib = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-zlib-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-zlib \
 zlib-ng-compat-devel \
 "
RDEPENDS:ghc-zlib-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-zlib-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-zlib-devel \
 "
