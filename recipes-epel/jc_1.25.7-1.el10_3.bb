# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jc"
PV = "1.25.7"
PR = "1.el10_3"
PACKAGES = " \
 jc \
 python3-jc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jc-1.25.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4c173d1e0ad53bd33a6b09b4b05500bda03eb6464237e0332c4f49c5dcffa50"

URI_x86_64_v2_jc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jc-1.25.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_jc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jc}"
SRC_URI[x86_64_v2_jc.sha256sum] = "9733e65909a3adab289bb31dcff08c27538126cdbc5c9f671d4a93c2531b501f"

URI_x86_64_v2_python3-jc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jc-1.25.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jc}"
SRC_URI[x86_64_v2_python3-jc.sha256sum] = "83012f520f1366268a544f4167d64c1d515c678bb38a894d06482858358c7474"

URI_aarch64_jc = "${EPEL_MIRROR}/aarch64/Packages/j/jc-1.25.7-1.el10_3.noarch.rpm;name=aarch64_jc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jc}"
SRC_URI[aarch64_jc.sha256sum] = "5612d40a41ed308fff5196e9ed7958731e643ae1f7e08508124256f2c6f5f127"

URI_aarch64_python3-jc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jc-1.25.7-1.el10_3.noarch.rpm;name=aarch64_python3-jc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jc}"
SRC_URI[aarch64_python3-jc.sha256sum] = "e8b6e8f5e4be611913e19fe92b18a79a27047b9e85cecc1d35f2009dc2227ad8"

RDEPENDS:jc = " \
 python3 \
 python3-jc \
 "
RDEPENDS:python3-jc = " \
 python3 \
 python3-pygments \
 python3-ruamel-yaml \
 python3-xmltodict \
 "
