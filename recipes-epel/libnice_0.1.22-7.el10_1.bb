# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnice"
PV = "0.1.22"
PR = "7.el10_1"
PACKAGES = " \
 libnice \
 libnice-devel \
 libnice-gstreamer1 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libnice-0.1.22-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c90f628c56266d5c8d425764dd520a4d6b593a911c9e5fd39a73f9b2adfbf8d6"

URI_x86_64_v2_libnice = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnice-0.1.22-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnice;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnice}"
SRC_URI[x86_64_v2_libnice.sha256sum] = "9de86f273ba240f790e21589d47078786db71b8212755de4f525e6650d871359"

URI_x86_64_v2_libnice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnice-devel-0.1.22-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnice-devel}"
SRC_URI[x86_64_v2_libnice-devel.sha256sum] = "fcffce303a449b3a349250a45269fa5d3f6b8dcfe45f4360bbd78085b01705ea"

URI_x86_64_v2_libnice-gstreamer1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnice-gstreamer1-0.1.22-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnice-gstreamer1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnice-gstreamer1}"
SRC_URI[x86_64_v2_libnice-gstreamer1.sha256sum] = "1ddb5077ce634fbcd05ce4c43c5c08238d3f7b0a74842775ee32c3938f6bffdd"

URI_aarch64_libnice = "${EPEL_MIRROR}/aarch64/Packages/l/libnice-0.1.22-7.el10_1.aarch64.rpm;name=aarch64_libnice;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnice}"
SRC_URI[aarch64_libnice.sha256sum] = "a08bb1365bdaf4b5a80486728b93a6542f6e52b2ebd1966acf2c5e4911381bd7"

URI_aarch64_libnice-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libnice-devel-0.1.22-7.el10_1.aarch64.rpm;name=aarch64_libnice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnice-devel}"
SRC_URI[aarch64_libnice-devel.sha256sum] = "0e892deee1cc1f62945b13bafa23a9d2e509e735170ef557c9dc5f707a9b30fb"

URI_aarch64_libnice-gstreamer1 = "${EPEL_MIRROR}/aarch64/Packages/l/libnice-gstreamer1-0.1.22-7.el10_1.aarch64.rpm;name=aarch64_libnice-gstreamer1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnice-gstreamer1}"
SRC_URI[aarch64_libnice-gstreamer1.sha256sum] = "227ac31b90ca70c3524e983d73670ca946ed2bab570cf1e0f6a874220d37240c"

RDEPENDS:libnice = " \
 glib2 \
 glibc \
 gnutls \
 gupnp-igd \
 "
RDEPENDS:libnice-devel = " \
 glib2-devel \
 gnutls-devel \
 gupnp-igd-devel \
 libnice \
 pkgconf-pkg-config \
 "
RDEPENDS:libnice-gstreamer1 = " \
 glib2 \
 glibc \
 gstreamer1 \
 libnice \
 "
