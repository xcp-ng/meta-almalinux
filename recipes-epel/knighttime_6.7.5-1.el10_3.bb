# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knighttime"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 knighttime \
 knighttime-devel \
 knighttime-doc \
 knighttime-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/knighttime-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "afdbeb017702414a50ab05fe831e8560f2f4267abfd5289917032bffe9b1dd73"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knighttime-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knighttime;unpack=0"
SRC_URI[x86_64_v2_knighttime.sha256sum] = "94efaa75c3e9bb7c074ad96e158adeacba1aefa96e795701db9d7e375f655d16"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knighttime-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knighttime-devel;unpack=0"
SRC_URI[x86_64_v2_knighttime-devel.sha256sum] = "fe161db54233dabf893726694b7c78261c7887dd5c18d78afe507bd862b14aa6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knighttime-doc-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_knighttime-doc;unpack=0"
SRC_URI[x86_64_v2_knighttime-doc.sha256sum] = "62aa8d5d9195963af906d76947566f07cb856b3e60febdf390254ae25eaff4b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knighttime-html-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_knighttime-html;unpack=0"
SRC_URI[x86_64_v2_knighttime-html.sha256sum] = "a0200a827f523ca14de987c8e9a0ac3be58ff3abfdd9a28218ed82eb2d044b6d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/knighttime-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_knighttime;unpack=0"
SRC_URI[aarch64_knighttime.sha256sum] = "459decd4572b82825ada5d8e7ce9217349f2421c219e1faeb204d70e28456e44"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/knighttime-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_knighttime-devel;unpack=0"
SRC_URI[aarch64_knighttime-devel.sha256sum] = "26b944f28c450dce6190feec8589a94d10e3b36b30f9a613122c2c14f225ce44"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/knighttime-doc-6.7.5-1.el10_3.noarch.rpm;name=aarch64_knighttime-doc;unpack=0"
SRC_URI[aarch64_knighttime-doc.sha256sum] = "cb64aaf64b1b212e13c5f3de92974a9155682af495e3f79e7a1c33c3c4eda518"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/knighttime-html-6.7.5-1.el10_3.noarch.rpm;name=aarch64_knighttime-html;unpack=0"
SRC_URI[aarch64_knighttime-html.sha256sum] = "f30a2882c20fc8fdb23e63a03bacd53edd16e16e13c992042b15cccf235fac12"

RDEPENDS:knighttime = " \
 bash \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kholidays \
 libstdc++ \
 qt6-qtbase \
 qt6-qtpositioning \
 "
RDEPENDS:knighttime-devel = " \
 cmake-filesystem \
 knighttime \
 "
RDEPENDS:knighttime-doc = " \
 "
RDEPENDS:knighttime-html = " \
 "
