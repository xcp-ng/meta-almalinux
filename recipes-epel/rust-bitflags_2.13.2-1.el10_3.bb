# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitflags"
PV = "2.13.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-bitflags+arbitrary-devel \
 rust-bitflags+bytemuck-devel \
 rust-bitflags+default-devel \
 rust-bitflags+example_generated-devel \
 rust-bitflags+serde-devel \
 rust-bitflags+serde_core-devel \
 rust-bitflags+std-devel \
 rust-bitflags-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-bitflags-2.13.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "61eb7a659ffc8331155106c6f3019e22549f2de3965706b2f261f48826acdedb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+arbitrary-devel-2.13.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags+arbitrary-devel.sha256sum] = "100a5c8e38aa36d0b634395ceaec9d04f6b5164771385d2fe7bec99e86014060"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+bytemuck-devel-2.13.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+bytemuck-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags+bytemuck-devel.sha256sum] = "da66112501f8d9afc1f7a4bd8fdddd41ea3ec3a4467748d88a71151acc8a0c7f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+default-devel-2.13.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags+default-devel.sha256sum] = "7edf7e6c7454ed3156903513b98f3c829d1df7642601cf7a531eedf47779809b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+example_generated-devel-2.13.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+example_generated-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags+example_generated-devel.sha256sum] = "e3b9434ed6c0ac79d51c9f1784553825244ca7b3097855db5e528ed57814e761"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+serde-devel-2.13.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags+serde-devel.sha256sum] = "b3bec0f35a9b765c736e1082b3c04863f36deebc5a56e6f8b7649d74833e1470"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+serde_core-devel-2.13.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+serde_core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags+serde_core-devel.sha256sum] = "6bebdc69cb5741237a1d2d11e9df0da95fa033ccaeae8fb74f358631d4bd2d69"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+std-devel-2.13.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags+std-devel.sha256sum] = "79d277ec856ea4138da3393ff07b01b6fe62b78886ae4afa73bd035f4aa07452"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags-devel-2.13.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags-devel.sha256sum] = "f61b1ed613223e32b3ee9c2ce261db1c04f8b1b814f2c084135b79881bc970fc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+arbitrary-devel-2.13.2-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags+arbitrary-devel.sha256sum] = "5392dd115575dfbf8535e8a6574486c1e8a6f3e17c49219975aeb316a7b20693"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+bytemuck-devel-2.13.2-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags+bytemuck-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags+bytemuck-devel.sha256sum] = "0d74e1997c4a79697b08b5084fae2ccb8b644b4d9e898f3d261416cc6e24beb0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+default-devel-2.13.2-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags+default-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags+default-devel.sha256sum] = "aeaf9032823d00a25c6bf966d052d6be405ac64da5b55dbc76180e9b3c8fffcf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+example_generated-devel-2.13.2-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags+example_generated-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags+example_generated-devel.sha256sum] = "39fe73c1aad0f7f3d3702bd5a931f46246159bf1c37223d15563a6b6bd446136"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+serde-devel-2.13.2-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags+serde-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags+serde-devel.sha256sum] = "e2aba4ec7b0ee46d9f43191960c3f197bfc2b8a6f4c6263df2f33e2db65f2d42"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+serde_core-devel-2.13.2-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags+serde_core-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags+serde_core-devel.sha256sum] = "d1508ef6a686a83c140eaefc167e2752b7c9f607e795b1c3f1c04f494ab5691e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+std-devel-2.13.2-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags+std-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags+std-devel.sha256sum] = "406841ad8c614c739bfc49c1196446d994dfb13f9f399429939b3c79d780d2b1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags-devel-2.13.2-1.el10_3.noarch.rpm;name=aarch64_rust-bitflags-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags-devel.sha256sum] = "f32a40a270b1535bc80a324172fc78f5bc0bcdabacbef607ecff7f262c099b7f"

RDEPENDS:rust-bitflags+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+bytemuck-devel = " \
 cargo \
 rust-bitflags-devel \
 rust-bytemuck+default-devel \
 "
RDEPENDS:rust-bitflags+default-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+example_generated-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+serde-devel = " \
 cargo \
 rust-bitflags+serde_core-devel \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+serde_core-devel = " \
 cargo \
 rust-bitflags-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bitflags+std-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags-devel = " \
 cargo \
 rust \
 "
