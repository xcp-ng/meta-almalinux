# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xrootd-s3-http"
PV = "0.5.3"
PR = "1.el10_0"
PACKAGES = " \
 xrootd-s3-http \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xrootd-s3-http-0.5.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0c34c19f0300a2f49910ff384b51697892a2369c5aea247aa67dd3312273008"

URI_x86_64_v2_xrootd-s3-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-s3-http-0.5.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-s3-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-s3-http}"
SRC_URI[x86_64_v2_xrootd-s3-http.sha256sum] = "8d3ed5278490296065cc8e5af3e4d8e96a5a7206e6d112b4a60c99c1215f8963"

URI_aarch64_xrootd-s3-http = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-s3-http-0.5.3-1.el10_0.aarch64.rpm;name=aarch64_xrootd-s3-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-s3-http}"
SRC_URI[aarch64_xrootd-s3-http.sha256sum] = "9594039eaa2de67eb4991d80647ea54850c810ff0febbb3c1441b23d7e313267"

RDEPENDS:xrootd-s3-http = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 tinyxml2 \
 virtual/libcurl.so.4___64bit_ \
 xrootd-libs \
 xrootd-server \
 xrootd-server-libs \
 "
