# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-LWP-UserAgent-Determined"
PV = "1.07"
PR = "31.el10_0"
PACKAGES = " \
 perl-LWP-UserAgent-Determined \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-LWP-UserAgent-Determined-1.07-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "058dca87785daac9b89409e14e538a92e4d0246a1266215c68047494aa897043"

URI_x86_64_v2_perl-LWP-UserAgent-Determined = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-LWP-UserAgent-Determined-1.07-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-LWP-UserAgent-Determined;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-LWP-UserAgent-Determined}"
SRC_URI[x86_64_v2_perl-LWP-UserAgent-Determined.sha256sum] = "f89dc69ec65c339d4a454e1223d6c9e3a5fea1e551b0504e86d73de6513e67ab"

URI_aarch64_perl-LWP-UserAgent-Determined = "${EPEL_MIRROR}/aarch64/Packages/p/perl-LWP-UserAgent-Determined-1.07-31.el10_0.noarch.rpm;name=aarch64_perl-LWP-UserAgent-Determined;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-LWP-UserAgent-Determined}"
SRC_URI[aarch64_perl-LWP-UserAgent-Determined.sha256sum] = "d89e03fb1535a0090c48a6f524ef72ce76506854ee6399dd707529c3f4ba6722"

RDEPENDS:perl-LWP-UserAgent-Determined = " \
 perl-libs \
 perl-libwww-perl \
 "
