# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-dependency-tree"
PV = "3.2.1"
PR = "7.el10"
PACKAGES = " \
 maven-dependency-tree \
 maven-dependency-tree-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/maven-dependency-tree-3.2.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fc17f3e7f2df5e4e0e876972f0ea1490d47598edb62108dcccbc1c1f246b13a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-dependency-tree-3.2.1-7.el10.noarch.rpm;name=x86_64_v2_maven-dependency-tree;unpack=0"
SRC_URI[x86_64_v2_maven-dependency-tree.sha256sum] = "6d1f9745dafe4ec2d8ba94b91d98f78dbd1ec2a14a1624375ebfb471c5157d4a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-dependency-tree-javadoc-3.2.1-7.el10.noarch.rpm;name=x86_64_v2_maven-dependency-tree-javadoc;unpack=0"
SRC_URI[x86_64_v2_maven-dependency-tree-javadoc.sha256sum] = "9403d23d064145d9b6f68120e7527b8396e219fd91039e89f1636fbc7b765580"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-dependency-tree-3.2.1-7.el10.noarch.rpm;name=aarch64_maven-dependency-tree;unpack=0"
SRC_URI[aarch64_maven-dependency-tree.sha256sum] = "6d1f9745dafe4ec2d8ba94b91d98f78dbd1ec2a14a1624375ebfb471c5157d4a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-dependency-tree-javadoc-3.2.1-7.el10.noarch.rpm;name=aarch64_maven-dependency-tree-javadoc;unpack=0"
SRC_URI[aarch64_maven-dependency-tree-javadoc.sha256sum] = "9403d23d064145d9b6f68120e7527b8396e219fd91039e89f1636fbc7b765580"

RDEPENDS:maven-dependency-tree = " \
 javapackages-filesystem \
 maven-resolver \
 slf4j \
 "
RDEPENDS:maven-dependency-tree-javadoc = " \
 javapackages-filesystem \
 "
