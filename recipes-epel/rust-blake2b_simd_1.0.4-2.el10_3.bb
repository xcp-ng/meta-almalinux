# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blake2b_simd"
PV = "1.0.4"
PR = "2.el10_3"
PACKAGES = " \
 rust-blake2b_simd+default-devel \
 rust-blake2b_simd+std-devel \
 rust-blake2b_simd+uninline_portable-devel \
 rust-blake2b_simd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blake2b_simd-1.0.4-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dabbc749c4d6940e24062397878e7c6603957beff66ff2a94134da44813b9e4f"

URI_x86_64_v2_rust-blake2b_simd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2b_simd+default-devel-1.0.4-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2b_simd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2b_simd+default-devel}"
SRC_URI[x86_64_v2_rust-blake2b_simd+default-devel.sha256sum] = "6e0324b3319a17243fbabc043502d0d0e98337a0eda61432c0b9007c4f050efd"

URI_x86_64_v2_rust-blake2b_simd+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2b_simd+std-devel-1.0.4-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2b_simd+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2b_simd+std-devel}"
SRC_URI[x86_64_v2_rust-blake2b_simd+std-devel.sha256sum] = "21c38d396a2c175e0d02cb9298b7190032ccdb382c85b57985acba10bd729e32"

URI_x86_64_v2_rust-blake2b_simd+uninline_portable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2b_simd+uninline_portable-devel-1.0.4-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2b_simd+uninline_portable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2b_simd+uninline_portable-devel}"
SRC_URI[x86_64_v2_rust-blake2b_simd+uninline_portable-devel.sha256sum] = "8af7ebdd98cefc8eefefa6d20a8a473308a44d8d4a0bed9c1055ef5f604eede5"

URI_x86_64_v2_rust-blake2b_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2b_simd-devel-1.0.4-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2b_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2b_simd-devel}"
SRC_URI[x86_64_v2_rust-blake2b_simd-devel.sha256sum] = "02aa645e0189bef617a65213c1ac185a46f393b0d0f7db5cc57206e94d1dd910"

URI_aarch64_rust-blake2b_simd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2b_simd+default-devel-1.0.4-2.el10_3.noarch.rpm;name=aarch64_rust-blake2b_simd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2b_simd+default-devel}"
SRC_URI[aarch64_rust-blake2b_simd+default-devel.sha256sum] = "aa7b855638299fb7069d5ec3e1789669317a35cdb93f0d6cfd9c076a9a5c0925"

URI_aarch64_rust-blake2b_simd+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2b_simd+std-devel-1.0.4-2.el10_3.noarch.rpm;name=aarch64_rust-blake2b_simd+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2b_simd+std-devel}"
SRC_URI[aarch64_rust-blake2b_simd+std-devel.sha256sum] = "63bbc3a25cf16b58e5cb1e4c8e3bbdb6d8326058e061a4493e689da16360ab71"

URI_aarch64_rust-blake2b_simd+uninline_portable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2b_simd+uninline_portable-devel-1.0.4-2.el10_3.noarch.rpm;name=aarch64_rust-blake2b_simd+uninline_portable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2b_simd+uninline_portable-devel}"
SRC_URI[aarch64_rust-blake2b_simd+uninline_portable-devel.sha256sum] = "fb9fa08487a25fff9dd7349aeac360f02d31bb6152e71a15663e77fb7a9d35e4"

URI_aarch64_rust-blake2b_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2b_simd-devel-1.0.4-2.el10_3.noarch.rpm;name=aarch64_rust-blake2b_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2b_simd-devel}"
SRC_URI[aarch64_rust-blake2b_simd-devel.sha256sum] = "a328c64fad648471086a7b9c45c3b74b10bdb00bb6384744078b35e4f34d5916"

RDEPENDS:rust-blake2b_simd+default-devel = " \
 cargo \
 rust-blake2b_simd+std-devel \
 rust-blake2b_simd-devel \
 "
RDEPENDS:rust-blake2b_simd+std-devel = " \
 cargo \
 rust-blake2b_simd-devel \
 rust-constant_time_eq+std-devel \
 "
RDEPENDS:rust-blake2b_simd+uninline_portable-devel = " \
 cargo \
 rust-blake2b_simd-devel \
 "
RDEPENDS:rust-blake2b_simd-devel = " \
 cargo \
 rust-arrayref+default-devel \
 rust-arrayvec-devel \
 rust-constant_time_eq-devel \
 "
