# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_false"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_false+default-devel \
 rust-uu_false-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_false-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "647e8e7735d77a91fc35236e6c431391850deca552ecc46f594c5b3554dca8e4"

URI_x86_64_v2_rust-uu_false+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_false+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_false+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_false+default-devel}"
SRC_URI[x86_64_v2_rust-uu_false+default-devel.sha256sum] = "5f4883afd3375bdff09782ccf19af837e29642d2e9bb51ed92a26a992979e65a"

URI_x86_64_v2_rust-uu_false-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_false-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_false-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_false-devel}"
SRC_URI[x86_64_v2_rust-uu_false-devel.sha256sum] = "3956516b353112e4d0e25826a836a99fbbe87e3e3aa5836f2ad56054cff96cc2"

URI_aarch64_rust-uu_false+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_false+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_false+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_false+default-devel}"
SRC_URI[aarch64_rust-uu_false+default-devel.sha256sum] = "bc22a896a979608f121f61fe7005765e534cee576dc34f8e042bbcaab16b683e"

URI_aarch64_rust-uu_false-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_false-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_false-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_false-devel}"
SRC_URI[aarch64_rust-uu_false-devel.sha256sum] = "3f1d5115b3774adc158ca6e74cd06b855f50e7530b74564ee726aec1c3c1d723"

RDEPENDS:rust-uu_false+default-devel = " \
 cargo \
 rust-uu_false-devel \
 "
RDEPENDS:rust-uu_false-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 "
