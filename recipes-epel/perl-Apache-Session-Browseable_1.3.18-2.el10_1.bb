# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Apache-Session-Browseable"
PV = "1.3.18"
PR = "2.el10_1"
PACKAGES = " \
 perl-Apache-Session-Browseable \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Apache-Session-Browseable-1.3.18-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1cd2bd7aa0c0ff4ffa9624913fc709c94b81327ffce26850d65d1cbb1bcfe75d"

URI_x86_64_v2_perl-Apache-Session-Browseable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Apache-Session-Browseable-1.3.18-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Apache-Session-Browseable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Apache-Session-Browseable}"
SRC_URI[x86_64_v2_perl-Apache-Session-Browseable.sha256sum] = "c6f6552714bb895080af313da1bb87c3a8d01215ec8258302ef78f8f85b6ccb7"

URI_aarch64_perl-Apache-Session-Browseable = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Apache-Session-Browseable-1.3.18-2.el10_1.noarch.rpm;name=aarch64_perl-Apache-Session-Browseable;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Apache-Session-Browseable}"
SRC_URI[aarch64_perl-Apache-Session-Browseable.sha256sum] = "ebc62ef430da4f749bf0bd331032605a284612fdd8d4e7cfc36dd3cedff70265"

RDEPENDS:perl-Apache-Session-Browseable = " \
 perl-Apache-Session \
 perl-Apache-Session-Browseable \
 perl-AutoLoader \
 perl-DBI \
 perl-Digest-SHA \
 perl-JSON \
 perl-LDAP \
 perl-MIME-Base64 \
 perl-Redis \
 perl-Storable \
 perl-constant \
 perl-libs \
 perl-vars \
 "
