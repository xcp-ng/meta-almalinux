# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libportal"
PV = "0.9.0"
PR = "2.el10"
PACKAGES = " \
 libportal \
 libportal-devel \
 libportal-devel-doc \
 libportal-gtk3 \
 libportal-gtk3-devel \
 libportal-gtk4 \
 libportal-gtk4-devel \
 libportal-qt6 \
 libportal-qt6-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libportal-0.9.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a8474c880896713127bbd7006af662366e4481fdc6e3a95798e63ac46ded800"

URI_x86_64_v2_libportal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libportal-0.9.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libportal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal}"
SRC_URI[x86_64_v2_libportal.sha256sum] = "3a85fc6bf63842a765aee897e24c4161a1d2ab56e0fc17236be70188f3d9da44"

URI_x86_64_v2_libportal-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libportal-devel-0.9.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libportal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-devel}"
SRC_URI[x86_64_v2_libportal-devel.sha256sum] = "809b80bf2f189719cea91e0fe62a512c3591a311430be8836392692b116e224d"

URI_x86_64_v2_libportal-devel-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libportal-devel-doc-0.9.0-2.el10.noarch.rpm;name=x86_64_v2_libportal-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-devel-doc}"
SRC_URI[x86_64_v2_libportal-devel-doc.sha256sum] = "0480b28ed9d723401e003945b8e53ec08ad80c9910dbf591128efef9245c5a16"

URI_x86_64_v2_libportal-gtk3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libportal-gtk3-0.9.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libportal-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-gtk3}"
SRC_URI[x86_64_v2_libportal-gtk3.sha256sum] = "ef496489281fef90fcc45fa541a21eb1ae205d6a9e88927f4cc6dcefd82c045a"

URI_x86_64_v2_libportal-gtk3-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libportal-gtk3-devel-0.9.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libportal-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-gtk3-devel}"
SRC_URI[x86_64_v2_libportal-gtk3-devel.sha256sum] = "c8d47213a82527f33b4faffcb5cf8ed220a26e74eb523f0e77368512ae0583a3"

URI_x86_64_v2_libportal-gtk4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libportal-gtk4-0.9.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libportal-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-gtk4}"
SRC_URI[x86_64_v2_libportal-gtk4.sha256sum] = "b051f13d8aa193cf4fdf289b0f58975d941041ecb531049f894461d88d420ad4"

URI_x86_64_v2_libportal-gtk4-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libportal-gtk4-devel-0.9.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libportal-gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-gtk4-devel}"
SRC_URI[x86_64_v2_libportal-gtk4-devel.sha256sum] = "0551843bf4d89a8ccee1530196dd0b14c90d8f58cbfd716af9baacb438ae42ec"

URI_x86_64_v2_libportal-qt6 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libportal-qt6-0.9.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libportal-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-qt6}"
SRC_URI[x86_64_v2_libportal-qt6.sha256sum] = "9a40a293525f4b6fc53571f6e1c64cabec3a15200bf6c755c6925fbfa5c9b38a"

URI_x86_64_v2_libportal-qt6-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libportal-qt6-devel-0.9.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libportal-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libportal-qt6-devel}"
SRC_URI[x86_64_v2_libportal-qt6-devel.sha256sum] = "b9892dc332d5f7f0479ab07f614657e7b119563f218166dd110bb29c5412ecf7"

URI_aarch64_libportal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libportal-0.9.0-2.el10.aarch64.rpm;name=aarch64_libportal;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal}"
SRC_URI[aarch64_libportal.sha256sum] = "e3c33372a0d98df1a6fca3d92cac35b6b71fbc2a3ee11a4cbcfb902fb7485730"

URI_aarch64_libportal-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libportal-devel-0.9.0-2.el10.aarch64.rpm;name=aarch64_libportal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-devel}"
SRC_URI[aarch64_libportal-devel.sha256sum] = "306116eaa256d072c1cb780fd7e2639488935bb93c8b36d678f83b51824171b4"

URI_aarch64_libportal-devel-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libportal-devel-doc-0.9.0-2.el10.noarch.rpm;name=aarch64_libportal-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-devel-doc}"
SRC_URI[aarch64_libportal-devel-doc.sha256sum] = "0480b28ed9d723401e003945b8e53ec08ad80c9910dbf591128efef9245c5a16"

URI_aarch64_libportal-gtk3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libportal-gtk3-0.9.0-2.el10.aarch64.rpm;name=aarch64_libportal-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-gtk3}"
SRC_URI[aarch64_libportal-gtk3.sha256sum] = "5ee568f001117213abc3b18f775ef505689e3b9d58ad7b8072ff9fd2ae570f50"

URI_aarch64_libportal-gtk3-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libportal-gtk3-devel-0.9.0-2.el10.aarch64.rpm;name=aarch64_libportal-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-gtk3-devel}"
SRC_URI[aarch64_libportal-gtk3-devel.sha256sum] = "ffd7d15a7a770080e572653e8e116b01b157fe59fceda622c74f17a135798c60"

URI_aarch64_libportal-gtk4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libportal-gtk4-0.9.0-2.el10.aarch64.rpm;name=aarch64_libportal-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-gtk4}"
SRC_URI[aarch64_libportal-gtk4.sha256sum] = "49f8a901cae12adf61162545ee620a4849b371b5a777820b4b27c06a73d43533"

URI_aarch64_libportal-gtk4-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libportal-gtk4-devel-0.9.0-2.el10.aarch64.rpm;name=aarch64_libportal-gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-gtk4-devel}"
SRC_URI[aarch64_libportal-gtk4-devel.sha256sum] = "946556eebcaabcad8afd3f832601d905401a4810db64e5feecfd6fdf1e570546"

URI_aarch64_libportal-qt6 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libportal-qt6-0.9.0-2.el10.aarch64.rpm;name=aarch64_libportal-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-qt6}"
SRC_URI[aarch64_libportal-qt6.sha256sum] = "be1c7b4386f029f32aa823d24ddbf28e06ded02281cf4f5d2ffe7cd259da79ac"

URI_aarch64_libportal-qt6-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libportal-qt6-devel-0.9.0-2.el10.aarch64.rpm;name=aarch64_libportal-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libportal-qt6-devel}"
SRC_URI[aarch64_libportal-qt6-devel.sha256sum] = "490f369ba450360484f077e7567b7142c8f34e22a0f1c92eb8cd639b59db88a7"

RDEPENDS:libportal = " \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:libportal-devel = " \
 glib2-devel \
 libportal \
 pkgconf-pkg-config \
 "
RDEPENDS:libportal-devel-doc = " \
 "
RDEPENDS:libportal-gtk3 = " \
 glib2 \
 glibc \
 gtk3 \
 libgcc \
 libportal \
 "
RDEPENDS:libportal-gtk3-devel = " \
 glib2-devel \
 gtk3-devel \
 libportal-devel \
 libportal-gtk3 \
 pkgconf-pkg-config \
 "
RDEPENDS:libportal-gtk4 = " \
 glib2 \
 glibc \
 gtk4 \
 libgcc \
 libportal \
 "
RDEPENDS:libportal-gtk4-devel = " \
 glib2-devel \
 gtk4-devel \
 libportal-devel \
 libportal-gtk4 \
 pkgconf-pkg-config \
 "
RDEPENDS:libportal-qt6 = " \
 glib2 \
 glibc \
 libgcc \
 libportal \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libportal-qt6-devel = " \
 glib2-devel \
 libportal-devel \
 libportal-qt6 \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
