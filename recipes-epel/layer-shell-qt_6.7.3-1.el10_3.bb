# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "layer-shell-qt"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 layer-shell-qt \
 layer-shell-qt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/layer-shell-qt-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0344ebac208e810b1456d13c48fdd341b86b484fb456e87b43a6a9f00006cfa"

URI_x86_64_v2_layer-shell-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/layer-shell-qt-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_layer-shell-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_layer-shell-qt}"
SRC_URI[x86_64_v2_layer-shell-qt.sha256sum] = "d8888134f2e0f7810c22b6bfcf73b35f5a94e33e52bcc0f5b59a375d7ccf5d60"

URI_x86_64_v2_layer-shell-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/layer-shell-qt-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_layer-shell-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_layer-shell-qt-devel}"
SRC_URI[x86_64_v2_layer-shell-qt-devel.sha256sum] = "179b009301a97804b38498aaabc2caeb88510d14040a1c508c126da101097a6f"

URI_aarch64_layer-shell-qt = "${EPEL_MIRROR}/aarch64/Packages/l/layer-shell-qt-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_layer-shell-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_layer-shell-qt}"
SRC_URI[aarch64_layer-shell-qt.sha256sum] = "4cd8ae5d2bd043afe163e5b237be69e0c7c83a53bb294a4cee1210c086a68e6f"

URI_aarch64_layer-shell-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/layer-shell-qt-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_layer-shell-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_layer-shell-qt-devel}"
SRC_URI[aarch64_layer-shell-qt-devel.sha256sum] = "29b69fe87fde49230ff197dd65fbbfc752b510593a5717713c83f791d3a620fb"

RDEPENDS:layer-shell-qt = " \
 glibc \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:layer-shell-qt-devel = " \
 cmake-filesystem \
 layer-shell-qt \
 qt6-qtbase-devel \
 "
