# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setroubleshoot"
PV = "3.3.35"
PR = "4.el10"
PACKAGES = " \
 setroubleshoot \
 setroubleshoot-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/setroubleshoot-3.3.35-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04813a16f99d605598fd83905570079582da406f74a8a97c9662092c2318df28"

URI_x86_64_v2_setroubleshoot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setroubleshoot-3.3.35-4.el10.x86_64_v2.rpm;name=x86_64_v2_setroubleshoot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setroubleshoot}"
SRC_URI[x86_64_v2_setroubleshoot.sha256sum] = "22e7561c5093825c2814c41e03066b7d806cc208360060fbbaec937d4b0861da"

URI_x86_64_v2_setroubleshoot-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setroubleshoot-server-3.3.35-4.el10.x86_64_v2.rpm;name=x86_64_v2_setroubleshoot-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setroubleshoot-server}"
SRC_URI[x86_64_v2_setroubleshoot-server.sha256sum] = "94ef9acca46c263dac8362bc279518edb72da9a69e8bfc579b9f4eb035ddd1f9"

URI_aarch64_setroubleshoot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setroubleshoot-3.3.35-4.el10.aarch64.rpm;name=aarch64_setroubleshoot;unpack=0"
SRC_URI:append = " ${URI_aarch64_setroubleshoot}"
SRC_URI[aarch64_setroubleshoot.sha256sum] = "852f966e050d0d44a526bd2d272ca42aeeaa02b1c32b88290f84d96f41f4d6e9"

URI_aarch64_setroubleshoot-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setroubleshoot-server-3.3.35-4.el10.aarch64.rpm;name=aarch64_setroubleshoot-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_setroubleshoot-server}"
SRC_URI[aarch64_setroubleshoot-server.sha256sum] = "ae00a029c1f8ab8a260316494ad0e42e4f75a87cdecf61a61a34a2c1a0857d05"

RDEPENDS:setroubleshoot = " \
 dbus \
 desktop-file-utils \
 gtk3 \
 libnotify \
 python3 \
 python3-dasbus \
 python3-gobject \
 setroubleshoot-server \
 xdg-utils \
 "
RDEPENDS:setroubleshoot-server = " \
 audit \
 audit-libs \
 bash \
 dbus \
 dbus-libs \
 glibc \
 libcap-ng \
 libselinux \
 policycoreutils-python-utils \
 polkit \
 python3 \
 python3-audit \
 python3-dasbus \
 python3-dbus \
 python3-gobject-base \
 python3-libselinux \
 python3-libxml2 \
 python3-rpm \
 python3-six \
 python3-systemd \
 setroubleshoot-plugins \
 "
