# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ykpers"
PV = "1.20.0"
PR = "15.el10_1"
PACKAGES = " \
 ykpers \
 ykpers-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/ykpers-1.20.0-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbf090997977a5d644985b226ea35b3edf471f356bed48016006b8f01080aff3"

URI_x86_64_v2_ykpers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ykpers-1.20.0-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ykpers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ykpers}"
SRC_URI[x86_64_v2_ykpers.sha256sum] = "affc6f2fb4041235383fc1dfe719a51dabf2037d03cf9eaaf6aa79f1e0114350"

URI_x86_64_v2_ykpers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ykpers-devel-1.20.0-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ykpers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ykpers-devel}"
SRC_URI[x86_64_v2_ykpers-devel.sha256sum] = "e2f683ff520a114fed0445f9ad3f6a37deddead16fc385e311003020d4b0cd07"

URI_aarch64_ykpers = "${EPEL_MIRROR}/aarch64/Packages/y/ykpers-1.20.0-15.el10_1.aarch64.rpm;name=aarch64_ykpers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ykpers}"
SRC_URI[aarch64_ykpers.sha256sum] = "c34ac736386ee095a900769a1d5e2ae2f79bf3fe013ab16f3ec38e1796418651"

URI_aarch64_ykpers-devel = "${EPEL_MIRROR}/aarch64/Packages/y/ykpers-devel-1.20.0-15.el10_1.aarch64.rpm;name=aarch64_ykpers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ykpers-devel}"
SRC_URI[aarch64_ykpers-devel.sha256sum] = "16677ed0537b97bdc155dd8da58c1aaea63be8ae5e6fe79409ab4d68b3b6f086"

RDEPENDS:ykpers = " \
 glibc \
 libusb1 \
 libyubikey \
 "
RDEPENDS:ykpers-devel = " \
 pkgconf-pkg-config \
 ykpers \
 "
