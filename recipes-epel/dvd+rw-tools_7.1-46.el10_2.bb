# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dvd+rw-tools"
PV = "7.1"
PR = "46.el10_2"
PACKAGES = " \
 dvd+rw-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dvd+rw-tools-7.1-46.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b20ed9bd2c531939a5844521a0f06ceaa4609e2ace602e798fead0cdae24dec"

URI_x86_64_v2_dvd+rw-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dvd+rw-tools-7.1-46.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dvd+rw-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dvd+rw-tools}"
SRC_URI[x86_64_v2_dvd+rw-tools.sha256sum] = "83ce3830e60c4564e701b1356ae63b5d77d34fd9fba6c6562255ee3d0140060a"

URI_aarch64_dvd+rw-tools = "${EPEL_MIRROR}/aarch64/Packages/d/dvd+rw-tools-7.1-46.el10_2.aarch64.rpm;name=aarch64_dvd+rw-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_dvd+rw-tools}"
SRC_URI[aarch64_dvd+rw-tools.sha256sum] = "b26a12df577e03939a831dbf9a48e45d32c7661e871dd8886b0204519045d17a"

RDEPENDS:dvd+rw-tools = " \
 genisoimage \
 glibc \
 libstdc++ \
 "
