# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-cli"
PV = "0.1.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-grep-cli+default-devel \
 rust-grep-cli-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-cli-0.1.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f81b16295158e52b278ec02a4fcad5a000654cad65444da010068df4def14e08"

URI_x86_64_v2_rust-grep-cli+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-cli+default-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-cli+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-cli+default-devel}"
SRC_URI[x86_64_v2_rust-grep-cli+default-devel.sha256sum] = "d884b3f7a2af22ed935efc23fb1899671e558469bd58ad5147ba2b323eef2fe1"

URI_x86_64_v2_rust-grep-cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-cli-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-cli-devel}"
SRC_URI[x86_64_v2_rust-grep-cli-devel.sha256sum] = "4b72fc818d0b4b8e56796b3a8a0b11d150b049b225da447b77f4feb2782edeea"

URI_aarch64_rust-grep-cli+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-cli+default-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-grep-cli+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-cli+default-devel}"
SRC_URI[aarch64_rust-grep-cli+default-devel.sha256sum] = "7dc3507d8dc698c51f20aa9b2a0696cc8eb55bc0504406b11cf1488721c95d86"

URI_aarch64_rust-grep-cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-cli-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-grep-cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-cli-devel}"
SRC_URI[aarch64_rust-grep-cli-devel.sha256sum] = "c8b7a9140229937b095833a942bfbe79299c1420433c7faa6321d669ba986689"

RDEPENDS:rust-grep-cli+default-devel = " \
 cargo \
 rust-grep-cli-devel \
 "
RDEPENDS:rust-grep-cli-devel = " \
 cargo \
 rust-bstr+default-devel \
 rust-bstr+std-devel \
 rust-globset+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-termcolor+default-devel \
 "
