# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-skylighting"
PV = "0.14.2"
PR = "11.el10_0"
PACKAGES = " \
 ghc-skylighting \
 ghc-skylighting-core \
 ghc-skylighting-core-devel \
 ghc-skylighting-core-doc \
 ghc-skylighting-core-prof \
 ghc-skylighting-devel \
 ghc-skylighting-doc \
 ghc-skylighting-format-ansi \
 ghc-skylighting-format-ansi-devel \
 ghc-skylighting-format-ansi-doc \
 ghc-skylighting-format-ansi-prof \
 ghc-skylighting-format-blaze-html \
 ghc-skylighting-format-blaze-html-devel \
 ghc-skylighting-format-blaze-html-doc \
 ghc-skylighting-format-blaze-html-prof \
 ghc-skylighting-format-context \
 ghc-skylighting-format-context-devel \
 ghc-skylighting-format-context-doc \
 ghc-skylighting-format-context-prof \
 ghc-skylighting-format-latex \
 ghc-skylighting-format-latex-devel \
 ghc-skylighting-format-latex-doc \
 ghc-skylighting-format-latex-prof \
 ghc-skylighting-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-skylighting-0.14.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c18783ed68e1cfc35b48e8fe013a33d329f23f0374fd476f3a35806f138ad484"

URI_x86_64_v2_ghc-skylighting = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-0.14.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting}"
SRC_URI[x86_64_v2_ghc-skylighting.sha256sum] = "5214c4879ac0aeb6e880d4befbe101c15638df8ec652cae70334cb9a826cc8ce"

URI_x86_64_v2_ghc-skylighting-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-core-0.14.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-core}"
SRC_URI[x86_64_v2_ghc-skylighting-core.sha256sum] = "950644cb4dcbbc61ab3f2af3c245e25e06dc54950ee6bc74730fd7fcc8bcb948"

URI_x86_64_v2_ghc-skylighting-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-core-devel-0.14.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-core-devel}"
SRC_URI[x86_64_v2_ghc-skylighting-core-devel.sha256sum] = "b6a7791c43c15a435d6b06517fe74d4534609b56e277d0248b309ba39d81eb6e"

URI_x86_64_v2_ghc-skylighting-core-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-core-doc-0.14.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-skylighting-core-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-core-doc}"
SRC_URI[x86_64_v2_ghc-skylighting-core-doc.sha256sum] = "862c080fc72958c84bfe7ef252de411eaeb747abdaf2dcc89e8e3cd8f249b95c"

URI_x86_64_v2_ghc-skylighting-core-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-core-prof-0.14.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-core-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-core-prof}"
SRC_URI[x86_64_v2_ghc-skylighting-core-prof.sha256sum] = "860db92488ae6ff7ee130c6aed2d087934c1dfad520df4828eca2f56b0826295"

URI_x86_64_v2_ghc-skylighting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-devel-0.14.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-devel}"
SRC_URI[x86_64_v2_ghc-skylighting-devel.sha256sum] = "c5b618b06221cc611793783e14cce593b1fb2e4be77d403c050455ed2125b8df"

URI_x86_64_v2_ghc-skylighting-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-doc-0.14.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-skylighting-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-doc}"
SRC_URI[x86_64_v2_ghc-skylighting-doc.sha256sum] = "23914a646702c1aa0bd92034696eb8e670565f5bc54d5d61beb8a6977d8615a1"

URI_x86_64_v2_ghc-skylighting-format-ansi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-ansi-0.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-format-ansi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-ansi}"
SRC_URI[x86_64_v2_ghc-skylighting-format-ansi.sha256sum] = "8f1954d6901eeaf872a96c378d3315466d3ca2f516b1021ebf62aa14795e3bf5"

URI_x86_64_v2_ghc-skylighting-format-ansi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-ansi-devel-0.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-format-ansi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-ansi-devel}"
SRC_URI[x86_64_v2_ghc-skylighting-format-ansi-devel.sha256sum] = "35f7c04d2e6fd9e404df1e2e212b054ba6ff71a08de2caa7c8a5c5e7a5d1c562"

URI_x86_64_v2_ghc-skylighting-format-ansi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-ansi-doc-0.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-skylighting-format-ansi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-ansi-doc}"
SRC_URI[x86_64_v2_ghc-skylighting-format-ansi-doc.sha256sum] = "bf6eb6ee9ad4d81c8f5fac565c9b8389c6d2aea815de63d60ab0d57e0db0b5b0"

URI_x86_64_v2_ghc-skylighting-format-ansi-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-ansi-prof-0.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-format-ansi-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-ansi-prof}"
SRC_URI[x86_64_v2_ghc-skylighting-format-ansi-prof.sha256sum] = "1f01fde4f32948a5602995faa4fc459bbd93755a9b6716a1b8e5abcdd0682919"

URI_x86_64_v2_ghc-skylighting-format-blaze-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-blaze-html-0.1.1.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-format-blaze-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-blaze-html}"
SRC_URI[x86_64_v2_ghc-skylighting-format-blaze-html.sha256sum] = "57ca44d0e0c76bb8e9d7bf82a63782c483fadc5d9ff5ffd42333559b17813a51"

URI_x86_64_v2_ghc-skylighting-format-blaze-html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-blaze-html-devel-0.1.1.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-format-blaze-html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-blaze-html-devel}"
SRC_URI[x86_64_v2_ghc-skylighting-format-blaze-html-devel.sha256sum] = "a18b64f5e32af8559bb4ec7f3fa7ab2a529f4a4bab552f5f8fa00fa63687fea7"

URI_x86_64_v2_ghc-skylighting-format-blaze-html-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-blaze-html-doc-0.1.1.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-skylighting-format-blaze-html-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-blaze-html-doc}"
SRC_URI[x86_64_v2_ghc-skylighting-format-blaze-html-doc.sha256sum] = "33e048ef40f0b64334ee972a06f6cf95e210289325e119c66b707e8408197274"

URI_x86_64_v2_ghc-skylighting-format-blaze-html-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-blaze-html-prof-0.1.1.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-format-blaze-html-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-blaze-html-prof}"
SRC_URI[x86_64_v2_ghc-skylighting-format-blaze-html-prof.sha256sum] = "274ebb8b81a31f90f9ae6912cbe156cecbde113a2988ecbd4ab0094395ee63a6"

URI_x86_64_v2_ghc-skylighting-format-context = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-context-0.1.0.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-format-context;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-context}"
SRC_URI[x86_64_v2_ghc-skylighting-format-context.sha256sum] = "8f312fbb16ef616acc59e268eeb4b7aa58fea2a3c7f1942f1a42eddef91ec870"

URI_x86_64_v2_ghc-skylighting-format-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-context-devel-0.1.0.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-format-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-context-devel}"
SRC_URI[x86_64_v2_ghc-skylighting-format-context-devel.sha256sum] = "0961b7a8ba8a8d0612162106a9c7d2b0dd84cdfc20c8df1db63876d6cd8d2fbb"

URI_x86_64_v2_ghc-skylighting-format-context-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-context-doc-0.1.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-skylighting-format-context-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-context-doc}"
SRC_URI[x86_64_v2_ghc-skylighting-format-context-doc.sha256sum] = "67d9a174aea71c12483eb6b510e85efecdb125993ad7194f40fd740688a4e957"

URI_x86_64_v2_ghc-skylighting-format-context-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-context-prof-0.1.0.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-format-context-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-context-prof}"
SRC_URI[x86_64_v2_ghc-skylighting-format-context-prof.sha256sum] = "a248e9fc505f36b2f3caad6388571d82561be3abbb24e653b8cb175e3500a541"

URI_x86_64_v2_ghc-skylighting-format-latex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-latex-0.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-format-latex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-latex}"
SRC_URI[x86_64_v2_ghc-skylighting-format-latex.sha256sum] = "c75720a0291b7b0ba691fcf0129aa5431011e3c773738fc07b5a23fa4b8d668f"

URI_x86_64_v2_ghc-skylighting-format-latex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-latex-devel-0.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-format-latex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-latex-devel}"
SRC_URI[x86_64_v2_ghc-skylighting-format-latex-devel.sha256sum] = "aece379687b8276d3677760f6cbae5895b50ef3aca88bb6e0625084ee99498a1"

URI_x86_64_v2_ghc-skylighting-format-latex-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-latex-doc-0.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-skylighting-format-latex-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-latex-doc}"
SRC_URI[x86_64_v2_ghc-skylighting-format-latex-doc.sha256sum] = "3a0e0a7186e805fbc73fbb6d9eb253afd34787e5c06bc46278d458bcdc735bff"

URI_x86_64_v2_ghc-skylighting-format-latex-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-format-latex-prof-0.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-format-latex-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-format-latex-prof}"
SRC_URI[x86_64_v2_ghc-skylighting-format-latex-prof.sha256sum] = "f7d7a048dd9f130ee713e144fec875b16c5b978f4dc5f3e9a5d899c03c6bc2a6"

URI_x86_64_v2_ghc-skylighting-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-skylighting-prof-0.14.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-skylighting-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-skylighting-prof}"
SRC_URI[x86_64_v2_ghc-skylighting-prof.sha256sum] = "c564abb3eca927babe7ff868606badea00f494b9cb9fd7a90ef89a52187e56b2"

URI_aarch64_ghc-skylighting = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-0.14.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting}"
SRC_URI[aarch64_ghc-skylighting.sha256sum] = "1a4cfffaab0af8e68faffab4457400a5d2aa1f8600a781ff8efdbc1b3ae7011d"

URI_aarch64_ghc-skylighting-core = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-core-0.14.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-core}"
SRC_URI[aarch64_ghc-skylighting-core.sha256sum] = "52ca7cb4c8aa16fd404738494ed63b2c32809226110a793aa4d9fd9a2a4fa732"

URI_aarch64_ghc-skylighting-core-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-core-devel-0.14.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-core-devel}"
SRC_URI[aarch64_ghc-skylighting-core-devel.sha256sum] = "2d0293620e48406fdf3c8b8e0f52bb37a3d7fcccd527d374cccef9edd0a435ff"

URI_aarch64_ghc-skylighting-core-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-core-doc-0.14.2-11.el10_0.noarch.rpm;name=aarch64_ghc-skylighting-core-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-core-doc}"
SRC_URI[aarch64_ghc-skylighting-core-doc.sha256sum] = "de1bb2e436466c7faeeea0d837c80427c040ef95ed9f495f9dc77f22620a2e9a"

URI_aarch64_ghc-skylighting-core-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-core-prof-0.14.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-core-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-core-prof}"
SRC_URI[aarch64_ghc-skylighting-core-prof.sha256sum] = "5b6795b756c84af1142c6f6ad2ef8007e3e6f7c0e94f5c49c4576133518d3d60"

URI_aarch64_ghc-skylighting-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-devel-0.14.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-devel}"
SRC_URI[aarch64_ghc-skylighting-devel.sha256sum] = "8aadcc6113a259b5b4184e1e6db14e742d6052a048b64c2e7931b7703ad89c9b"

URI_aarch64_ghc-skylighting-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-doc-0.14.2-11.el10_0.noarch.rpm;name=aarch64_ghc-skylighting-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-doc}"
SRC_URI[aarch64_ghc-skylighting-doc.sha256sum] = "bbf8befdaab319cec05994d4602ee7425f21e5bcba0daa5d6124df847fae5bbb"

URI_aarch64_ghc-skylighting-format-ansi = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-ansi-0.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-format-ansi;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-ansi}"
SRC_URI[aarch64_ghc-skylighting-format-ansi.sha256sum] = "4622c41db662d94e4f405bd84702b74ec73bdde2e3a284f8560533e6187a5ce1"

URI_aarch64_ghc-skylighting-format-ansi-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-ansi-devel-0.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-format-ansi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-ansi-devel}"
SRC_URI[aarch64_ghc-skylighting-format-ansi-devel.sha256sum] = "680ed8db3a46fc86402b0344e0031f5d663b50aa256f483f67f79f77af40e4d5"

URI_aarch64_ghc-skylighting-format-ansi-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-ansi-doc-0.1-11.el10_0.noarch.rpm;name=aarch64_ghc-skylighting-format-ansi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-ansi-doc}"
SRC_URI[aarch64_ghc-skylighting-format-ansi-doc.sha256sum] = "40cf50f632e69151db516ccc3a5e9348c44fe49ea19952bf0ab0f798f2806918"

URI_aarch64_ghc-skylighting-format-ansi-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-ansi-prof-0.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-format-ansi-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-ansi-prof}"
SRC_URI[aarch64_ghc-skylighting-format-ansi-prof.sha256sum] = "789e11a38d48bf92ad5a1df04dbee1dd7f3d01fff638f55d408e392778e2fd10"

URI_aarch64_ghc-skylighting-format-blaze-html = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-blaze-html-0.1.1.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-format-blaze-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-blaze-html}"
SRC_URI[aarch64_ghc-skylighting-format-blaze-html.sha256sum] = "c66f1205d91e998e5c4ecda5f522cb856e2f51faf87a24a4308048bb60540423"

URI_aarch64_ghc-skylighting-format-blaze-html-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-blaze-html-devel-0.1.1.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-format-blaze-html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-blaze-html-devel}"
SRC_URI[aarch64_ghc-skylighting-format-blaze-html-devel.sha256sum] = "cd29778b1d1df32a7a325449d992ba0e51c78ebdb5194516ccc3e4f58346fbe7"

URI_aarch64_ghc-skylighting-format-blaze-html-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-blaze-html-doc-0.1.1.2-11.el10_0.noarch.rpm;name=aarch64_ghc-skylighting-format-blaze-html-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-blaze-html-doc}"
SRC_URI[aarch64_ghc-skylighting-format-blaze-html-doc.sha256sum] = "03b6764ad679a128c364e1965270bcb9392e221b8429a7d867bf90467f333af8"

URI_aarch64_ghc-skylighting-format-blaze-html-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-blaze-html-prof-0.1.1.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-format-blaze-html-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-blaze-html-prof}"
SRC_URI[aarch64_ghc-skylighting-format-blaze-html-prof.sha256sum] = "20f1cff5836c79ad733a2846d46f4ac7730bc9d8cc5c59f3ea4c7ea8f975a4ad"

URI_aarch64_ghc-skylighting-format-context = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-context-0.1.0.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-format-context;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-context}"
SRC_URI[aarch64_ghc-skylighting-format-context.sha256sum] = "0ac9bd28c06f2511781148847d0ce75c2f0d771551746839036c272023c25f8e"

URI_aarch64_ghc-skylighting-format-context-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-context-devel-0.1.0.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-format-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-context-devel}"
SRC_URI[aarch64_ghc-skylighting-format-context-devel.sha256sum] = "d801003848bdc4f7bef74c99d81273a2b85bae9dbdd9091615d1081190c12691"

URI_aarch64_ghc-skylighting-format-context-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-context-doc-0.1.0.2-11.el10_0.noarch.rpm;name=aarch64_ghc-skylighting-format-context-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-context-doc}"
SRC_URI[aarch64_ghc-skylighting-format-context-doc.sha256sum] = "be25b579d08150fdd4b5083ec6ad83632992f858b30eada72366bf74411bad91"

URI_aarch64_ghc-skylighting-format-context-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-context-prof-0.1.0.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-format-context-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-context-prof}"
SRC_URI[aarch64_ghc-skylighting-format-context-prof.sha256sum] = "48a5a601f8a308842d7d2595bb9c43508e763c028e6944b5e36cab08df7ac9bf"

URI_aarch64_ghc-skylighting-format-latex = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-latex-0.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-format-latex;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-latex}"
SRC_URI[aarch64_ghc-skylighting-format-latex.sha256sum] = "bb3c886dd2f7911ec842ebca4893fe83cde9e2a87dedd019df006ea2465d51bb"

URI_aarch64_ghc-skylighting-format-latex-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-latex-devel-0.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-format-latex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-latex-devel}"
SRC_URI[aarch64_ghc-skylighting-format-latex-devel.sha256sum] = "f7e15889504e799eb85df56d37d97a148b69455810a21945a64b62375b8e7687"

URI_aarch64_ghc-skylighting-format-latex-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-latex-doc-0.1-11.el10_0.noarch.rpm;name=aarch64_ghc-skylighting-format-latex-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-latex-doc}"
SRC_URI[aarch64_ghc-skylighting-format-latex-doc.sha256sum] = "2f6e934a65dba446e9e40dff0c1ca81de5408a021211041c141bb2893fc70a5e"

URI_aarch64_ghc-skylighting-format-latex-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-format-latex-prof-0.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-format-latex-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-format-latex-prof}"
SRC_URI[aarch64_ghc-skylighting-format-latex-prof.sha256sum] = "1dfc5545d196cd84582527629528678ab1ba0fa55aea5bf875f249a3753561bb"

URI_aarch64_ghc-skylighting-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-skylighting-prof-0.14.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-skylighting-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-skylighting-prof}"
SRC_URI[aarch64_ghc-skylighting-prof.sha256sum] = "ca4fb07d5b171c0f519e46adb9b39b5d57b86a3c1419133ed0cdd9e019b82c0a"

RDEPENDS:ghc-skylighting = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-colour \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-skylighting-core \
 ghc-skylighting-format-ansi \
 ghc-skylighting-format-blaze-html \
 ghc-skylighting-format-context \
 ghc-skylighting-format-latex \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-skylighting-core = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-colour \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-skylighting-core-devel = " \
 ghc-aeson-devel \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-base64-bytestring-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-colour-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-mtl-devel \
 ghc-safe-devel \
 ghc-skylighting-core \
 ghc-text-devel \
 ghc-transformers-devel \
 ghc-utf8-string-devel \
 ghc-xml-conduit-devel \
 "
RDEPENDS:ghc-skylighting-core-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-skylighting-core-prof = " \
 ghc-aeson-prof \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-base64-bytestring-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-colour-prof \
 ghc-containers-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-mtl-prof \
 ghc-safe-prof \
 ghc-skylighting-core-devel \
 ghc-text-prof \
 ghc-transformers-prof \
 ghc-utf8-string-prof \
 ghc-xml-conduit-prof \
 "
RDEPENDS:ghc-skylighting-devel = " \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-skylighting \
 ghc-skylighting-core-devel \
 ghc-skylighting-format-ansi-devel \
 ghc-skylighting-format-blaze-html-devel \
 ghc-skylighting-format-context-devel \
 ghc-skylighting-format-latex-devel \
 "
RDEPENDS:ghc-skylighting-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-skylighting-format-ansi = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-colour \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-skylighting-core \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-skylighting-format-ansi-devel = " \
 ghc-ansi-terminal-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-colour-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-skylighting-core-devel \
 ghc-skylighting-format-ansi \
 ghc-text-devel \
 "
RDEPENDS:ghc-skylighting-format-ansi-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-skylighting-format-ansi-prof = " \
 ghc-ansi-terminal-prof \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-colour-prof \
 ghc-containers-prof \
 ghc-skylighting-core-prof \
 ghc-skylighting-format-ansi-devel \
 ghc-text-prof \
 "
RDEPENDS:ghc-skylighting-format-blaze-html = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-colour \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-skylighting-core \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-skylighting-format-blaze-html-devel = " \
 ghc-base-devel \
 ghc-blaze-html-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-skylighting-core-devel \
 ghc-skylighting-format-blaze-html \
 ghc-text-devel \
 "
RDEPENDS:ghc-skylighting-format-blaze-html-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-skylighting-format-blaze-html-prof = " \
 ghc-base-prof \
 ghc-blaze-html-prof \
 ghc-containers-prof \
 ghc-skylighting-core-prof \
 ghc-skylighting-format-blaze-html-devel \
 ghc-text-prof \
 "
RDEPENDS:ghc-skylighting-format-context = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-colour \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-skylighting-core \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-skylighting-format-context-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-skylighting-core-devel \
 ghc-skylighting-format-context \
 ghc-text-devel \
 "
RDEPENDS:ghc-skylighting-format-context-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-skylighting-format-context-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-skylighting-core-prof \
 ghc-skylighting-format-context-devel \
 ghc-text-prof \
 "
RDEPENDS:ghc-skylighting-format-latex = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-colour \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-skylighting-core \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-skylighting-format-latex-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-skylighting-core-devel \
 ghc-skylighting-format-latex \
 ghc-text-devel \
 "
RDEPENDS:ghc-skylighting-format-latex-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-skylighting-format-latex-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-skylighting-core-prof \
 ghc-skylighting-format-latex-devel \
 ghc-text-prof \
 "
RDEPENDS:ghc-skylighting-prof = " \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-containers-prof \
 ghc-skylighting-core-prof \
 ghc-skylighting-devel \
 ghc-skylighting-format-ansi-prof \
 ghc-skylighting-format-blaze-html-prof \
 ghc-skylighting-format-context-prof \
 ghc-skylighting-format-latex-prof \
 "
