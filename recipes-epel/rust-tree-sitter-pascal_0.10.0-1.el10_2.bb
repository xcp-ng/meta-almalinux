# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-pascal"
PV = "0.10.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-pascal+default-devel \
 rust-tree-sitter-pascal-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-pascal-0.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b4b892cbbe5e1b48a8cdfaf5a19066052b7cad375fcc824d3bcf840155982de9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-pascal+default-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-pascal+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tree-sitter-pascal+default-devel.sha256sum] = "33a281c27b96357c5f02565326f2bf6bba0fae3dd678cfcaebd342586be740aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-pascal-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-pascal-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tree-sitter-pascal-devel.sha256sum] = "806a3f33e095e02b602d45e97fc62f3a5fab429dbac0c3a1b9b85bac28f7b221"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-pascal+default-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-pascal+default-devel;unpack=0"
SRC_URI[aarch64_rust-tree-sitter-pascal+default-devel.sha256sum] = "2d652b8fa30e86611e3ff9f81726b90acf3140191986a9395d839c6b073009bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-pascal-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-pascal-devel;unpack=0"
SRC_URI[aarch64_rust-tree-sitter-pascal-devel.sha256sum] = "242f4f32e31ab4e378bb36e376dc0c1e38374e043db276145f71092649db43ec"

RDEPENDS:rust-tree-sitter-pascal+default-devel = " \
 cargo \
 rust-tree-sitter-pascal-devel \
 "
RDEPENDS:rust-tree-sitter-pascal-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
