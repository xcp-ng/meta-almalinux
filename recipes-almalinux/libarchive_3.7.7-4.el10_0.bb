# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libarchive"
PV = "3.7.7"
PR = "4.el10_0"
PACKAGES = " \
 bsdtar \
 libarchive \
 libarchive-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libarchive-3.7.7-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f90555e2eeba4ebe85adbd1292c12351c0e6f089c555ca599db44e765242e1df"

URI_x86_64_v2_bsdtar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bsdtar-3.7.7-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_bsdtar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bsdtar}"
SRC_URI[x86_64_v2_bsdtar.sha256sum] = "7d908aa6b22af00a3c51bf76617d52c374e2e848df6b11d1b303e56b820f6549"

URI_x86_64_v2_libarchive = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libarchive-3.7.7-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libarchive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarchive}"
SRC_URI[x86_64_v2_libarchive.sha256sum] = "07fe1b78a2e4274e9f87d24840713c8faf2f95fe5d29a939ca6959970d707f59"

URI_x86_64_v2_libarchive-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libarchive-devel-3.7.7-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libarchive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarchive-devel}"
SRC_URI[x86_64_v2_libarchive-devel.sha256sum] = "11161f02ec862d459a869dcecf5ce6353a6648b9eb4c1db940dc8187eb7520c3"

URI_aarch64_bsdtar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bsdtar-3.7.7-4.el10_0.aarch64.rpm;name=aarch64_bsdtar;unpack=0"
SRC_URI:append = " ${URI_aarch64_bsdtar}"
SRC_URI[aarch64_bsdtar.sha256sum] = "5aceeacbf2f3da7996d7de8c1a40a61bc299ce7f77095f2d0f5f5d1105fff762"

URI_aarch64_libarchive = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libarchive-3.7.7-4.el10_0.aarch64.rpm;name=aarch64_libarchive;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarchive}"
SRC_URI[aarch64_libarchive.sha256sum] = "ac1a25ac26d41961f38d88ae72c81e4669bd6c71a12710db0f961f698ad6843e"

URI_aarch64_libarchive-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libarchive-devel-3.7.7-4.el10_0.aarch64.rpm;name=aarch64_libarchive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarchive-devel}"
SRC_URI[aarch64_libarchive-devel.sha256sum] = "b2f68279a79f03b22bc096ee039e618a9d9dc8af96f6c2961521e227c09cdf11"

RDEPENDS:bsdtar = " \
 glibc \
 libarchive \
 "
RDEPENDS:libarchive = " \
 bzip2-libs \
 glibc \
 libacl \
 libxml2 \
 libzstd \
 lz4-libs \
 openssl-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libarchive-devel = " \
 libarchive \
 openssl-devel \
 pkgconf-pkg-config \
 "
