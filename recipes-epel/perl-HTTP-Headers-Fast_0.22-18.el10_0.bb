# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Headers-Fast"
PV = "0.22"
PR = "18.el10_0"
PACKAGES = " \
 perl-HTTP-Headers-Fast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTTP-Headers-Fast-0.22-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cbb5e010e543e816f2e6b39f50fd23c5146bb0e49013ce4c683deb43ea921c7"

URI_x86_64_v2_perl-HTTP-Headers-Fast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Headers-Fast-0.22-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Headers-Fast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Headers-Fast}"
SRC_URI[x86_64_v2_perl-HTTP-Headers-Fast.sha256sum] = "7dcb3a25b844ee7d582982b5deeace8bca0c141063819f07bd516c426e2a9d8c"

URI_aarch64_perl-HTTP-Headers-Fast = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Headers-Fast-0.22-18.el10_0.noarch.rpm;name=aarch64_perl-HTTP-Headers-Fast;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Headers-Fast}"
SRC_URI[aarch64_perl-HTTP-Headers-Fast.sha256sum] = "2b7c68ecef22d8c14be032299c773f9a372c8551a2d0ac570ae0c1e613ff857f"

RDEPENDS:perl-HTTP-Headers-Fast = " \
 perl-Carp \
 perl-HTTP-Date \
 perl-MIME-Base64 \
 perl-Storable \
 perl-libs \
 "
