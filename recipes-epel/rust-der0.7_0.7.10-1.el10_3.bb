# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-der0.7"
PV = "0.7.10"
PR = "1.el10_3"
PACKAGES = " \
 rust-der0.7+alloc-devel \
 rust-der0.7+arbitrary-devel \
 rust-der0.7+bytes-devel \
 rust-der0.7+default-devel \
 rust-der0.7+derive-devel \
 rust-der0.7+flagset-devel \
 rust-der0.7+oid-devel \
 rust-der0.7+pem-devel \
 rust-der0.7+real-devel \
 rust-der0.7+std-devel \
 rust-der0.7+time-devel \
 rust-der0.7+zeroize-devel \
 rust-der0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-der0.7-0.7.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47556e3e6ff8ed6b8cf297efebcd722e484cc48d619f1e0c9c891defe41894d0"

URI_x86_64_v2_rust-der0.7+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der0.7+alloc-devel-0.7.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der0.7+alloc-devel}"
SRC_URI[x86_64_v2_rust-der0.7+alloc-devel.sha256sum] = "802c94a34a6336943d29e0c4b35855220b9810173ecd89c21ad6dd936317944d"

URI_x86_64_v2_rust-der0.7+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der0.7+arbitrary-devel-0.7.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der0.7+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der0.7+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-der0.7+arbitrary-devel.sha256sum] = "ecb254122ee645b7a41da46b249e41d683fb49322c7930db3d93bc5063beb35d"

URI_x86_64_v2_rust-der0.7+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der0.7+bytes-devel-0.7.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der0.7+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der0.7+bytes-devel}"
SRC_URI[x86_64_v2_rust-der0.7+bytes-devel.sha256sum] = "3b485f7f664f68517000318b0cc9adfb0956a078a1802ffdf9f7ec9d5cf16047"

URI_x86_64_v2_rust-der0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der0.7+default-devel-0.7.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der0.7+default-devel}"
SRC_URI[x86_64_v2_rust-der0.7+default-devel.sha256sum] = "92901173141e27de4af6ff4c518a2d2ca3b2004cb92d7f454aea4c5e7f12dea1"

URI_x86_64_v2_rust-der0.7+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der0.7+derive-devel-0.7.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der0.7+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der0.7+derive-devel}"
SRC_URI[x86_64_v2_rust-der0.7+derive-devel.sha256sum] = "516cbf58748af02995741c09759d2f13cb38b86d1892a418df6de81de83bee42"

URI_x86_64_v2_rust-der0.7+flagset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der0.7+flagset-devel-0.7.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der0.7+flagset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der0.7+flagset-devel}"
SRC_URI[x86_64_v2_rust-der0.7+flagset-devel.sha256sum] = "e24fb2e838d0e1f604ef4b0c399ed5b1377ae3024b1e545aec3e32e776931aa5"

URI_x86_64_v2_rust-der0.7+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der0.7+oid-devel-0.7.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der0.7+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der0.7+oid-devel}"
SRC_URI[x86_64_v2_rust-der0.7+oid-devel.sha256sum] = "168f6113be02dc8b68bbdf5627d83cfb8bf63fe46b40948028e9e79d34a9addb"

URI_x86_64_v2_rust-der0.7+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der0.7+pem-devel-0.7.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der0.7+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der0.7+pem-devel}"
SRC_URI[x86_64_v2_rust-der0.7+pem-devel.sha256sum] = "a3b651f851c73c2f4bfc3c35af2f33af38024673b4879c7aeb01985bf3dcaf2e"

URI_x86_64_v2_rust-der0.7+real-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der0.7+real-devel-0.7.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der0.7+real-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der0.7+real-devel}"
SRC_URI[x86_64_v2_rust-der0.7+real-devel.sha256sum] = "8757ecc6fa1d077e1f8d58a7d689da4c99d855c5f683ce58850d30b0ec208a2c"

URI_x86_64_v2_rust-der0.7+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der0.7+std-devel-0.7.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der0.7+std-devel}"
SRC_URI[x86_64_v2_rust-der0.7+std-devel.sha256sum] = "7445d8ec0e34c65f96ce6b157cf86903cb0529854c7794a098a2f94b2190cf28"

URI_x86_64_v2_rust-der0.7+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der0.7+time-devel-0.7.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der0.7+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der0.7+time-devel}"
SRC_URI[x86_64_v2_rust-der0.7+time-devel.sha256sum] = "012fe4f5d771b39bc2be581023117a1d48980a258ea893be042aa5c3305df878"

URI_x86_64_v2_rust-der0.7+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der0.7+zeroize-devel-0.7.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der0.7+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der0.7+zeroize-devel}"
SRC_URI[x86_64_v2_rust-der0.7+zeroize-devel.sha256sum] = "682be1687d6a416b6b53696f0b143ee6bfc0e1c2db3c4c8fe7fc6415156d0cca"

URI_x86_64_v2_rust-der0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der0.7-devel-0.7.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der0.7-devel}"
SRC_URI[x86_64_v2_rust-der0.7-devel.sha256sum] = "d39e4402ce316108dd2e2902f046c7106e5c1e31308953eb005f929940da59ac"

URI_aarch64_rust-der0.7+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der0.7+alloc-devel-0.7.10-1.el10_3.noarch.rpm;name=aarch64_rust-der0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der0.7+alloc-devel}"
SRC_URI[aarch64_rust-der0.7+alloc-devel.sha256sum] = "8fbb98dfacd860f77939898c91058be6a613c8e070210753244b2d8cb624d227"

URI_aarch64_rust-der0.7+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der0.7+arbitrary-devel-0.7.10-1.el10_3.noarch.rpm;name=aarch64_rust-der0.7+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der0.7+arbitrary-devel}"
SRC_URI[aarch64_rust-der0.7+arbitrary-devel.sha256sum] = "0bcab1b4ffa33485746fcd10b133f10078c71fc03103e77091f3b6a9f5ee4982"

URI_aarch64_rust-der0.7+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der0.7+bytes-devel-0.7.10-1.el10_3.noarch.rpm;name=aarch64_rust-der0.7+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der0.7+bytes-devel}"
SRC_URI[aarch64_rust-der0.7+bytes-devel.sha256sum] = "9a36a22389b31cd5f3af4f55dea4709b8eb6bc042dfdee6b9e8d0c4bb0e52828"

URI_aarch64_rust-der0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der0.7+default-devel-0.7.10-1.el10_3.noarch.rpm;name=aarch64_rust-der0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der0.7+default-devel}"
SRC_URI[aarch64_rust-der0.7+default-devel.sha256sum] = "2237d331218b0cdc756e4b09c7e3c57ff47bfb2b4440571ebee081189f34746a"

URI_aarch64_rust-der0.7+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der0.7+derive-devel-0.7.10-1.el10_3.noarch.rpm;name=aarch64_rust-der0.7+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der0.7+derive-devel}"
SRC_URI[aarch64_rust-der0.7+derive-devel.sha256sum] = "98bad1f9370416c25cd3401226455247d9ad2abb325ac6b6238bbff59944b825"

URI_aarch64_rust-der0.7+flagset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der0.7+flagset-devel-0.7.10-1.el10_3.noarch.rpm;name=aarch64_rust-der0.7+flagset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der0.7+flagset-devel}"
SRC_URI[aarch64_rust-der0.7+flagset-devel.sha256sum] = "27d14933cad05f2807765f294fb4ab19f5f052aa4a4dc6ef6ad3dc639a57d894"

URI_aarch64_rust-der0.7+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der0.7+oid-devel-0.7.10-1.el10_3.noarch.rpm;name=aarch64_rust-der0.7+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der0.7+oid-devel}"
SRC_URI[aarch64_rust-der0.7+oid-devel.sha256sum] = "1b4264893dcd4b1f578578b18a157aae77aedb01198fd38309e6db855425100f"

URI_aarch64_rust-der0.7+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der0.7+pem-devel-0.7.10-1.el10_3.noarch.rpm;name=aarch64_rust-der0.7+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der0.7+pem-devel}"
SRC_URI[aarch64_rust-der0.7+pem-devel.sha256sum] = "4626e84cf54079cfd2884b63194688eecd101571d291a63fc830f537354b3e96"

URI_aarch64_rust-der0.7+real-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der0.7+real-devel-0.7.10-1.el10_3.noarch.rpm;name=aarch64_rust-der0.7+real-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der0.7+real-devel}"
SRC_URI[aarch64_rust-der0.7+real-devel.sha256sum] = "a4f03e044539d76be56784933b8179b6b495d336bec0221b028e16cb946cacb6"

URI_aarch64_rust-der0.7+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der0.7+std-devel-0.7.10-1.el10_3.noarch.rpm;name=aarch64_rust-der0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der0.7+std-devel}"
SRC_URI[aarch64_rust-der0.7+std-devel.sha256sum] = "d72216a92cd2001164ab0ad597d7eb2249074d4b2a47b2923675558aa47c5b23"

URI_aarch64_rust-der0.7+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der0.7+time-devel-0.7.10-1.el10_3.noarch.rpm;name=aarch64_rust-der0.7+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der0.7+time-devel}"
SRC_URI[aarch64_rust-der0.7+time-devel.sha256sum] = "39abe9163ede856bc5a8e52e1e3fbe39f99fdf5824d557c6248fcabf7b0d34dd"

URI_aarch64_rust-der0.7+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der0.7+zeroize-devel-0.7.10-1.el10_3.noarch.rpm;name=aarch64_rust-der0.7+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der0.7+zeroize-devel}"
SRC_URI[aarch64_rust-der0.7+zeroize-devel.sha256sum] = "7af2a757125b43245b55e2fa6007f5cdb04de8a04044620ed799f0cbd99d0498"

URI_aarch64_rust-der0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der0.7-devel-0.7.10-1.el10_3.noarch.rpm;name=aarch64_rust-der0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der0.7-devel}"
SRC_URI[aarch64_rust-der0.7-devel.sha256sum] = "e7bee324635f842f4bd7845162123265f22c25e82686698afbcf8d1ac715e0ee"

RDEPENDS:rust-der0.7+alloc-devel = " \
 cargo \
 rust-der0.7-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-der0.7+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-const-oid0.9+arbitrary-devel \
 rust-const-oid0.9+default-devel \
 rust-der0.7+std-devel \
 rust-der0.7-devel \
 "
RDEPENDS:rust-der0.7+bytes-devel = " \
 cargo \
 rust-bytes-devel \
 rust-der0.7+alloc-devel \
 rust-der0.7-devel \
 "
RDEPENDS:rust-der0.7+default-devel = " \
 cargo \
 rust-der0.7-devel \
 "
RDEPENDS:rust-der0.7+derive-devel = " \
 cargo \
 rust-der0.7-devel \
 rust-der_derive0.7+default-devel \
 "
RDEPENDS:rust-der0.7+flagset-devel = " \
 cargo \
 rust-der0.7-devel \
 rust-flagset+default-devel \
 "
RDEPENDS:rust-der0.7+oid-devel = " \
 cargo \
 rust-const-oid0.9+default-devel \
 rust-der0.7-devel \
 "
RDEPENDS:rust-der0.7+pem-devel = " \
 cargo \
 rust-der0.7+alloc-devel \
 rust-der0.7+zeroize-devel \
 rust-der0.7-devel \
 rust-pem-rfc7468_0.7+alloc-devel \
 rust-pem-rfc7468_0.7+default-devel \
 "
RDEPENDS:rust-der0.7+real-devel = " \
 cargo \
 rust-der0.7-devel \
 "
RDEPENDS:rust-der0.7+std-devel = " \
 cargo \
 rust-der0.7+alloc-devel \
 rust-der0.7-devel \
 "
RDEPENDS:rust-der0.7+time-devel = " \
 cargo \
 rust-der0.7-devel \
 rust-time-devel \
 "
RDEPENDS:rust-der0.7+zeroize-devel = " \
 cargo \
 rust-der0.7-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-der0.7-devel = " \
 cargo \
 rust \
 "
