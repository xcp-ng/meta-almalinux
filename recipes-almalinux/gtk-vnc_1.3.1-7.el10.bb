# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtk-vnc"
PV = "1.3.1"
PR = "7.el10"
PACKAGES = " \
 gtk-vnc2 \
 gtk-vnc2-devel \
 gvnc \
 gvnc-devel \
 gvncpulse \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gtk-vnc-1.3.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c6146fdff4c288fc2f5530d93ff5fea7a911bb759fdc7881e4443fb4b65014f"

URI_x86_64_v2_gtk-vnc2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk-vnc2-1.3.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_gtk-vnc2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk-vnc2}"
SRC_URI[x86_64_v2_gtk-vnc2.sha256sum] = "921a35c73ab07414375652953ea73104f0772fa055e4281b98e506be098a2fdd"

URI_x86_64_v2_gtk-vnc2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gtk-vnc2-devel-1.3.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_gtk-vnc2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk-vnc2-devel}"
SRC_URI[x86_64_v2_gtk-vnc2-devel.sha256sum] = "efd33833dce6fb63a49fab5fcef566af2863cb453e273cfdcbe57e553ac89371"

URI_x86_64_v2_gvnc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvnc-1.3.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_gvnc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvnc}"
SRC_URI[x86_64_v2_gvnc.sha256sum] = "1f7dd4c6b51dd34c6552da57cdbe17bdfdf21665412fca6824ba431b95282aa5"

URI_x86_64_v2_gvnc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gvnc-devel-1.3.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_gvnc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvnc-devel}"
SRC_URI[x86_64_v2_gvnc-devel.sha256sum] = "afa4db14a4378464d694d16354cb93bd06c39cf1abc93891f8c5a1f3e8adeceb"

URI_x86_64_v2_gvncpulse = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvncpulse-1.3.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_gvncpulse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvncpulse}"
SRC_URI[x86_64_v2_gvncpulse.sha256sum] = "ec08f3b9dde2c44f69e83b258796d657c94f87761273b104b8cbf63ff0d0c492"

URI_aarch64_gtk-vnc2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk-vnc2-1.3.1-7.el10.aarch64.rpm;name=aarch64_gtk-vnc2;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk-vnc2}"
SRC_URI[aarch64_gtk-vnc2.sha256sum] = "373d6d5293c75d1720c5603e4e135dd2bb607aa8c015439c36b7094375414d2f"

URI_aarch64_gtk-vnc2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gtk-vnc2-devel-1.3.1-7.el10.aarch64.rpm;name=aarch64_gtk-vnc2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk-vnc2-devel}"
SRC_URI[aarch64_gtk-vnc2-devel.sha256sum] = "d9b979c311022493aae5e2d55703a2a23d80204f38d4e345d6e87d33290f3784"

URI_aarch64_gvnc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvnc-1.3.1-7.el10.aarch64.rpm;name=aarch64_gvnc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvnc}"
SRC_URI[aarch64_gvnc.sha256sum] = "1a486d44cc28f2697053e6f1349e1350a8aa5abd52245a56453237be0c94b7a3"

URI_aarch64_gvnc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gvnc-devel-1.3.1-7.el10.aarch64.rpm;name=aarch64_gvnc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvnc-devel}"
SRC_URI[aarch64_gvnc-devel.sha256sum] = "68c1e339e2d84d4765301e368d9a75d213b578c5c59479dd91f3b0457d078cfe"

URI_aarch64_gvncpulse = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvncpulse-1.3.1-7.el10.aarch64.rpm;name=aarch64_gvncpulse;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvncpulse}"
SRC_URI[aarch64_gvncpulse.sha256sum] = "efb33ddbdcf93a8b95b8fbc5d149a06368c8c26e4a50322078122ec95c74636f"

RDEPENDS:gtk-vnc2 = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 gvnc \
 libX11 \
 "
RDEPENDS:gtk-vnc2-devel = " \
 cyrus-sasl-devel \
 gdk-pixbuf2-devel \
 glib2-devel \
 gnutls-devel \
 gtk-vnc2 \
 gtk3-devel \
 gvnc-devel \
 libX11-devel \
 libgcrypt-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:gvnc = " \
 cyrus-sasl-lib \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnutls \
 libgcrypt \
 zlib-ng-compat \
 "
RDEPENDS:gvnc-devel = " \
 cyrus-sasl-devel \
 gdk-pixbuf2-devel \
 glib2-devel \
 gnutls-devel \
 gvnc \
 libgcrypt-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:gvncpulse = " \
 glib2 \
 glibc \
 gvnc \
 pulseaudio-libs \
 "
