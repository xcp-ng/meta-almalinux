# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtommath"
PV = "1.3.1~rc1"
PR = "3.el10_0"
PACKAGES = " \
 libtommath \
 libtommath-devel \
 libtommath-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libtommath-1.3.1~rc1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9904eafc3db28bc8689540e7399064a9f4ca8b8e6f7265152e4eb14193298d76"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtommath-1.3.1~rc1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtommath;unpack=0"
SRC_URI[x86_64_v2_libtommath.sha256sum] = "753cea048fd6fcedaa2ad51d29bb31c6ad41e45f3892dd5e6b1d0f4f94023fce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtommath-devel-1.3.1~rc1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtommath-devel;unpack=0"
SRC_URI[x86_64_v2_libtommath-devel.sha256sum] = "00b7d97c189e86b230d71b4175f01477f79e1df85c4202d280b08e3202b64192"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtommath-doc-1.3.1~rc1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libtommath-doc;unpack=0"
SRC_URI[x86_64_v2_libtommath-doc.sha256sum] = "d8aeaa3cb9cb52b4d98d03a7ab1dde719bb66db1a9346cd4827f7fa66efdb607"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libtommath-1.3.1~rc1-3.el10_0.aarch64.rpm;name=aarch64_libtommath;unpack=0"
SRC_URI[aarch64_libtommath.sha256sum] = "64250b5df4c677294257848944feacbcbdaf693e10a16f978227953d4cfad62a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libtommath-devel-1.3.1~rc1-3.el10_0.aarch64.rpm;name=aarch64_libtommath-devel;unpack=0"
SRC_URI[aarch64_libtommath-devel.sha256sum] = "b226ff573c295e7ceae7fd5dc15b273f10b196f94fac99a02b65203aa211ab24"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libtommath-doc-1.3.1~rc1-3.el10_0.noarch.rpm;name=aarch64_libtommath-doc;unpack=0"
SRC_URI[aarch64_libtommath-doc.sha256sum] = "5802b6301fe69ff9215de2a8eb5afa36fb2195549d0c17c7cffd40c8bc77400b"

RDEPENDS:libtommath = " \
 glibc \
 "
RDEPENDS:libtommath-devel = " \
 libtommath \
 pkgconf-pkg-config \
 "
RDEPENDS:libtommath-doc = " \
 "
