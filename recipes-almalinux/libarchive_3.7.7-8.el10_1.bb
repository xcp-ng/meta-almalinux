# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libarchive"
PV = "3.7.7"
PR = "8.el10_1"
PACKAGES = " \
 bsdtar \
 libarchive \
 libarchive-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libarchive-3.7.7-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92a7211eea8f48950b969e20e8f9b0a719262d8722e54a66d1dfda8ac83e7cee"

URI_x86_64_v2_bsdtar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bsdtar-3.7.7-8.el10_1.x86_64_v2.rpm;name=x86_64_v2_bsdtar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bsdtar}"
SRC_URI[x86_64_v2_bsdtar.sha256sum] = "6f1c6757ee3d565aa2e787a7f8bc8036329afc900c23f8ef1809f3f9503632d9"

URI_x86_64_v2_libarchive = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libarchive-3.7.7-8.el10_1.x86_64_v2.rpm;name=x86_64_v2_libarchive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarchive}"
SRC_URI[x86_64_v2_libarchive.sha256sum] = "f0ee10ca7ca8d9bcd0d3f41ec1df699d790bb569ff68ca3ca2d40ac11d329dd3"

URI_x86_64_v2_libarchive-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libarchive-devel-3.7.7-8.el10_1.x86_64_v2.rpm;name=x86_64_v2_libarchive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarchive-devel}"
SRC_URI[x86_64_v2_libarchive-devel.sha256sum] = "c9c0228e4869abea156de797b72c1c2ab6c8d25158f61279d58491fa166e4f7f"

URI_aarch64_bsdtar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bsdtar-3.7.7-8.el10_1.aarch64.rpm;name=aarch64_bsdtar;unpack=0"
SRC_URI:append = " ${URI_aarch64_bsdtar}"
SRC_URI[aarch64_bsdtar.sha256sum] = "3de6d25003647af5158e4b2141123851c9500812cbeac21eeedb73f086944c3c"

URI_aarch64_libarchive = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libarchive-3.7.7-8.el10_1.aarch64.rpm;name=aarch64_libarchive;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarchive}"
SRC_URI[aarch64_libarchive.sha256sum] = "99dd164af000cdf0f6ea7f6a09f400948f8a23d229452d55360426cdc7b6feda"

URI_aarch64_libarchive-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libarchive-devel-3.7.7-8.el10_1.aarch64.rpm;name=aarch64_libarchive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarchive-devel}"
SRC_URI[aarch64_libarchive-devel.sha256sum] = "4539d3e970bde7bcb1d6260a3a0da0673825cbb31c1bcda3ed5c359455e63deb"

RDEPENDS:bsdtar = " \
 glibc \
 libarchive \
 "
RDEPENDS:libarchive = " \
 bzip2-libs \
 glibc \
 libacl \
 libxml2 \
 libzstd \
 lz4-libs \
 openssl-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libarchive-devel = " \
 libarchive \
 openssl-devel \
 pkgconf-pkg-config \
 "
