# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_datetime"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_datetime+compiled_data-devel \
 rust-icu_datetime+datagen-devel \
 rust-icu_datetime+default-devel \
 rust-icu_datetime+ixdtf-devel \
 rust-icu_datetime+logging-devel \
 rust-icu_datetime+serde-devel \
 rust-icu_datetime+unstable-devel \
 rust-icu_datetime+unstable_chrono_0_4-devel \
 rust-icu_datetime+unstable_jiff_0_2-devel \
 rust-icu_datetime+unstable_time_0_3-devel \
 rust-icu_datetime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_datetime-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c72f5643776fa5ba9b63f52a49a85e4cb040bad5d1c4aa99ac160a376a8553e"

URI_x86_64_v2_rust-icu_datetime+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+compiled_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+compiled_data-devel.sha256sum] = "2a7aaec295a348e05f7d278495d6b888b12b866b007b88bcd29ec3be356b17e8"

URI_x86_64_v2_rust-icu_datetime+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+datagen-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+datagen-devel.sha256sum] = "e5bf1e10d1ccf478d6305dfccecb79ed5466039719aa5d48b74b124a5f870d27"

URI_x86_64_v2_rust-icu_datetime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+default-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+default-devel.sha256sum] = "482d2d9420148cb849992be9ba8ce4539bbfd49d75b2f8db3ec34d845a7341a0"

URI_x86_64_v2_rust-icu_datetime+ixdtf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+ixdtf-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+ixdtf-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+ixdtf-devel.sha256sum] = "355f29c5bc37234e32df0fd44823cfd2e495e2664eb6ceba1b8265501dac6082"

URI_x86_64_v2_rust-icu_datetime+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+logging-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+logging-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+logging-devel.sha256sum] = "2fdf2cb915734900a98164f95bd512edeb338b42b33ed0b9dde6405824309736"

URI_x86_64_v2_rust-icu_datetime+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+serde-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+serde-devel.sha256sum] = "f35e6bfc8a75d55c4fc8b66095ba2f8fc9b71cdcc5f4ff2fdc74062879be3c57"

URI_x86_64_v2_rust-icu_datetime+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+unstable-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+unstable-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+unstable-devel.sha256sum] = "2322a43a296b444aae56a3c0800810f75e753e98e98cc2b866fac2292da01b08"

URI_x86_64_v2_rust-icu_datetime+unstable_chrono_0_4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+unstable_chrono_0_4-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+unstable_chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+unstable_chrono_0_4-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+unstable_chrono_0_4-devel.sha256sum] = "b26598d8c7399f0dc9a65f1f8c659d39e33c73ee2c32d2ea2d6219a6c578372b"

URI_x86_64_v2_rust-icu_datetime+unstable_jiff_0_2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+unstable_jiff_0_2-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+unstable_jiff_0_2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+unstable_jiff_0_2-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+unstable_jiff_0_2-devel.sha256sum] = "d4d3b0b9fc21a69a3e260cc30317349047a5c5a5572a9ef48d1da5c312128f5e"

URI_x86_64_v2_rust-icu_datetime+unstable_time_0_3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+unstable_time_0_3-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+unstable_time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+unstable_time_0_3-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+unstable_time_0_3-devel.sha256sum] = "6796669f3180e3cf015bec187f3c8defcc581dfe5d933d3262a5f33f9c1e69b2"

URI_x86_64_v2_rust-icu_datetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime-devel.sha256sum] = "753dbf063511788e7f9662ac022638786baa85c3e62fba51a86ae57492a008f4"

URI_aarch64_rust-icu_datetime+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+compiled_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_datetime+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_datetime+compiled_data-devel.sha256sum] = "45bfda28778d445c10f739750018ba981bc16fdf4c046a7cab6d0cd5487fbc41"

URI_aarch64_rust-icu_datetime+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+datagen-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_datetime+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+datagen-devel}"
SRC_URI[aarch64_rust-icu_datetime+datagen-devel.sha256sum] = "5783a732fb84dd8d44dddd2fa0e42399be202a9ef39d59ccd258e754d738130b"

URI_aarch64_rust-icu_datetime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_datetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+default-devel}"
SRC_URI[aarch64_rust-icu_datetime+default-devel.sha256sum] = "9db4f153aed803c2187e5a15240207a4e53daf00b4b52ea22189c4bc248b8533"

URI_aarch64_rust-icu_datetime+ixdtf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+ixdtf-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_datetime+ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+ixdtf-devel}"
SRC_URI[aarch64_rust-icu_datetime+ixdtf-devel.sha256sum] = "3b9250ecd24d9dda87410162247a99a8d8e97eb5844a79510fa86180c034c0b5"

URI_aarch64_rust-icu_datetime+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+logging-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_datetime+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+logging-devel}"
SRC_URI[aarch64_rust-icu_datetime+logging-devel.sha256sum] = "6d7877349c928650206e808b86cdf99ad3d9f2824bedad1bc9a9f844ea6c3401"

URI_aarch64_rust-icu_datetime+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+serde-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_datetime+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+serde-devel}"
SRC_URI[aarch64_rust-icu_datetime+serde-devel.sha256sum] = "48fd236e41a894a8d3757865d11e2ed824bfb7b010181e7a7789ca11e10c5932"

URI_aarch64_rust-icu_datetime+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+unstable-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_datetime+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+unstable-devel}"
SRC_URI[aarch64_rust-icu_datetime+unstable-devel.sha256sum] = "7e6b03b35a7111f339054caa49c9cfdd7008e3dbb197952c550c9c246d72768e"

URI_aarch64_rust-icu_datetime+unstable_chrono_0_4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+unstable_chrono_0_4-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_datetime+unstable_chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+unstable_chrono_0_4-devel}"
SRC_URI[aarch64_rust-icu_datetime+unstable_chrono_0_4-devel.sha256sum] = "d868a0c89c30751623a0c2e9f4270e83f7aaa96222e719a697719b8a679551e9"

URI_aarch64_rust-icu_datetime+unstable_jiff_0_2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+unstable_jiff_0_2-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_datetime+unstable_jiff_0_2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+unstable_jiff_0_2-devel}"
SRC_URI[aarch64_rust-icu_datetime+unstable_jiff_0_2-devel.sha256sum] = "a6b000504e1c13b1b1eb58f1c9effa968b8aa78d8539e00b13712127fab289c6"

URI_aarch64_rust-icu_datetime+unstable_time_0_3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+unstable_time_0_3-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_datetime+unstable_time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+unstable_time_0_3-devel}"
SRC_URI[aarch64_rust-icu_datetime+unstable_time_0_3-devel.sha256sum] = "e59770371c21d7975c41b6c58c3eebbbb6181a638cf24cb922ec77093cc8c063"

URI_aarch64_rust-icu_datetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime-devel}"
SRC_URI[aarch64_rust-icu_datetime-devel.sha256sum] = "9a270c5142af1d684260f4410150b5c6cf2a8ffa76dbba699b9d2adc0297c57e"

RDEPENDS:rust-icu_datetime+compiled_data-devel = " \
 cargo \
 rust-icu_calendar+compiled_data-devel \
 rust-icu_datetime-devel \
 rust-icu_datetime_data-devel \
 rust-icu_decimal+compiled_data-devel \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale-devel \
 rust-icu_plurals+compiled_data-devel \
 rust-icu_provider+baked-devel \
 rust-icu_time+compiled_data-devel \
 "
RDEPENDS:rust-icu_datetime+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_calendar+datagen-devel \
 rust-icu_datetime+serde-devel \
 rust-icu_datetime-devel \
 rust-icu_pattern+databake-devel \
 rust-icu_plurals+datagen-devel \
 rust-icu_provider+export-devel \
 rust-icu_time+datagen-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-icu_datetime+default-devel = " \
 cargo \
 rust-icu_datetime+compiled_data-devel \
 rust-icu_datetime+ixdtf-devel \
 rust-icu_datetime-devel \
 "
RDEPENDS:rust-icu_datetime+ixdtf-devel = " \
 cargo \
 rust-icu_calendar+ixdtf-devel \
 rust-icu_datetime-devel \
 rust-icu_time+ixdtf-devel \
 "
RDEPENDS:rust-icu_datetime+logging-devel = " \
 cargo \
 rust-icu_calendar+logging-devel \
 rust-icu_datetime-devel \
 "
RDEPENDS:rust-icu_datetime+serde-devel = " \
 cargo \
 rust-icu_calendar+serde-devel \
 rust-icu_datetime-devel \
 rust-icu_decimal+serde-devel \
 rust-icu_pattern+serde-devel \
 rust-icu_plurals+serde-devel \
 rust-icu_provider+alloc-devel \
 rust-icu_provider+serde-devel \
 rust-icu_time+serde-devel \
 rust-potential_utf+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-smallvec+serde-devel \
 rust-smallvec-devel \
 rust-tinystr+serde-devel \
 rust-zerotrie+alloc-devel \
 rust-zerotrie-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_datetime+unstable-devel = " \
 cargo \
 rust-icu_datetime-devel \
 rust-icu_time+unstable-devel \
 "
RDEPENDS:rust-icu_datetime+unstable_chrono_0_4-devel = " \
 cargo \
 rust-chrono-devel \
 rust-icu_calendar+unstable_chrono_0_4-devel \
 rust-icu_datetime-devel \
 rust-icu_time+unstable_chrono_0_4-devel \
 "
RDEPENDS:rust-icu_datetime+unstable_jiff_0_2-devel = " \
 cargo \
 rust-icu_calendar+unstable_jiff_0_2-devel \
 rust-icu_datetime-devel \
 rust-icu_time+unstable_jiff_0_2-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-icu_datetime+unstable_time_0_3-devel = " \
 cargo \
 rust-icu_calendar+unstable_time_0_3-devel \
 rust-icu_datetime-devel \
 rust-icu_time+unstable_time_0_3-devel \
 rust-time-devel \
 "
RDEPENDS:rust-icu_datetime-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-fixed_decimal-devel \
 rust-icu_calendar-devel \
 rust-icu_decimal-devel \
 rust-icu_locale_core-devel \
 rust-icu_pattern+alloc-devel \
 rust-icu_pattern+zerovec-devel \
 rust-icu_pattern-devel \
 rust-icu_plurals-devel \
 rust-icu_provider-devel \
 rust-icu_time+alloc-devel \
 rust-icu_time-devel \
 rust-potential_utf+alloc-devel \
 rust-potential_utf+zerovec-devel \
 rust-potential_utf-devel \
 rust-tinystr+alloc-devel \
 rust-tinystr+zerovec-devel \
 rust-tinystr-devel \
 rust-writeable-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
