# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tenacity"
PV = "9.1.4"
PR = "1.el10_2"
PACKAGES = " \
 python3-tenacity \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tenacity-9.1.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "339061839659d78cb9da080e17e5d022e27b7bde1f7b0d47f7a6b9bf23eb23d4"

URI_x86_64_v2_python3-tenacity = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tenacity-9.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tenacity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tenacity}"
SRC_URI[x86_64_v2_python3-tenacity.sha256sum] = "fae145a52f2f7140f1209a6710cb13a5562e7573f8e342a73b8947f6729281e6"

URI_aarch64_python3-tenacity = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tenacity-9.1.4-1.el10_2.noarch.rpm;name=aarch64_python3-tenacity;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tenacity}"
SRC_URI[aarch64_python3-tenacity.sha256sum] = "9ae6f80ab28b088a73371ea1cec90ac6663f090f2f28892fac5aa12bd4ab3480"

RDEPENDS:python3-tenacity = " \
 python3 \
 "
