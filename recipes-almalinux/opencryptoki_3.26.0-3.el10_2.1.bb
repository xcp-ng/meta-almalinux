# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opencryptoki"
PV = "3.26.0"
PR = "3.el10_2.1"
PACKAGES:x86_64_v2 = " \
 opencryptoki \
 opencryptoki-ccatok \
 opencryptoki-devel \
 opencryptoki-icsftok \
 opencryptoki-libs \
 opencryptoki-swtok \
"
PACKAGES:aarch64 = " \
 opencryptoki \
 opencryptoki-devel \
 opencryptoki-icsftok \
 opencryptoki-libs \
 opencryptoki-swtok \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/opencryptoki-3.26.0-3.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "93858af9b61a1474016618a8fbe12b3b91508c7b87615d7faf529c361645c5c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-3.26.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_opencryptoki;unpack=0"
SRC_URI[x86_64_v2_opencryptoki.sha256sum] = "df9c19b8dae7d3101f374f0ed7c9a213ee46ea05f067edb7518d754cc4bb348a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-ccatok-3.26.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-ccatok;unpack=0"
SRC_URI[x86_64_v2_opencryptoki-ccatok.sha256sum] = "73d6b381f17c5ca4ef585adcd9a8a2837b71f2696919b7a9dbcf09d63c33bb7a"
RPROVIDES:opencryptoki-ccatok:append:x86_64_v2 = " virtual/opencryptoki_token_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/opencryptoki-devel-3.26.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-devel;unpack=0"
SRC_URI[x86_64_v2_opencryptoki-devel.sha256sum] = "2b3c864ec3ca25581465281b4e0a62164515deb1c723921747bb42842df2f3e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-icsftok-3.26.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-icsftok;unpack=0"
SRC_URI[x86_64_v2_opencryptoki-icsftok.sha256sum] = "e3e85e61c01389cda75329449b9444a711e6d92bc67254aa4825e364fe5ed1b6"
RPROVIDES:opencryptoki-icsftok:append:x86_64_v2 = " virtual/opencryptoki_token_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-libs-3.26.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-libs;unpack=0"
SRC_URI[x86_64_v2_opencryptoki-libs.sha256sum] = "881747385c2ccf7efa43f6eeaae025d7581acc2f09e4c7d4dd2228b0a2958b55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-swtok-3.26.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-swtok;unpack=0"
SRC_URI[x86_64_v2_opencryptoki-swtok.sha256sum] = "8430a9c5f7c75b6e61d1cfed8a9d3fa06a6688061c83e7c6fe795946db943db5"
RPROVIDES:opencryptoki-swtok:append:x86_64_v2 = " virtual/opencryptoki_token_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-3.26.0-3.el10_2.1.aarch64.rpm;name=aarch64_opencryptoki;unpack=0"
SRC_URI[aarch64_opencryptoki.sha256sum] = "ff5d902a003006ec30fba178ed9af3575e287c071db3582a74c8ffd8bf8bd208"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/opencryptoki-devel-3.26.0-3.el10_2.1.aarch64.rpm;name=aarch64_opencryptoki-devel;unpack=0"
SRC_URI[aarch64_opencryptoki-devel.sha256sum] = "e37bf6a87ab259fe9bbfdec4eeef8b32c26861c7c77e772776f95c095476c6c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-icsftok-3.26.0-3.el10_2.1.aarch64.rpm;name=aarch64_opencryptoki-icsftok;unpack=0"
SRC_URI[aarch64_opencryptoki-icsftok.sha256sum] = "97d1d4648aa026bd7f509e42f8c151be87d0d0c06d6095f68c4aa664053cd25e"
RPROVIDES:opencryptoki-icsftok:append:aarch64 = " virtual/opencryptoki_token_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-libs-3.26.0-3.el10_2.1.aarch64.rpm;name=aarch64_opencryptoki-libs;unpack=0"
SRC_URI[aarch64_opencryptoki-libs.sha256sum] = "60019c565c4cff0c0b557108385dff09cdc00a1702d94fa8601dddee92abbdc7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-swtok-3.26.0-3.el10_2.1.aarch64.rpm;name=aarch64_opencryptoki-swtok;unpack=0"
SRC_URI[aarch64_opencryptoki-swtok.sha256sum] = "ef6c9a5c189a2077a7ac9805a1ca1e64349e0a9bf245b997b4256afd243e9e74"
RPROVIDES:opencryptoki-swtok:append:aarch64 = " virtual/opencryptoki_token_"

RDEPENDS:opencryptoki = " \
 bash \
 diffutils \
 glibc \
 libcap \
 opencryptoki-libs \
 openssl \
 openssl-libs \
 selinux-policy \
 shadow-utils \
 systemd \
 virtual/coreutils \
 virtual/opencryptoki_token_ \
 "
RDEPENDS:opencryptoki-ccatok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:opencryptoki-devel = " \
 opencryptoki-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:opencryptoki-icsftok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:opencryptoki-libs = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 shadow-utils \
 "
RDEPENDS:opencryptoki-swtok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "
