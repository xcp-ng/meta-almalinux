# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro-crate"
PV = "3.3.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-proc-macro-crate+default-devel \
 rust-proc-macro-crate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro-crate-3.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9629793ad3f195b0ed68bf03207c52e49dc0eaa66aaba55cabc168b564da1118"

URI_x86_64_v2_rust-proc-macro-crate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-crate+default-devel-3.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-crate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-crate+default-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-crate+default-devel.sha256sum] = "7923b212b3e260f9b90ad81823bec0bfa7ee0205bd7c629b4165d6389dae7bb0"

URI_x86_64_v2_rust-proc-macro-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-crate-devel-3.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-crate-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-crate-devel.sha256sum] = "df25d90fabb85dc9a08f6f12c385d26d70ce5b7a4db2c551bb1723caddad1bec"

URI_aarch64_rust-proc-macro-crate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-crate+default-devel-3.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-proc-macro-crate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-crate+default-devel}"
SRC_URI[aarch64_rust-proc-macro-crate+default-devel.sha256sum] = "03f6af359d9aa2d34d7f4a1d9d1c45c3e3c855222ae36681939b2dffa072a5ab"

URI_aarch64_rust-proc-macro-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-crate-devel-3.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-crate-devel}"
SRC_URI[aarch64_rust-proc-macro-crate-devel.sha256sum] = "efcaaaefa019a7a08563f208d27bf6ef87c23502a72c05353731455e721774cc"

RDEPENDS:rust-proc-macro-crate+default-devel = " \
 cargo \
 rust-proc-macro-crate-devel \
 "
RDEPENDS:rust-proc-macro-crate-devel = " \
 cargo \
 rust \
 rust-toml_edit+parse-devel \
 rust-toml_edit-devel \
 "
