# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maturin"
PV = "1.9.6"
PR = "4.el10_2"
PACKAGES = " \
 maturin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/maturin-1.9.6-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "846a67bcb21da725a3354a614da16ae9e10ccedb32795a8af406b2f207320b2f"

URI_x86_64_v2_maturin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maturin-1.9.6-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_maturin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maturin}"
SRC_URI[x86_64_v2_maturin.sha256sum] = "e9657b6e86d165933dbfa5ab526a0e3f4e032a6a7a5565da5f406ce035848b60"

URI_aarch64_maturin = "${EPEL_MIRROR}/aarch64/Packages/m/maturin-1.9.6-4.el10_2.aarch64.rpm;name=aarch64_maturin;unpack=0"
SRC_URI:append = " ${URI_aarch64_maturin}"
SRC_URI[aarch64_maturin.sha256sum] = "8090c1fd4cb24b4fe4da076605a461cb4595088625f6dfda65dfde7202f90811"

RDEPENDS:maturin = " \
 cargo \
 glibc \
 libgcc \
 libzstd \
 python3 \
 "
