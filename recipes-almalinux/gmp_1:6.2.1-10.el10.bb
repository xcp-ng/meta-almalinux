# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gmp"
PE = "1"
PV = "6.2.1"
PR = "10.el10"
PACKAGES = " \
 gmp \
 gmp-c++ \
 gmp-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gmp-6.2.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "defc1fdb7a7e03208e61329f6dab3e2828b95cb7114e655628630fafbf1477b1"

URI_x86_64_v2_gmp = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gmp-6.2.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_gmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gmp}"
SRC_URI[x86_64_v2_gmp.sha256sum] = "9fcb66297dac3b2ee396858f111ac44298dcf8121b06edd9ca83f35aae15b294"

URI_x86_64_v2_gmp-c++ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gmp-c++-6.2.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_gmp-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gmp-c++}"
SRC_URI[x86_64_v2_gmp-c++.sha256sum] = "b8f99e1bb42d63ef5f3e34eaba3ee735da41a238875d24b5680b74d43213e663"

URI_x86_64_v2_gmp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gmp-devel-6.2.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_gmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gmp-devel}"
SRC_URI[x86_64_v2_gmp-devel.sha256sum] = "91c30307f722134e68500a10d51472e0b73065bc980e484a6e34a9a53747c5c4"

URI_aarch64_gmp = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gmp-6.2.1-10.el10.aarch64.rpm;name=aarch64_gmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_gmp}"
SRC_URI[aarch64_gmp.sha256sum] = "cbefb94e2f7b81b84586225ed87e5daf798ef27cfebea007359d6d58fde4373d"

URI_aarch64_gmp-c++ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gmp-c++-6.2.1-10.el10.aarch64.rpm;name=aarch64_gmp-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_gmp-c++}"
SRC_URI[aarch64_gmp-c++.sha256sum] = "73d5f8abcdc193a434805e45284e8a21278e7727f8336508915cc0f08f955325"

URI_aarch64_gmp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gmp-devel-6.2.1-10.el10.aarch64.rpm;name=aarch64_gmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gmp-devel}"
SRC_URI[aarch64_gmp-devel.sha256sum] = "99771ddbca6d098ed25fe559d0b9c54d958b551cfa4dd3c4e4f25c400d8656bd"

RDEPENDS:gmp = " \
 glibc \
 "
RDEPENDS:gmp-c++ = " \
 glibc \
 gmp \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gmp-devel = " \
 gmp \
 gmp-c++ \
 gmp-devel \
 pkgconf-pkg-config \
 "
