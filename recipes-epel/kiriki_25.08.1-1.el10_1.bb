# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiriki"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kiriki \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiriki-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba40e3b1746e28b475b02b79710f20c4deaf614388b15b4209a6b907cfc35735"

URI_x86_64_v2_kiriki = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiriki-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiriki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiriki}"
SRC_URI[x86_64_v2_kiriki.sha256sum] = "f63bc6ab29b0d0bd52294eadccd5d10af523f66c3145327383398c75906667b2"

URI_aarch64_kiriki = "${EPEL_MIRROR}/aarch64/Packages/k/kiriki-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kiriki;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiriki}"
SRC_URI[aarch64_kiriki.sha256sum] = "ecf3f4191c161319cc3ff236425867570dfbcdedfee85010ecfb707040d493a0"

RDEPENDS:kiriki = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
