# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fast-simplification"
PV = "0.1.12"
PR = "1.el10_0"
PACKAGES = " \
 python3-fast-simplification \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fast-simplification-0.1.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "451c43e2dbc65bb5b5f8bcda0468a57710f95566f5e7e1bee4273b59c69e8936"

URI_x86_64_v2_python3-fast-simplification = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fast-simplification-0.1.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fast-simplification;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fast-simplification}"
SRC_URI[x86_64_v2_python3-fast-simplification.sha256sum] = "62b9fcc07f91085573de5e15d04ab190fed4087fcd05600a29e75b6804233ed5"

URI_aarch64_python3-fast-simplification = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fast-simplification-0.1.12-1.el10_0.aarch64.rpm;name=aarch64_python3-fast-simplification;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fast-simplification}"
SRC_URI[aarch64_python3-fast-simplification.sha256sum] = "83cd2922d2b71c8ebb2e25da044f206efc1d5bd7d88af44fc48b627e19fa8ba3"

RDEPENDS:python3-fast-simplification = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-numpy \
 "
