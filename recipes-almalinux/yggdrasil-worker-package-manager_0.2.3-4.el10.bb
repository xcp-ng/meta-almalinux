# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yggdrasil-worker-package-manager"
PV = "0.2.3"
PR = "4.el10"
PACKAGES = " \
 yggdrasil-worker-package-manager \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yggdrasil-worker-package-manager-0.2.3-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "701830abce183f994a28014585892f87365e9e98724fc96dcbd9cd23ef674aa4"

URI_x86_64_v2_yggdrasil-worker-package-manager = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yggdrasil-worker-package-manager-0.2.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_yggdrasil-worker-package-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yggdrasil-worker-package-manager}"
SRC_URI[x86_64_v2_yggdrasil-worker-package-manager.sha256sum] = "873cdfa385574ede5b9fa9ad2a9bb54211e2f94498eb6e2a100c53dd8211c92d"

URI_aarch64_yggdrasil-worker-package-manager = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yggdrasil-worker-package-manager-0.2.3-4.el10.aarch64.rpm;name=aarch64_yggdrasil-worker-package-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_yggdrasil-worker-package-manager}"
SRC_URI[aarch64_yggdrasil-worker-package-manager.sha256sum] = "80036fd323787d8a7061028fcba770b3f1f225a3468978a99c37446ce021764b"

RDEPENDS:yggdrasil-worker-package-manager = " \
 bash \
 glibc \
 "
