# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "roctracer"
PV = "6.4.0"
PR = "3.el10_1"
PACKAGES:x86_64_v2 = " \
 roctracer \
 roctracer-devel \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/roctracer-6.4.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5c75274d155314c4d5f52e35b9aaabe57541700afaf83805781d9537338f4625"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/roctracer-6.4.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_roctracer;unpack=0"
SRC_URI[x86_64_v2_roctracer.sha256sum] = "ba722ba7ed05dc894b7f71002306912b56ce4ab8892e638bd42114ebd210a921"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/roctracer-devel-6.4.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_roctracer-devel;unpack=0"
SRC_URI[x86_64_v2_roctracer-devel.sha256sum] = "270d94b8edd9ea11b34125f492a8a4d87ae6d4c25f5913e4b4a460fde70355ea"

RDEPENDS:roctracer = " \
 glibc \
 libatomic \
 libgcc \
 libstdc++ \
 rocm-comgr \
 rocm-runtime \
 "
RDEPENDS:roctracer-devel = " \
 roctracer \
 "
