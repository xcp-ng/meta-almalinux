# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "Pencil2D"
PV = "0.7.0"
PR = "12.el10_0"
PACKAGES = " \
 Pencil2D \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/Pencil2D-0.7.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fbfdfa4c3c40ed481919aa118333b8895e9e957510568aa611aad9cd25749b1"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - Pencil2D: /usr/bin/ffmpeg

URI_x86_64_v2_Pencil2D = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/Pencil2D-0.7.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_Pencil2D;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_Pencil2D}"
SRC_URI[x86_64_v2_Pencil2D.sha256sum] = "7185258c03cee06f99df66e3579c28b3bd29f027fd547688f8a3fa1271dcfca9"

URI_aarch64_Pencil2D = "${EPEL_MIRROR}/aarch64/Packages/p/Pencil2D-0.7.0-12.el10_0.aarch64.rpm;name=aarch64_Pencil2D;unpack=0"
SRC_URI:append = " ${URI_aarch64_Pencil2D}"
SRC_URI[aarch64_Pencil2D.sha256sum] = "1d25fc2fb7a8e8c6c7132625d6d567b8e6bf432f83b1fc9a1f582356372ddab6"

RDEPENDS:Pencil2D:x86_64_v2 = " \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 miniz \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
"
RDEPENDS:Pencil2D:aarch64 = " \
 ffmpeg-free \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 miniz \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
"
