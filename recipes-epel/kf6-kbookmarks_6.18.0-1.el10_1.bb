# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kbookmarks"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kbookmarks \
 kf6-kbookmarks-devel \
 kf6-kbookmarks-doc \
 kf6-kbookmarks-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kbookmarks-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88afd4e995644fead0e0702ffbc77dd20a3ff2eb188d2c48b292d0fd0f14b9a9"

URI_x86_64_v2_kf6-kbookmarks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kbookmarks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks}"
SRC_URI[x86_64_v2_kf6-kbookmarks.sha256sum] = "7f202d077288ea8bfba9d0b05e2533a67ae76108ba0bfcb62f596af807340be4"

URI_x86_64_v2_kf6-kbookmarks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kbookmarks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks-devel}"
SRC_URI[x86_64_v2_kf6-kbookmarks-devel.sha256sum] = "23fe17c9a2d5dd673aecedb8d8ee92ef1bd5c111dc14df67187ef40c2282e483"

URI_x86_64_v2_kf6-kbookmarks-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kbookmarks-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks-doc}"
SRC_URI[x86_64_v2_kf6-kbookmarks-doc.sha256sum] = "006be31ccb4a6459b51ee2ea9bebf1b74ab45bb61d65f6768fbb27608748520d"

URI_x86_64_v2_kf6-kbookmarks-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kbookmarks-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks-html}"
SRC_URI[x86_64_v2_kf6-kbookmarks-html.sha256sum] = "274e1967456cac9c6bc229a9077679f974bbe091e6601810095bc1674263a0ff"

URI_aarch64_kf6-kbookmarks = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kbookmarks;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks}"
SRC_URI[aarch64_kf6-kbookmarks.sha256sum] = "d4296a3304e937f34ae3b1d2b05ee7fcc3bc7dc66fef8ec09b14a12641ce6586"

URI_aarch64_kf6-kbookmarks-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kbookmarks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks-devel}"
SRC_URI[aarch64_kf6-kbookmarks-devel.sha256sum] = "5370aee2906f1c8c5e654444bb225ee9a61d34bc0594f3f931a940ed6756ceb0"

URI_aarch64_kf6-kbookmarks-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kbookmarks-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks-doc}"
SRC_URI[aarch64_kf6-kbookmarks-doc.sha256sum] = "f26f70eb8cad2083b125196b937441fa01911ea2eb76774bd76845aeb850a249"

URI_aarch64_kf6-kbookmarks-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kbookmarks-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks-html}"
SRC_URI[aarch64_kf6-kbookmarks-html.sha256sum] = "458ffe8f85a3e56e84d97ceef8fcd3ace0e541d27c8f09e604662ada70b3d1a2"

RDEPENDS:kf6-kbookmarks = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kbookmarks-devel = " \
 cmake-filesystem \
 kf6-kbookmarks \
 kf6-kwidgetsaddons-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kbookmarks-doc = " \
 "
RDEPENDS:kf6-kbookmarks-html = " \
 "
