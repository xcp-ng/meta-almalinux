# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vim"
PE = "2"
PV = "9.1.083"
PR = "5.el10_0.1"
PACKAGES = " \
 vim-X11 \
 vim-common \
 vim-data \
 vim-enhanced \
 vim-filesystem \
 vim-minimal \
 xxd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/vim-9.1.083-5.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fd4dd1561f9fc79983333d035254aa32f9aaff90312eaf011aefc13f4001a85"

URI_x86_64_v2_vim-X11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-X11-9.1.083-5.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_vim-X11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-X11}"
SRC_URI[x86_64_v2_vim-X11.sha256sum] = "daa912f0df1f4939909e0c3121ddc58af948ebf11c5250bfb9ed85734e693d3f"

URI_x86_64_v2_vim-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-common-9.1.083-5.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_vim-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-common}"
SRC_URI[x86_64_v2_vim-common.sha256sum] = "3921138d60e76763c259f2fd74d410b51028f1b9568f657a1e5bbaccda8552c9"

URI_x86_64_v2_vim-data = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-data-9.1.083-5.el10_0.1.noarch.rpm;name=x86_64_v2_vim-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-data}"
SRC_URI[x86_64_v2_vim-data.sha256sum] = "54e1243815069deac11366953092dd2a4d1bc40f0e1419020f1900ee207efad6"

URI_x86_64_v2_vim-enhanced = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-enhanced-9.1.083-5.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_vim-enhanced;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-enhanced}"
SRC_URI[x86_64_v2_vim-enhanced.sha256sum] = "5565f36a9595fe35291cb5d8b3b40ad254e9d7afa3c9a79711a997b161eb17fa"

URI_x86_64_v2_vim-filesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-filesystem-9.1.083-5.el10_0.1.noarch.rpm;name=x86_64_v2_vim-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-filesystem}"
SRC_URI[x86_64_v2_vim-filesystem.sha256sum] = "f5a7e74ae9822a40769fc46ad09243f375b9921e705a6211d7dd7cf35907852a"

URI_x86_64_v2_vim-minimal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-minimal-9.1.083-5.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_vim-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-minimal}"
SRC_URI[x86_64_v2_vim-minimal.sha256sum] = "de6be66dc6a2cadb783db29c1cda8e5fcf8bcfb9ec38a89d11b5c52b96a59995"

URI_x86_64_v2_xxd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xxd-9.1.083-5.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_xxd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xxd}"
SRC_URI[x86_64_v2_xxd.sha256sum] = "bf58292177b954263c3ebf71019d56877bf67b69a1d8eb57c20b799f6ebfd8ec"

URI_aarch64_vim-X11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-X11-9.1.083-5.el10_0.1.aarch64.rpm;name=aarch64_vim-X11;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-X11}"
SRC_URI[aarch64_vim-X11.sha256sum] = "6fb87892dd41053bdf0c18ec8850a0a437cc6031768e7fda2b0b70a4490690d3"

URI_aarch64_vim-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-common-9.1.083-5.el10_0.1.aarch64.rpm;name=aarch64_vim-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-common}"
SRC_URI[aarch64_vim-common.sha256sum] = "ab088f16e9d1348c73254bd19ac05b09b764870e082441cc9281f84a523713a1"

URI_aarch64_vim-data = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-data-9.1.083-5.el10_0.1.noarch.rpm;name=aarch64_vim-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-data}"
SRC_URI[aarch64_vim-data.sha256sum] = "54e1243815069deac11366953092dd2a4d1bc40f0e1419020f1900ee207efad6"

URI_aarch64_vim-enhanced = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-enhanced-9.1.083-5.el10_0.1.aarch64.rpm;name=aarch64_vim-enhanced;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-enhanced}"
SRC_URI[aarch64_vim-enhanced.sha256sum] = "ebc9e0f1186cf8a692a2eebdd4168e94ed691bda39c86fca60a5825e17a00f33"

URI_aarch64_vim-filesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-filesystem-9.1.083-5.el10_0.1.noarch.rpm;name=aarch64_vim-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-filesystem}"
SRC_URI[aarch64_vim-filesystem.sha256sum] = "f5a7e74ae9822a40769fc46ad09243f375b9921e705a6211d7dd7cf35907852a"

URI_aarch64_vim-minimal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-minimal-9.1.083-5.el10_0.1.aarch64.rpm;name=aarch64_vim-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-minimal}"
SRC_URI[aarch64_vim-minimal.sha256sum] = "ee896257de38451746949c7a598dcbc1734f0826caf1b9b49a51f3f91ac5c41a"

URI_aarch64_xxd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xxd-9.1.083-5.el10_0.1.aarch64.rpm;name=aarch64_xxd;unpack=0"
SRC_URI:append = " ${URI_aarch64_xxd}"
SRC_URI[aarch64_xxd.sha256sum] = "b287ac857068150bb6b2e8ff9d798401271426eaaddd157d66f92e37699cfb5c"

RDEPENDS:vim-X11 = " \
 bash \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libICE \
 libSM \
 libX11 \
 libXt \
 libacl \
 libattr \
 libcanberra \
 libselinux \
 ncurses-libs \
 pango \
 vim-common \
 "
RDEPENDS:vim-common = " \
 bash \
 vim-data \
 vim-filesystem \
 xxd \
 "
RDEPENDS:vim-data = " \
 "
RDEPENDS:vim-enhanced = " \
 bash \
 glibc \
 libacl \
 libselinux \
 ncurses-libs \
 vim-common \
 which \
 "
RDEPENDS:vim-filesystem = " \
 "
RDEPENDS:vim-minimal = " \
 bash \
 glibc \
 libacl \
 libselinux \
 ncurses-libs \
 vim-data \
 "
RDEPENDS:xxd = " \
 glibc \
 "
