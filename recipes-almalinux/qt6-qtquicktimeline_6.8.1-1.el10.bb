# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtquicktimeline"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtquicktimeline \
 qt6-qtquicktimeline-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtquicktimeline-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6928c0c4f0504ca03f9898dc0033eea47446307cee4bdc53ac04da402f6fc69"

URI_x86_64_v2_qt6-qtquicktimeline = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtquicktimeline-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtquicktimeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtquicktimeline}"
SRC_URI[x86_64_v2_qt6-qtquicktimeline.sha256sum] = "0a0d8a1f5b1468b0caa67e4246003d5912a6ba537e579dcd7f5001e1f00d0ae2"

URI_x86_64_v2_qt6-qtquicktimeline-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtquicktimeline-devel-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtquicktimeline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtquicktimeline-devel}"
SRC_URI[x86_64_v2_qt6-qtquicktimeline-devel.sha256sum] = "2f3c708ebb7c4da252b9278f99a442a8437cb318747bfde7abc69cd5183063b3"

URI_aarch64_qt6-qtquicktimeline = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtquicktimeline-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtquicktimeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtquicktimeline}"
SRC_URI[aarch64_qt6-qtquicktimeline.sha256sum] = "b7c3129d15dd5a7377b2f30f6a0741eeb615c3c53ed99f86c4bb7d043a751c81"

URI_aarch64_qt6-qtquicktimeline-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtquicktimeline-devel-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtquicktimeline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtquicktimeline-devel}"
SRC_URI[aarch64_qt6-qtquicktimeline-devel.sha256sum] = "cbfe6b4cc52444b9a4cfb33657a7ad79d25cb94481b3dd06bb4d2a9964b72367"

RDEPENDS:qt6-qtquicktimeline = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtquicktimeline-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtquicktimeline \
 qt6-qtquicktimeline-devel \
 "
