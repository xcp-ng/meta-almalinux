# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "js-jquery-ui"
PV = "1.14.2"
PR = "1.el10_2"
PACKAGES = " \
 js-jquery-ui \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/js-jquery-ui-1.14.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b3a8cb6017cf0694f8a251e9c6f68f971570cdd95ed028cbbbb84c59bb2fdb5a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/js-jquery-ui-1.14.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_js-jquery-ui;unpack=0"
SRC_URI[x86_64_v2_js-jquery-ui.sha256sum] = "e6e300b830342d54bbde51cd6eae65c4497d8734cab66793689455b808e591ce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/js-jquery-ui-1.14.2-1.el10_2.noarch.rpm;name=aarch64_js-jquery-ui;unpack=0"
SRC_URI[aarch64_js-jquery-ui.sha256sum] = "9361fc8a423d408af2de7a156d602eba864cf32859a5dd56e3b1799944db1786"

RDEPENDS:js-jquery-ui = " \
 js-jquery \
 web-assets-filesystem \
 "
