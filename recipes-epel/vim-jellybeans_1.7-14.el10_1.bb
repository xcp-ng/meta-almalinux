# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vim-jellybeans"
PV = "1.7"
PR = "14.el10_1"
PACKAGES = " \
 vim-jellybeans \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vim-jellybeans-1.7-14.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddf2e4a87390ec4270ea8da1665a8ed9d9c01a4d89ab0cf6192918fe94dce6d8"

URI_x86_64_v2_vim-jellybeans = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vim-jellybeans-1.7-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_vim-jellybeans;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-jellybeans}"
SRC_URI[x86_64_v2_vim-jellybeans.sha256sum] = "7e497bb4766d8fb98b6287b27b53cff852b87713773ecf521798c9e9a0026488"

URI_aarch64_vim-jellybeans = "${EPEL_MIRROR}/aarch64/Packages/v/vim-jellybeans-1.7-14.el10_1.noarch.rpm;name=aarch64_vim-jellybeans;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-jellybeans}"
SRC_URI[aarch64_vim-jellybeans.sha256sum] = "e882e02efb37dfe3036e94f8a52355fa5ee1924cdf805687ed422dca445f087c"

RDEPENDS:vim-jellybeans = " \
 vim-filesystem \
 "
