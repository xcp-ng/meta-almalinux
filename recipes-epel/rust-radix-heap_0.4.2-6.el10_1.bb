# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-radix-heap"
PV = "0.4.2"
PR = "6.el10_1"
PACKAGES = " \
 rust-radix-heap+default-devel \
 rust-radix-heap+ordered-float-devel \
 rust-radix-heap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-radix-heap-0.4.2-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "361f625652bd0b4e556b6229080ab5487b2289913a4290590d9b175c571ac959"

URI_x86_64_v2_rust-radix-heap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-radix-heap+default-devel-0.4.2-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-radix-heap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-radix-heap+default-devel}"
SRC_URI[x86_64_v2_rust-radix-heap+default-devel.sha256sum] = "7d8fd9a13ae6dca65c5b61abee638a631c3010c69c1d2c6fd16f71c9801934b6"

URI_x86_64_v2_rust-radix-heap+ordered-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-radix-heap+ordered-float-devel-0.4.2-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-radix-heap+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-radix-heap+ordered-float-devel}"
SRC_URI[x86_64_v2_rust-radix-heap+ordered-float-devel.sha256sum] = "74a5cf3b0a0cc5fbb500bde83765bc612b982e4aa18cacd5f38ba297532e4d63"

URI_x86_64_v2_rust-radix-heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-radix-heap-devel-0.4.2-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-radix-heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-radix-heap-devel}"
SRC_URI[x86_64_v2_rust-radix-heap-devel.sha256sum] = "fd7f8f8d4933085e7619c347ea3209e19128780cb875742715dab4d63c8801e2"

URI_aarch64_rust-radix-heap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-radix-heap+default-devel-0.4.2-6.el10_1.noarch.rpm;name=aarch64_rust-radix-heap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-radix-heap+default-devel}"
SRC_URI[aarch64_rust-radix-heap+default-devel.sha256sum] = "d26ff902d08c7a3e5c6fb70c628cb9cdc6b5a03835ea0c4d78a4a8af5b8a0a7b"

URI_aarch64_rust-radix-heap+ordered-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-radix-heap+ordered-float-devel-0.4.2-6.el10_1.noarch.rpm;name=aarch64_rust-radix-heap+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-radix-heap+ordered-float-devel}"
SRC_URI[aarch64_rust-radix-heap+ordered-float-devel.sha256sum] = "6284bbe419d37097be459629dbe1e10127ab8e818c66b887a5c3eb14491b2778"

URI_aarch64_rust-radix-heap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-radix-heap-devel-0.4.2-6.el10_1.noarch.rpm;name=aarch64_rust-radix-heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-radix-heap-devel}"
SRC_URI[aarch64_rust-radix-heap-devel.sha256sum] = "505748de9a028eff8b29f67bb956fc018b1f3a0cb32e9c6b692513cd762728d2"

RDEPENDS:rust-radix-heap+default-devel = " \
 cargo \
 rust-radix-heap-devel \
 "
RDEPENDS:rust-radix-heap+ordered-float-devel = " \
 cargo \
 rust-ordered-float2+default-devel \
 rust-radix-heap-devel \
 "
RDEPENDS:rust-radix-heap-devel = " \
 cargo \
 "
