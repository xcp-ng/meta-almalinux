# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "double-conversion"
PV = "3.3.0"
PR = "4.el10_0"
PACKAGES = " \
 double-conversion \
 double-conversion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/double-conversion-3.3.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "743fca7afe16346d6cd465616c57c5645f0e972bdd4825027792e50f8675194b"

URI_x86_64_v2_double-conversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/double-conversion-3.3.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_double-conversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_double-conversion}"
SRC_URI[x86_64_v2_double-conversion.sha256sum] = "39daf2c9b0f4713047215b9faa5b1c071370d0b912ef1b4994de3931608737df"

URI_x86_64_v2_double-conversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/double-conversion-devel-3.3.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_double-conversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_double-conversion-devel}"
SRC_URI[x86_64_v2_double-conversion-devel.sha256sum] = "91d535000d7189a2d8df4fa72be7db78413b585757d2e430a79dff41ca90e36c"

URI_aarch64_double-conversion = "${EPEL_MIRROR}/aarch64/Packages/d/double-conversion-3.3.0-4.el10_0.aarch64.rpm;name=aarch64_double-conversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_double-conversion}"
SRC_URI[aarch64_double-conversion.sha256sum] = "b57ca2fbe6313b4ccb95aa1fe03ac915ec7a7d15b72deb7c3a1a6ac2ac14d8fd"

URI_aarch64_double-conversion-devel = "${EPEL_MIRROR}/aarch64/Packages/d/double-conversion-devel-3.3.0-4.el10_0.aarch64.rpm;name=aarch64_double-conversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_double-conversion-devel}"
SRC_URI[aarch64_double-conversion-devel.sha256sum] = "c0faaa2c61a513c3bbb1b8e1380cd756a301af18915b7b436d1820e91f6d7c7d"

RDEPENDS:double-conversion = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:double-conversion-devel = " \
 cmake-filesystem \
 double-conversion \
 "
