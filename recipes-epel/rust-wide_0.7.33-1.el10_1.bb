# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wide"
PV = "0.7.33"
PR = "1.el10_1"
PACKAGES = " \
 rust-wide+default-devel \
 rust-wide+serde-devel \
 rust-wide+std-devel \
 rust-wide-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wide-0.7.33-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0ed7865a914b1e8f42321c1cc95d108648b3902e1442d0f5d209cc2d62c7124"

URI_x86_64_v2_rust-wide+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wide+default-devel-0.7.33-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wide+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wide+default-devel}"
SRC_URI[x86_64_v2_rust-wide+default-devel.sha256sum] = "539f720b68293c35d6719ed501073afff0b61ee5a8a16272cd067a63a3c0d0e9"

URI_x86_64_v2_rust-wide+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wide+serde-devel-0.7.33-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wide+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wide+serde-devel}"
SRC_URI[x86_64_v2_rust-wide+serde-devel.sha256sum] = "ee1119525e95908368d4a51984b1a79352bb1a626d2b7342e6fd59f0c0ba7cc5"

URI_x86_64_v2_rust-wide+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wide+std-devel-0.7.33-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wide+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wide+std-devel}"
SRC_URI[x86_64_v2_rust-wide+std-devel.sha256sum] = "b7959fe3987331e227e18cdfdda0f47d1dfdbd379bcb79386bbd0f9f8e190ac1"

URI_x86_64_v2_rust-wide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wide-devel-0.7.33-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wide-devel}"
SRC_URI[x86_64_v2_rust-wide-devel.sha256sum] = "49ff65d966eb352a715b27c9498677eec2abaca59f7f14a34e63daaf09ca9150"

URI_aarch64_rust-wide+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wide+default-devel-0.7.33-1.el10_1.noarch.rpm;name=aarch64_rust-wide+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wide+default-devel}"
SRC_URI[aarch64_rust-wide+default-devel.sha256sum] = "d8b7058ae893c0a5986e295fbd6f0a44d224b328ef1b25b984f89ed35b5e8388"

URI_aarch64_rust-wide+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wide+serde-devel-0.7.33-1.el10_1.noarch.rpm;name=aarch64_rust-wide+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wide+serde-devel}"
SRC_URI[aarch64_rust-wide+serde-devel.sha256sum] = "76edef0612792532d536094c45b1af7219192dcb5f0748dd760342808a115351"

URI_aarch64_rust-wide+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wide+std-devel-0.7.33-1.el10_1.noarch.rpm;name=aarch64_rust-wide+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wide+std-devel}"
SRC_URI[aarch64_rust-wide+std-devel.sha256sum] = "4850477f7ca3a95479d841b3a0bee90bd62e7ba162079f1765ce3729ee103388"

URI_aarch64_rust-wide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wide-devel-0.7.33-1.el10_1.noarch.rpm;name=aarch64_rust-wide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wide-devel}"
SRC_URI[aarch64_rust-wide-devel.sha256sum] = "ec7567f863795e6fa9b37ef2491a5683d26131790a17fda634b545923d0f76a7"

RDEPENDS:rust-wide+default-devel = " \
 cargo \
 rust-wide+std-devel \
 rust-wide-devel \
 "
RDEPENDS:rust-wide+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-wide-devel \
 "
RDEPENDS:rust-wide+std-devel = " \
 cargo \
 rust-wide-devel \
 "
RDEPENDS:rust-wide-devel = " \
 cargo \
 rust \
 rust-bytemuck+default-devel \
 rust-safe_arch+bytemuck-devel \
 rust-safe_arch+default-devel \
 "
