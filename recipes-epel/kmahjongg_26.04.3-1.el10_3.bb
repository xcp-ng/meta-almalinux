# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmahjongg"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kmahjongg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmahjongg-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3f657308065540e5612f8d42b0c9f2d70dbc2f7e1c2e73d34e4ce2607505c91"

URI_x86_64_v2_kmahjongg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmahjongg-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmahjongg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmahjongg}"
SRC_URI[x86_64_v2_kmahjongg.sha256sum] = "edc17136c6c0ac89eaf61e7b5ef48138813492c60052b51882d339155c25ebbe"

URI_aarch64_kmahjongg = "${EPEL_MIRROR}/aarch64/Packages/k/kmahjongg-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmahjongg;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmahjongg}"
SRC_URI[aarch64_kmahjongg.sha256sum] = "c8784c55a633806eb226f136736ac6164b5a6da51f7dae2d5098c253a10334c0"

RDEPENDS:kmahjongg = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libkmahjongg \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
