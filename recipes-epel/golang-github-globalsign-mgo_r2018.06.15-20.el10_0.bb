# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-globalsign-mgo"
PV = "r2018.06.15"
PR = "20.el10_0"
PACKAGES = " \
 golang-github-globalsign-mgo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-globalsign-mgo-r2018.06.15-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d405f983b8f476a9270b22fe14741730722169859f2f1e1855717e338285b965"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-github-globalsign-mgo-devel: golang(gopkg.in/tomb.v2)

URI_x86_64_v2_golang-github-globalsign-mgo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-globalsign-mgo-devel-r2018.06.15-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-globalsign-mgo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-globalsign-mgo-devel}"
SRC_URI[x86_64_v2_golang-github-globalsign-mgo-devel.sha256sum] = "206b49bad8ce22601aee8efd7eee27537614d73ef6fc1fb9a963663fdcfd51f9"

URI_aarch64_golang-github-globalsign-mgo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-globalsign-mgo-devel-r2018.06.15-20.el10_0.noarch.rpm;name=aarch64_golang-github-globalsign-mgo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-globalsign-mgo-devel}"
SRC_URI[aarch64_golang-github-globalsign-mgo-devel.sha256sum] = "a725a71c90bf770152d6823d01c1c852f0ef35d109305ff9244c2d17b45651c9"

RDEPENDS:golang-github-globalsign-mgo-devel:x86_64_v2 = " \
 go-filesystem \
"
RDEPENDS:golang-github-globalsign-mgo-devel:aarch64 = " \
 go-filesystem \
 golang-gopkg-tomb-2-devel \
"
