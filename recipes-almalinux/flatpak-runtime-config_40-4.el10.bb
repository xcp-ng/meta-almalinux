# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak-runtime-config"
PV = "40"
PR = "4.el10"
PACKAGES = " \
 flatpak-runtime-config \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/flatpak-runtime-config-40-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a9aeb8c0b7633eec03cbf2d59ddbeffd24c8458c4c38a89a949a2e8e57be3a0"

URI_x86_64_v2_flatpak-runtime-config = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/flatpak-runtime-config-40-4.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-runtime-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-runtime-config}"
SRC_URI[x86_64_v2_flatpak-runtime-config.sha256sum] = "1ee9af81ea6c4f8c52917f7feaa364fa860ef7739a987da31e510e19e4287f8b"

URI_aarch64_flatpak-runtime-config = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/flatpak-runtime-config-40-4.el10.aarch64.rpm;name=aarch64_flatpak-runtime-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-runtime-config}"
SRC_URI[aarch64_flatpak-runtime-config.sha256sum] = "d8188e1543940f4c06842bcbacfd503010bcb42b3f6ed0c1c567a340e910f2d8"

RDEPENDS:flatpak-runtime-config = " \
 bash \
 findutils \
 fonts-filesystem \
 glibc \
 "
