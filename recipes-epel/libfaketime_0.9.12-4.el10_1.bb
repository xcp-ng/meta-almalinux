# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libfaketime"
PV = "0.9.12"
PR = "4.el10_1"
PACKAGES = " \
 libfaketime \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libfaketime-0.9.12-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6e318ef9cf39c26077fecf6b90b8bb4494b861a7f4e411ef86f43d07cb3ab86"

URI_x86_64_v2_libfaketime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfaketime-0.9.12-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfaketime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfaketime}"
SRC_URI[x86_64_v2_libfaketime.sha256sum] = "d1601e22a3154b2e6f3997bb670cc771e0ecadcfdda6e6d54624cf6bfc03e408"

URI_aarch64_libfaketime = "${EPEL_MIRROR}/aarch64/Packages/l/libfaketime-0.9.12-4.el10_1.aarch64.rpm;name=aarch64_libfaketime;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfaketime}"
SRC_URI[aarch64_libfaketime.sha256sum] = "68024817428d85bea5ee48b9b7bbe01c135968447a1d28d917154687f7ab1aae"

RDEPENDS:libfaketime = " \
 glibc \
 libgcc \
 "
