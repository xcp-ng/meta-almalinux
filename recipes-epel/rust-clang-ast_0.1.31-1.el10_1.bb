# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clang-ast"
PV = "0.1.31"
PR = "1.el10_1"
PACKAGES = " \
 rust-clang-ast+default-devel \
 rust-clang-ast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clang-ast-0.1.31-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7ac10910456f747730bb39ca53b50e5b6313385f1baf4afa45014bcd11f92b9"

URI_x86_64_v2_rust-clang-ast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-ast+default-devel-0.1.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-ast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-ast+default-devel}"
SRC_URI[x86_64_v2_rust-clang-ast+default-devel.sha256sum] = "5c488f8374ed14c9b03782bbeb6075ed3cb8c74a6dc1175bcedc1a93b849d838"

URI_x86_64_v2_rust-clang-ast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-ast-devel-0.1.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-ast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-ast-devel}"
SRC_URI[x86_64_v2_rust-clang-ast-devel.sha256sum] = "ed40c6ed2e0e0d3ff5b6a16cbc9302a5e8307d6b4527a718308a1e7d0b38e915"

URI_aarch64_rust-clang-ast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-ast+default-devel-0.1.31-1.el10_1.noarch.rpm;name=aarch64_rust-clang-ast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-ast+default-devel}"
SRC_URI[aarch64_rust-clang-ast+default-devel.sha256sum] = "7c651ac534ea3cf312701b2cfeef053c508476c871f27754623dd1df853b7111"

URI_aarch64_rust-clang-ast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-ast-devel-0.1.31-1.el10_1.noarch.rpm;name=aarch64_rust-clang-ast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-ast-devel}"
SRC_URI[aarch64_rust-clang-ast-devel.sha256sum] = "16e6a27009069f7b75b058ed68ee9f26614c23bd3fc0db51448708fb2deb5884"

RDEPENDS:rust-clang-ast+default-devel = " \
 cargo \
 rust-clang-ast-devel \
 "
RDEPENDS:rust-clang-ast-devel = " \
 cargo \
 rust-foldhash0.1+default-devel \
 rust-serde+default-devel \
 "
