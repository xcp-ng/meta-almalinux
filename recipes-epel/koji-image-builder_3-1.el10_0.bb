# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "koji-image-builder"
PV = "3"
PR = "1.el10_0"
PACKAGES = " \
 koji-image-builder \
 koji-image-builder-builder \
 koji-image-builder-cli \
 koji-image-builder-hub \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/koji-image-builder-3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bae4e98e05dd1bf3abf0d2d51a8c695274e1633dac8325a10c303fda8c240a86"

URI_x86_64_v2_koji-image-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-image-builder-3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_koji-image-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-image-builder}"
SRC_URI[x86_64_v2_koji-image-builder.sha256sum] = "02daa58e1bded83cbe2eaa1ba26f6b24a5ca53b03d09358ea96e0c713652aee6"

URI_x86_64_v2_koji-image-builder-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-image-builder-builder-3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_koji-image-builder-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-image-builder-builder}"
SRC_URI[x86_64_v2_koji-image-builder-builder.sha256sum] = "e13f1463c8707a353602414d86db9aa7b935ebb8d3ecd3ffed4c697b886fba30"

URI_x86_64_v2_koji-image-builder-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-image-builder-cli-3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_koji-image-builder-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-image-builder-cli}"
SRC_URI[x86_64_v2_koji-image-builder-cli.sha256sum] = "254f9baabf13222ac65f4237672f4fbc964efd236fba5bc229e00dd852dfbfd1"

URI_x86_64_v2_koji-image-builder-hub = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-image-builder-hub-3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_koji-image-builder-hub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-image-builder-hub}"
SRC_URI[x86_64_v2_koji-image-builder-hub.sha256sum] = "727ea24db666d51a9e5909d1346b8fba44cfd0669c8a7adcea5efb86e01b60f4"

URI_aarch64_koji-image-builder = "${EPEL_MIRROR}/aarch64/Packages/k/koji-image-builder-3-1.el10_0.noarch.rpm;name=aarch64_koji-image-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-image-builder}"
SRC_URI[aarch64_koji-image-builder.sha256sum] = "dbf8a358b89a72a0e95f5efbaa8b40980b10935085f91ef96bd950524477f1c2"

URI_aarch64_koji-image-builder-builder = "${EPEL_MIRROR}/aarch64/Packages/k/koji-image-builder-builder-3-1.el10_0.noarch.rpm;name=aarch64_koji-image-builder-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-image-builder-builder}"
SRC_URI[aarch64_koji-image-builder-builder.sha256sum] = "f8a5b740f51d9c60e5513df4ec7d23bb7ceb4a413f14a2789428f45a49ba70c8"

URI_aarch64_koji-image-builder-cli = "${EPEL_MIRROR}/aarch64/Packages/k/koji-image-builder-cli-3-1.el10_0.noarch.rpm;name=aarch64_koji-image-builder-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-image-builder-cli}"
SRC_URI[aarch64_koji-image-builder-cli.sha256sum] = "c69da86c4675f5785269019b795d938f73363f6002f2722ebb7f37c7faa9c6b2"

URI_aarch64_koji-image-builder-hub = "${EPEL_MIRROR}/aarch64/Packages/k/koji-image-builder-hub-3-1.el10_0.noarch.rpm;name=aarch64_koji-image-builder-hub;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-image-builder-hub}"
SRC_URI[aarch64_koji-image-builder-hub.sha256sum] = "7a21e4d4f0fd772d4ebd9817c6d84ae64968245f8b5ea6a2c4973a8d68fd4717"

RDEPENDS:koji-image-builder = " \
 "
RDEPENDS:koji-image-builder-builder = " \
 koji-builder \
 koji-builder-plugins \
 koji-image-builder \
 python3 \
 "
RDEPENDS:koji-image-builder-cli = " \
 koji \
 koji-image-builder \
 python3 \
 python3-koji-cli-plugins \
 "
RDEPENDS:koji-image-builder-hub = " \
 koji-hub \
 koji-hub-plugins \
 koji-image-builder \
 python3-jsonschema \
 "
