# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-OpenSSL-AES"
PV = "0.23"
PR = "1.el10_2"
PACKAGES = " \
 perl-Crypt-OpenSSL-AES \
 perl-Crypt-OpenSSL-AES-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-OpenSSL-AES-0.23-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63313b2ba9a2e1f4cc46f957999ad73d6bd7330e247a5748c3c05afe8e866556"

URI_x86_64_v2_perl-Crypt-OpenSSL-AES = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-AES-0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-AES;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-AES}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-AES.sha256sum] = "424b896997c1fbdbde4c2339f129d63459f0c8264ee29852aa5d9c7888c2996f"

URI_x86_64_v2_perl-Crypt-OpenSSL-AES-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-AES-tests-0.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-AES-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-AES-tests}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-AES-tests.sha256sum] = "489275c647e8bb10a102635358067aa40b79f524730fd62f3a701cfbdda4226b"

URI_aarch64_perl-Crypt-OpenSSL-AES = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-AES-0.23-1.el10_2.aarch64.rpm;name=aarch64_perl-Crypt-OpenSSL-AES;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-AES}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-AES.sha256sum] = "85af35ad74faaa0e75b87a4fddb72d519b6d8c135c4634e14065477a8689dec8"

URI_aarch64_perl-Crypt-OpenSSL-AES-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-AES-tests-0.23-1.el10_2.noarch.rpm;name=aarch64_perl-Crypt-OpenSSL-AES-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-AES-tests}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-AES-tests.sha256sum] = "c9d661bf604334e00fb15e1b51f39210f96b4c0946ca334b67e8554d5f3ee67a"

RDEPENDS:perl-Crypt-OpenSSL-AES = " \
 glibc \
 openssl-libs \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Crypt-OpenSSL-AES-tests = " \
 bash \
 openssl \
 perl-Crypt-OpenSSL-AES \
 perl-Crypt-OpenSSL-Guess \
 perl-Crypt-URandom \
 perl-Digest-SHA \
 perl-MIME-Base64 \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
