# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipa"
PV = "4.13.4"
PR = "1.el10"
PACKAGES = " \
 ipa-client \
 ipa-client-common \
 ipa-client-encrypted-dns \
 ipa-client-epn \
 ipa-client-samba \
 ipa-common \
 ipa-selinux \
 ipa-selinux-luna \
 ipa-selinux-nfast \
 ipa-server \
 ipa-server-common \
 ipa-server-dns \
 ipa-server-encrypted-dns \
 ipa-server-trust-ad \
 python3-ipaclient \
 python3-ipalib \
 python3-ipaserver \
 python3-ipatests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ipa-4.13.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "deeebc663dfa2147c647da50b5f328f36149534c4d68983d58d19008fda47e3b"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3-ipaclient: augeas-libs >= 1.12.1-0
# - python3-ipaserver: augeas-libs >= 1.12.1-0

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - python3-ipaclient: augeas-libs >= 1.12.1-0
# - python3-ipaserver: augeas-libs >= 1.12.1-0

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-4.13.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_ipa-client;unpack=0"
SRC_URI[x86_64_v2_ipa-client.sha256sum] = "1b2af088d362b963fa84e58ee2f5ae7bcacef43e2af4c20b53467a21c94d0659"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-common-4.13.4-1.el10.noarch.rpm;name=x86_64_v2_ipa-client-common;unpack=0"
SRC_URI[x86_64_v2_ipa-client-common.sha256sum] = "de6ab20fa5d5968125327acc78309c82a8a5f04d17fea8e8f917b86df4665457"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-encrypted-dns-4.13.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_ipa-client-encrypted-dns;unpack=0"
SRC_URI[x86_64_v2_ipa-client-encrypted-dns.sha256sum] = "ea389c8f54f7dc55ae0d28b9c9330340470bfc535653184e86c8c518715c1ba0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-epn-4.13.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_ipa-client-epn;unpack=0"
SRC_URI[x86_64_v2_ipa-client-epn.sha256sum] = "b328da01b234d4b8e879a2b9e678ae725c757bc6583273a57861ca705b9130ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-samba-4.13.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_ipa-client-samba;unpack=0"
SRC_URI[x86_64_v2_ipa-client-samba.sha256sum] = "ecc187ca628b5ac1d00089b399483a5d99579f11c76aeecd4bc27b04b11de4cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-common-4.13.4-1.el10.noarch.rpm;name=x86_64_v2_ipa-common;unpack=0"
SRC_URI[x86_64_v2_ipa-common.sha256sum] = "348b1aa7792fa0f83293c0c979bee490b58a4df1dd1342feacbfb8371217dddf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-4.13.4-1.el10.noarch.rpm;name=x86_64_v2_ipa-selinux;unpack=0"
SRC_URI[x86_64_v2_ipa-selinux.sha256sum] = "5f111d33ba1cfb75753bd2e1e0ccbc63a10980fb7dbc482794cdb085dbb0edf2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-luna-4.13.4-1.el10.noarch.rpm;name=x86_64_v2_ipa-selinux-luna;unpack=0"
SRC_URI[x86_64_v2_ipa-selinux-luna.sha256sum] = "557ce131cfbffe0d2c744623108c1ca71efa200f0d62f22435a9890609bd6576"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-nfast-4.13.4-1.el10.noarch.rpm;name=x86_64_v2_ipa-selinux-nfast;unpack=0"
SRC_URI[x86_64_v2_ipa-selinux-nfast.sha256sum] = "69a3271c74ff45dc9bd924b9584c15b0a94ee0fc680d4938929c5e68d4fe59f1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-4.13.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_ipa-server;unpack=0"
SRC_URI[x86_64_v2_ipa-server.sha256sum] = "1d864a780ca5b84abf77b848ec9fec9d8cab80991e1bf9333fa8971cc68208e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-common-4.13.4-1.el10.noarch.rpm;name=x86_64_v2_ipa-server-common;unpack=0"
SRC_URI[x86_64_v2_ipa-server-common.sha256sum] = "547d45fb57a3b05bb582136d12b5af7daee819df1da8c34ec487ab5c22a479bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-dns-4.13.4-1.el10.noarch.rpm;name=x86_64_v2_ipa-server-dns;unpack=0"
SRC_URI[x86_64_v2_ipa-server-dns.sha256sum] = "229aa52cf80985bd814d8a1f8abded037cb7433cf2f884a3c2743df7fa5c1bb5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-encrypted-dns-4.13.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_ipa-server-encrypted-dns;unpack=0"
SRC_URI[x86_64_v2_ipa-server-encrypted-dns.sha256sum] = "0994901a16fc60dfee906ebfd0f1f6be190183cf473cdd0ee078bb17ebef093f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-trust-ad-4.13.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_ipa-server-trust-ad;unpack=0"
SRC_URI[x86_64_v2_ipa-server-trust-ad.sha256sum] = "9a450ff3ce2772dc91db1b041344d06580aad928d19b4ac6f56d732135d14360"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipaclient-4.13.4-1.el10.noarch.rpm;name=x86_64_v2_python3-ipaclient;unpack=0"
SRC_URI[x86_64_v2_python3-ipaclient.sha256sum] = "5269c24f31da5c2e39f54d1eb981f6d29116ca256bea508da59484510433b5da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipalib-4.13.4-1.el10.noarch.rpm;name=x86_64_v2_python3-ipalib;unpack=0"
SRC_URI[x86_64_v2_python3-ipalib.sha256sum] = "3d844adeecc871fd78ea3b551b4f0cda01999b7166513a02e6aef98312d7d51e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipaserver-4.13.4-1.el10.noarch.rpm;name=x86_64_v2_python3-ipaserver;unpack=0"
SRC_URI[x86_64_v2_python3-ipaserver.sha256sum] = "1d13742955f4bb5b663ac72ada5e7b3c31b530f93e1ecba65650258d06aa7832"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-ipatests-4.13.4-1.el10.noarch.rpm;name=x86_64_v2_python3-ipatests;unpack=0"
SRC_URI[x86_64_v2_python3-ipatests.sha256sum] = "d358a76c25855eb43fd5429adf50400a75a0f036a024be38895ca53ca6a88cee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-4.13.4-1.el10.aarch64.rpm;name=aarch64_ipa-client;unpack=0"
SRC_URI[aarch64_ipa-client.sha256sum] = "ca223efae8bdeec706985f934832fe9ef27c3b86a33c7436c481c012301261ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-common-4.13.4-1.el10.noarch.rpm;name=aarch64_ipa-client-common;unpack=0"
SRC_URI[aarch64_ipa-client-common.sha256sum] = "de6ab20fa5d5968125327acc78309c82a8a5f04d17fea8e8f917b86df4665457"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-encrypted-dns-4.13.4-1.el10.aarch64.rpm;name=aarch64_ipa-client-encrypted-dns;unpack=0"
SRC_URI[aarch64_ipa-client-encrypted-dns.sha256sum] = "bd105f84bdd33c91b92eb7400ffd4f045ebfe66d9115caac4bebdcd3bbf0fdc4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-epn-4.13.4-1.el10.aarch64.rpm;name=aarch64_ipa-client-epn;unpack=0"
SRC_URI[aarch64_ipa-client-epn.sha256sum] = "04f3c1b4c8897d590b2be0ad46e4c7ad64420081d19667e712cdebe6c6f368a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-samba-4.13.4-1.el10.aarch64.rpm;name=aarch64_ipa-client-samba;unpack=0"
SRC_URI[aarch64_ipa-client-samba.sha256sum] = "18aca16f414eb54dd1265f259896eea4bea61121c7fdfe09bc1d51be35401a7b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-common-4.13.4-1.el10.noarch.rpm;name=aarch64_ipa-common;unpack=0"
SRC_URI[aarch64_ipa-common.sha256sum] = "348b1aa7792fa0f83293c0c979bee490b58a4df1dd1342feacbfb8371217dddf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-4.13.4-1.el10.noarch.rpm;name=aarch64_ipa-selinux;unpack=0"
SRC_URI[aarch64_ipa-selinux.sha256sum] = "5f111d33ba1cfb75753bd2e1e0ccbc63a10980fb7dbc482794cdb085dbb0edf2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-luna-4.13.4-1.el10.noarch.rpm;name=aarch64_ipa-selinux-luna;unpack=0"
SRC_URI[aarch64_ipa-selinux-luna.sha256sum] = "557ce131cfbffe0d2c744623108c1ca71efa200f0d62f22435a9890609bd6576"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-nfast-4.13.4-1.el10.noarch.rpm;name=aarch64_ipa-selinux-nfast;unpack=0"
SRC_URI[aarch64_ipa-selinux-nfast.sha256sum] = "69a3271c74ff45dc9bd924b9584c15b0a94ee0fc680d4938929c5e68d4fe59f1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-4.13.4-1.el10.aarch64.rpm;name=aarch64_ipa-server;unpack=0"
SRC_URI[aarch64_ipa-server.sha256sum] = "6c16db69e230d56019594ea48f54fb367d84f42ffa61c1203a132cab352c6ac1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-common-4.13.4-1.el10.noarch.rpm;name=aarch64_ipa-server-common;unpack=0"
SRC_URI[aarch64_ipa-server-common.sha256sum] = "547d45fb57a3b05bb582136d12b5af7daee819df1da8c34ec487ab5c22a479bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-dns-4.13.4-1.el10.noarch.rpm;name=aarch64_ipa-server-dns;unpack=0"
SRC_URI[aarch64_ipa-server-dns.sha256sum] = "229aa52cf80985bd814d8a1f8abded037cb7433cf2f884a3c2743df7fa5c1bb5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-encrypted-dns-4.13.4-1.el10.aarch64.rpm;name=aarch64_ipa-server-encrypted-dns;unpack=0"
SRC_URI[aarch64_ipa-server-encrypted-dns.sha256sum] = "9b2cb8fb5db7b1f992cbb473d084cef4290dabc8ed8d3c7403135c10ac12c89d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-trust-ad-4.13.4-1.el10.aarch64.rpm;name=aarch64_ipa-server-trust-ad;unpack=0"
SRC_URI[aarch64_ipa-server-trust-ad.sha256sum] = "2e401687871047eff1cc8d75d9c143096774204a13a076cb8dcc7404abeb6515"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipaclient-4.13.4-1.el10.noarch.rpm;name=aarch64_python3-ipaclient;unpack=0"
SRC_URI[aarch64_python3-ipaclient.sha256sum] = "5269c24f31da5c2e39f54d1eb981f6d29116ca256bea508da59484510433b5da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipalib-4.13.4-1.el10.noarch.rpm;name=aarch64_python3-ipalib;unpack=0"
SRC_URI[aarch64_python3-ipalib.sha256sum] = "3d844adeecc871fd78ea3b551b4f0cda01999b7166513a02e6aef98312d7d51e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipaserver-4.13.4-1.el10.noarch.rpm;name=aarch64_python3-ipaserver;unpack=0"
SRC_URI[aarch64_python3-ipaserver.sha256sum] = "1d13742955f4bb5b663ac72ada5e7b3c31b530f93e1ecba65650258d06aa7832"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-ipatests-4.13.4-1.el10.noarch.rpm;name=aarch64_python3-ipatests;unpack=0"
SRC_URI[aarch64_python3-ipatests.sha256sum] = "d358a76c25855eb43fd5429adf50400a75a0f036a024be38895ca53ca6a88cee"

RDEPENDS:ipa-client = " \
 authselect \
 autofs \
 bash \
 bind-utils \
 certmonger \
 chrony \
 curl \
 cyrus-sasl-gssapi \
 glibc \
 hostname \
 ipa-client-common \
 ipa-common \
 jansson \
 krb5-libs \
 krb5-pkinit \
 krb5-workstation \
 libcom_err \
 libini_config \
 libnfsidmap \
 libsss_autofs \
 libsss_sudo \
 nss-tools \
 oddjob-mkhomedir \
 openldap \
 openssl-libs \
 policycoreutils \
 popt \
 python3 \
 python3-gssapi \
 python3-ipaclient \
 python3-ldap \
 python3-sssdconfig \
 sssd-idp \
 sssd-ipa \
 sssd-krb5 \
 sssd-tools \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_ge_7.21.7-2 \
 virtual/nfs-utils_or_nfsv4-client-utils \
 "
RDEPENDS:ipa-client-common = " \
 "
RDEPENDS:ipa-client-encrypted-dns = " \
 unbound \
 "
RDEPENDS:ipa-client-epn = " \
 bash \
 ipa-client \
 python3 \
 systemd \
 "
RDEPENDS:ipa-client-samba = " \
 cifs-utils \
 ipa-client \
 python3 \
 python3-samba \
 samba \
 samba-client \
 samba-common-tools \
 samba-winbind \
 sssd-winbind-idmap \
 tdb-tools \
 "
RDEPENDS:ipa-common = " \
 ipa-selinux \
 "
RDEPENDS:ipa-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-selinux-luna = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-selinux-nfast = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-server = " \
 389-ds-base \
 acl \
 bash \
 certmonger \
 chrony \
 cracklib-dicts \
 cyrus-sasl-gssapi \
 fontawesome4-fonts \
 glibc \
 gssproxy \
 gzip \
 httpd \
 idm-pki-acme \
 idm-pki-ca \
 idm-pki-kra \
 ipa-client \
 ipa-common \
 ipa-server-common \
 jansson \
 krb5-libs \
 krb5-server \
 libcom_err \
 libgcc \
 libpwquality \
 libsss_certmap \
 libsss_nss_idmap \
 libtalloc \
 libtevent \
 libunistring \
 libuuid \
 libverto \
 mod_auth_gssapi \
 mod_lookup_identity \
 mod_session \
 mod_ssl \
 nss-tools \
 oddjob \
 open-sans-fonts \
 openldap \
 openldap-clients \
 openssl \
 openssl-libs \
 p11-kit \
 policycoreutils \
 popt \
 python3 \
 python3-gssapi \
 python3-ipaserver \
 python3-ldap \
 python3-mod_wsgi \
 python3-systemd \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 selinux-policy \
 shadow-utils \
 slapi-nis \
 softhsm \
 sssd-dbus \
 systemd \
 tar \
 "
RDEPENDS:ipa-server-common = " \
 almalinux-logos-ipa \
 httpd \
 ipa-client-common \
 systemd \
 "
RDEPENDS:ipa-server-dns = " \
 bash \
 bind \
 bind-dnssec-utils \
 bind-dyndb-ldap \
 bind-utils \
 ipa-server \
 opendnssec \
 pkcs11-provider \
 python3 \
 softhsm \
 systemd \
 "
RDEPENDS:ipa-server-encrypted-dns = " \
 bind-dyndb-ldap \
 ipa-client-encrypted-dns \
 "
RDEPENDS:ipa-server-trust-ad = " \
 alternatives \
 bash \
 glibc \
 ipa-common \
 ipa-server \
 krb5-libs \
 libcom_err \
 libpwquality \
 libsss_idmap \
 libtalloc \
 libtevent \
 openldap \
 openssl-libs \
 python3 \
 python3-libsss_nss_idmap \
 python3-samba \
 python3-sss \
 samba \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 samba-winbind \
 sssd-winbind-idmap \
 "
RDEPENDS:python3-ipaclient = " \
 ipa-client-common \
 ipa-common \
 python3 \
 python3-augeas \
 python3-cryptography \
 python3-dns \
 python3-ipalib \
 python3-jinja2 \
 python3-qrcode \
 python3-six \
 "
RDEPENDS:python3-ipalib = " \
 gnupg2 \
 ipa-common \
 keyutils \
 python3 \
 python3-argcomplete \
 python3-cffi \
 python3-cryptography \
 python3-dateutil \
 python3-dbus \
 python3-dns \
 python3-gssapi \
 python3-ifaddr \
 python3-jwcrypto \
 python3-ldap \
 python3-libipa_hbac \
 python3-netaddr \
 python3-packaging \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-pyusb \
 python3-qrcode \
 python3-requests \
 python3-six \
 python3-sss-murmur \
 python3-systemd \
 python3-urllib3 \
 python3-yubico \
 "
RDEPENDS:python3-ipaserver = " \
 ipa-common \
 ipa-server-common \
 python3 \
 python3-augeas \
 python3-cryptography \
 python3-dbus \
 python3-dns \
 python3-gssapi \
 python3-idm-pki \
 python3-ipaclient \
 python3-ipalib \
 python3-jwcrypto \
 python3-kdcproxy \
 python3-ldap \
 python3-lxml \
 python3-netaddr \
 python3-psutil \
 python3-pyasn1 \
 python3-requests \
 python3-six \
 python3-sssdconfig \
 python3-urllib3 \
 rpm-libs \
 "
RDEPENDS:python3-ipatests = " \
 iptables-nft \
 openssh-clients \
 python3-cryptography \
 python3-ipaclient \
 python3-ipaserver \
 python3-sssdconfig \
 tar \
 xz \
 "
