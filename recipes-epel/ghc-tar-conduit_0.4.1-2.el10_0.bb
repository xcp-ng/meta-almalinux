# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-tar-conduit"
PV = "0.4.1"
PR = "2.el10_0"
PACKAGES = " \
 ghc-tar-conduit \
 ghc-tar-conduit-devel \
 ghc-tar-conduit-doc \
 ghc-tar-conduit-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-tar-conduit-0.4.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cc6d5d022c469382c58c117ab29d6b1093c70008ff530dc1a324cf2e76f5e09"

URI_x86_64_v2_ghc-tar-conduit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tar-conduit-0.4.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tar-conduit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tar-conduit}"
SRC_URI[x86_64_v2_ghc-tar-conduit.sha256sum] = "7fcfb2e72f698ae3349cfdd7f7841468c2797146ca31d9fda61bba12e4a63109"

URI_x86_64_v2_ghc-tar-conduit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tar-conduit-devel-0.4.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tar-conduit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tar-conduit-devel}"
SRC_URI[x86_64_v2_ghc-tar-conduit-devel.sha256sum] = "22e882b923c143e7ddb76df988adde4e3236417ece51556070918fa79d3a869f"

URI_x86_64_v2_ghc-tar-conduit-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tar-conduit-doc-0.4.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-tar-conduit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tar-conduit-doc}"
SRC_URI[x86_64_v2_ghc-tar-conduit-doc.sha256sum] = "1ab3b357a3a0c108d2fc9d99f74534c352087120623e54f9e24c1112127b4ad5"

URI_x86_64_v2_ghc-tar-conduit-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tar-conduit-prof-0.4.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tar-conduit-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tar-conduit-prof}"
SRC_URI[x86_64_v2_ghc-tar-conduit-prof.sha256sum] = "f5a80b2f439b04fa09fc543dfeec34c09ee02ff1d7cfb8348ec961e7abb34ffa"

URI_aarch64_ghc-tar-conduit = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tar-conduit-0.4.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-tar-conduit;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tar-conduit}"
SRC_URI[aarch64_ghc-tar-conduit.sha256sum] = "349073cf239516b50fa4c12a8abd0b0521d28340e7c897e3e7cb201114b8acae"

URI_aarch64_ghc-tar-conduit-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tar-conduit-devel-0.4.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-tar-conduit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tar-conduit-devel}"
SRC_URI[aarch64_ghc-tar-conduit-devel.sha256sum] = "94edc0ab170263bc610cfc06323922e7efc25cbac436218b6ce974d44bb932e9"

URI_aarch64_ghc-tar-conduit-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tar-conduit-doc-0.4.1-2.el10_0.noarch.rpm;name=aarch64_ghc-tar-conduit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tar-conduit-doc}"
SRC_URI[aarch64_ghc-tar-conduit-doc.sha256sum] = "bcc4886fcacb55478e7dd09287e134ae2cd4448dc8d586613b0235db11a0e954"

URI_aarch64_ghc-tar-conduit-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tar-conduit-prof-0.4.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-tar-conduit-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tar-conduit-prof}"
SRC_URI[aarch64_ghc-tar-conduit-prof.sha256sum] = "843476f6665a2689fc8a6cfa461d8c24a7580dfcc64b40b606bc0c2568abcbdc"

RDEPENDS:ghc-tar-conduit = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bitvec \
 ghc-bytestring \
 ghc-conduit \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-resourcet \
 ghc-safe-exceptions \
 ghc-split \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-tar-conduit-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-containers-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-mtl-devel \
 ghc-safe-exceptions-devel \
 ghc-tar-conduit \
 ghc-text-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-tar-conduit-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-tar-conduit-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-conduit-prof \
 ghc-containers-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-mtl-prof \
 ghc-safe-exceptions-prof \
 ghc-tar-conduit-devel \
 ghc-text-prof \
 ghc-unix-prof \
 "
