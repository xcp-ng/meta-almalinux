# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kglobalacceld"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kglobalacceld \
 kglobalacceld-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kglobalacceld-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66fa45197607748efd0acffd9bdcd9ede7addbbd0daa5124e7457ef317140b46"

URI_x86_64_v2_kglobalacceld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kglobalacceld-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kglobalacceld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kglobalacceld}"
SRC_URI[x86_64_v2_kglobalacceld.sha256sum] = "a6a2037fbf34bd8cc76af19bb0a765adf6e249f943f0a167583ce99716a2d307"

URI_x86_64_v2_kglobalacceld-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kglobalacceld-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kglobalacceld-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kglobalacceld-devel}"
SRC_URI[x86_64_v2_kglobalacceld-devel.sha256sum] = "4539b6932c0bfce93db7168eaf457540a8b268300306abd5b2dc7311ce7e3820"

URI_aarch64_kglobalacceld = "${EPEL_MIRROR}/aarch64/Packages/k/kglobalacceld-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kglobalacceld;unpack=0"
SRC_URI:append = " ${URI_aarch64_kglobalacceld}"
SRC_URI[aarch64_kglobalacceld.sha256sum] = "05bde0375b382befd50e66f218ea77fa12e9b0974f9d1257455a9f71a39d4eb5"

URI_aarch64_kglobalacceld-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kglobalacceld-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kglobalacceld-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kglobalacceld-devel}"
SRC_URI[aarch64_kglobalacceld-devel.sha256sum] = "615d0f50d5bc1ffd6edda727c7436eba6b6c3c77f8458faee0fed951a57b1849"

RDEPENDS:kglobalacceld = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kwindowsystem \
 libX11 \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 xcb-util-keysyms \
 "
RDEPENDS:kglobalacceld-devel = " \
 cmake-filesystem \
 kglobalacceld \
 qt6-qtbase-devel \
 "
