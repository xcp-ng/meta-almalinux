# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-linux-raw-sys0.6"
PV = "0.6.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-linux-raw-sys0.6+bootparam-devel \
 rust-linux-raw-sys0.6+default-devel \
 rust-linux-raw-sys0.6+elf-devel \
 rust-linux-raw-sys0.6+errno-devel \
 rust-linux-raw-sys0.6+general-devel \
 rust-linux-raw-sys0.6+if_arp-devel \
 rust-linux-raw-sys0.6+if_ether-devel \
 rust-linux-raw-sys0.6+if_packet-devel \
 rust-linux-raw-sys0.6+io_uring-devel \
 rust-linux-raw-sys0.6+ioctl-devel \
 rust-linux-raw-sys0.6+loop_device-devel \
 rust-linux-raw-sys0.6+mempolicy-devel \
 rust-linux-raw-sys0.6+net-devel \
 rust-linux-raw-sys0.6+netlink-devel \
 rust-linux-raw-sys0.6+no_std-devel \
 rust-linux-raw-sys0.6+prctl-devel \
 rust-linux-raw-sys0.6+std-devel \
 rust-linux-raw-sys0.6+system-devel \
 rust-linux-raw-sys0.6+xdp-devel \
 rust-linux-raw-sys0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-linux-raw-sys0.6-0.6.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1400006d4187fffb7f6eb38e9fa56a4f8a04e5e9926622a65288677602f8a326"

URI_x86_64_v2_rust-linux-raw-sys0.6+bootparam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+bootparam-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+bootparam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+bootparam-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+bootparam-devel.sha256sum] = "45ce173e5f7b67fdf88a0cfede68a2f69aed248dc30239751aebdcad8956f8fe"

URI_x86_64_v2_rust-linux-raw-sys0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+default-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+default-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+default-devel.sha256sum] = "2182e55b9a63d221f35c56ba0661dce88ca758c72cdf211a7f3516ecd7a2df82"

URI_x86_64_v2_rust-linux-raw-sys0.6+elf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+elf-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+elf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+elf-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+elf-devel.sha256sum] = "cd2a834c0c15ce3fb9f29f56571193143ce98613791bc4c4ae395303b53bee74"

URI_x86_64_v2_rust-linux-raw-sys0.6+errno-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+errno-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+errno-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+errno-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+errno-devel.sha256sum] = "ac55eef8f65de06dbb45b35bc9a4c51016b583256b637a9343ba07b2a495960a"

URI_x86_64_v2_rust-linux-raw-sys0.6+general-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+general-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+general-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+general-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+general-devel.sha256sum] = "57d23cb2280ef81fed4ad6e46af1b34e8aeb7112ef72b4295723af8a65f4ef32"

URI_x86_64_v2_rust-linux-raw-sys0.6+if_arp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+if_arp-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+if_arp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+if_arp-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+if_arp-devel.sha256sum] = "c47dce1f676aa85e4c4c93b470c4677feb1e31feef2df2946ec3b876ab4f87ad"

URI_x86_64_v2_rust-linux-raw-sys0.6+if_ether-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+if_ether-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+if_ether-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+if_ether-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+if_ether-devel.sha256sum] = "390a2993b584f972e4327d6d9ade1e3e21f6fb711ea762e544cda5de5ac31edc"

URI_x86_64_v2_rust-linux-raw-sys0.6+if_packet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+if_packet-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+if_packet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+if_packet-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+if_packet-devel.sha256sum] = "302a53b5683151794c360f7d5fbcf6127fd3dfe233eec3aad392ce054bf662ca"

URI_x86_64_v2_rust-linux-raw-sys0.6+io_uring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+io_uring-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+io_uring-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+io_uring-devel.sha256sum] = "f0e6eac77808626f8b2b086f7f4deada28e6c72062b2737b856efd6d768a5b1e"

URI_x86_64_v2_rust-linux-raw-sys0.6+ioctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+ioctl-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+ioctl-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+ioctl-devel.sha256sum] = "bbe17b31a6239ee9db511c0a2466e252e1bdcbaed58c9e170548a8075a620642"

URI_x86_64_v2_rust-linux-raw-sys0.6+loop_device-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+loop_device-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+loop_device-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+loop_device-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+loop_device-devel.sha256sum] = "f82ddd7a94cf44e37609ff97c1e34cf06b1672de338ecf287f5ff2aa8c65cc7f"

URI_x86_64_v2_rust-linux-raw-sys0.6+mempolicy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+mempolicy-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+mempolicy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+mempolicy-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+mempolicy-devel.sha256sum] = "9b8f011e6e68f0713aa2f05c45d746e62f4569bc3b76a17138e5428b1c008f04"

URI_x86_64_v2_rust-linux-raw-sys0.6+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+net-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+net-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+net-devel.sha256sum] = "6827e5defbf7cae5357f21958defee5bb434b0bb3372dc951b8b7bf1590f4a39"

URI_x86_64_v2_rust-linux-raw-sys0.6+netlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+netlink-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+netlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+netlink-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+netlink-devel.sha256sum] = "5a992a6cda9c4634af9eacad50b69b50dd10efdf507dd48399cc65ceeff14adb"

URI_x86_64_v2_rust-linux-raw-sys0.6+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+no_std-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+no_std-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+no_std-devel.sha256sum] = "3096e80e6007cb1d6b2856f66a303f4427fcd7733a2ad75a78c17e3b49b34c99"

URI_x86_64_v2_rust-linux-raw-sys0.6+prctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+prctl-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+prctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+prctl-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+prctl-devel.sha256sum] = "2eacf83d67b9e033ff16c0a3fb9b02da7a2278de2f2c1e5bf32afc23297a819c"

URI_x86_64_v2_rust-linux-raw-sys0.6+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+std-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+std-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+std-devel.sha256sum] = "8f707c64c214e974c87f56368adcf769c9d91dec745efe16820a334dd5412386"

URI_x86_64_v2_rust-linux-raw-sys0.6+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+system-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+system-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+system-devel.sha256sum] = "13868e76e2d5e008643dafc40a21c88e41cc47ac253611699ac138e796b2c91d"

URI_x86_64_v2_rust-linux-raw-sys0.6+xdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6+xdp-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6+xdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6+xdp-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6+xdp-devel.sha256sum] = "576417b6685c69cdcb7ddcd8201d60ffb23741061e3bfe3654919ac0f0a314cb"

URI_x86_64_v2_rust-linux-raw-sys0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.6-devel-0.6.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.6-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.6-devel.sha256sum] = "4ac8a0ab9228b2da509d4a4449a0539714b15110d40403eb987706dbe8a1bacb"

URI_aarch64_rust-linux-raw-sys0.6+bootparam-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+bootparam-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+bootparam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+bootparam-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+bootparam-devel.sha256sum] = "eb8b2a48ac2c60fce3538cb3981c9a75f324785fd833900c6fcf53a970058692"

URI_aarch64_rust-linux-raw-sys0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+default-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+default-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+default-devel.sha256sum] = "9ea9b9c5755ea3331df25298da7a784ac2d38c50939e2bd5ca8813f7ecead340"

URI_aarch64_rust-linux-raw-sys0.6+elf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+elf-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+elf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+elf-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+elf-devel.sha256sum] = "d143d0adcf2b4e1ac77d2eb8480edcdbe9933764cba6f45b48855e78073a85db"

URI_aarch64_rust-linux-raw-sys0.6+errno-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+errno-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+errno-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+errno-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+errno-devel.sha256sum] = "717c60d0f5152df28bcbc54ee06d61e5aabe6f03ef96a33c33582a96368dce7f"

URI_aarch64_rust-linux-raw-sys0.6+general-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+general-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+general-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+general-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+general-devel.sha256sum] = "3650aa61c47d821910ea19e9649f08db178cb3ff015acf3ffc323792fe917f9e"

URI_aarch64_rust-linux-raw-sys0.6+if_arp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+if_arp-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+if_arp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+if_arp-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+if_arp-devel.sha256sum] = "d9dc93c382ca635f2a1c868fe66917480dfb35bfdc77176413f694a31add6d48"

URI_aarch64_rust-linux-raw-sys0.6+if_ether-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+if_ether-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+if_ether-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+if_ether-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+if_ether-devel.sha256sum] = "7ca93ba26611a3798c6dfc8dd5a92088014422cb9098a1f8a58af2206edce1bd"

URI_aarch64_rust-linux-raw-sys0.6+if_packet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+if_packet-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+if_packet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+if_packet-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+if_packet-devel.sha256sum] = "62f974a5cc3c5c84aa0e3ced586ef3c6d64c18f777921fb4f0d45cfaa9bd36c6"

URI_aarch64_rust-linux-raw-sys0.6+io_uring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+io_uring-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+io_uring-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+io_uring-devel.sha256sum] = "b91761e770e13a5e85c305a38105bffd231edae1e9555091c2c79c7d8a09f51f"

URI_aarch64_rust-linux-raw-sys0.6+ioctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+ioctl-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+ioctl-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+ioctl-devel.sha256sum] = "6479672249637d312a7010436066cc52b24527ca3c8c440680bb54a435b1ea27"

URI_aarch64_rust-linux-raw-sys0.6+loop_device-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+loop_device-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+loop_device-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+loop_device-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+loop_device-devel.sha256sum] = "eb0442b7eaf1ac601a32f750917cce05aa6f77cd144b6356c5497b36714494e3"

URI_aarch64_rust-linux-raw-sys0.6+mempolicy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+mempolicy-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+mempolicy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+mempolicy-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+mempolicy-devel.sha256sum] = "c258f37a322974a85c95c3563181c68dae3c63451e9f5491c566642d4efddeaa"

URI_aarch64_rust-linux-raw-sys0.6+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+net-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+net-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+net-devel.sha256sum] = "dde70ffec3e2124a6fe23edcba9d517d24fcbccd3097c0693ab27b98331f7ddb"

URI_aarch64_rust-linux-raw-sys0.6+netlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+netlink-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+netlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+netlink-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+netlink-devel.sha256sum] = "d4ceaa77b0e753036f49551e74711a6e47b6b61dadf3ef04cac3a5b00112682c"

URI_aarch64_rust-linux-raw-sys0.6+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+no_std-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+no_std-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+no_std-devel.sha256sum] = "f8f1782ac1de7885d7af00d29f05cf5811ec8ad808130a23a4fccd652aaade16"

URI_aarch64_rust-linux-raw-sys0.6+prctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+prctl-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+prctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+prctl-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+prctl-devel.sha256sum] = "0e9cdd97db1fc9ec8f8830f0a8135600ace55842207574e1b7bec126f0862db1"

URI_aarch64_rust-linux-raw-sys0.6+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+std-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+std-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+std-devel.sha256sum] = "fba14ba74066ef25644860d003dda9062780bde886cc491d158e422825bd7e3a"

URI_aarch64_rust-linux-raw-sys0.6+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+system-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+system-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+system-devel.sha256sum] = "597d5056b04ceb2e5f5a24d7857bd74daee13557d0bbc8595c9e8d3aa3312263"

URI_aarch64_rust-linux-raw-sys0.6+xdp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6+xdp-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6+xdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6+xdp-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6+xdp-devel.sha256sum] = "faf4e222a498d0c2ed9a2274994e2983d4ed695decbdfda9580d6c94a8b46c3f"

URI_aarch64_rust-linux-raw-sys0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.6-devel-0.6.5-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.6-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.6-devel.sha256sum] = "f896b764d2067da33dc9ab4c168ebb63ef3a83aa0433a13ec027360f20809307"

RDEPENDS:rust-linux-raw-sys0.6+bootparam-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+default-devel = " \
 cargo \
 rust-linux-raw-sys0.6+errno-devel \
 rust-linux-raw-sys0.6+general-devel \
 rust-linux-raw-sys0.6+std-devel \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+elf-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+errno-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+general-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+if_arp-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+if_ether-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+if_packet-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+io_uring-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+ioctl-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+loop_device-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+mempolicy-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+net-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+netlink-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+no_std-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+prctl-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+std-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+system-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6+xdp-devel = " \
 cargo \
 rust-linux-raw-sys0.6-devel \
 "
RDEPENDS:rust-linux-raw-sys0.6-devel = " \
 cargo \
 rust \
 "
