# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtscxml"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtscxml \
 qt6-qtscxml-devel \
 qt6-qtscxml-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtscxml-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d094e909bf9858e1bc2a10918a82a6bec487c6bebeb6f2defd3be596b3123b57"

URI_x86_64_v2_qt6-qtscxml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtscxml-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtscxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtscxml}"
SRC_URI[x86_64_v2_qt6-qtscxml.sha256sum] = "2b447793994f54d37870af5ac44d9ff95d8e2ce5676d2a48abb065105bc4c367"

URI_x86_64_v2_qt6-qtscxml-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtscxml-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtscxml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtscxml-devel}"
SRC_URI[x86_64_v2_qt6-qtscxml-devel.sha256sum] = "f67ebff28ebc68141c852d751148e6c7f12b174c3b92d4c1a8b72c02440b8bbc"

URI_x86_64_v2_qt6-qtscxml-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtscxml-examples-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtscxml-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtscxml-examples}"
SRC_URI[x86_64_v2_qt6-qtscxml-examples.sha256sum] = "38b0e19009c2891c9d46b4d48e6db9447404d2e9cb23f44ef80debfb35789122"

URI_aarch64_qt6-qtscxml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtscxml-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtscxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtscxml}"
SRC_URI[aarch64_qt6-qtscxml.sha256sum] = "aaf816e7e828a263dcb9d19c928df3b374ad23a999ea7baa00cd83b7c677fa8b"

URI_aarch64_qt6-qtscxml-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtscxml-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtscxml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtscxml-devel}"
SRC_URI[aarch64_qt6-qtscxml-devel.sha256sum] = "952c90268fd8d7d407ce5cbe01d58d27dbcdeaba8ffcefae4bf9ad236ade6534"

URI_aarch64_qt6-qtscxml-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtscxml-examples-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtscxml-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtscxml-examples}"
SRC_URI[aarch64_qt6-qtscxml-examples.sha256sum] = "3ca1c9b0954e7e4f0f9582ebcc0ac4f609ca6913800530f997e76d27285389ff"

RDEPENDS:qt6-qtscxml = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtscxml-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtscxml \
 qt6-qtscxml-devel \
 "
RDEPENDS:qt6-qtscxml-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtscxml \
 "
