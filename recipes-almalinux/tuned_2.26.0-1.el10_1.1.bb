# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tuned"
PV = "2.26.0"
PR = "1.el10_1.1"
PACKAGES = " \
 tuned \
 tuned-gtk \
 tuned-ppd \
 tuned-profiles-atomic \
 tuned-profiles-cpu-partitioning \
 tuned-profiles-mssql \
 tuned-profiles-oracle \
 tuned-profiles-postgresql \
 tuned-profiles-spectrumscale \
 tuned-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tuned-2.26.0-1.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a96e41e414ecc6707b401bcde8bf80a19792659e390484fce7e29806bb6cd7aa"

URI_x86_64_v2_tuned = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tuned-2.26.0-1.el10_1.1.noarch.rpm;name=x86_64_v2_tuned;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned}"
SRC_URI[x86_64_v2_tuned.sha256sum] = "5ae2b8547db220a0a6764b8361296be22d3b648d432188dd8e33632c3b712b00"

URI_x86_64_v2_tuned-gtk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-gtk-2.26.0-1.el10_1.1.noarch.rpm;name=x86_64_v2_tuned-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-gtk}"
SRC_URI[x86_64_v2_tuned-gtk.sha256sum] = "3e1a2794f0d878188291acf00678af58e726a0f9ab5a31440c6a97bfffedc210"

URI_x86_64_v2_tuned-ppd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-ppd-2.26.0-1.el10_1.1.noarch.rpm;name=x86_64_v2_tuned-ppd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-ppd}"
SRC_URI[x86_64_v2_tuned-ppd.sha256sum] = "12d871350d09d9a45e6c280f37dd2f1e369ee8bda6302096481d72cf766b0dad"

URI_x86_64_v2_tuned-profiles-atomic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-atomic-2.26.0-1.el10_1.1.noarch.rpm;name=x86_64_v2_tuned-profiles-atomic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-atomic}"
SRC_URI[x86_64_v2_tuned-profiles-atomic.sha256sum] = "ad43b2aced94a0fd2f672718f99bdaf903e54cbfc530a1d106dc8dfc0f20487b"

URI_x86_64_v2_tuned-profiles-cpu-partitioning = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tuned-profiles-cpu-partitioning-2.26.0-1.el10_1.1.noarch.rpm;name=x86_64_v2_tuned-profiles-cpu-partitioning;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-cpu-partitioning}"
SRC_URI[x86_64_v2_tuned-profiles-cpu-partitioning.sha256sum] = "cd2beb2e3616dce16645920003467de66a46856618d1a3a2592d2bd3b4d316b4"

URI_x86_64_v2_tuned-profiles-mssql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-mssql-2.26.0-1.el10_1.1.noarch.rpm;name=x86_64_v2_tuned-profiles-mssql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-mssql}"
SRC_URI[x86_64_v2_tuned-profiles-mssql.sha256sum] = "6141db8b6064550d1b339352afe2e6b1b7de20ae6dd680db694ca3538bd011c5"

URI_x86_64_v2_tuned-profiles-oracle = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-oracle-2.26.0-1.el10_1.1.noarch.rpm;name=x86_64_v2_tuned-profiles-oracle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-oracle}"
SRC_URI[x86_64_v2_tuned-profiles-oracle.sha256sum] = "9fd0fc731e96a7817b414b5a18d2d97c7a67b5a1ab9a00e711c6260bc4ec9562"

URI_x86_64_v2_tuned-profiles-postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-postgresql-2.26.0-1.el10_1.1.noarch.rpm;name=x86_64_v2_tuned-profiles-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-postgresql}"
SRC_URI[x86_64_v2_tuned-profiles-postgresql.sha256sum] = "8d2c2203008fc1a5942f445517d1b26342e0705ac70c5022fe852b854a68ee64"

URI_x86_64_v2_tuned-profiles-spectrumscale = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-spectrumscale-2.26.0-1.el10_1.1.noarch.rpm;name=x86_64_v2_tuned-profiles-spectrumscale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-spectrumscale}"
SRC_URI[x86_64_v2_tuned-profiles-spectrumscale.sha256sum] = "b2f1b36ce513f05552b5e5a0df47fa8a2e5554268fcbf3e38e3f1fcd4ab94307"

URI_x86_64_v2_tuned-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-utils-2.26.0-1.el10_1.1.noarch.rpm;name=x86_64_v2_tuned-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-utils}"
SRC_URI[x86_64_v2_tuned-utils.sha256sum] = "2527049eb040fe074b507cd0f7e2d754083b4f602b949434f4d5696bd687ac57"

URI_aarch64_tuned = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tuned-2.26.0-1.el10_1.1.noarch.rpm;name=aarch64_tuned;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned}"
SRC_URI[aarch64_tuned.sha256sum] = "5ae2b8547db220a0a6764b8361296be22d3b648d432188dd8e33632c3b712b00"

URI_aarch64_tuned-gtk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-gtk-2.26.0-1.el10_1.1.noarch.rpm;name=aarch64_tuned-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-gtk}"
SRC_URI[aarch64_tuned-gtk.sha256sum] = "3e1a2794f0d878188291acf00678af58e726a0f9ab5a31440c6a97bfffedc210"

URI_aarch64_tuned-ppd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-ppd-2.26.0-1.el10_1.1.noarch.rpm;name=aarch64_tuned-ppd;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-ppd}"
SRC_URI[aarch64_tuned-ppd.sha256sum] = "12d871350d09d9a45e6c280f37dd2f1e369ee8bda6302096481d72cf766b0dad"

URI_aarch64_tuned-profiles-atomic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-atomic-2.26.0-1.el10_1.1.noarch.rpm;name=aarch64_tuned-profiles-atomic;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-atomic}"
SRC_URI[aarch64_tuned-profiles-atomic.sha256sum] = "ad43b2aced94a0fd2f672718f99bdaf903e54cbfc530a1d106dc8dfc0f20487b"

URI_aarch64_tuned-profiles-cpu-partitioning = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tuned-profiles-cpu-partitioning-2.26.0-1.el10_1.1.noarch.rpm;name=aarch64_tuned-profiles-cpu-partitioning;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-cpu-partitioning}"
SRC_URI[aarch64_tuned-profiles-cpu-partitioning.sha256sum] = "cd2beb2e3616dce16645920003467de66a46856618d1a3a2592d2bd3b4d316b4"

URI_aarch64_tuned-profiles-mssql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-mssql-2.26.0-1.el10_1.1.noarch.rpm;name=aarch64_tuned-profiles-mssql;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-mssql}"
SRC_URI[aarch64_tuned-profiles-mssql.sha256sum] = "6141db8b6064550d1b339352afe2e6b1b7de20ae6dd680db694ca3538bd011c5"

URI_aarch64_tuned-profiles-oracle = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-oracle-2.26.0-1.el10_1.1.noarch.rpm;name=aarch64_tuned-profiles-oracle;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-oracle}"
SRC_URI[aarch64_tuned-profiles-oracle.sha256sum] = "9fd0fc731e96a7817b414b5a18d2d97c7a67b5a1ab9a00e711c6260bc4ec9562"

URI_aarch64_tuned-profiles-postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-postgresql-2.26.0-1.el10_1.1.noarch.rpm;name=aarch64_tuned-profiles-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-postgresql}"
SRC_URI[aarch64_tuned-profiles-postgresql.sha256sum] = "8d2c2203008fc1a5942f445517d1b26342e0705ac70c5022fe852b854a68ee64"

URI_aarch64_tuned-profiles-spectrumscale = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-spectrumscale-2.26.0-1.el10_1.1.noarch.rpm;name=aarch64_tuned-profiles-spectrumscale;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-spectrumscale}"
SRC_URI[aarch64_tuned-profiles-spectrumscale.sha256sum] = "b2f1b36ce513f05552b5e5a0df47fa8a2e5554268fcbf3e38e3f1fcd4ab94307"

URI_aarch64_tuned-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-utils-2.26.0-1.el10_1.1.noarch.rpm;name=aarch64_tuned-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-utils}"
SRC_URI[aarch64_tuned-utils.sha256sum] = "2527049eb040fe074b507cd0f7e2d754083b4f602b949434f4d5696bd687ac57"

RDEPENDS:tuned = " \
 bash \
 dbus \
 ethtool \
 gawk \
 hdparm \
 iproute \
 kmod \
 polkit \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-inotify \
 python3-linux-procfs \
 python3-pyudev \
 systemd \
 util-linux \
 virt-what \
 "
RDEPENDS:tuned-gtk = " \
 polkit \
 powertop \
 python3 \
 python3-gobject-base \
 tuned \
 "
RDEPENDS:tuned-ppd = " \
 bash \
 python3 \
 tuned \
 "
RDEPENDS:tuned-profiles-atomic = " \
 tuned \
 "
RDEPENDS:tuned-profiles-cpu-partitioning = " \
 bash \
 tuned \
 "
RDEPENDS:tuned-profiles-mssql = " \
 tuned \
 "
RDEPENDS:tuned-profiles-oracle = " \
 tuned \
 "
RDEPENDS:tuned-profiles-postgresql = " \
 tuned \
 "
RDEPENDS:tuned-profiles-spectrumscale = " \
 tuned \
 "
RDEPENDS:tuned-utils = " \
 powertop \
 python3 \
 tuned \
 "
