# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocclr"
PV = "7.2.2"
PR = "2.el10_3"
PACKAGES:x86_64_v2 = " \
 rocm-hip \
 rocm-hip-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocclr-7.2.2-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc93d9fd92365fa717ce2b9c5babe0fad5df3ca26ce4d4386f6587c7d5b946d2"

URI_x86_64_v2_rocm-hip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-hip-7.2.2-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-hip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-hip}"
SRC_URI[x86_64_v2_rocm-hip.sha256sum] = "2a940efbc6f77ca9b7c5d25e07c604cd6213bcfaaa6b8b7317fd490969022960"

URI_x86_64_v2_rocm-hip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-hip-devel-7.2.2-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-hip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-hip-devel}"
SRC_URI[x86_64_v2_rocm-hip-devel.sha256sum] = "c02bdf71a71321579f5a8fe12c77ea57bb246f91dbb617b4b91c1879df882e55"

RDEPENDS:rocm-hip = " \
 glibc \
 hipcc \
 libgcc \
 libstdc++ \
 rocm-comgr \
 rocm-filesystem \
 rocm-runtime \
 "
RDEPENDS:rocm-hip-devel = " \
 bash \
 binutils \
 cmake-filesystem \
 gawk \
 perl-interpreter \
 rocm-comgr-devel \
 rocm-hip \
 rocm-runtime-devel \
 "
