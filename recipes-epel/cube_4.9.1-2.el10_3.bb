# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cube"
PV = "4.9.1"
PR = "2.el10_3"
PACKAGES = " \
 cube \
 cube-devel \
 cube-doc \
 cube-guilib \
 cube-guilib-devel \
 cube-libs \
 cube-libs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cube-4.9.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "915606d8c979b51bb1b4bc25f6584c01ef01ca8c8a3ebdaf1e9fc7116ba3e220"

URI_x86_64_v2_cube = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-4.9.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube}"
SRC_URI[x86_64_v2_cube.sha256sum] = "836d373b849d4cc4dede9df1c354df3e0bf353f81b942d170bd3a6563e750b5e"

URI_x86_64_v2_cube-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-devel-4.9.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-devel}"
SRC_URI[x86_64_v2_cube-devel.sha256sum] = "0112c737f751678c112b335dd60f73561061a4c5bc770ba5744d2881f501a749"

URI_x86_64_v2_cube-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-doc-4.9.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_cube-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-doc}"
SRC_URI[x86_64_v2_cube-doc.sha256sum] = "fa00376cd942a3c9793f68ac8659205bc584d8d7286b936883a950e40b7e7467"

URI_x86_64_v2_cube-guilib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-guilib-4.9.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-guilib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-guilib}"
SRC_URI[x86_64_v2_cube-guilib.sha256sum] = "c04f2a9edba024037704a241b4a21f88b3547ba2c548eb4037a59f0b6aee14e2"

URI_x86_64_v2_cube-guilib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-guilib-devel-4.9.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-guilib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-guilib-devel}"
SRC_URI[x86_64_v2_cube-guilib-devel.sha256sum] = "955771238231172b0a25c941273dd770ced64ef807ce8844f260dca70c7e586f"

URI_x86_64_v2_cube-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-libs-4.9.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-libs}"
SRC_URI[x86_64_v2_cube-libs.sha256sum] = "8642a3cf83f6f71ce07216d902f4c669abe269a1b9410248504bb24edf569dc6"

URI_x86_64_v2_cube-libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-libs-devel-4.9.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-libs-devel}"
SRC_URI[x86_64_v2_cube-libs-devel.sha256sum] = "bc5b6ee937bfe5fdd9ec09c947346b916e70bf72445c9e1c9f8f11660868ea6a"

URI_aarch64_cube = "${EPEL_MIRROR}/aarch64/Packages/c/cube-4.9.1-2.el10_3.aarch64.rpm;name=aarch64_cube;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube}"
SRC_URI[aarch64_cube.sha256sum] = "4a03d85e40e82098468cc72092d25ee2b062589b968a57ff8690e3781b757ec5"

URI_aarch64_cube-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cube-devel-4.9.1-2.el10_3.aarch64.rpm;name=aarch64_cube-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-devel}"
SRC_URI[aarch64_cube-devel.sha256sum] = "7544b7f6f7c465f06b2bc8cbba86e164dfe33aa67b5274f81b9257d40f5a7b57"

URI_aarch64_cube-doc = "${EPEL_MIRROR}/aarch64/Packages/c/cube-doc-4.9.1-2.el10_3.noarch.rpm;name=aarch64_cube-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-doc}"
SRC_URI[aarch64_cube-doc.sha256sum] = "aead36c1b809b51fe5751fb51eb0fe52a7921474202ffa6ca9f4dfab2b721f17"

URI_aarch64_cube-guilib = "${EPEL_MIRROR}/aarch64/Packages/c/cube-guilib-4.9.1-2.el10_3.aarch64.rpm;name=aarch64_cube-guilib;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-guilib}"
SRC_URI[aarch64_cube-guilib.sha256sum] = "5e0dd29f7346d9e3e0b7b89a79ec1a9e865fbec3aaf94034bed928bfaa60b395"

URI_aarch64_cube-guilib-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cube-guilib-devel-4.9.1-2.el10_3.aarch64.rpm;name=aarch64_cube-guilib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-guilib-devel}"
SRC_URI[aarch64_cube-guilib-devel.sha256sum] = "9d65b0219cfc5987d69cae41e481ec7fe26714451298b036165c321bda46d07f"

URI_aarch64_cube-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cube-libs-4.9.1-2.el10_3.aarch64.rpm;name=aarch64_cube-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-libs}"
SRC_URI[aarch64_cube-libs.sha256sum] = "09b60154cfec1d040d29f559cd30c976e00579877655072683070de58e014f74"

URI_aarch64_cube-libs-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cube-libs-devel-4.9.1-2.el10_3.aarch64.rpm;name=aarch64_cube-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-libs-devel}"
SRC_URI[aarch64_cube-libs-devel.sha256sum] = "2a4495d1b3eb19fbc05ca11fa424c94acef7ae392c3c6821d81225549fb172a5"

RDEPENDS:cube = " \
 bash \
 cube-guilib \
 cube-libs \
 dbus-libs \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:cube-devel = " \
 cube-guilib-devel \
 cube-libs-devel \
 "
RDEPENDS:cube-doc = " \
 "
RDEPENDS:cube-guilib = " \
 cube-libs \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:cube-guilib-devel = " \
 cmake-filesystem \
 cube-guilib \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:cube-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:cube-libs-devel = " \
 cmake-filesystem \
 cube-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
