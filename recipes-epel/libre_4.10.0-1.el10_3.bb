# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libre"
PV = "4.10.0"
PR = "1.el10_3"
PACKAGES = " \
 libre \
 libre-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libre-4.10.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c52ae2b86e98f1b2262d85da3af5b2ca795af9c2135fafb9b44e468e1392097f"

URI_x86_64_v2_libre = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libre-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libre}"
SRC_URI[x86_64_v2_libre.sha256sum] = "dff29938ef3d888dc2b0aec885b7c83a74399bf2f734cfaa6dcfa211f20aca3a"

URI_x86_64_v2_libre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libre-devel-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libre-devel}"
SRC_URI[x86_64_v2_libre-devel.sha256sum] = "9c0b5917247130bf36a7934ff676930cf04b9cadb1e22169afc23ad0e1d5d461"

URI_aarch64_libre = "${EPEL_MIRROR}/aarch64/Packages/l/libre-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_libre;unpack=0"
SRC_URI:append = " ${URI_aarch64_libre}"
SRC_URI[aarch64_libre.sha256sum] = "a608c9dad7f1cbc9f30c7efd718e49301629f79556fa5951b16f15c88cbb5a87"

URI_aarch64_libre-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libre-devel-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_libre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libre-devel}"
SRC_URI[aarch64_libre-devel.sha256sum] = "010674ce194ccc5313d8a1a5f0ee7e14b07a0c1f0e3b0cce1710e3e5fe1909f6"

RDEPENDS:libre = " \
 glibc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libre-devel = " \
 cmake-filesystem \
 libre \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
