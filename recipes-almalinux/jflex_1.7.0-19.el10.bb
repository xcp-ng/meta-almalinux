# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jflex"
PV = "1.7.0"
PR = "19.el10"
PACKAGES = " \
 jflex \
 jflex-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/jflex-1.7.0-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df6f3f395c8da1750e1498be711631192888254100eb79cb18a502710ac0acd9"

URI_x86_64_v2_jflex = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jflex-1.7.0-19.el10.noarch.rpm;name=x86_64_v2_jflex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jflex}"
SRC_URI[x86_64_v2_jflex.sha256sum] = "76aeb5e465d2eebf69a059c559aa021cb7d310f6403dacc1ba427a61049e80c6"

URI_x86_64_v2_jflex-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jflex-javadoc-1.7.0-19.el10.noarch.rpm;name=x86_64_v2_jflex-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jflex-javadoc}"
SRC_URI[x86_64_v2_jflex-javadoc.sha256sum] = "9c7c58272e397bc7bc98cd229b3c2077f50ccdf55a66838a2fe4dff9a3df0eac"

URI_aarch64_jflex = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jflex-1.7.0-19.el10.noarch.rpm;name=aarch64_jflex;unpack=0"
SRC_URI:append = " ${URI_aarch64_jflex}"
SRC_URI[aarch64_jflex.sha256sum] = "76aeb5e465d2eebf69a059c559aa021cb7d310f6403dacc1ba427a61049e80c6"

URI_aarch64_jflex-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jflex-javadoc-1.7.0-19.el10.noarch.rpm;name=aarch64_jflex-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jflex-javadoc}"
SRC_URI[aarch64_jflex-javadoc.sha256sum] = "9c7c58272e397bc7bc98cd229b3c2077f50ccdf55a66838a2fe4dff9a3df0eac"

RDEPENDS:jflex = " \
 ant-lib \
 bash \
 java_cup \
 javapackages-filesystem \
 javapackages-tools \
 "
RDEPENDS:jflex-javadoc = " \
 javapackages-filesystem \
 "
