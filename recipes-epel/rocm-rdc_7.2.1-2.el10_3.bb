# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-rdc"
PV = "7.2.1"
PR = "2.el10_3"
PACKAGES:x86_64_v2 = " \
 rocm-rdc \
 rocm-rdc-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-rdc-7.2.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eec3b4f80354b820c8ee8ae0a8fc0cd83a5a51f23fa14dc12a0f4cc060bfba6b"

URI_x86_64_v2_rocm-rdc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-rdc-7.2.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-rdc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-rdc}"
SRC_URI[x86_64_v2_rocm-rdc.sha256sum] = "31cfaeb818426ab2b08bf96f0be39c3cd00e6fd61d6b7ba4df97ca24f8d12bf6"

URI_x86_64_v2_rocm-rdc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-rdc-devel-7.2.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-rdc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-rdc-devel}"
SRC_URI[x86_64_v2_rocm-rdc-devel.sha256sum] = "e8e65e4fc860d2c9e1b2f587154d217f70897e48e63d0a55f244f2b65cabbb24"

RDEPENDS:rocm-rdc = " \
 abseil-cpp \
 amdsmi \
 bash \
 glibc \
 grpc \
 grpc-cpp \
 libcap \
 libgcc \
 libstdc++ \
 protobuf \
 rocm-filesystem \
 rocm-hip \
 rocm-runtime \
 "
RDEPENDS:rocm-rdc-devel = " \
 cmake-filesystem \
 rocm-filesystem \
 rocm-rdc \
 "
