# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "edk2"
PV = "20260221"
PR = "5.el10"
PACKAGES = " \
 edk2-aarch64 \
 edk2-ovmf \
 edk2-tools \
 edk2-tools-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/edk2-20260221-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a021ec18fbae2618cb28e5c302f8a2832d14f7bcf572bd0436955eb5edd47fe7"

URI_x86_64_v2_edk2-aarch64 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-aarch64-20260221-5.el10.noarch.rpm;name=x86_64_v2_edk2-aarch64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edk2-aarch64}"
SRC_URI[x86_64_v2_edk2-aarch64.sha256sum] = "7f798333d31e10f6296aeeaa2a6ee8a5e883b24af35a6b72e57bc9781f46983e"

URI_x86_64_v2_edk2-ovmf = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-ovmf-20260221-5.el10.noarch.rpm;name=x86_64_v2_edk2-ovmf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edk2-ovmf}"
SRC_URI[x86_64_v2_edk2-ovmf.sha256sum] = "32141d8c6fa93f5bc4354adf27362422d58c1466132e48c6d56b68145e1f4a3f"

URI_x86_64_v2_edk2-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-tools-20260221-5.el10.x86_64_v2.rpm;name=x86_64_v2_edk2-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edk2-tools}"
SRC_URI[x86_64_v2_edk2-tools.sha256sum] = "6f64c64545879b234eb40993fca1884d23bb00e6f83292fa4cfb7504273d1626"

URI_x86_64_v2_edk2-tools-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-tools-doc-20260221-5.el10.noarch.rpm;name=x86_64_v2_edk2-tools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edk2-tools-doc}"
SRC_URI[x86_64_v2_edk2-tools-doc.sha256sum] = "93f7b2d7d41fc9b6af663f27b229e69180db5379ed65ac704682484c39e7890a"

URI_aarch64_edk2-aarch64 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-aarch64-20260221-5.el10.noarch.rpm;name=aarch64_edk2-aarch64;unpack=0"
SRC_URI:append = " ${URI_aarch64_edk2-aarch64}"
SRC_URI[aarch64_edk2-aarch64.sha256sum] = "7f798333d31e10f6296aeeaa2a6ee8a5e883b24af35a6b72e57bc9781f46983e"

URI_aarch64_edk2-ovmf = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-ovmf-20260221-5.el10.noarch.rpm;name=aarch64_edk2-ovmf;unpack=0"
SRC_URI:append = " ${URI_aarch64_edk2-ovmf}"
SRC_URI[aarch64_edk2-ovmf.sha256sum] = "32141d8c6fa93f5bc4354adf27362422d58c1466132e48c6d56b68145e1f4a3f"

URI_aarch64_edk2-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-tools-20260221-5.el10.aarch64.rpm;name=aarch64_edk2-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_edk2-tools}"
SRC_URI[aarch64_edk2-tools.sha256sum] = "ebad4329429a0d9ef02945a91ee2aaea645052abf7f4cae808c8e102db233e58"

URI_aarch64_edk2-tools-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-tools-doc-20260221-5.el10.noarch.rpm;name=aarch64_edk2-tools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_edk2-tools-doc}"
SRC_URI[aarch64_edk2-tools-doc.sha256sum] = "93f7b2d7d41fc9b6af663f27b229e69180db5379ed65ac704682484c39e7890a"

RDEPENDS:edk2-aarch64 = " \
 "
RDEPENDS:edk2-ovmf = " \
 "
RDEPENDS:edk2-tools = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:edk2-tools-doc = " \
 "
