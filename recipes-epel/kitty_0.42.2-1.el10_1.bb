# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kitty"
PV = "0.42.2"
PR = "1.el10_1"
PACKAGES = " \
 kitty \
 kitty-doc \
 kitty-kitten \
 kitty-shell-integration \
 kitty-terminfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kitty-0.42.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2d3d4bcea3d29c65ac9d23490fe440fd23bf1ffce2b4483af4a89a603edbea5"

URI_x86_64_v2_kitty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-0.42.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitty}"
SRC_URI[x86_64_v2_kitty.sha256sum] = "a3ed4c8a8305ff5537f1eb7267041adb1e18f66cc3b0057a40cd4ded1b790727"

URI_x86_64_v2_kitty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-doc-0.42.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kitty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitty-doc}"
SRC_URI[x86_64_v2_kitty-doc.sha256sum] = "ac4bd9e1925d738e71d004768664b17e62f40df8b39fa19c5db208b241e7cb23"

URI_x86_64_v2_kitty-kitten = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-kitten-0.42.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitty-kitten;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitty-kitten}"
SRC_URI[x86_64_v2_kitty-kitten.sha256sum] = "77adab3cf819f9073c61f92b888d5c5aa9d4674fdaa581c67bc0eda553ca7c54"

URI_x86_64_v2_kitty-shell-integration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-shell-integration-0.42.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kitty-shell-integration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitty-shell-integration}"
SRC_URI[x86_64_v2_kitty-shell-integration.sha256sum] = "f3e3c8b3186cd259f9befed678759984abba430ff7049984371b2209f83bb99f"

URI_x86_64_v2_kitty-terminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-terminfo-0.42.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kitty-terminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitty-terminfo}"
SRC_URI[x86_64_v2_kitty-terminfo.sha256sum] = "0d56ddf0aa04a53742a33df95cd70080cbd9dced7cff2ee8133724ba30006b5c"

URI_aarch64_kitty = "${EPEL_MIRROR}/aarch64/Packages/k/kitty-0.42.2-1.el10_1.aarch64.rpm;name=aarch64_kitty;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitty}"
SRC_URI[aarch64_kitty.sha256sum] = "fdae2aa495885570e6904f266b1c59c25840c54147785269122415a800d351b4"

URI_aarch64_kitty-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kitty-doc-0.42.2-1.el10_1.noarch.rpm;name=aarch64_kitty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitty-doc}"
SRC_URI[aarch64_kitty-doc.sha256sum] = "ed1f6c59e18993f66250559af59df549a22e46ac7aad9399149f9e3f7f11ee69"

URI_aarch64_kitty-kitten = "${EPEL_MIRROR}/aarch64/Packages/k/kitty-kitten-0.42.2-1.el10_1.aarch64.rpm;name=aarch64_kitty-kitten;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitty-kitten}"
SRC_URI[aarch64_kitty-kitten.sha256sum] = "76934cfca91c777eb345523b6423b931204e1bf86f6016fcbb3904874b2252b8"

URI_aarch64_kitty-shell-integration = "${EPEL_MIRROR}/aarch64/Packages/k/kitty-shell-integration-0.42.2-1.el10_1.noarch.rpm;name=aarch64_kitty-shell-integration;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitty-shell-integration}"
SRC_URI[aarch64_kitty-shell-integration.sha256sum] = "984747b00e86d86c90846dcb01aba143b6d9c22694dec4a227735490c8dc144b"

URI_aarch64_kitty-terminfo = "${EPEL_MIRROR}/aarch64/Packages/k/kitty-terminfo-0.42.2-1.el10_1.noarch.rpm;name=aarch64_kitty-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitty-terminfo}"
SRC_URI[aarch64_kitty-terminfo.sha256sum] = "e06ee61170927ae70f46541ca7cb430cd775cc85cf97b04d184687aa84fd206c"

RDEPENDS:kitty = " \
 cairo \
 dbus-libs \
 freetype \
 glibc \
 harfbuzz \
 hicolor-icon-theme \
 kitty-kitten \
 kitty-shell-integration \
 kitty-terminfo \
 lcms2 \
 libX11 \
 libX11-xcb \
 libXcursor \
 libgcc \
 libpng \
 libwayland-client \
 libxkbcommon \
 libxkbcommon-x11 \
 openssl-libs \
 python3 \
 python3-libs \
 xxhash-libs \
 zlib-ng-compat \
 "
RDEPENDS:kitty-doc = " \
 "
RDEPENDS:kitty-kitten = " \
 glibc \
 "
RDEPENDS:kitty-shell-integration = " \
 bash \
 "
RDEPENDS:kitty-terminfo = " \
 ncurses-base \
 "
