# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bugreport"
PV = "0.5.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-bugreport+collector_operating_system-devel \
 rust-bugreport+default-devel \
 rust-bugreport+format_markdown-devel \
 rust-bugreport+format_plaintext-devel \
 rust-bugreport+git-version-devel \
 rust-bugreport+git_hash-devel \
 rust-bugreport-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bugreport-0.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1df061540386bb623647c62758011e059cdccd990da316ee13642bf1c228cf46"

URI_x86_64_v2_rust-bugreport+collector_operating_system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bugreport+collector_operating_system-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bugreport+collector_operating_system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bugreport+collector_operating_system-devel}"
SRC_URI[x86_64_v2_rust-bugreport+collector_operating_system-devel.sha256sum] = "4b0f0a36e6774a7d980e43277f38f3225ed69703e9b75190f34634364c8958d4"

URI_x86_64_v2_rust-bugreport+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bugreport+default-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bugreport+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bugreport+default-devel}"
SRC_URI[x86_64_v2_rust-bugreport+default-devel.sha256sum] = "9b66d9fe31b0543735efc5e2e2e93f9d7503d8d2aba39a8b1270aa7f9cb3a16a"

URI_x86_64_v2_rust-bugreport+format_markdown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bugreport+format_markdown-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bugreport+format_markdown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bugreport+format_markdown-devel}"
SRC_URI[x86_64_v2_rust-bugreport+format_markdown-devel.sha256sum] = "19d07de07abf6b4aa73eb2bfc9e30d36bead3fcb4a4384c6e65f57bb625c0504"

URI_x86_64_v2_rust-bugreport+format_plaintext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bugreport+format_plaintext-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bugreport+format_plaintext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bugreport+format_plaintext-devel}"
SRC_URI[x86_64_v2_rust-bugreport+format_plaintext-devel.sha256sum] = "550e0e5ede5e0d9b74c52372c591323b96a0afb8d11f93c572160c0d5b815d72"

URI_x86_64_v2_rust-bugreport+git-version-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bugreport+git-version-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bugreport+git-version-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bugreport+git-version-devel}"
SRC_URI[x86_64_v2_rust-bugreport+git-version-devel.sha256sum] = "0b9e2a4c1e249d0a9a7601962660fd3a7a6472764c10239c63681f7545dc7d44"

URI_x86_64_v2_rust-bugreport+git_hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bugreport+git_hash-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bugreport+git_hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bugreport+git_hash-devel}"
SRC_URI[x86_64_v2_rust-bugreport+git_hash-devel.sha256sum] = "431221a3898cb9552cd6c67ef53a8ae76130e758c969267491ed0a1b4a4a21f5"

URI_x86_64_v2_rust-bugreport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bugreport-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bugreport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bugreport-devel}"
SRC_URI[x86_64_v2_rust-bugreport-devel.sha256sum] = "5aea14243a2494337cc63661debe5ed7089005981d5ec77f6eebcef1c4a279cc"

URI_aarch64_rust-bugreport+collector_operating_system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bugreport+collector_operating_system-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-bugreport+collector_operating_system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bugreport+collector_operating_system-devel}"
SRC_URI[aarch64_rust-bugreport+collector_operating_system-devel.sha256sum] = "b77fc0fa77956432d0150abcc72dbfaf32d538df8f8ad47058da13b5adba32a8"

URI_aarch64_rust-bugreport+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bugreport+default-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-bugreport+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bugreport+default-devel}"
SRC_URI[aarch64_rust-bugreport+default-devel.sha256sum] = "a94b30ee900c20b72b3e35f528d52ecb07f55142566ff257bd7219b78c7cec44"

URI_aarch64_rust-bugreport+format_markdown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bugreport+format_markdown-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-bugreport+format_markdown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bugreport+format_markdown-devel}"
SRC_URI[aarch64_rust-bugreport+format_markdown-devel.sha256sum] = "bfd4cf58b2af2497167ed31fadbdf92d642670dfd61b9e8b7a8c532dab644dab"

URI_aarch64_rust-bugreport+format_plaintext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bugreport+format_plaintext-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-bugreport+format_plaintext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bugreport+format_plaintext-devel}"
SRC_URI[aarch64_rust-bugreport+format_plaintext-devel.sha256sum] = "eebd586e3fdcef79e17eaf096ffeb621f22fca643dab9f3ebaf3ac3846a48fd3"

URI_aarch64_rust-bugreport+git-version-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bugreport+git-version-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-bugreport+git-version-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bugreport+git-version-devel}"
SRC_URI[aarch64_rust-bugreport+git-version-devel.sha256sum] = "77c3a8808e6f7655becc1774334e4a827ec58a465cadff43d7ac2f59458afc93"

URI_aarch64_rust-bugreport+git_hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bugreport+git_hash-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-bugreport+git_hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bugreport+git_hash-devel}"
SRC_URI[aarch64_rust-bugreport+git_hash-devel.sha256sum] = "d788142a5feeb3fe78d4202fe70d6565c148d116cad2000201b3bcc295f9d37a"

URI_aarch64_rust-bugreport-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bugreport-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-bugreport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bugreport-devel}"
SRC_URI[aarch64_rust-bugreport-devel.sha256sum] = "61e734f9efe83e8da10be62377ba3cd1b818474e3e8dd7ed9197cacec14d2161"

RDEPENDS:rust-bugreport+collector_operating_system-devel = " \
 cargo \
 rust-bugreport-devel \
 rust-sysinfo+default-devel \
 "
RDEPENDS:rust-bugreport+default-devel = " \
 cargo \
 rust-bugreport+collector_operating_system-devel \
 rust-bugreport+format_markdown-devel \
 rust-bugreport+git_hash-devel \
 rust-bugreport-devel \
 "
RDEPENDS:rust-bugreport+format_markdown-devel = " \
 cargo \
 rust-bugreport-devel \
 "
RDEPENDS:rust-bugreport+format_plaintext-devel = " \
 cargo \
 rust-bugreport-devel \
 "
RDEPENDS:rust-bugreport+git-version-devel = " \
 cargo \
 rust-bugreport-devel \
 rust-git-version+default-devel \
 "
RDEPENDS:rust-bugreport+git_hash-devel = " \
 cargo \
 rust-bugreport+git-version-devel \
 rust-bugreport-devel \
 "
RDEPENDS:rust-bugreport-devel = " \
 bash \
 cargo \
 rust-shell-escape+default-devel \
 "
