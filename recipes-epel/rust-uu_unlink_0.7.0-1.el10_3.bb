# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_unlink"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_unlink+default-devel \
 rust-uu_unlink-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_unlink-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2bcf176c054af77f4cd6e59a5e1cf74669500711103cf465fac657aeeb5df89"

URI_x86_64_v2_rust-uu_unlink+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_unlink+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_unlink+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_unlink+default-devel}"
SRC_URI[x86_64_v2_rust-uu_unlink+default-devel.sha256sum] = "6bc080d18ee782cd7f605b262ba60ead3df2ca18115344ba654ab512466989a2"

URI_x86_64_v2_rust-uu_unlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_unlink-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_unlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_unlink-devel}"
SRC_URI[x86_64_v2_rust-uu_unlink-devel.sha256sum] = "b2b5c99144e4974ac57fa03ade7e40b9452ee9c2d0bd94beab05153f241f9b39"

URI_aarch64_rust-uu_unlink+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_unlink+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_unlink+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_unlink+default-devel}"
SRC_URI[aarch64_rust-uu_unlink+default-devel.sha256sum] = "83646d3b621b15372584b57b8280b5de4d3b0033177f83f1f4713b1b410aa0dc"

URI_aarch64_rust-uu_unlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_unlink-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_unlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_unlink-devel}"
SRC_URI[aarch64_rust-uu_unlink-devel.sha256sum] = "f892cb715ac76d56b08c5182f4258ca814ce4699c7a6c372bb709e12697c3d1e"

RDEPENDS:rust-uu_unlink+default-devel = " \
 cargo \
 rust-uu_unlink-devel \
 "
RDEPENDS:rust-uu_unlink-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 "
