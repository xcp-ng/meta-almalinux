# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pnet_base"
PV = "0.35.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-pnet_base+default-devel \
 rust-pnet_base+serde-devel \
 rust-pnet_base+std-devel \
 rust-pnet_base-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-pnet_base-0.35.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1b006355579239e4f6e48a442f4ee20fb355e026904af2ac632e9f4e2cb8a34b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pnet_base+default-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pnet_base+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pnet_base+default-devel.sha256sum] = "d90d7dae8d1b732db0e09e4da9b74a7bd478f284c554291f21aebbf0aeb683fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pnet_base+serde-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pnet_base+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pnet_base+serde-devel.sha256sum] = "5da535f38825d569c236b25980330d09627258711d791a646f6a19416bf2e2c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pnet_base+std-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pnet_base+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pnet_base+std-devel.sha256sum] = "0b9e21ce2fd30bcdd813dbbc1b7b4cab6812dc1d773a985285de76e98c70ed99"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pnet_base-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pnet_base-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pnet_base-devel.sha256sum] = "bab517739cdbb3f6c52e50d5deff28f537fa66ec70f4ced60d8815fe159aaf60"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pnet_base+default-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-pnet_base+default-devel;unpack=0"
SRC_URI[aarch64_rust-pnet_base+default-devel.sha256sum] = "d692c9c4e2606b8da4b2117e987fbf3bea33e47ca1cb825935652c42776393f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pnet_base+serde-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-pnet_base+serde-devel;unpack=0"
SRC_URI[aarch64_rust-pnet_base+serde-devel.sha256sum] = "ad3ea716da45077ebfc19925ac85a30df7bbc323ed0b3797bea0870dd1af2ea5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pnet_base+std-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-pnet_base+std-devel;unpack=0"
SRC_URI[aarch64_rust-pnet_base+std-devel.sha256sum] = "d3f5ee57175b0d5fc24c8ace46adfc9c2829fb05cbe2284f33e00d34cd260414"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pnet_base-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-pnet_base-devel;unpack=0"
SRC_URI[aarch64_rust-pnet_base-devel.sha256sum] = "6e9e5d2ece59710326774dc29d9ec32ac44b2570279e89d20d61bfafd30c6272"

RDEPENDS:rust-pnet_base+default-devel = " \
 cargo \
 rust-pnet_base+std-devel \
 rust-pnet_base-devel \
 "
RDEPENDS:rust-pnet_base+serde-devel = " \
 cargo \
 rust-pnet_base-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-pnet_base+std-devel = " \
 cargo \
 rust-no-std-net+std-devel \
 rust-pnet_base-devel \
 "
RDEPENDS:rust-pnet_base-devel = " \
 cargo \
 rust-no-std-net-devel \
 "
