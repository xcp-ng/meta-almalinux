# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktimer"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 ktimer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktimer-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77349d14ee38a1c381cecc34e2b8641a87050cbcee9369d84d133fadb0258a57"

URI_x86_64_v2_ktimer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktimer-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktimer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktimer}"
SRC_URI[x86_64_v2_ktimer.sha256sum] = "36caba83afea17a42bcba6e40d4a3113dfc4c453807a6076072fe5d61e26b71a"

URI_aarch64_ktimer = "${EPEL_MIRROR}/aarch64/Packages/k/ktimer-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ktimer;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktimer}"
SRC_URI[aarch64_ktimer.sha256sum] = "397ee32afa71cf6da2c928787c287e885554256ed82c35f9b7a1dceb8869e9ff"

RDEPENDS:ktimer = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
