# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-io"
PV = "0.3.31"
PR = "1.el10_0"
PACKAGES = " \
 rust-futures-io+default-devel \
 rust-futures-io+std-devel \
 rust-futures-io+unstable-devel \
 rust-futures-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-io-0.3.31-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f212b430c87099ba2703923d976bfcaf9315e71b4147d42a43016101066c4ae"

URI_x86_64_v2_rust-futures-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io+default-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-io+default-devel}"
SRC_URI[x86_64_v2_rust-futures-io+default-devel.sha256sum] = "683091caf2c92d7844b5cc0f0c181b99e1f209b77dd8dc8f02925e6b61936657"

URI_x86_64_v2_rust-futures-io+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io+std-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-io+std-devel}"
SRC_URI[x86_64_v2_rust-futures-io+std-devel.sha256sum] = "1b85ee8c94e8d4545b24fa4b6b437f3c2b7581d2a6709535fe29e18924e7e29b"

URI_x86_64_v2_rust-futures-io+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io+unstable-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-io+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-io+unstable-devel.sha256sum] = "f376a73df56932658fc01f7734e6ec0bd20e4073c1312760829c98c55ac7f5a6"

URI_x86_64_v2_rust-futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-io-devel}"
SRC_URI[x86_64_v2_rust-futures-io-devel.sha256sum] = "92302cdf2f19531148bae56a4ccda90211b74186b5dea1fc3adc118e42020656"

URI_aarch64_rust-futures-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io+default-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-io+default-devel}"
SRC_URI[aarch64_rust-futures-io+default-devel.sha256sum] = "05b8c1cc545a25a03e948eb9c59486adb2b850835316a38d037650a59527ecdb"

URI_aarch64_rust-futures-io+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io+std-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-io+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-io+std-devel}"
SRC_URI[aarch64_rust-futures-io+std-devel.sha256sum] = "9738ad70c0f413aec468fc49e1a56b935e09c4b1a4806f61a183508da71fed99"

URI_aarch64_rust-futures-io+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io+unstable-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-io+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-io+unstable-devel}"
SRC_URI[aarch64_rust-futures-io+unstable-devel.sha256sum] = "8dc2649a4b0a4e0ef696801ce52d8883cf8fc0238226e48aa6327d44d1d67cf7"

URI_aarch64_rust-futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-io-devel}"
SRC_URI[aarch64_rust-futures-io-devel.sha256sum] = "89f05e3182f57eba5ba5a706a4d66db81320c584117a4f1e4ce4bb04916260b5"

RDEPENDS:rust-futures-io+default-devel = " \
 cargo \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 "
RDEPENDS:rust-futures-io+std-devel = " \
 cargo \
 rust-futures-io-devel \
 "
RDEPENDS:rust-futures-io+unstable-devel = " \
 cargo \
 rust-futures-io-devel \
 "
RDEPENDS:rust-futures-io-devel = " \
 cargo \
 rust \
 "
