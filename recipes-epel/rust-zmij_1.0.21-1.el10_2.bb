# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zmij"
PV = "1.0.21"
PR = "1.el10_2"
PACKAGES = " \
 rust-zmij+default-devel \
 rust-zmij+no-panic-devel \
 rust-zmij-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zmij-1.0.21-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6df80400b00184e44dec706454f994ac6b11e29ac9576ac9ba18e99d4f331738"

URI_x86_64_v2_rust-zmij+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zmij+default-devel-1.0.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zmij+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zmij+default-devel}"
SRC_URI[x86_64_v2_rust-zmij+default-devel.sha256sum] = "626e26c0835684a358c4592cbf76833d0a31af36fa2552356df13495c97524ae"

URI_x86_64_v2_rust-zmij+no-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zmij+no-panic-devel-1.0.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zmij+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zmij+no-panic-devel}"
SRC_URI[x86_64_v2_rust-zmij+no-panic-devel.sha256sum] = "db56589f193441a37fb0f85355c2f34a50f67862a53ffc7daa4beb728aa4ee78"

URI_x86_64_v2_rust-zmij-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zmij-devel-1.0.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zmij-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zmij-devel}"
SRC_URI[x86_64_v2_rust-zmij-devel.sha256sum] = "32c93578ffa8a7ea364db416564443927a08e879f4f055c075d0acf10c774367"

URI_aarch64_rust-zmij+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zmij+default-devel-1.0.21-1.el10_2.noarch.rpm;name=aarch64_rust-zmij+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zmij+default-devel}"
SRC_URI[aarch64_rust-zmij+default-devel.sha256sum] = "1bab73e377237aa1a212fd048d6088e7cb3213844096f26b6e6bdf36060c7e21"

URI_aarch64_rust-zmij+no-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zmij+no-panic-devel-1.0.21-1.el10_2.noarch.rpm;name=aarch64_rust-zmij+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zmij+no-panic-devel}"
SRC_URI[aarch64_rust-zmij+no-panic-devel.sha256sum] = "44462c67d6210f3a4fa77cb7b6415544847e15e450afd339c1589f10c8ef6e80"

URI_aarch64_rust-zmij-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zmij-devel-1.0.21-1.el10_2.noarch.rpm;name=aarch64_rust-zmij-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zmij-devel}"
SRC_URI[aarch64_rust-zmij-devel.sha256sum] = "a18adad6db260b7299b2ff1be13c51d8c55f2c9ed348007f8003f7c8fe7d0d47"

RDEPENDS:rust-zmij+default-devel = " \
 cargo \
 rust-zmij-devel \
 "
RDEPENDS:rust-zmij+no-panic-devel = " \
 cargo \
 rust-no-panic+default-devel \
 rust-zmij-devel \
 "
RDEPENDS:rust-zmij-devel = " \
 cargo \
 rust \
 "
