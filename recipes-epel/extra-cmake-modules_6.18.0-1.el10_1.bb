# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "extra-cmake-modules"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 extra-cmake-modules \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/extra-cmake-modules-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "792aa37ece0e69cbd96d1de1793cd392527ddc8b191e685ccea384c7b1d87271"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/extra-cmake-modules-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_extra-cmake-modules;unpack=0"
SRC_URI[x86_64_v2_extra-cmake-modules.sha256sum] = "ebeef623cbc2db871c0a602143d3995cd225833533c9a8f3ccaad852affb585e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/extra-cmake-modules-6.18.0-1.el10_1.noarch.rpm;name=aarch64_extra-cmake-modules;unpack=0"
SRC_URI[aarch64_extra-cmake-modules.sha256sum] = "e9f9ac03d425e38899b015696dc14f932bf9a0c766184dc37392f9190e6e2677"

RDEPENDS:extra-cmake-modules = " \
 bash \
 kf6-rpm-macros \
 python3 \
 "
