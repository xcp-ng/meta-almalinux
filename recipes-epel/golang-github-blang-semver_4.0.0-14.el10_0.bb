# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-blang-semver"
PV = "4.0.0"
PR = "14.el10_0"
PACKAGES = " \
 golang-github-blang-semver-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-blang-semver-4.0.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "61da5137f802227014159da1dc2c7495bed4ed599687b9636bc9d726810cf078"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-blang-semver-devel-4.0.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-blang-semver-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-blang-semver-devel.sha256sum] = "9a532af56c52e792d836570972973cb6d560dde7d842e2d553162e1ae3409cc0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-blang-semver-devel-4.0.0-14.el10_0.noarch.rpm;name=aarch64_golang-github-blang-semver-devel;unpack=0"
SRC_URI[aarch64_golang-github-blang-semver-devel.sha256sum] = "a34de15435a1e81473137b06c36ab7ccec190c36160040efc31cab48428c2ff1"

RDEPENDS:golang-github-blang-semver-devel = " \
 go-filesystem \
 "
