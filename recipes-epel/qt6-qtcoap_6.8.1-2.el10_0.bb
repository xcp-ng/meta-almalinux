# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtcoap"
PV = "6.8.1"
PR = "2.el10_0"
PACKAGES = " \
 qt6-qtcoap \
 qt6-qtcoap-devel \
 qt6-qtcoap-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtcoap-6.8.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83808bd87bcb008feba52b11f7f9b82c37de96337b775bb02af7103856a8de78"

URI_x86_64_v2_qt6-qtcoap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtcoap-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcoap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcoap}"
SRC_URI[x86_64_v2_qt6-qtcoap.sha256sum] = "aff8e44e220735274474e623a0f538f53bb510367787eba3667ca1f9049e367c"

URI_x86_64_v2_qt6-qtcoap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtcoap-devel-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcoap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcoap-devel}"
SRC_URI[x86_64_v2_qt6-qtcoap-devel.sha256sum] = "edb444e77aceee9ff747410d48622202b8e047f3b1b51d238e04cb7ad79a8138"

URI_x86_64_v2_qt6-qtcoap-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtcoap-examples-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcoap-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcoap-examples}"
SRC_URI[x86_64_v2_qt6-qtcoap-examples.sha256sum] = "d31c393dfef9056460b3350bc5bd7c6401739d26f9583ac3a606bee3d75e5877"

URI_aarch64_qt6-qtcoap = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtcoap-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtcoap;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcoap}"
SRC_URI[aarch64_qt6-qtcoap.sha256sum] = "e08a36f9428d22d5253b79cc8a392b12dc6654993dcf1fed09f8ca040f7ff17a"

URI_aarch64_qt6-qtcoap-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtcoap-devel-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtcoap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcoap-devel}"
SRC_URI[aarch64_qt6-qtcoap-devel.sha256sum] = "a0bfcd06b6b6c4ffb75bf78c908186c0769e26c94023568d565ee881dc030be1"

URI_aarch64_qt6-qtcoap-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtcoap-examples-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtcoap-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcoap-examples}"
SRC_URI[aarch64_qt6-qtcoap-examples.sha256sum] = "68449471353435b78476eb6e6718a8d33ca716f5233b96fe39a6dfbac267e7ef"

RDEPENDS:qt6-qtcoap = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtcoap-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtcoap \
 "
RDEPENDS:qt6-qtcoap-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcoap \
 qt6-qtcoap-devel \
 qt6-qtdeclarative \
 "
