# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pathdiff"
PV = "0.2.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-pathdiff+camino-devel \
 rust-pathdiff+default-devel \
 rust-pathdiff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pathdiff-0.2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f6fb224fdad6c253ba2e2a9730895a1a11caeeba36c30ed0101b24442f179b2"

URI_x86_64_v2_rust-pathdiff+camino-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pathdiff+camino-devel-0.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pathdiff+camino-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pathdiff+camino-devel}"
SRC_URI[x86_64_v2_rust-pathdiff+camino-devel.sha256sum] = "2ecb53f9a48f187ebfcc6cbf05e62e8325a7142f0a9b3d58a64143f0c0b73d3e"

URI_x86_64_v2_rust-pathdiff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pathdiff+default-devel-0.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pathdiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pathdiff+default-devel}"
SRC_URI[x86_64_v2_rust-pathdiff+default-devel.sha256sum] = "0b49e96a5bf2251fa6e1e79939d64a3332946046719fd5a22b7a0dda522c8b5f"

URI_x86_64_v2_rust-pathdiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pathdiff-devel-0.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pathdiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pathdiff-devel}"
SRC_URI[x86_64_v2_rust-pathdiff-devel.sha256sum] = "2e071c4b389a40ab13ea38b8cb2720009acf5b4a3e258d7fe365dbc02e9a67bb"

URI_aarch64_rust-pathdiff+camino-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pathdiff+camino-devel-0.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-pathdiff+camino-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pathdiff+camino-devel}"
SRC_URI[aarch64_rust-pathdiff+camino-devel.sha256sum] = "8d01ea91a920b395c280da7fa15e98d6f0663b3ac60e619501c18ee698bb6680"

URI_aarch64_rust-pathdiff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pathdiff+default-devel-0.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-pathdiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pathdiff+default-devel}"
SRC_URI[aarch64_rust-pathdiff+default-devel.sha256sum] = "a310c9b273a6d6c5ba5fe92189d1dc97f7a8164427be2885600e645221c2dce9"

URI_aarch64_rust-pathdiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pathdiff-devel-0.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-pathdiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pathdiff-devel}"
SRC_URI[aarch64_rust-pathdiff-devel.sha256sum] = "beceecb6ef972d167684f59e703a83d05498e78d3d9e14cece6b6a2319627ff4"

RDEPENDS:rust-pathdiff+camino-devel = " \
 cargo \
 rust-camino+default-devel \
 rust-pathdiff-devel \
 "
RDEPENDS:rust-pathdiff+default-devel = " \
 cargo \
 rust-pathdiff-devel \
 "
RDEPENDS:rust-pathdiff-devel = " \
 cargo \
 "
