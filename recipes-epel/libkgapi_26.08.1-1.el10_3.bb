# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkgapi"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 libkgapi \
 libkgapi-devel \
 libkgapi-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libkgapi-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f920f3b54959b8d01f65d44453bd2368845c3b3cc1c8ed819e98caa9bd173027"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkgapi;unpack=0"
SRC_URI[x86_64_v2_libkgapi.sha256sum] = "a248a5785105cebfc9b75094e40b54920ebb5438c3cea494afba959f58ed93c5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkgapi-devel;unpack=0"
SRC_URI[x86_64_v2_libkgapi-devel.sha256sum] = "cd3fca72e01fad11a59846fa710608610dbeb63dd7b67e0c69201affe1bfda43"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libkgapi-doc;unpack=0"
SRC_URI[x86_64_v2_libkgapi-doc.sha256sum] = "b231c4a777c6999979cb0e157c1cc7577a73344383369276e70e9d24d84fc050"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkgapi;unpack=0"
SRC_URI[aarch64_libkgapi.sha256sum] = "ecafc268f663baceb3de51233cef8f1d1082549dae026091588b7b4b80b6d6c9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkgapi-devel;unpack=0"
SRC_URI[aarch64_libkgapi-devel.sha256sum] = "d4dfd9be0477cbe73898fe155e6389c183273eaae42b61ef2086ed392f30f827"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_libkgapi-doc;unpack=0"
SRC_URI[aarch64_libkgapi-doc.sha256sum] = "10985c6b21c6e83ddcabfa6d37485ca689a602bf2dcc76f904093c2fb6e6723e"

RDEPENDS:libkgapi = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-kwallet-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkgapi-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kf6-kcoreaddons-devel \
 libkgapi \
 "
RDEPENDS:libkgapi-doc = " \
 "
