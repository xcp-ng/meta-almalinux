# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ammonia"
PV = "4.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-ammonia+default-devel \
 rust-ammonia-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ammonia-4.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ed80b21fc38a848e8bc1ecff1b8cb34a9a83b38cb71f7d0d7d55fffbdd71efa"

URI_x86_64_v2_rust-ammonia+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ammonia+default-devel-4.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ammonia+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ammonia+default-devel}"
SRC_URI[x86_64_v2_rust-ammonia+default-devel.sha256sum] = "61a8d13f4f7f540bdfe89d6c736a28153722f45fd9e699de98e1fc3200593038"

URI_x86_64_v2_rust-ammonia-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ammonia-devel-4.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ammonia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ammonia-devel}"
SRC_URI[x86_64_v2_rust-ammonia-devel.sha256sum] = "5e1af2176a299bd5c3c0e91ef1d27aa32d773ec9a8be71ad27b8dc539f106ea9"

URI_aarch64_rust-ammonia+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ammonia+default-devel-4.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-ammonia+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ammonia+default-devel}"
SRC_URI[aarch64_rust-ammonia+default-devel.sha256sum] = "e4d188ccb64dce5811d6f8ec3354c4b2130c8f509c5c0a581f61c39dbb2f2201"

URI_aarch64_rust-ammonia-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ammonia-devel-4.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-ammonia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ammonia-devel}"
SRC_URI[aarch64_rust-ammonia-devel.sha256sum] = "168a0d4c2f38ce222776b295f8afab828f921865e5e7c21809fddc3f7360e295"

RDEPENDS:rust-ammonia+default-devel = " \
 cargo \
 rust-ammonia-devel \
 "
RDEPENDS:rust-ammonia-devel = " \
 cargo \
 rust \
 rust-html5ever0.29+default-devel \
 rust-maplit+default-devel \
 rust-once_cell+default-devel \
 rust-tendril0.4+default-devel \
 rust-url+default-devel \
 "
