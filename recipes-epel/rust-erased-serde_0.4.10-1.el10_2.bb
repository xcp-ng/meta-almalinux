# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-erased-serde"
PV = "0.4.10"
PR = "1.el10_2"
PACKAGES = " \
 rust-erased-serde+alloc-devel \
 rust-erased-serde+default-devel \
 rust-erased-serde+std-devel \
 rust-erased-serde+unstable-debug-devel \
 rust-erased-serde-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-erased-serde-0.4.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "836863d2c203eeef502f0f7fed89f1e7abf7b4813e4564699ee3d24e6d174137"

URI_x86_64_v2_rust-erased-serde+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+alloc-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+alloc-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+alloc-devel.sha256sum] = "5ce718dd675d9d6276d13439ad432efe1305de922266cbbb11c521c7c6f012d2"

URI_x86_64_v2_rust-erased-serde+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+default-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+default-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+default-devel.sha256sum] = "f8b769ce3d8e65f2068f749adfe822543969a001884c8d369d02df208710e739"

URI_x86_64_v2_rust-erased-serde+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+std-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+std-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+std-devel.sha256sum] = "ce29ecacf31de5f261f87cc2bcd3a77fc7fe041c5fe673b61dc0d26e1dab52dd"

URI_x86_64_v2_rust-erased-serde+unstable-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+unstable-debug-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+unstable-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+unstable-debug-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+unstable-debug-devel.sha256sum] = "4cb681da9507823a2efbc8ce7cbf3692eb6bd0f2c99609f4d80911ba5d8fcaee"

URI_x86_64_v2_rust-erased-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde-devel}"
SRC_URI[x86_64_v2_rust-erased-serde-devel.sha256sum] = "8e68c410d4baa35fde0b5ae7f57a37498d67a06bd55d3da8b92218d5ea1bb9f6"

URI_aarch64_rust-erased-serde+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+alloc-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-erased-serde+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+alloc-devel}"
SRC_URI[aarch64_rust-erased-serde+alloc-devel.sha256sum] = "0748be489982f3e0121b0bfd4f109f28f9fd5a7d6ff10a320f1e6d8e26666aee"

URI_aarch64_rust-erased-serde+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+default-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-erased-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+default-devel}"
SRC_URI[aarch64_rust-erased-serde+default-devel.sha256sum] = "0100340a5a04d57acb4c910b3fdecb144e86727640eb161ca79450d1b680db0b"

URI_aarch64_rust-erased-serde+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+std-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-erased-serde+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+std-devel}"
SRC_URI[aarch64_rust-erased-serde+std-devel.sha256sum] = "3d82915f7651cabe35cdbcf08f8ee717cdd4ba195f8d28a9c7cbdbb33f2314d0"

URI_aarch64_rust-erased-serde+unstable-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+unstable-debug-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-erased-serde+unstable-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+unstable-debug-devel}"
SRC_URI[aarch64_rust-erased-serde+unstable-debug-devel.sha256sum] = "d5f92d8f50b8424aa9c1e6bcdd40ed22c234be24a4a59f81ad54ecc8f25e9ee4"

URI_aarch64_rust-erased-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde-devel}"
SRC_URI[aarch64_rust-erased-serde-devel.sha256sum] = "2621af2afcb268ad492593292fc58cbea8629123ca9a72cad639b0e2010ce24c"

RDEPENDS:rust-erased-serde+alloc-devel = " \
 cargo \
 rust-erased-serde-devel \
 rust-serde_core+alloc-devel \
 "
RDEPENDS:rust-erased-serde+default-devel = " \
 cargo \
 rust-erased-serde+std-devel \
 rust-erased-serde-devel \
 "
RDEPENDS:rust-erased-serde+std-devel = " \
 cargo \
 rust-erased-serde+alloc-devel \
 rust-erased-serde-devel \
 rust-serde_core+std-devel \
 "
RDEPENDS:rust-erased-serde+unstable-debug-devel = " \
 cargo \
 rust-erased-serde-devel \
 "
RDEPENDS:rust-erased-serde-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 rust-serde_core-devel \
 rust-typeid+default-devel \
 "
