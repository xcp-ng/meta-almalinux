# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-hatch-jupyter-builder"
PV = "0.9.0"
PR = "4.el10_0"
PACKAGES = " \
 python3-hatch-jupyter-builder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-hatch-jupyter-builder-0.9.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eaed6f41bb5b03aaa9102db7358a236e3c5f1cd4b24dc31adfe14b35f5ceb1c9"

URI_x86_64_v2_python3-hatch-jupyter-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hatch-jupyter-builder-0.9.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hatch-jupyter-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hatch-jupyter-builder}"
SRC_URI[x86_64_v2_python3-hatch-jupyter-builder.sha256sum] = "52f3bd77c37c06d45a668d90f53aa4ade5783835e41d169bf587ff862a4e9e4c"

URI_aarch64_python3-hatch-jupyter-builder = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hatch-jupyter-builder-0.9.0-4.el10_0.noarch.rpm;name=aarch64_python3-hatch-jupyter-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hatch-jupyter-builder}"
SRC_URI[aarch64_python3-hatch-jupyter-builder.sha256sum] = "96650184c4bbd4ce26d8e51c48ab0f1d8398d6c765571a7b7bb6ea265b925842"

RDEPENDS:python3-hatch-jupyter-builder = " \
 python3 \
 python3-hatchling \
 "
