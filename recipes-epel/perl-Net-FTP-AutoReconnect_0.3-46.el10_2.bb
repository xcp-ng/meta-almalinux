# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-FTP-AutoReconnect"
PV = "0.3"
PR = "46.el10_2"
PACKAGES = " \
 perl-Net-FTP-AutoReconnect \
 perl-Net-FTP-AutoReconnect-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-FTP-AutoReconnect-0.3-46.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88d9234a69bc921f4fecd85c9b0c0146dfc02438090ddf9030b651b5c43f1ac7"

URI_x86_64_v2_perl-Net-FTP-AutoReconnect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-FTP-AutoReconnect-0.3-46.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-FTP-AutoReconnect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-FTP-AutoReconnect}"
SRC_URI[x86_64_v2_perl-Net-FTP-AutoReconnect.sha256sum] = "0bbe10afc80ae1cf4e7e074f0d38e224262c125c469fc408b3f93959db078778"

URI_x86_64_v2_perl-Net-FTP-AutoReconnect-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-FTP-AutoReconnect-tests-0.3-46.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-FTP-AutoReconnect-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-FTP-AutoReconnect-tests}"
SRC_URI[x86_64_v2_perl-Net-FTP-AutoReconnect-tests.sha256sum] = "0e690f79e6e1a2022e1c92a62a7618354091e4663362dc37c3dbedce52a6b6c4"

URI_aarch64_perl-Net-FTP-AutoReconnect = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-FTP-AutoReconnect-0.3-46.el10_2.noarch.rpm;name=aarch64_perl-Net-FTP-AutoReconnect;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-FTP-AutoReconnect}"
SRC_URI[aarch64_perl-Net-FTP-AutoReconnect.sha256sum] = "d92ef92af17e4570792328c02867594e0ff65515083623a5f3189aa93f551279"

URI_aarch64_perl-Net-FTP-AutoReconnect-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-FTP-AutoReconnect-tests-0.3-46.el10_2.noarch.rpm;name=aarch64_perl-Net-FTP-AutoReconnect-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-FTP-AutoReconnect-tests}"
SRC_URI[aarch64_perl-Net-FTP-AutoReconnect-tests.sha256sum] = "eeeadd6b956594658920530b25fb242395e30be84e6abd68469406a84e3425cd"

RDEPENDS:perl-Net-FTP-AutoReconnect = " \
 perl-libnet \
 perl-libs \
 "
RDEPENDS:perl-Net-FTP-AutoReconnect-tests = " \
 bash \
 perl-Net-FTP-AutoReconnect \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
