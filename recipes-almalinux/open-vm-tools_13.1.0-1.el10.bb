# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "open-vm-tools"
PV = "13.1.0"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 open-vm-tools \
 open-vm-tools-desktop \
 open-vm-tools-salt-minion \
 open-vm-tools-sdmp \
 open-vm-tools-test \
"
PACKAGES:aarch64 = " \
 open-vm-tools \
 open-vm-tools-desktop \
 open-vm-tools-test \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/open-vm-tools-13.1.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6badc2816feb486c3e6047f353c68496e0b23626de12440820a9828956fadf2e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-13.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools;unpack=0"
SRC_URI[x86_64_v2_open-vm-tools.sha256sum] = "8677ffe71fdf2877902d536351d8f017dc4018bd60b6dfe909abd635806776ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-desktop-13.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools-desktop;unpack=0"
SRC_URI[x86_64_v2_open-vm-tools-desktop.sha256sum] = "b039625dc011699b0f8c2eabfbed1c0a666c56afbb9af1eb918822ce78c8f0d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-salt-minion-13.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools-salt-minion;unpack=0"
SRC_URI[x86_64_v2_open-vm-tools-salt-minion.sha256sum] = "0b8698a2156f758f3bd069cca6036f7d34d40184e88fe4b56fd5e0c78efe750a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-sdmp-13.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools-sdmp;unpack=0"
SRC_URI[x86_64_v2_open-vm-tools-sdmp.sha256sum] = "36d9a01a87f531fa1cdde29d1f806cca9ee834678782d32ea7f09a7ec2f05202"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-test-13.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools-test;unpack=0"
SRC_URI[x86_64_v2_open-vm-tools-test.sha256sum] = "f50657221225ff22a021dac1cb6fafa9c930320b4c40083f07a0ca773b9e42a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/open-vm-tools-13.1.0-1.el10.aarch64.rpm;name=aarch64_open-vm-tools;unpack=0"
SRC_URI[aarch64_open-vm-tools.sha256sum] = "0be4555b0947a41158e40d9659856340a2f69dde3231878db3af1e9ce9fa8fa9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/open-vm-tools-desktop-13.1.0-1.el10.aarch64.rpm;name=aarch64_open-vm-tools-desktop;unpack=0"
SRC_URI[aarch64_open-vm-tools-desktop.sha256sum] = "aa392556e03a01de55ba8d641a3da751b53af763e3c732c2da2cbbd1e410c767"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/open-vm-tools-test-13.1.0-1.el10.aarch64.rpm;name=aarch64_open-vm-tools-test;unpack=0"
SRC_URI[aarch64_open-vm-tools-test.sha256sum] = "b13aed141c4113c3cf78946595a6ca539dda98c1331e9b5c86bf24897b4c4fbc"

RDEPENDS:open-vm-tools:x86_64_v2 = " \
 bash \
 dbus-tools \
 fuse3 \
 fuse3-libs \
 glib2 \
 glibc \
 grep \
 iproute \
 libdrm \
 libgcc \
 libmspack \
 libtirpc \
 libxml2 \
 openssl-libs \
 pciutils \
 sed \
 systemd \
 systemd-libs \
 tar \
 util-linux \
 virtual/coreutils \
 which \
 xmlsec1 \
 xmlsec1-openssl \
"
RDEPENDS:open-vm-tools:aarch64 = " \
 bash \
 dbus-tools \
 fuse3 \
 fuse3-libs \
 glib2 \
 glibc \
 grep \
 iproute \
 libdrm \
 libmspack \
 libtirpc \
 libxml2 \
 openssl-libs \
 pciutils \
 sed \
 systemd \
 systemd-libs \
 tar \
 util-linux \
 virtual/coreutils \
 which \
 xmlsec1 \
 xmlsec1-openssl \
"
RDEPENDS:open-vm-tools-desktop = " \
 bash \
 fuse3-libs \
 glib2 \
 glibc \
 glibmm2.68 \
 gtk4 \
 gtkmm4.0 \
 libX11 \
 libXext \
 libXi \
 libXinerama \
 libXrandr \
 libXtst \
 libdrm \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtirpc \
 open-vm-tools \
 systemd-libs \
 "
RDEPENDS:open-vm-tools-salt-minion = " \
 bash \
 curl \
 gawk \
 grep \
 open-vm-tools \
 systemd \
 virtual/coreutils \
 "
RDEPENDS:open-vm-tools-sdmp = " \
 bash \
 gawk \
 glib2 \
 glibc \
 glibc-common \
 grep \
 iproute \
 open-vm-tools \
 procps-ng \
 virtual/coreutils \
 "
RDEPENDS:open-vm-tools-test = " \
 glib2 \
 glibc \
 open-vm-tools \
 "
