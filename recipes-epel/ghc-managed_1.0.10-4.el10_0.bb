# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-managed"
PV = "1.0.10"
PR = "4.el10_0"
PACKAGES = " \
 ghc-managed \
 ghc-managed-devel \
 ghc-managed-doc \
 ghc-managed-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-managed-1.0.10-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f4cdd26008dc60b37315498d94e8aa8a80f0a3609bd31bb3ee889a9b3b08b2c"

URI_x86_64_v2_ghc-managed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-managed-1.0.10-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-managed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-managed}"
SRC_URI[x86_64_v2_ghc-managed.sha256sum] = "87ff6845232758d673a81ed0f9ebbe29a2a02000f2bddce258a8789a7fbcf288"

URI_x86_64_v2_ghc-managed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-managed-devel-1.0.10-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-managed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-managed-devel}"
SRC_URI[x86_64_v2_ghc-managed-devel.sha256sum] = "2f122ca33dbdb6bdf145f6a3543e88002f21fc7eaeeebe224f1f3d05bb9e60c5"

URI_x86_64_v2_ghc-managed-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-managed-doc-1.0.10-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-managed-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-managed-doc}"
SRC_URI[x86_64_v2_ghc-managed-doc.sha256sum] = "1d9770d524991a839f796ad83afc4fb5ce139ec0f922d1c2d91a3c046fb9440d"

URI_x86_64_v2_ghc-managed-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-managed-prof-1.0.10-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-managed-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-managed-prof}"
SRC_URI[x86_64_v2_ghc-managed-prof.sha256sum] = "b7864a087a511dfb8a40950e9d6091bef201179083c6ccbc128b49aa59f2a3f3"

URI_aarch64_ghc-managed = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-managed-1.0.10-4.el10_0.aarch64.rpm;name=aarch64_ghc-managed;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-managed}"
SRC_URI[aarch64_ghc-managed.sha256sum] = "c7b007c51ff759eecb8fd2b1f8c72019f890e3b7228c6fea761e93d758ec4d14"

URI_aarch64_ghc-managed-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-managed-devel-1.0.10-4.el10_0.aarch64.rpm;name=aarch64_ghc-managed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-managed-devel}"
SRC_URI[aarch64_ghc-managed-devel.sha256sum] = "b291d0424bcd8980f30d33455f2b44473291317d52c30dd7cfd4f11e183030bc"

URI_aarch64_ghc-managed-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-managed-doc-1.0.10-4.el10_0.noarch.rpm;name=aarch64_ghc-managed-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-managed-doc}"
SRC_URI[aarch64_ghc-managed-doc.sha256sum] = "26a61dba67942675ea67f71ab93278833098e2d0c2ab8c2ee1126a340069bcd6"

URI_aarch64_ghc-managed-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-managed-prof-1.0.10-4.el10_0.aarch64.rpm;name=aarch64_ghc-managed-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-managed-prof}"
SRC_URI[aarch64_ghc-managed-prof.sha256sum] = "e187905347fa69c6d12019b071aa380f5db92a27df54f35947fbcc2f7e1c09ee"

RDEPENDS:ghc-managed = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-managed-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-managed \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-managed-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-managed-prof = " \
 ghc-base-prof \
 ghc-managed-devel \
 ghc-transformers-prof \
 "
