# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-scipy-doctest"
PV = "1.8.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-scipy-doctest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-scipy-doctest-1.8.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4f5155718e61f781eb68b841cee620f98a959e3478076a707a4b9953dc384f0"

URI_x86_64_v2_python3-scipy-doctest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-scipy-doctest-1.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-scipy-doctest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-scipy-doctest}"
SRC_URI[x86_64_v2_python3-scipy-doctest.sha256sum] = "75ea6f09531d124538339f5ad0b0f2a142b002f7e88c79a4e709a48c037746c3"

URI_aarch64_python3-scipy-doctest = "${EPEL_MIRROR}/aarch64/Packages/p/python3-scipy-doctest-1.8.0-1.el10_1.noarch.rpm;name=aarch64_python3-scipy-doctest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-scipy-doctest}"
SRC_URI[aarch64_python3-scipy-doctest.sha256sum] = "185777d6567460fa7176722fa2ee515cdb9914cacec0df163e4a59a366938a04"

RDEPENDS:python3-scipy-doctest = " \
 python3 \
 python3-numpy \
 python3-pytest \
 "
