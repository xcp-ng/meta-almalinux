# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zstd-safe"
PV = "7.2.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-zstd-safe+arrays-devel \
 rust-zstd-safe+bindgen-devel \
 rust-zstd-safe+debug-devel \
 rust-zstd-safe+default-devel \
 rust-zstd-safe+doc-cfg-devel \
 rust-zstd-safe+experimental-devel \
 rust-zstd-safe+fat-lto-devel \
 rust-zstd-safe+legacy-devel \
 rust-zstd-safe+no_asm-devel \
 rust-zstd-safe+pkg-config-devel \
 rust-zstd-safe+std-devel \
 rust-zstd-safe+thin-devel \
 rust-zstd-safe+thin-lto-devel \
 rust-zstd-safe+zdict_builder-devel \
 rust-zstd-safe+zstdmt-devel \
 rust-zstd-safe-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zstd-safe-7.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0828b69d152b5abc8a86c89e7f657f75a3c8b4cbd809894b394afeeffc38439"

URI_x86_64_v2_rust-zstd-safe+arrays-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+arrays-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+arrays-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+arrays-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+arrays-devel.sha256sum] = "9e82a5e9e132daa8fdf35d26e67cc2b4c072339f8705d3b274e9f97b12e29281"

URI_x86_64_v2_rust-zstd-safe+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+bindgen-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+bindgen-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+bindgen-devel.sha256sum] = "b3570950f3f335e04d93f4ae3270a6c74eb2eb3433d71787f4f32eb9a3805892"

URI_x86_64_v2_rust-zstd-safe+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+debug-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+debug-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+debug-devel.sha256sum] = "ac50ed0c3184114f043c78154a5b6cdf6c77fa5592953ccb527a210d47bb3e6d"

URI_x86_64_v2_rust-zstd-safe+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+default-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+default-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+default-devel.sha256sum] = "733c7d5d0604a6a62433f7a1750511dce0693e85a607e8e7a47efb19b19b8dbf"

URI_x86_64_v2_rust-zstd-safe+doc-cfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+doc-cfg-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+doc-cfg-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+doc-cfg-devel.sha256sum] = "be9d4dc04ef8255f95700cdf4541a88a98a2ec55cd06d9d18182336c7f3361d5"

URI_x86_64_v2_rust-zstd-safe+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+experimental-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+experimental-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+experimental-devel.sha256sum] = "d27729f390c86c8f8398c05847fdb7c7db5c51b4e0fd846cb2a1158d8e1799d2"

URI_x86_64_v2_rust-zstd-safe+fat-lto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+fat-lto-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+fat-lto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+fat-lto-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+fat-lto-devel.sha256sum] = "669d484abd7c44f0e759db52e10d1cd8c0603fc7a94f1934f2a6febdf8b51cc1"

URI_x86_64_v2_rust-zstd-safe+legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+legacy-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+legacy-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+legacy-devel.sha256sum] = "f15da078612cd3a53af6486258d884a060808f2f7b3ec975319c8ac2a8c715c0"

URI_x86_64_v2_rust-zstd-safe+no_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+no_asm-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+no_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+no_asm-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+no_asm-devel.sha256sum] = "60dcc7562d1f557753763212bad91f7e43f418fbf59228c03057d7a33967eaa0"

URI_x86_64_v2_rust-zstd-safe+pkg-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+pkg-config-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+pkg-config-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+pkg-config-devel.sha256sum] = "589abd64c1f469837da0a1c3a2304836a441875321b95c0f640c5934652f1c1d"

URI_x86_64_v2_rust-zstd-safe+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+std-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+std-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+std-devel.sha256sum] = "dfbf890ec9b4c2b9f4bb374b9a6f64c139e303a831c2a723e96dfc8fa0cd68c1"

URI_x86_64_v2_rust-zstd-safe+thin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+thin-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+thin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+thin-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+thin-devel.sha256sum] = "1c12cb73a32f7f1c64469aba327329ae1f793e42b536e5f299eb227fed466eca"

URI_x86_64_v2_rust-zstd-safe+thin-lto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+thin-lto-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+thin-lto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+thin-lto-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+thin-lto-devel.sha256sum] = "6928e59f13ab710775077cc511e913ec91086f04b174a7971aa933b796bb7b0d"

URI_x86_64_v2_rust-zstd-safe+zdict_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+zdict_builder-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+zdict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+zdict_builder-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+zdict_builder-devel.sha256sum] = "8ccae0439c88db86d2cbc126de1156801a3cf8ea52dd8391dabbe6a3505252be"

URI_x86_64_v2_rust-zstd-safe+zstdmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe+zstdmt-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe+zstdmt-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe+zstdmt-devel.sha256sum] = "e7498650da2dfe0a1e91e69d49ca034c422cd1801dc7a7f71bbd66b1d09679b3"

URI_x86_64_v2_rust-zstd-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-safe-devel-7.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-safe-devel}"
SRC_URI[x86_64_v2_rust-zstd-safe-devel.sha256sum] = "cebfdb0d0c140c79df1a444b8e6d24322a0c502d4c002eb9469f90439815e49b"

URI_aarch64_rust-zstd-safe+arrays-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+arrays-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+arrays-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+arrays-devel}"
SRC_URI[aarch64_rust-zstd-safe+arrays-devel.sha256sum] = "06585a087a47d1f51b5729dc3f9e3ed0ba330ec884e31e299386c91d7a649ef3"

URI_aarch64_rust-zstd-safe+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+bindgen-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+bindgen-devel}"
SRC_URI[aarch64_rust-zstd-safe+bindgen-devel.sha256sum] = "daa57baa352b6f46b249d28a05692301c688d9f631c6581af5bd4c3dfaedf2c2"

URI_aarch64_rust-zstd-safe+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+debug-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+debug-devel}"
SRC_URI[aarch64_rust-zstd-safe+debug-devel.sha256sum] = "95d8062accb86dc163335d6600a88d828f6b4e02aa19bdfba23986ab6e064600"

URI_aarch64_rust-zstd-safe+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+default-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+default-devel}"
SRC_URI[aarch64_rust-zstd-safe+default-devel.sha256sum] = "96882ac3682c2b9ac10b1d9d88db9034997b402ce8bc0508ddd3d5f7eeb75401"

URI_aarch64_rust-zstd-safe+doc-cfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+doc-cfg-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+doc-cfg-devel}"
SRC_URI[aarch64_rust-zstd-safe+doc-cfg-devel.sha256sum] = "3474a1a7b0ccf1ac4e71fa11e6083a956a165f09ca92a7afcb68e2c581af791f"

URI_aarch64_rust-zstd-safe+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+experimental-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+experimental-devel}"
SRC_URI[aarch64_rust-zstd-safe+experimental-devel.sha256sum] = "f4448bd6fa73224c2482d4ef73689e5ce128ee41629eace55636299801a89f9b"

URI_aarch64_rust-zstd-safe+fat-lto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+fat-lto-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+fat-lto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+fat-lto-devel}"
SRC_URI[aarch64_rust-zstd-safe+fat-lto-devel.sha256sum] = "0056a70deb91b3eda6d5dddd7e771334e47fe9f96f4a17cf47e8f54125c5ffe3"

URI_aarch64_rust-zstd-safe+legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+legacy-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+legacy-devel}"
SRC_URI[aarch64_rust-zstd-safe+legacy-devel.sha256sum] = "24f30f6862caa77d4c323e0ecaefc59706a182a944294124109cadd7150b75ca"

URI_aarch64_rust-zstd-safe+no_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+no_asm-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+no_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+no_asm-devel}"
SRC_URI[aarch64_rust-zstd-safe+no_asm-devel.sha256sum] = "d296ca0a3c7c52896ba7312d0c4455e49f74c0319f248d52139316e9e08f75f6"

URI_aarch64_rust-zstd-safe+pkg-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+pkg-config-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+pkg-config-devel}"
SRC_URI[aarch64_rust-zstd-safe+pkg-config-devel.sha256sum] = "fd7ebecbff6fde510d605f49f8e8ff5904afa624a5bbeaa70200a5fcf1320ea0"

URI_aarch64_rust-zstd-safe+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+std-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+std-devel}"
SRC_URI[aarch64_rust-zstd-safe+std-devel.sha256sum] = "4e5cf02a1e441dbee54185757c2f0a3b3d856af90836f24d58b9f4788e4d3511"

URI_aarch64_rust-zstd-safe+thin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+thin-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+thin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+thin-devel}"
SRC_URI[aarch64_rust-zstd-safe+thin-devel.sha256sum] = "0b38f1d00fb2087aeeb4a04bc56184bdd6c868da19bb75372baf2e4bcaf19179"

URI_aarch64_rust-zstd-safe+thin-lto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+thin-lto-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+thin-lto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+thin-lto-devel}"
SRC_URI[aarch64_rust-zstd-safe+thin-lto-devel.sha256sum] = "a03626ea2a911494956f321efca4a36ac76069c8219e7fc2946ba8280a35be9c"

URI_aarch64_rust-zstd-safe+zdict_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+zdict_builder-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+zdict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+zdict_builder-devel}"
SRC_URI[aarch64_rust-zstd-safe+zdict_builder-devel.sha256sum] = "f5aade0f8997ea457d7c1c70f05eb65736f4973d13e2a5c29e8e0ac2cb053bfd"

URI_aarch64_rust-zstd-safe+zstdmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe+zstdmt-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe+zstdmt-devel}"
SRC_URI[aarch64_rust-zstd-safe+zstdmt-devel.sha256sum] = "b0c744a243283f2ff1601e6f770f69c6ab3e01e4db85ff1695951f1cf34e2107"

URI_aarch64_rust-zstd-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-safe-devel-7.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-safe-devel}"
SRC_URI[aarch64_rust-zstd-safe-devel.sha256sum] = "8db93af67479e27e64949a1160557e780e3f12b4bfe5663ec09e7723dc8db549"

RDEPENDS:rust-zstd-safe+arrays-devel = " \
 cargo \
 rust-zstd-safe-devel \
 "
RDEPENDS:rust-zstd-safe+bindgen-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+bindgen-devel \
 "
RDEPENDS:rust-zstd-safe+debug-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+debug-devel \
 "
RDEPENDS:rust-zstd-safe+default-devel = " \
 cargo \
 rust-zstd-safe+arrays-devel \
 rust-zstd-safe+legacy-devel \
 rust-zstd-safe+zdict_builder-devel \
 rust-zstd-safe-devel \
 "
RDEPENDS:rust-zstd-safe+doc-cfg-devel = " \
 cargo \
 rust-zstd-safe-devel \
 "
RDEPENDS:rust-zstd-safe+experimental-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+experimental-devel \
 "
RDEPENDS:rust-zstd-safe+fat-lto-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+fat-lto-devel \
 "
RDEPENDS:rust-zstd-safe+legacy-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+legacy-devel \
 "
RDEPENDS:rust-zstd-safe+no_asm-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+no_asm-devel \
 "
RDEPENDS:rust-zstd-safe+pkg-config-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+pkg-config-devel \
 "
RDEPENDS:rust-zstd-safe+std-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+std-devel \
 "
RDEPENDS:rust-zstd-safe+thin-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+thin-devel \
 "
RDEPENDS:rust-zstd-safe+thin-lto-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+thin-lto-devel \
 "
RDEPENDS:rust-zstd-safe+zdict_builder-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+zdict_builder-devel \
 "
RDEPENDS:rust-zstd-safe+zstdmt-devel = " \
 cargo \
 rust-zstd-safe-devel \
 rust-zstd-sys+zstdmt-devel \
 "
RDEPENDS:rust-zstd-safe-devel = " \
 cargo \
 rust \
 rust-zstd-sys-devel \
 "
