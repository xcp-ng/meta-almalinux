# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-colored2"
PV = "2.2.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-colored2+default-devel \
 rust-colored2+no-color-devel \
 rust-colored2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-colored2-2.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6b042399cbc8f2243d6983385792b69fcbdb52c082fef28e8c559032f349eec"

URI_x86_64_v2_rust-colored2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colored2+default-devel-2.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colored2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colored2+default-devel}"
SRC_URI[x86_64_v2_rust-colored2+default-devel.sha256sum] = "b5e13081d0e0cd0e2ef3f5c7f1d99f1db6dfc6976146a019bb8ff2e909093971"
RPROVIDES:rust-colored2+default-devel:append:x86_64_v2 = " virtual/crate_colored/default__ge_2.0.0_with_crate_colored/default__lt_4.0.0~"

URI_x86_64_v2_rust-colored2+no-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colored2+no-color-devel-2.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colored2+no-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colored2+no-color-devel}"
SRC_URI[x86_64_v2_rust-colored2+no-color-devel.sha256sum] = "8d5599bd6bbf57e0028d842bf05ba049e33f957fabf4e08800b24590713befb7"

URI_x86_64_v2_rust-colored2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colored2-devel-2.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colored2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colored2-devel}"
SRC_URI[x86_64_v2_rust-colored2-devel.sha256sum] = "b931063da38ddb5084de634a0bee005e25e2cd310ed9c51c8059c9ce1ef6d4a2"

URI_aarch64_rust-colored2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colored2+default-devel-2.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-colored2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colored2+default-devel}"
SRC_URI[aarch64_rust-colored2+default-devel.sha256sum] = "a5af5f8e40d2c909efe09acef3bf8eed7b3f68c9f429ee2900bde2823eeeafc8"
RPROVIDES:rust-colored2+default-devel:append:aarch64 = " virtual/crate_colored/default__ge_2.0.0_with_crate_colored/default__lt_4.0.0~"

URI_aarch64_rust-colored2+no-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colored2+no-color-devel-2.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-colored2+no-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colored2+no-color-devel}"
SRC_URI[aarch64_rust-colored2+no-color-devel.sha256sum] = "86dc7c18cbc11b1478a96faaf5f07897aeedba9a560891590066e8748304002b"

URI_aarch64_rust-colored2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colored2-devel-2.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-colored2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colored2-devel}"
SRC_URI[aarch64_rust-colored2-devel.sha256sum] = "4f3ee28d465c0f2b6ee4414a3d6ebdeeb748030b17ab05c44b99cda564d621f7"

RDEPENDS:rust-colored2+default-devel = " \
 cargo \
 rust-colored2-devel \
 "
RDEPENDS:rust-colored2+no-color-devel = " \
 cargo \
 rust-colored2-devel \
 "
RDEPENDS:rust-colored2-devel = " \
 cargo \
 rust \
 rust-lazy_static+default-devel \
 "
