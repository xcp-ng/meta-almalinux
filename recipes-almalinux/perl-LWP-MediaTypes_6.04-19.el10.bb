# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-LWP-MediaTypes"
PV = "6.04"
PR = "19.el10"
PACKAGES = " \
 perl-LWP-MediaTypes \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-LWP-MediaTypes-6.04-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edd6b8952198ec0af64e86c1656a7a4d82d4602d9abc3bf5ffdd6717753ebc47"

URI_x86_64_v2_perl-LWP-MediaTypes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-LWP-MediaTypes-6.04-19.el10.noarch.rpm;name=x86_64_v2_perl-LWP-MediaTypes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-LWP-MediaTypes}"
SRC_URI[x86_64_v2_perl-LWP-MediaTypes.sha256sum] = "3f6a08f7163022c3e27d16fbf10e27d256ac5341940267d3259a65fb9638372f"

URI_aarch64_perl-LWP-MediaTypes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-LWP-MediaTypes-6.04-19.el10.noarch.rpm;name=aarch64_perl-LWP-MediaTypes;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-LWP-MediaTypes}"
SRC_URI[aarch64_perl-LWP-MediaTypes.sha256sum] = "3f6a08f7163022c3e27d16fbf10e27d256ac5341940267d3259a65fb9638372f"

RDEPENDS:perl-LWP-MediaTypes = " \
 mailcap \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-Scalar-List-Utils \
 perl-libs \
 "
