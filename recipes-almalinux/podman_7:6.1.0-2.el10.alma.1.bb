# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "podman"
PE = "7"
PV = "6.1.0"
PR = "2.el10.alma.1"
PACKAGES = " \
 podman \
 podman-docker \
 podman-remote \
 podman-tests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/podman-6.1.0-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5bcf7133b571be9552602a6109f7ee4bd946a93ccc8e58a4449cc6eaef733354"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-6.1.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman;unpack=0"
SRC_URI[x86_64_v2_podman.sha256sum] = "40f2cff6c2621dbf32547851be3e195126db9ad53ce85d13fb5fbfa9dd328c24"
RPROVIDES:podman:append:x86_64_v2 = " virtual/podman_or_/usr/bin/docker"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-docker-6.1.0-2.el10.alma.1.noarch.rpm;name=x86_64_v2_podman-docker;unpack=0"
SRC_URI[x86_64_v2_podman-docker.sha256sum] = "2a7663888574402c09d12c6f49d33a554cf03d958394a0eee340cfe94f5e438b"
RPROVIDES:podman-docker:append:x86_64_v2 = " virtual/podman_or_/usr/bin/docker"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-remote-6.1.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman-remote;unpack=0"
SRC_URI[x86_64_v2_podman-remote.sha256sum] = "f039ae9f1da9d3c24cf560ceb1ea430274e4a44526aa717d38c0eeb133345994"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/podman-tests-6.1.0-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman-tests;unpack=0"
SRC_URI[x86_64_v2_podman-tests.sha256sum] = "f4c83f4131bb1a334137465e15d41cba5c98ce2d94c4dfa0fd1225f9ebd9f92c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-6.1.0-2.el10.alma.1.aarch64.rpm;name=aarch64_podman;unpack=0"
SRC_URI[aarch64_podman.sha256sum] = "cb3f60ec6a2dda699f77004ffc93b7a5a38fe785408a4396b72a57a243f2d07b"
RPROVIDES:podman:append:aarch64 = " virtual/podman_or_/usr/bin/docker"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-docker-6.1.0-2.el10.alma.1.noarch.rpm;name=aarch64_podman-docker;unpack=0"
SRC_URI[aarch64_podman-docker.sha256sum] = "2a7663888574402c09d12c6f49d33a554cf03d958394a0eee340cfe94f5e438b"
RPROVIDES:podman-docker:append:aarch64 = " virtual/podman_or_/usr/bin/docker"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-remote-6.1.0-2.el10.alma.1.aarch64.rpm;name=aarch64_podman-remote;unpack=0"
SRC_URI[aarch64_podman-remote.sha256sum] = "61aa227ae32a6c9eedab20e695159c9686204665f13f1828daa15437fe2c42a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/podman-tests-6.1.0-2.el10.alma.1.aarch64.rpm;name=aarch64_podman-tests;unpack=0"
SRC_URI[aarch64_podman-tests.sha256sum] = "24225bc91545bd83c100aa4e68d6cb76134d96b26dad2950279c636451b219ae"

RDEPENDS:podman = " \
 catatonit \
 conmon \
 containers-common-extra \
 glibc \
 gpgme \
 libgcc \
 libseccomp \
 podman-sequoia \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:podman-docker = " \
 bash \
 podman \
 "
RDEPENDS:podman-remote = " \
 glibc \
 gpgme \
 libgcc \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:podman-tests = " \
 attr \
 bash \
 buildah \
 glibc \
 gnupg2 \
 gpgme \
 httpd-tools \
 jq \
 libgcc \
 libseccomp \
 nmap-ncat \
 openssl \
 podman \
 shadow-utils-subid \
 skopeo \
 socat \
 sqlite-libs \
 xfsprogs \
 "
