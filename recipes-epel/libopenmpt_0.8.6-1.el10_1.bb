# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libopenmpt"
PV = "0.8.6"
PR = "1.el10_1"
PACKAGES = " \
 libopenmpt \
 libopenmpt-devel \
 openmpt123 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libopenmpt-0.8.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86f2e1d4130e82872fcb3ddda391209aad369a3c31e3b069556e301ea2a315cf"

URI_x86_64_v2_libopenmpt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenmpt-0.8.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenmpt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenmpt}"
SRC_URI[x86_64_v2_libopenmpt.sha256sum] = "ba01af3e4f4cc4700e8a8fa309f1c5fc8e70b1211ccd2a178f364f25f1b3be01"

URI_x86_64_v2_libopenmpt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenmpt-devel-0.8.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenmpt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenmpt-devel}"
SRC_URI[x86_64_v2_libopenmpt-devel.sha256sum] = "c8aac5aff6189cfbb26070282f7b28878731041b7ed00cea0dfcb5b72968e449"

URI_x86_64_v2_openmpt123 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openmpt123-0.8.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openmpt123;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openmpt123}"
SRC_URI[x86_64_v2_openmpt123.sha256sum] = "161b7af28855bab46c20546602b8cf551d7ab710b5e14e2e571281f38c0186ba"

URI_aarch64_libopenmpt = "${EPEL_MIRROR}/aarch64/Packages/l/libopenmpt-0.8.6-1.el10_1.aarch64.rpm;name=aarch64_libopenmpt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenmpt}"
SRC_URI[aarch64_libopenmpt.sha256sum] = "08c9c47a35c53495a7eada6bbe9d361e0ed472554a00168ebdd9cabdbb1e22a7"

URI_aarch64_libopenmpt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libopenmpt-devel-0.8.6-1.el10_1.aarch64.rpm;name=aarch64_libopenmpt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenmpt-devel}"
SRC_URI[aarch64_libopenmpt-devel.sha256sum] = "216465c02d604e1c161c2322450cc45e700b0fea3e143d8c86859173deda75e0"

URI_aarch64_openmpt123 = "${EPEL_MIRROR}/aarch64/Packages/o/openmpt123-0.8.6-1.el10_1.aarch64.rpm;name=aarch64_openmpt123;unpack=0"
SRC_URI:append = " ${URI_aarch64_openmpt123}"
SRC_URI[aarch64_openmpt123.sha256sum] = "5d87cb8ded767d29ae40fe4b8c18878d6fb4a5e472d369ee53344b0cc374cef5"

RDEPENDS:libopenmpt = " \
 glibc \
 libgcc \
 libogg \
 libstdc++ \
 libvorbis \
 mpg123-libs \
 zlib-ng-compat \
 "
RDEPENDS:libopenmpt-devel = " \
 libogg-devel \
 libopenmpt \
 libvorbis-devel \
 mpg123-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:openmpt123 = " \
 flac-libs \
 glibc \
 libgcc \
 libopenmpt \
 libsndfile \
 libstdc++ \
 pulseaudio-libs \
 "
