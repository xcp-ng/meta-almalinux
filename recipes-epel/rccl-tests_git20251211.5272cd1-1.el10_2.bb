# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rccl-tests"
PV = "git20251211.5272cd1"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 rccl-tests \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rccl-tests-git20251211.5272cd1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bbd85dbcc65817289aab2f1926a1219c40c0019a09f7f4f5098f081e07284d0"

URI_x86_64_v2_rccl-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rccl-tests-git20251211.5272cd1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rccl-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rccl-tests}"
SRC_URI[x86_64_v2_rccl-tests.sha256sum] = "e67d740bad3aa45a3f432021718957f333c0cafaa5336117178fd59ab9980abe"

RDEPENDS:rccl-tests = " \
 glibc \
 libgcc \
 libstdc++ \
 rccl \
 rocm-hip \
 "
