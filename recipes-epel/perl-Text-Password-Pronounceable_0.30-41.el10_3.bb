# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-Password-Pronounceable"
PV = "0.30"
PR = "41.el10_3"
PACKAGES = " \
 perl-Text-Password-Pronounceable \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-Password-Pronounceable-0.30-41.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62204c67b1fd9aa980584e8232054e64a0b39a2c3de0dbec4559924fa7f150c4"

URI_x86_64_v2_perl-Text-Password-Pronounceable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-Password-Pronounceable-0.30-41.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-Password-Pronounceable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-Password-Pronounceable}"
SRC_URI[x86_64_v2_perl-Text-Password-Pronounceable.sha256sum] = "5d2f1c147544a2dbcb63b0db435d6fba00db07b3484f58d0f1394f4775d5a62a"

URI_aarch64_perl-Text-Password-Pronounceable = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-Password-Pronounceable-0.30-41.el10_3.noarch.rpm;name=aarch64_perl-Text-Password-Pronounceable;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-Password-Pronounceable}"
SRC_URI[aarch64_perl-Text-Password-Pronounceable.sha256sum] = "3f24db971148a326312151353a640503bbc7f329023502f91c73935cddef985f"

RDEPENDS:perl-Text-Password-Pronounceable = " \
 perl-Carp \
 perl-libs \
 "
