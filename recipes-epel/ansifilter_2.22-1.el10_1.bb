# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansifilter"
PV = "2.22"
PR = "1.el10_1"
PACKAGES = " \
 ansifilter \
 ansifilter-gui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansifilter-2.22-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "450725341b7daea6f12a20ed22ef3d0393b8998cd2865277d4d5e63ccaabfce3"

URI_x86_64_v2_ansifilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansifilter-2.22-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ansifilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansifilter}"
SRC_URI[x86_64_v2_ansifilter.sha256sum] = "2013d189177d06565dfcd433abfc38286d300b469503c4550db5ca6cee5008ee"

URI_x86_64_v2_ansifilter-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansifilter-gui-2.22-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ansifilter-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansifilter-gui}"
SRC_URI[x86_64_v2_ansifilter-gui.sha256sum] = "8fec003675f9da903358e66760bd9122371a501bc26e5962f35c8ad8570a66f6"

URI_aarch64_ansifilter = "${EPEL_MIRROR}/aarch64/Packages/a/ansifilter-2.22-1.el10_1.aarch64.rpm;name=aarch64_ansifilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansifilter}"
SRC_URI[aarch64_ansifilter.sha256sum] = "8c41c088e7e21aa917e96a07a98932317eac3d1e0f532d784357ed9f294717ee"

URI_aarch64_ansifilter-gui = "${EPEL_MIRROR}/aarch64/Packages/a/ansifilter-gui-2.22-1.el10_1.aarch64.rpm;name=aarch64_ansifilter-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansifilter-gui}"
SRC_URI[aarch64_ansifilter-gui.sha256sum] = "1d56f9144660093492fac9b88128f34c476078fc888fb5eadd58a0eee6dd8466"

RDEPENDS:ansifilter = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:ansifilter-gui = " \
 glibc \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
