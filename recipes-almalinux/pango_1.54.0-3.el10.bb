# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pango"
PV = "1.54.0"
PR = "3.el10"
PACKAGES = " \
 pango \
 pango-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pango-1.54.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09b1e77c52f1be17a9df36edb00480efda73f4d899142a1001f16a447be7e250"

URI_x86_64_v2_pango = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pango-1.54.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_pango;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pango}"
SRC_URI[x86_64_v2_pango.sha256sum] = "c21e43b86ec1f24c973cbb06d96024c40b0d6537a5c1760e8aa39687fa000c14"

URI_x86_64_v2_pango-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pango-devel-1.54.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_pango-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pango-devel}"
SRC_URI[x86_64_v2_pango-devel.sha256sum] = "2c95309f8af3ec966d9bce1bdfcc087896b1e2ed9839b5e649211aa664ed6ca3"

URI_aarch64_pango = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pango-1.54.0-3.el10.aarch64.rpm;name=aarch64_pango;unpack=0"
SRC_URI:append = " ${URI_aarch64_pango}"
SRC_URI[aarch64_pango.sha256sum] = "19f02274e23a362a638a7dd3e64d06ddce424ec93a25106f5cd9baa921822979"

URI_aarch64_pango-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pango-devel-1.54.0-3.el10.aarch64.rpm;name=aarch64_pango-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pango-devel}"
SRC_URI[aarch64_pango-devel.sha256sum] = "5e6a79b3f36cba8fec599e8a738d2c64ab940febbc9476d3ff041fe1169ab306"

RDEPENDS:pango = " \
 cairo \
 fontconfig \
 freetype \
 fribidi \
 glib2 \
 glibc \
 harfbuzz \
 libX11 \
 libXft \
 libXrender \
 libthai \
 "
RDEPENDS:pango-devel = " \
 cairo-devel \
 fontconfig-devel \
 freetype-devel \
 fribidi-devel \
 glib2-devel \
 harfbuzz-devel \
 libXft-devel \
 libXrender-devel \
 libthai-devel \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 "
