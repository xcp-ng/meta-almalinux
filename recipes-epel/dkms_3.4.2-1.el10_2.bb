# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dkms"
PV = "3.4.2"
PR = "1.el10_2"
PACKAGES = " \
 dkms \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dkms-3.4.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6ec32a883006bb3f9d0b68f126067db55d929ad2972d25eb972acd10dbe4102"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - dkms: (kernel-64k-devel-matched if kernel-64k-core)
# - dkms: (kernel-rt-debug-devel if kernel-rt-debug-core)
# - dkms: (kernel-rt-devel if kernel-rt-core)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - dkms: (kernel-rt-debug-devel if kernel-rt-debug-core)
# - dkms: (kernel-rt-devel if kernel-rt-core)

URI_x86_64_v2_dkms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dkms-3.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dkms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dkms}"
SRC_URI[x86_64_v2_dkms.sha256sum] = "3419c6e95be7627df2d356002a90e469b5fdc5e4fa0556cd50c88bb9c5a1e98f"

URI_aarch64_dkms = "${EPEL_MIRROR}/aarch64/Packages/d/dkms-3.4.2-1.el10_2.noarch.rpm;name=aarch64_dkms;unpack=0"
SRC_URI:append = " ${URI_aarch64_dkms}"
SRC_URI[aarch64_dkms.sha256sum] = "b59a38ef1fbad70f5fb6f259272d2d4fc664c0abaf8d6c6eaa39f6c3660f88dd"

RDEPENDS:dkms:x86_64_v2 = " \
 bash \
 cpio \
 elfutils-libelf-devel \
 file \
 findutils \
 gawk \
 gcc \
 grep \
 gzip \
 kernel-debug-devel-matched \
 kernel-devel-matched \
 kmod \
 make \
 patch \
 sed \
 tar \
 virtual/coreutils \
 which \
"
RDEPENDS:dkms:aarch64 = " \
 bash \
 cpio \
 elfutils-libelf-devel \
 file \
 findutils \
 gawk \
 gcc \
 grep \
 gzip \
 kernel-64k-devel-matched \
 kernel-debug-devel-matched \
 kernel-devel-matched \
 kmod \
 make \
 patch \
 sed \
 tar \
 virtual/coreutils \
 which \
"
