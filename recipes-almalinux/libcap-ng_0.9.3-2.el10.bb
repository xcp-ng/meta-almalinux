# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcap-ng"
PV = "0.9.3"
PR = "2.el10"
PACKAGES = " \
 libcap-ng \
 libcap-ng-devel \
 libcap-ng-python3 \
 libcap-ng-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libcap-ng-0.9.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b08b89918e0af8072870f746c239e77ddfd4f31e834168169e8eae605e2adf4e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcap-ng-0.9.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_libcap-ng;unpack=0"
SRC_URI[x86_64_v2_libcap-ng.sha256sum] = "9b398b4a2f7e153fb37017cc825d959a2d540c9e28cfc11aa1ed2ac03ff2bb6b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcap-ng-devel-0.9.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_libcap-ng-devel;unpack=0"
SRC_URI[x86_64_v2_libcap-ng-devel.sha256sum] = "d6e1ce88979136f5c6ca107f51fa52db04134052c2f1def24cea5f4621ae1df6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcap-ng-python3-0.9.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_libcap-ng-python3;unpack=0"
SRC_URI[x86_64_v2_libcap-ng-python3.sha256sum] = "a550a35620a24f04403fb5cdfe6ac8e531f2e98b02b629ab42cc03a61c4e929d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcap-ng-utils-0.9.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_libcap-ng-utils;unpack=0"
SRC_URI[x86_64_v2_libcap-ng-utils.sha256sum] = "736634911c7a5a8d200981edc7e5c487c5428b04a8ddb11d8012053cb04c05f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcap-ng-0.9.3-2.el10.aarch64.rpm;name=aarch64_libcap-ng;unpack=0"
SRC_URI[aarch64_libcap-ng.sha256sum] = "b35f16eafc478a46526a6f790c54a418b4ab6812fa471f4efb62ef5db9dae484"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcap-ng-devel-0.9.3-2.el10.aarch64.rpm;name=aarch64_libcap-ng-devel;unpack=0"
SRC_URI[aarch64_libcap-ng-devel.sha256sum] = "9e02b5731842872b676d8d28b1eb8c96715c11e8307436ef2414093db96a7184"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcap-ng-python3-0.9.3-2.el10.aarch64.rpm;name=aarch64_libcap-ng-python3;unpack=0"
SRC_URI[aarch64_libcap-ng-python3.sha256sum] = "02576c2523afa33d3e196adba005d65f3ee927af67f119ccc49e02557b0512ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcap-ng-utils-0.9.3-2.el10.aarch64.rpm;name=aarch64_libcap-ng-utils;unpack=0"
SRC_URI[aarch64_libcap-ng-utils.sha256sum] = "bd70592313ceda07f2ad1a43a997b4829ef6404e0c36f0573ea0b5658000d58e"

RDEPENDS:libcap-ng = " \
 glibc \
 "
RDEPENDS:libcap-ng-devel = " \
 kernel-headers \
 libcap-ng \
 pkgconf-pkg-config \
 "
RDEPENDS:libcap-ng-python3 = " \
 glibc \
 libcap-ng \
 python3 \
 "
RDEPENDS:libcap-ng-utils = " \
 audit-libs \
 glibc \
 libbpf \
 libcap-ng \
 "
