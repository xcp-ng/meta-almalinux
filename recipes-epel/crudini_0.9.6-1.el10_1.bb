# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crudini"
PV = "0.9.6"
PR = "1.el10_1"
PACKAGES = " \
 crudini \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/crudini-0.9.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d553f1a918be10b553aa04aef285a38db5933b2cb51764d41107b35e02b58cdf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/crudini-0.9.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_crudini;unpack=0"
SRC_URI[x86_64_v2_crudini.sha256sum] = "f6c3db579afe89854022bfa48aaedcb1ab691d1a90993d7c5a7d3cb06f38ea22"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/crudini-0.9.6-1.el10_1.noarch.rpm;name=aarch64_crudini;unpack=0"
SRC_URI[aarch64_crudini.sha256sum] = "9a82ac223ea7237e04fbb60b191d8b4b8c4d69e67ab1504b49bd66033ab19d1d"

RDEPENDS:crudini = " \
 python3 \
 python3-iniparse \
 "
