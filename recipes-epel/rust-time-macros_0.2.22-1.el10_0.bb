# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-time-macros"
PV = "0.2.22"
PR = "1.el10_0"
PACKAGES = " \
 rust-time-macros+default-devel \
 rust-time-macros+formatting-devel \
 rust-time-macros+large-dates-devel \
 rust-time-macros+parsing-devel \
 rust-time-macros+serde-devel \
 rust-time-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-time-macros-0.2.22-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7ae472f38d71cd9a83186fed4039fbb75e677d35fb637f1f86fb311c4a8861e"

URI_x86_64_v2_rust-time-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+default-devel-0.2.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+default-devel}"
SRC_URI[x86_64_v2_rust-time-macros+default-devel.sha256sum] = "17f76797f223e4e2ff3c85b7b46a84e1b4f99f7f23428a02434d0459d8ed9268"

URI_x86_64_v2_rust-time-macros+formatting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+formatting-devel-0.2.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+formatting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+formatting-devel}"
SRC_URI[x86_64_v2_rust-time-macros+formatting-devel.sha256sum] = "ae4cdac7f6e2175461dc39e3e0d244e9723664b7c95f5bbf56e94fbc56ddb687"

URI_x86_64_v2_rust-time-macros+large-dates-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+large-dates-devel-0.2.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+large-dates-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+large-dates-devel}"
SRC_URI[x86_64_v2_rust-time-macros+large-dates-devel.sha256sum] = "82db65618b3839972dcf7d25b93d25791336152dc092f9dead64f7dc8e99f168"

URI_x86_64_v2_rust-time-macros+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+parsing-devel-0.2.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+parsing-devel}"
SRC_URI[x86_64_v2_rust-time-macros+parsing-devel.sha256sum] = "715d04baad8c6423f8d1fd8ab76caf2773c99c0c5106d2db8cfc7b32f6236ee4"

URI_x86_64_v2_rust-time-macros+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+serde-devel-0.2.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+serde-devel}"
SRC_URI[x86_64_v2_rust-time-macros+serde-devel.sha256sum] = "f777165ba42729a8e64990b33ccf58f94e50c895bfe16711c9dc4e39334940d8"

URI_x86_64_v2_rust-time-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros-devel-0.2.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros-devel}"
SRC_URI[x86_64_v2_rust-time-macros-devel.sha256sum] = "658f55aff04d0d7c1f649b56833556cee1ec88ddf22f0dab7e49d4a4328fd4e4"

URI_aarch64_rust-time-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+default-devel-0.2.22-1.el10_0.noarch.rpm;name=aarch64_rust-time-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+default-devel}"
SRC_URI[aarch64_rust-time-macros+default-devel.sha256sum] = "61909ceb3318ecf1c8fb897d6b472ebeb17f09a75aeb5bdf996052ed73b36d7d"

URI_aarch64_rust-time-macros+formatting-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+formatting-devel-0.2.22-1.el10_0.noarch.rpm;name=aarch64_rust-time-macros+formatting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+formatting-devel}"
SRC_URI[aarch64_rust-time-macros+formatting-devel.sha256sum] = "4c314a1231d7829cf3b92283466dca934ef88905e110c6cac9c517848ff4f364"

URI_aarch64_rust-time-macros+large-dates-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+large-dates-devel-0.2.22-1.el10_0.noarch.rpm;name=aarch64_rust-time-macros+large-dates-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+large-dates-devel}"
SRC_URI[aarch64_rust-time-macros+large-dates-devel.sha256sum] = "fc2b5ef3c4445751fcf7c546d4ad885b1f1c2d05082b93128407a138cf7d7c04"

URI_aarch64_rust-time-macros+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+parsing-devel-0.2.22-1.el10_0.noarch.rpm;name=aarch64_rust-time-macros+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+parsing-devel}"
SRC_URI[aarch64_rust-time-macros+parsing-devel.sha256sum] = "e6dd7b06c4cbd00c3107dbd2fb4269c3f016807d7f17bb1466f161f0fb3d0d1a"

URI_aarch64_rust-time-macros+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+serde-devel-0.2.22-1.el10_0.noarch.rpm;name=aarch64_rust-time-macros+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+serde-devel}"
SRC_URI[aarch64_rust-time-macros+serde-devel.sha256sum] = "9e8a40bfef54d4eae85eb45c32106bbd55fd6032a489fa11e71bdfc00deff38c"

URI_aarch64_rust-time-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros-devel-0.2.22-1.el10_0.noarch.rpm;name=aarch64_rust-time-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros-devel}"
SRC_URI[aarch64_rust-time-macros-devel.sha256sum] = "8a3910924a8614c52cfa53273779a7a6e2537e046f5b570506e2e157a7523498"

RDEPENDS:rust-time-macros+default-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros+formatting-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros+large-dates-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros+parsing-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros+serde-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros-devel = " \
 cargo \
 rust \
 rust-num-conv+default-devel \
 rust-time-core+default-devel \
 "
