# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scalapack"
PV = "2.2.2"
PR = "3.el10_0"
PACKAGES = " \
 scalapack-common \
 scalapack-mpich \
 scalapack-mpich-devel \
 scalapack-mpich-static \
 scalapack-openmpi \
 scalapack-openmpi-devel \
 scalapack-openmpi-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scalapack-2.2.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e54018963d04928943369ec63d49524631ff29006a5b6d91a336aeb649e624a"

URI_x86_64_v2_scalapack-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-common-2.2.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-common}"
SRC_URI[x86_64_v2_scalapack-common.sha256sum] = "a7883d6f9949914fe999150825cae7c8ed7758fea07636091a4271ce8e58d650"

URI_x86_64_v2_scalapack-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-mpich-2.2.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-mpich}"
SRC_URI[x86_64_v2_scalapack-mpich.sha256sum] = "e879f77e794601d0b2d2f6c9b3803838eaf6d72235bd3bc5840058bbde322c80"

URI_x86_64_v2_scalapack-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-mpich-devel-2.2.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-mpich-devel}"
SRC_URI[x86_64_v2_scalapack-mpich-devel.sha256sum] = "a0c732f5d72e7a3fda4223174994291a7b4628c0f81d2e61238db911dded43c6"

URI_x86_64_v2_scalapack-mpich-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-mpich-static-2.2.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-mpich-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-mpich-static}"
SRC_URI[x86_64_v2_scalapack-mpich-static.sha256sum] = "14a864be74caff700d65a513890e99601a6342a67e81204a969bc2fc1116cd9c"

URI_x86_64_v2_scalapack-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-openmpi-2.2.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-openmpi}"
SRC_URI[x86_64_v2_scalapack-openmpi.sha256sum] = "d57e3f48d8604418d99c88b6703e2be7a7aac8616d3051c52810b0d644a7e100"

URI_x86_64_v2_scalapack-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-openmpi-devel-2.2.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-openmpi-devel}"
SRC_URI[x86_64_v2_scalapack-openmpi-devel.sha256sum] = "977e6e37c5cd96bf9a84d46d99e8e38070848f3b4ad3c857b3d7ce3510341b2a"

URI_x86_64_v2_scalapack-openmpi-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-openmpi-static-2.2.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-openmpi-static}"
SRC_URI[x86_64_v2_scalapack-openmpi-static.sha256sum] = "249276e0b138c6f810989f358aa2be206807c2f1ea6e5af2de1f676e8b0a7125"

URI_aarch64_scalapack-common = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-common-2.2.2-3.el10_0.aarch64.rpm;name=aarch64_scalapack-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-common}"
SRC_URI[aarch64_scalapack-common.sha256sum] = "c159138915dea6832ddf6ec63d306a11b803f123c1605080642b12761c808a12"

URI_aarch64_scalapack-mpich = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-mpich-2.2.2-3.el10_0.aarch64.rpm;name=aarch64_scalapack-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-mpich}"
SRC_URI[aarch64_scalapack-mpich.sha256sum] = "c137ceae32cf4fb1817413488c30e60dad509bfc1f026fe76722806bc2962672"

URI_aarch64_scalapack-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-mpich-devel-2.2.2-3.el10_0.aarch64.rpm;name=aarch64_scalapack-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-mpich-devel}"
SRC_URI[aarch64_scalapack-mpich-devel.sha256sum] = "7ac3661ff4fa54be6a1bbc71fae09772879ebac8a323ca885bea0cae0f73aacb"

URI_aarch64_scalapack-mpich-static = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-mpich-static-2.2.2-3.el10_0.aarch64.rpm;name=aarch64_scalapack-mpich-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-mpich-static}"
SRC_URI[aarch64_scalapack-mpich-static.sha256sum] = "943b39e0779b926736cfb9238a093ec985d2423b1a766c5d896590a42cbf64df"

URI_aarch64_scalapack-openmpi = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-openmpi-2.2.2-3.el10_0.aarch64.rpm;name=aarch64_scalapack-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-openmpi}"
SRC_URI[aarch64_scalapack-openmpi.sha256sum] = "211f086ae1b737ff0cd84b075af44cf1a873bbf8178c9c62d093865f6b5cd037"

URI_aarch64_scalapack-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-openmpi-devel-2.2.2-3.el10_0.aarch64.rpm;name=aarch64_scalapack-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-openmpi-devel}"
SRC_URI[aarch64_scalapack-openmpi-devel.sha256sum] = "e5487d8511579d683c6503b4b05fb944cf6f0cd39da0970d88a2452454d2e0e6"

URI_aarch64_scalapack-openmpi-static = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-openmpi-static-2.2.2-3.el10_0.aarch64.rpm;name=aarch64_scalapack-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-openmpi-static}"
SRC_URI[aarch64_scalapack-openmpi-static.sha256sum] = "acc97aa891a404924cae7145865b9d6c227f0bb57df15b86bcbc706f4f6d0118"

RDEPENDS:scalapack-common = " \
 cmake-filesystem \
 "
RDEPENDS:scalapack-mpich = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 mpich \
 scalapack-common \
 "
RDEPENDS:scalapack-mpich-devel = " \
 mpich-devel \
 scalapack-mpich \
 "
RDEPENDS:scalapack-mpich-static = " \
 scalapack-mpich-devel \
 "
RDEPENDS:scalapack-openmpi = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 openmpi \
 scalapack-common \
 "
RDEPENDS:scalapack-openmpi-devel = " \
 openmpi-devel \
 scalapack-openmpi \
 "
RDEPENDS:scalapack-openmpi-static = " \
 scalapack-openmpi-devel \
 "
