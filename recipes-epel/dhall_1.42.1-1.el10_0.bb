# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dhall"
PV = "1.42.1"
PR = "1.el10_0"
PACKAGES = " \
 dhall \
 dhall-common \
 ghc-dhall \
 ghc-dhall-devel \
 ghc-dhall-doc \
 ghc-dhall-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dhall-1.42.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0de73afa1416a4f1e3018208e230c452cee57c44056effeb4fb32f98a000f432"

URI_x86_64_v2_dhall = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dhall-1.42.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dhall;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dhall}"
SRC_URI[x86_64_v2_dhall.sha256sum] = "eb1ed491ca6e004e2e7c548db62ab86523fd9e241e23b9af0945ce68da52d18c"

URI_x86_64_v2_dhall-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dhall-common-1.42.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dhall-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dhall-common}"
SRC_URI[x86_64_v2_dhall-common.sha256sum] = "771e5e072f5a765b59eb836a0934b5244d36674f006461ee75af2b1b1a750848"

URI_x86_64_v2_ghc-dhall = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dhall-1.42.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dhall;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dhall}"
SRC_URI[x86_64_v2_ghc-dhall.sha256sum] = "9c0f74821f8eb814b74b45ed245b9a32bed6e5d39d520da290bbe74addb8aa0e"

URI_x86_64_v2_ghc-dhall-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dhall-devel-1.42.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dhall-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dhall-devel}"
SRC_URI[x86_64_v2_ghc-dhall-devel.sha256sum] = "d0cce6dc072718b2183c9907346217d203d207d675de253eacb4fd5798843089"

URI_x86_64_v2_ghc-dhall-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dhall-doc-1.42.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-dhall-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dhall-doc}"
SRC_URI[x86_64_v2_ghc-dhall-doc.sha256sum] = "ede4c6d63448a0a78a59ecc4b68aeb82e333e9bbce49d2ab143df30c733878a0"

URI_x86_64_v2_ghc-dhall-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dhall-prof-1.42.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dhall-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dhall-prof}"
SRC_URI[x86_64_v2_ghc-dhall-prof.sha256sum] = "306134c067355bfca84fc1ceae2fbd5768bda3d1306fc88c4ddaca7ac269f8b8"

URI_aarch64_dhall = "${EPEL_MIRROR}/aarch64/Packages/d/dhall-1.42.1-1.el10_0.aarch64.rpm;name=aarch64_dhall;unpack=0"
SRC_URI:append = " ${URI_aarch64_dhall}"
SRC_URI[aarch64_dhall.sha256sum] = "1ac295017253ae4a80ec43f521de6d2dc57513e9272752d335958a86099913de"

URI_aarch64_dhall-common = "${EPEL_MIRROR}/aarch64/Packages/d/dhall-common-1.42.1-1.el10_0.noarch.rpm;name=aarch64_dhall-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_dhall-common}"
SRC_URI[aarch64_dhall-common.sha256sum] = "22ae4132b363b28b0a7be23ee482c390ca07c81269f58bfebddc1a6602f52a69"

URI_aarch64_ghc-dhall = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dhall-1.42.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-dhall;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dhall}"
SRC_URI[aarch64_ghc-dhall.sha256sum] = "9b18959bffae5c11fef64716c6493d83a2f0187a1550725abc90ba0861a65517"

URI_aarch64_ghc-dhall-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dhall-devel-1.42.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-dhall-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dhall-devel}"
SRC_URI[aarch64_ghc-dhall-devel.sha256sum] = "046836481b5bd98f9a3a7ffa4a0b362e2c16d878a68b7473b667343626ceb39a"

URI_aarch64_ghc-dhall-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dhall-doc-1.42.1-1.el10_0.noarch.rpm;name=aarch64_ghc-dhall-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dhall-doc}"
SRC_URI[aarch64_ghc-dhall-doc.sha256sum] = "71207bf984c3b3763f163a90e1bf4404697ccaeb2b5ee813af9c38452390bc69"

URI_aarch64_ghc-dhall-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dhall-prof-1.42.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-dhall-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dhall-prof}"
SRC_URI[aarch64_ghc-dhall-prof.sha256sum] = "bd060d3be42e47bc5345bb499956791c3ce9018afe814f004d003245827eff1e"

RDEPENDS:dhall = " \
 dhall-common \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:dhall-common = " \
 "
RDEPENDS:ghc-dhall = " \
 dhall-common \
 ghc-Diff \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-aeson-pretty \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-atomic-write \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base16-bytestring \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-blaze-builder \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cborg \
 ghc-cborg-json \
 ghc-cereal \
 ghc-charset \
 ghc-colour \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-cryptohash-sha256 \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-dotgen \
 ghc-either \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-half \
 ghc-hashable \
 ghc-haskeline \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-lens-family-core \
 ghc-megaparsec \
 ghc-memory \
 ghc-mime-types \
 ghc-mmorph \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-optparse-applicative \
 ghc-os-string \
 ghc-parsec \
 ghc-parser-combinators \
 ghc-parsers \
 ghc-pem \
 ghc-pretty \
 ghc-pretty-simple \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-primitive \
 ghc-process \
 ghc-profunctors \
 ghc-random \
 ghc-repline \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-serialise \
 ghc-socks \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-temporary \
 ghc-terminfo \
 ghc-text \
 ghc-text-manipulate \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 glibc \
 gmp \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:ghc-dhall-devel = " \
 ghc-Diff-devel \
 ghc-aeson-devel \
 ghc-aeson-pretty-devel \
 ghc-ansi-terminal-devel \
 ghc-atomic-write-devel \
 ghc-base-devel \
 ghc-base16-bytestring-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-cborg-devel \
 ghc-cborg-json-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-contravariant-devel \
 ghc-cryptohash-sha256-devel \
 ghc-data-fix-devel \
 ghc-deepseq-devel \
 ghc-dhall \
 ghc-directory-devel \
 ghc-dotgen-devel \
 ghc-either-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-half-devel \
 ghc-hashable-devel \
 ghc-haskeline-devel \
 ghc-http-client-devel \
 ghc-http-client-tls-devel \
 ghc-http-types-devel \
 ghc-indexed-traversable-devel \
 ghc-lens-family-core-devel \
 ghc-megaparsec-devel \
 ghc-mmorph-devel \
 ghc-mtl-devel \
 ghc-network-uri-devel \
 ghc-optparse-applicative-devel \
 ghc-parser-combinators-devel \
 ghc-parsers-devel \
 ghc-pretty-simple-devel \
 ghc-prettyprinter-ansi-terminal-devel \
 ghc-prettyprinter-devel \
 ghc-profunctors-devel \
 ghc-repline-devel \
 ghc-scientific-devel \
 ghc-serialise-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-text-manipulate-devel \
 ghc-text-short-devel \
 ghc-th-lift-instances-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unix-compat-devel \
 ghc-unix-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-dhall-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-dhall-prof = " \
 ghc-Diff-prof \
 ghc-aeson-pretty-prof \
 ghc-aeson-prof \
 ghc-ansi-terminal-prof \
 ghc-atomic-write-prof \
 ghc-base-prof \
 ghc-base16-bytestring-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-cborg-json-prof \
 ghc-cborg-prof \
 ghc-containers-prof \
 ghc-contravariant-prof \
 ghc-cryptohash-sha256-prof \
 ghc-data-fix-prof \
 ghc-deepseq-prof \
 ghc-dhall-devel \
 ghc-directory-prof \
 ghc-dotgen-prof \
 ghc-either-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-half-prof \
 ghc-hashable-prof \
 ghc-haskeline-prof \
 ghc-http-client-prof \
 ghc-http-client-tls-prof \
 ghc-http-types-prof \
 ghc-indexed-traversable-prof \
 ghc-lens-family-core-prof \
 ghc-megaparsec-prof \
 ghc-mmorph-prof \
 ghc-mtl-prof \
 ghc-network-uri-prof \
 ghc-optparse-applicative-prof \
 ghc-parser-combinators-prof \
 ghc-parsers-prof \
 ghc-pretty-simple-prof \
 ghc-prettyprinter-ansi-terminal-prof \
 ghc-prettyprinter-prof \
 ghc-profunctors-prof \
 ghc-repline-prof \
 ghc-scientific-prof \
 ghc-serialise-prof \
 ghc-template-haskell-prof \
 ghc-text-manipulate-prof \
 ghc-text-prof \
 ghc-text-short-prof \
 ghc-th-lift-instances-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unix-compat-prof \
 ghc-unix-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
