# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-latest-openjdk"
PE = "1"
PV = "27.0.0.0.35"
PR = "0.0.1.0.ea.el10_2"
PACKAGES = " \
 java-latest-openjdk \
 java-latest-openjdk-crypto-adapter \
 java-latest-openjdk-crypto-adapter-fastdebug \
 java-latest-openjdk-crypto-adapter-slowdebug \
 java-latest-openjdk-demo \
 java-latest-openjdk-demo-fastdebug \
 java-latest-openjdk-demo-slowdebug \
 java-latest-openjdk-devel \
 java-latest-openjdk-devel-fastdebug \
 java-latest-openjdk-devel-slowdebug \
 java-latest-openjdk-fastdebug \
 java-latest-openjdk-headless \
 java-latest-openjdk-headless-fastdebug \
 java-latest-openjdk-headless-slowdebug \
 java-latest-openjdk-javadoc \
 java-latest-openjdk-javadoc-zip \
 java-latest-openjdk-jmods \
 java-latest-openjdk-jmods-fastdebug \
 java-latest-openjdk-jmods-slowdebug \
 java-latest-openjdk-slowdebug \
 java-latest-openjdk-src \
 java-latest-openjdk-src-fastdebug \
 java-latest-openjdk-src-slowdebug \
 java-latest-openjdk-static-libs \
 java-latest-openjdk-static-libs-fastdebug \
 java-latest-openjdk-static-libs-slowdebug \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/java-latest-openjdk-27.0.0.0.35-0.0.1.0.ea.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0abdc593fe423a4e409396b14139385ec2c41c451a59aefe18e5be5032592740"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk.sha256sum] = "533ead313deea5df95bb3770ae63439a400ddbc76ac6107ae410b5c65db7bb93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter.sha256sum] = "5735863e692076f0af461f395824abc992f722d2a73bc8e854c139bf848093d9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug.sha256sum] = "e2a4e5f6ac28656c0842282f43945487d22affb652e4e11f27410ddbbb860eb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug.sha256sum] = "813db006064e3c1ac7b851bed21205a6ed114388c774dda42418017419421b59"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-demo.sha256sum] = "7011c1a41e7b4a250d67614236cb95f234455d72d0de8bf1ecd6c138a0df6539"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-demo-fastdebug.sha256sum] = "c7ee62615808a6c783af6c6d4d9de862aad452c7669e6aaabc95d6ac5cc9e8d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-demo-slowdebug.sha256sum] = "1fdcfcf03c968013ce177e910c76c24e97e2b539eb45b83878e731a37f94a885"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-devel.sha256sum] = "209100e57dd38d8c912988fd52d2152b89ee51b3284a4e85ddc744cb640cbf12"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-devel-fastdebug.sha256sum] = "5dc7838d5ce5d73b3b13f5d8c6082096394891ecd2ea017b9551dc9be956f49f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-devel-slowdebug.sha256sum] = "ae126c77fc2134572fc7144e9ec997b6ca569fef7cecd0467c514fa6726ef0ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-fastdebug.sha256sum] = "8aba78c7f4277d780c96b7c065c91a06edee516cf42cef9d660d366e2e23c960"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-headless.sha256sum] = "2dd832815d2781d4dd565c602f7403ee84d58ecfa61170ee3e5dbb8726dba49c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-headless-fastdebug.sha256sum] = "e036762d107ba932a5e62f930bf362a419c83a97c6548a40622778b48aac1eda"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-headless-slowdebug.sha256sum] = "ff883daaa6a23827d5acc2ef4d5a54e725e589fe06f91db2949c315d7c270e27"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-javadoc-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-javadoc;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-javadoc.sha256sum] = "e6bf37ad526f64b3dba7a1ea2d7c1400c3a5d82cd7b50fe9a9b7e2f8212718bf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-javadoc-zip-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-javadoc-zip;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-javadoc-zip.sha256sum] = "283ef2f1330f7be39901e9803e6cafa414faebf0cbc9509ee2ac3c3273e1b1ec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods.sha256sum] = "7408afb1256ffde0d3144ccff278a691731cce59db6177a9dd2781eedbcf534f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods-fastdebug.sha256sum] = "3417367b5534a843d6c5e541936826faa7114f9d1002dcc15e652d03d70f0624"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods-slowdebug.sha256sum] = "40769a7d4df35ea14983ea7765c17246ec2574dbb3e5f04faa4c2bc5aff08bcd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-slowdebug.sha256sum] = "a2f959bc5efba50f65e221e83633102f7fd2402a14ea9839e3767033f251d24a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-src.sha256sum] = "0beba474de5406536adb1f165b166a64d7b91e658194aa08e64193c42aace23b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-src-fastdebug.sha256sum] = "c0c9b4a00993d38591a63630b68db95f69c760f5bc6482704fbccaf65a1f2f26"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-src-slowdebug.sha256sum] = "309a9b77d86329883c854554264e9c3e6082090467c552e446e9bd269f2b4dde"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs.sha256sum] = "fc72c1cfc4f4d860dce93b5d04e3a544ec17e3f92f06a7f2c98de1d42da619ab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs-fastdebug.sha256sum] = "87b58eddef9fce1299717262817b13744cf3c3cca6a81559a2d9509eb78e29f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs-slowdebug.sha256sum] = "43e505835feb5dd84d50cb797dbddbf5dfab8272037f91dfd4990bddcb922494"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk;unpack=0"
SRC_URI[aarch64_java-latest-openjdk.sha256sum] = "a2b18ed80ecebdf30dc0b0c5a06cfb2c87e05eed18e470b543fc55a304fa4101"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter.sha256sum] = "abbd70696172ba0624bea11b640535123e74709adcc7e0dfb6e1d3b28d556934"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter-fastdebug.sha256sum] = "5403a6c92c6469fc40cb5b3240e8774411bc21d9e0fd40facc76e57f642f0d4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter-slowdebug.sha256sum] = "d5cd75d3f5825ae6a557a2718b5c407751d7f93790499b9d187a55747e554578"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-demo;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-demo.sha256sum] = "8a46dc11c16771951c01cda0d2705ff5c114dcdcce8d91ad9ec2e95dcbc6ca02"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-demo-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-demo-fastdebug.sha256sum] = "4ffda3671a877e6f4c116f18ecdf9166c92eb8621d5fc70c4488911394d0d068"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-demo-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-demo-slowdebug.sha256sum] = "fbe378dcc330d627cc3a068634423492863b902b37069217d81308cc8b2ce44a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-devel;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-devel.sha256sum] = "3ab94e634520ebddb779cba5fc2f134d6f644c83d266ba9a47d0e6fc60c80974"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-devel-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-devel-fastdebug.sha256sum] = "0eff2cb5a9e8fef7a453a95f95080116bc0038c77614f9fa9ef826c235efe5d6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-devel-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-devel-slowdebug.sha256sum] = "b6cc4be8318d24782cc3f9077840e74c5d0beadd357b9c87fb2297cb58628186"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-fastdebug.sha256sum] = "4c89a9fef1541de0517b32d1c8470d93e250ccb0e829cfba2454aeba92712c63"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-headless;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-headless.sha256sum] = "3aacfe0fb6811dd7068fa5c69d378b28686814c95b7c5b47073a618c623bac4e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-headless-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-headless-fastdebug.sha256sum] = "7a4c861e439673db0aa3e361ffe0caf7c0629ec60ebaf7bf1d780df7c788f24f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-headless-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-headless-slowdebug.sha256sum] = "03617a4376dffd2394de64235b5f192dc51553d0e50e5ab44c409dbf2a83c22f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-javadoc-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-javadoc;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-javadoc.sha256sum] = "b3d633f5a6ae8092d806c10541961fa41beff11959be374caeb52b793aa76270"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-javadoc-zip-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-javadoc-zip;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-javadoc-zip.sha256sum] = "5baf658248955c456db2b94f360fc20b65dc212fd0ab50f56390220d218788ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-jmods.sha256sum] = "9295c5f0cafea526e50e124ba3d0d62108b2dded2b372139922204a51093d7c7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-jmods-fastdebug.sha256sum] = "486ad1dbc9273f0c826691eb67346efd9e9c5bbe85e5b471e1dcfffc13b57fce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-jmods-slowdebug.sha256sum] = "8c56842077539bde77b84acc3febe79d1d1d8bbd5b13213c82ed7fc8158b1270"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-slowdebug.sha256sum] = "3789d7ec9cd68205a9edf488b5eb19bf83b9c0aa08e780db6905aeaef3e997e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-src;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-src.sha256sum] = "99b2ca27cff5e1fac0420e95899b362d07792da8435dfda4dd5aeead006b042e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-src-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-src-fastdebug.sha256sum] = "bbacea11781f40773e27b383a4748be49412d7ca82af8f6d788e2bec2d059851"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-src-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-src-slowdebug.sha256sum] = "356f26a5c48ac03f2476f6c2585e047fff91a1d6fd7b66298e46cefe10b57a86"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-static-libs.sha256sum] = "707a5687021687de93362bbf492e972e084316ffe532259f0bf1ff63aacca63e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-static-libs-fastdebug.sha256sum] = "29800c17d0fac1448e07fca1ab5b72672e133682171542c559608a04dd305455"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-static-libs-slowdebug.sha256sum] = "eade12495e8ae08aa68eb0218ef3f84872e305e83d2655d648d9dfd02b545591"

RDEPENDS:java-latest-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter-fastdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter-slowdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-demo = " \
 java-latest-openjdk \
 "
RDEPENDS:java-latest-openjdk-demo-fastdebug = " \
 java-latest-openjdk-fastdebug \
 "
RDEPENDS:java-latest-openjdk-demo-slowdebug = " \
 java-latest-openjdk-slowdebug \
 "
RDEPENDS:java-latest-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk \
 "
RDEPENDS:java-latest-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk-fastdebug \
 "
RDEPENDS:java-latest-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk-slowdebug \
 "
RDEPENDS:java-latest-openjdk-fastdebug = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless-fastdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-headless-fastdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter-fastdebug \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-headless-slowdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter-slowdebug \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-javadoc = " \
 alternatives \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:java-latest-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:java-latest-openjdk-jmods = " \
 java-latest-openjdk-devel \
 "
RDEPENDS:java-latest-openjdk-jmods-fastdebug = " \
 java-latest-openjdk-devel-fastdebug \
 "
RDEPENDS:java-latest-openjdk-jmods-slowdebug = " \
 java-latest-openjdk-devel-slowdebug \
 "
RDEPENDS:java-latest-openjdk-slowdebug = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless-slowdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-src = " \
 java-latest-openjdk-headless \
 "
RDEPENDS:java-latest-openjdk-src-fastdebug = " \
 java-latest-openjdk-headless-fastdebug \
 "
RDEPENDS:java-latest-openjdk-src-slowdebug = " \
 java-latest-openjdk-headless-slowdebug \
 "
RDEPENDS:java-latest-openjdk-static-libs = " \
 java-latest-openjdk-devel \
 "
RDEPENDS:java-latest-openjdk-static-libs-fastdebug = " \
 java-latest-openjdk-devel-fastdebug \
 "
RDEPENDS:java-latest-openjdk-static-libs-slowdebug = " \
 java-latest-openjdk-devel-slowdebug \
 "
