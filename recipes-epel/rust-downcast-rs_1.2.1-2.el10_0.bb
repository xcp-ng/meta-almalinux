# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-downcast-rs"
PV = "1.2.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-downcast-rs+default-devel \
 rust-downcast-rs+std-devel \
 rust-downcast-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-downcast-rs-1.2.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03992186ef82bd8aa6cb08c9ad123ca90b8a60dc292a47502231f76eb6f93ba2"

URI_x86_64_v2_rust-downcast-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-downcast-rs+default-devel-1.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-downcast-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-downcast-rs+default-devel}"
SRC_URI[x86_64_v2_rust-downcast-rs+default-devel.sha256sum] = "7b9566ff4d0a008dec095664b95fab09f8b187dca405509ca66f676d2fb64d9a"

URI_x86_64_v2_rust-downcast-rs+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-downcast-rs+std-devel-1.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-downcast-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-downcast-rs+std-devel}"
SRC_URI[x86_64_v2_rust-downcast-rs+std-devel.sha256sum] = "d959dca608dd161985dd72bf1af385039c85f3d327dd951d7bd5153f1a3b4fff"

URI_x86_64_v2_rust-downcast-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-downcast-rs-devel-1.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-downcast-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-downcast-rs-devel}"
SRC_URI[x86_64_v2_rust-downcast-rs-devel.sha256sum] = "4b4f5bf16ad3c8d667cc70b6f582b034b123e0ecf047ba958cb113ce6c25c7e4"

URI_aarch64_rust-downcast-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-downcast-rs+default-devel-1.2.1-2.el10_0.noarch.rpm;name=aarch64_rust-downcast-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-downcast-rs+default-devel}"
SRC_URI[aarch64_rust-downcast-rs+default-devel.sha256sum] = "059080341d911be74b9755cb7beba55295f6240307ed261adf131bd073fa9f56"

URI_aarch64_rust-downcast-rs+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-downcast-rs+std-devel-1.2.1-2.el10_0.noarch.rpm;name=aarch64_rust-downcast-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-downcast-rs+std-devel}"
SRC_URI[aarch64_rust-downcast-rs+std-devel.sha256sum] = "2ca9e3e93ce0b00f14280ce8f379458da8807baec18a099dbc09a2fcccdedc66"

URI_aarch64_rust-downcast-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-downcast-rs-devel-1.2.1-2.el10_0.noarch.rpm;name=aarch64_rust-downcast-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-downcast-rs-devel}"
SRC_URI[aarch64_rust-downcast-rs-devel.sha256sum] = "87f28a04129473b864ea1cdadcfd97ca389380227c6a5eea99c6744d0fc3b47b"

RDEPENDS:rust-downcast-rs+default-devel = " \
 cargo \
 rust-downcast-rs+std-devel \
 rust-downcast-rs-devel \
 "
RDEPENDS:rust-downcast-rs+std-devel = " \
 cargo \
 rust-downcast-rs-devel \
 "
RDEPENDS:rust-downcast-rs-devel = " \
 cargo \
 "
