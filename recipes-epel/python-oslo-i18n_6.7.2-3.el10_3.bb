# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslo-i18n"
PV = "6.7.2"
PR = "3.el10_3"
PACKAGES = " \
 python-oslo-i18n-doc \
 python-oslo-i18n-lang \
 python3-oslo-i18n \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-oslo-i18n-6.7.2-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49b6f33bbf239ce968471ce55260be41963ab87e6b028ee957edcccb5bd9341b"

URI_x86_64_v2_python-oslo-i18n-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-i18n-doc-6.7.2-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-i18n-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-i18n-doc}"
SRC_URI[x86_64_v2_python-oslo-i18n-doc.sha256sum] = "bede9bdcc89ae92ac8b21b1be9d9c927a25288a6f3bfd532bb94ce7e26f01c81"

URI_x86_64_v2_python-oslo-i18n-lang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-i18n-lang-6.7.2-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-i18n-lang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-i18n-lang}"
SRC_URI[x86_64_v2_python-oslo-i18n-lang.sha256sum] = "7cd20258e165eead385518d32ea6a1dd2367237e306a5048a7a3247fde4f82b9"

URI_x86_64_v2_python3-oslo-i18n = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-i18n-6.7.2-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-i18n}"
SRC_URI[x86_64_v2_python3-oslo-i18n.sha256sum] = "18cb8393189042f54367eab7a9573ec79db3b786cfbb9137dd8f443fa318b45f"

URI_aarch64_python-oslo-i18n-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-i18n-doc-6.7.2-3.el10_3.noarch.rpm;name=aarch64_python-oslo-i18n-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-i18n-doc}"
SRC_URI[aarch64_python-oslo-i18n-doc.sha256sum] = "3fe6d02705461b6c6a5c714599eeb91415e286daa617ed57c3b872867276a6c3"

URI_aarch64_python-oslo-i18n-lang = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-i18n-lang-6.7.2-3.el10_3.noarch.rpm;name=aarch64_python-oslo-i18n-lang;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-i18n-lang}"
SRC_URI[aarch64_python-oslo-i18n-lang.sha256sum] = "a7de1fd804aa45a24c21b0b4063746c026a1fa2999696805fcc044b5868e1bb1"

URI_aarch64_python3-oslo-i18n = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-i18n-6.7.2-3.el10_3.noarch.rpm;name=aarch64_python3-oslo-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-i18n}"
SRC_URI[aarch64_python3-oslo-i18n.sha256sum] = "eee854838f030e77e783b1d8b509820874b0ea6a3608868c52d32980923f7cf8"

RDEPENDS:python-oslo-i18n-doc = " \
 "
RDEPENDS:python-oslo-i18n-lang = " \
 "
RDEPENDS:python3-oslo-i18n = " \
 python-oslo-i18n-lang \
 python3 \
 python3-pbr \
 "
