# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Mixin-Linewise"
PV = "0.111"
PR = "1.el10_0"
PACKAGES = " \
 perl-Mixin-Linewise \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Mixin-Linewise-0.111-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74f8e31dbdd18bc708ccb2a11d4e3c7d8f4f5dd7c2a5f9eea1c370827e463d76"

URI_x86_64_v2_perl-Mixin-Linewise = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Mixin-Linewise-0.111-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Mixin-Linewise;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Mixin-Linewise}"
SRC_URI[x86_64_v2_perl-Mixin-Linewise.sha256sum] = "d5ecdf7ca95a1d06600ffaa8f6de14b0fd5050ab6b96f4d6bf79fecfd43c7796"

URI_aarch64_perl-Mixin-Linewise = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Mixin-Linewise-0.111-1.el10_0.noarch.rpm;name=aarch64_perl-Mixin-Linewise;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Mixin-Linewise}"
SRC_URI[aarch64_perl-Mixin-Linewise.sha256sum] = "d238e9ba236739dfa2fdc7932018d8fedd5ff392a5bfa543b3c0692099b09a1c"

RDEPENDS:perl-Mixin-Linewise = " \
 perl-Carp \
 perl-IO \
 perl-PerlIO-utf8_strict \
 perl-Sub-Exporter \
 perl-libs \
 "
