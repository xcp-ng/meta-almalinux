# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cscppc"
PV = "2.2.8"
PR = "1.el10_3"
PACKAGES = " \
 csclng \
 cscppc \
 csgcca \
 csmatch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cscppc-2.2.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8dff4da35827985515a274a12646806910a2dd8b4e66cbc4e489ca2237611390"

URI_x86_64_v2_csclng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csclng-2.2.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csclng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csclng}"
SRC_URI[x86_64_v2_csclng.sha256sum] = "b7eb8152ccb0fd298e484c79211c094d8876f66fd60f68771e148b56c8968560"

URI_x86_64_v2_cscppc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cscppc-2.2.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cscppc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cscppc}"
SRC_URI[x86_64_v2_cscppc.sha256sum] = "a49b8a25c157b99ba54e57bc2594319d0c1503dc2f673078e670748f45cdc81e"

URI_x86_64_v2_csgcca = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csgcca-2.2.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csgcca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csgcca}"
SRC_URI[x86_64_v2_csgcca.sha256sum] = "deeb477e038e8e22b3c3bd9224f341fe01a78cf74eb55bd74aebb80a780ff311"

URI_x86_64_v2_csmatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmatch-2.2.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csmatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmatch}"
SRC_URI[x86_64_v2_csmatch.sha256sum] = "2333b5e7157e8923e99047cc2b05c840fc78fe97962e4438e5c3da44ba4c2b74"

URI_aarch64_csclng = "${EPEL_MIRROR}/aarch64/Packages/c/csclng-2.2.8-1.el10_3.aarch64.rpm;name=aarch64_csclng;unpack=0"
SRC_URI:append = " ${URI_aarch64_csclng}"
SRC_URI[aarch64_csclng.sha256sum] = "a60c14fdcee1ca702efc1eee172e215377baaae64e1b03403856606d14c03ca5"

URI_aarch64_cscppc = "${EPEL_MIRROR}/aarch64/Packages/c/cscppc-2.2.8-1.el10_3.aarch64.rpm;name=aarch64_cscppc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cscppc}"
SRC_URI[aarch64_cscppc.sha256sum] = "e3b9b6f42a8327e525efeca09cb70785475890e348cdc3c819cf2111d6f6c361"

URI_aarch64_csgcca = "${EPEL_MIRROR}/aarch64/Packages/c/csgcca-2.2.8-1.el10_3.aarch64.rpm;name=aarch64_csgcca;unpack=0"
SRC_URI:append = " ${URI_aarch64_csgcca}"
SRC_URI[aarch64_csgcca.sha256sum] = "3caae931a5f1ee962711bb76e4a84200e6f9e6c002638dd158a667fee7b4d046"

URI_aarch64_csmatch = "${EPEL_MIRROR}/aarch64/Packages/c/csmatch-2.2.8-1.el10_3.aarch64.rpm;name=aarch64_csmatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmatch}"
SRC_URI[aarch64_csmatch.sha256sum] = "f5542e8665e9dab22b36c421d0e3ec36d6f0793c27740bc6685f1a66e6596a5a"

RDEPENDS:csclng = " \
 clang \
 glibc \
 "
RDEPENDS:cscppc = " \
 glibc \
 "
RDEPENDS:csgcca = " \
 gcc \
 glibc \
 "
RDEPENDS:csmatch = " \
 glibc \
 "
