# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-utils"
PV = "0.8.21"
PR = "1.el10_0"
PACKAGES = " \
 rust-crossbeam-utils+default-devel \
 rust-crossbeam-utils+nightly-devel \
 rust-crossbeam-utils+std-devel \
 rust-crossbeam-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-utils-0.8.21-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa0271240a3f804aac648570991af79c0db315783e74129d1cf8f5561aff8a56"

URI_x86_64_v2_rust-crossbeam-utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+default-devel-0.8.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-utils+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-utils+default-devel.sha256sum] = "fda321c1d60e68e7c8ca12295dbd450b5c7e722b101e732365af759cac7c52cf"

URI_x86_64_v2_rust-crossbeam-utils+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+nightly-devel-0.8.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-utils+nightly-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-utils+nightly-devel.sha256sum] = "8566e76078ee3f3ef40b79b761b31d9543b579c4a39b866207e6c4e0fd6ed0c6"

URI_x86_64_v2_rust-crossbeam-utils+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+std-devel-0.8.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-utils+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-utils+std-devel.sha256sum] = "8cda5f19691e141bee495150f13f4a105d5208dc2079a96b7bc470289e890807"

URI_x86_64_v2_rust-crossbeam-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils-devel-0.8.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-utils-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-utils-devel.sha256sum] = "d07309c2ab12a99c9ea973422f275e05d2ba812570ebd89c60814af912227033"

URI_aarch64_rust-crossbeam-utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+default-devel-0.8.21-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-utils+default-devel}"
SRC_URI[aarch64_rust-crossbeam-utils+default-devel.sha256sum] = "769ee77e6409410fd9499c827ca1a739c343eb899e8d002530419a9405f75f5f"

URI_aarch64_rust-crossbeam-utils+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+nightly-devel-0.8.21-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-utils+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-utils+nightly-devel}"
SRC_URI[aarch64_rust-crossbeam-utils+nightly-devel.sha256sum] = "18ee7d52994d467401d550fe9c4abdd7d587e5df27d45204ed224f804fbba585"

URI_aarch64_rust-crossbeam-utils+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+std-devel-0.8.21-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-utils+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-utils+std-devel}"
SRC_URI[aarch64_rust-crossbeam-utils+std-devel.sha256sum] = "c53877ea8a02d9b70a2d33eceb7a255fc839d509d202990ad8d4e574956b7df9"

URI_aarch64_rust-crossbeam-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils-devel-0.8.21-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-utils-devel}"
SRC_URI[aarch64_rust-crossbeam-utils-devel.sha256sum] = "2c619738f56e3987bd6501f3e6d62a2c39de2811769119e168e781d8c700b50a"

RDEPENDS:rust-crossbeam-utils+default-devel = " \
 cargo \
 rust-crossbeam-utils+std-devel \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils+nightly-devel = " \
 cargo \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils+std-devel = " \
 cargo \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils-devel = " \
 cargo \
 rust \
 "
