# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perltidy"
PV = "20240511"
PR = "1.el10_0"
PACKAGES = " \
 perltidy \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perltidy-20240511-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "69fc827eb8682000ba1becbbaadeba36ebde32d41eecde59443bffc472f3cbdc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perltidy-20240511-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perltidy;unpack=0"
SRC_URI[x86_64_v2_perltidy.sha256sum] = "ebc3ba02c96758fcd232854db3bef208707c32e8be65aecfa0287fa760eee59d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perltidy-20240511-1.el10_0.noarch.rpm;name=aarch64_perltidy;unpack=0"
SRC_URI[aarch64_perltidy.sha256sum] = "d6ed1d9d27fbf9afb613c0fa38b7d096396b8854b82e34cf56882aeac80dcf5c"

RDEPENDS:perltidy = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Encode \
 perl-English \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-HTML-Parser \
 perl-IO \
 perl-PathTools \
 perl-Pod-Html \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 perltidy \
 "
