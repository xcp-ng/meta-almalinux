# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dotenv"
PV = "1.0.1"
PR = "3.el10_0"
PACKAGES = " \
 python3-dotenv \
 python3-dotenv+cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-dotenv-1.0.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66711dba2fa5a807f7cc6218b7945a1673e95034be7cd998eeea4cc2d4a690c5"

URI_x86_64_v2_python3-dotenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dotenv-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dotenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dotenv}"
SRC_URI[x86_64_v2_python3-dotenv.sha256sum] = "8e0675be6e4d1e9361dea87658b09e645d07d61b0aba302a63a09133336b6fea"

URI_x86_64_v2_python3-dotenv+cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dotenv+cli-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dotenv+cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dotenv+cli}"
SRC_URI[x86_64_v2_python3-dotenv+cli.sha256sum] = "943a8dc373124e53862700a29e1964306760bcc51228bcd88486d9779e799893"

URI_aarch64_python3-dotenv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dotenv-1.0.1-3.el10_0.noarch.rpm;name=aarch64_python3-dotenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dotenv}"
SRC_URI[aarch64_python3-dotenv.sha256sum] = "f248d05f58e38f77ed4e0a5975d469bc2dd40d95792aa37818d6d806b2f29b51"

URI_aarch64_python3-dotenv+cli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dotenv+cli-1.0.1-3.el10_0.noarch.rpm;name=aarch64_python3-dotenv+cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dotenv+cli}"
SRC_URI[aarch64_python3-dotenv+cli.sha256sum] = "44eb3930535b16e2562ac16fc8a6f6184b580b36e098f6d237caa0cf8fcc8406"

RDEPENDS:python3-dotenv = " \
 python3 \
 "
RDEPENDS:python3-dotenv+cli = " \
 python3 \
 python3-click \
 python3-dotenv \
 "
