# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ml"
PV = "0.1"
PR = "35.el10"
PACKAGES = " \
 hunspell-ml \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ml-0.1-35.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "867ddb8316570e4179548d25337eeb22ba1cbcbeca91a2afc8dcaaa5e502ee45"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ml-0.1-35.el10.noarch.rpm;name=x86_64_v2_hunspell-ml;unpack=0"
SRC_URI[x86_64_v2_hunspell-ml.sha256sum] = "e5fca9b493e029ab9a6f4dc6ab9328525e213df0d12279e84d727575e07b43e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ml-0.1-35.el10.noarch.rpm;name=aarch64_hunspell-ml;unpack=0"
SRC_URI[aarch64_hunspell-ml.sha256sum] = "e5fca9b493e029ab9a6f4dc6ab9328525e213df0d12279e84d727575e07b43e2"

RDEPENDS:hunspell-ml = " \
 hunspell-filesystem \
 "
