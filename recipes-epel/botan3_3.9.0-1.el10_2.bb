# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "botan3"
PV = "3.9.0"
PR = "1.el10_2"
PACKAGES = " \
 botan3 \
 botan3-devel \
 botan3-doc \
 python3-botan3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/botan3-3.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bf01ce2dc273411618ce2f7e8290b938825e821246046c3fa3c4d26c3fd6e48"

URI_x86_64_v2_botan3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/botan3-3.9.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_botan3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_botan3}"
SRC_URI[x86_64_v2_botan3.sha256sum] = "e4990c93745701a5e9b063e0112a4c1ebd5eb6912bb7146d0f32d7464b0524de"

URI_x86_64_v2_botan3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/botan3-devel-3.9.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_botan3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_botan3-devel}"
SRC_URI[x86_64_v2_botan3-devel.sha256sum] = "f2a259c8fc6ae9aa935347318efe6f04f9942d2bf6f5877d256248c6d6936be9"

URI_x86_64_v2_botan3-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/botan3-doc-3.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_botan3-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_botan3-doc}"
SRC_URI[x86_64_v2_botan3-doc.sha256sum] = "d121b3ba380a50ae20b35e2de8405df1b6dce6b7866d8000790fe62ac3346d01"

URI_x86_64_v2_python3-botan3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-botan3-3.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-botan3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-botan3}"
SRC_URI[x86_64_v2_python3-botan3.sha256sum] = "c65c20c1ab88a8679e0be519780032819d780b7a2a4cce067e7ed1931f36e276"

URI_aarch64_botan3 = "${EPEL_MIRROR}/aarch64/Packages/b/botan3-3.9.0-1.el10_2.aarch64.rpm;name=aarch64_botan3;unpack=0"
SRC_URI:append = " ${URI_aarch64_botan3}"
SRC_URI[aarch64_botan3.sha256sum] = "1791e4b8876ae1c02062f4d7c12af31484ca0f851bab06a67c9dac54d03d22e3"

URI_aarch64_botan3-devel = "${EPEL_MIRROR}/aarch64/Packages/b/botan3-devel-3.9.0-1.el10_2.aarch64.rpm;name=aarch64_botan3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_botan3-devel}"
SRC_URI[aarch64_botan3-devel.sha256sum] = "88578c46d41ec546473de115a1509ca98f3d8fe598c673721064a89bdbbf070f"

URI_aarch64_botan3-doc = "${EPEL_MIRROR}/aarch64/Packages/b/botan3-doc-3.9.0-1.el10_2.noarch.rpm;name=aarch64_botan3-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_botan3-doc}"
SRC_URI[aarch64_botan3-doc.sha256sum] = "6dcf38b7eff62df097a6b2e730f41c1201eb231e5d2b2b387f655266b2e7ded4"

URI_aarch64_python3-botan3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-botan3-3.9.0-1.el10_2.noarch.rpm;name=aarch64_python3-botan3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-botan3}"
SRC_URI[aarch64_python3-botan3.sha256sum] = "78ce16576c1317bdc5abd331fa4d9b164309f70de69b12cc78b07dafe99318ce"

RDEPENDS:botan3 = " \
 bzip2-libs \
 glibc \
 jitterentropy \
 libgcc \
 libstdc++ \
 sqlite-libs \
 tpm2-tss \
 zlib-ng-compat \
 "
RDEPENDS:botan3-devel = " \
 botan3 \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:botan3-doc = " \
 "
RDEPENDS:python3-botan3 = " \
 botan3 \
 python3 \
 python3-libs \
 "
