# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nftables"
PE = "1"
PV = "1.1.5"
PR = "6.el10_2"
PACKAGES = " \
 nftables \
 nftables-devel \
 python3-nftables \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nftables-1.1.5-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "513c414e1b517656420c6f92a4d4c98c6f029b5ddec40120cc1d6750923c879c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nftables-1.1.5-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_nftables;unpack=0"
SRC_URI[x86_64_v2_nftables.sha256sum] = "1047492fa7a2826f9310a1cc88121e10114323e2073878874344587ae5745e4f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nftables-devel-1.1.5-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_nftables-devel;unpack=0"
SRC_URI[x86_64_v2_nftables-devel.sha256sum] = "d400327a0ddedebf54e289e713d35e8f70da05a62f8163b374987d07b0c799fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-nftables-1.1.5-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-nftables;unpack=0"
SRC_URI[x86_64_v2_python3-nftables.sha256sum] = "143d60d63811c6291bc942172baef590f92276b9031ff74693e314992630823b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nftables-1.1.5-6.el10_2.aarch64.rpm;name=aarch64_nftables;unpack=0"
SRC_URI[aarch64_nftables.sha256sum] = "1abbd50032e2f6bd5c1f88ebb27da4d4f60fe4bd6f780f0c8399338dd043473d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nftables-devel-1.1.5-6.el10_2.aarch64.rpm;name=aarch64_nftables-devel;unpack=0"
SRC_URI[aarch64_nftables-devel.sha256sum] = "0ccc417ae1fe09d6b35a0b20c5f15cb448f72b73001003d61ef3ea27d7a16edd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-nftables-1.1.5-6.el10_2.aarch64.rpm;name=aarch64_python3-nftables;unpack=0"
SRC_URI[aarch64_python3-nftables.sha256sum] = "1ba53978e0bcf2592b7594a53b02bfba8caefdad9865e97b8be6afa5e2da2610"

RDEPENDS:nftables = " \
 bash \
 glibc \
 gmp \
 iptables-libs \
 jansson \
 libmnl \
 libnftnl \
 readline \
 "
RDEPENDS:nftables-devel = " \
 nftables \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-nftables = " \
 nftables \
 python3 \
 "
