# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rstest_reuse"
PV = "0.7.0"
PR = "4.el10_1"
PACKAGES = " \
 rust-rstest_reuse+default-devel \
 rust-rstest_reuse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rstest_reuse-0.7.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0abdca2b9415d05d9a92478614c2f3d8689800928ed503b00690ae528ea5502"

URI_x86_64_v2_rust-rstest_reuse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest_reuse+default-devel-0.7.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest_reuse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest_reuse+default-devel}"
SRC_URI[x86_64_v2_rust-rstest_reuse+default-devel.sha256sum] = "4007a3570efb8bc91becfcb80a433426a2cdb428659f578cee49e7b42d8a30b3"

URI_x86_64_v2_rust-rstest_reuse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest_reuse-devel-0.7.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest_reuse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest_reuse-devel}"
SRC_URI[x86_64_v2_rust-rstest_reuse-devel.sha256sum] = "2e336d4295b5bdef5e0cf254a49e1275ab3874613f2d8faae8e32546b2e3d4fb"

URI_aarch64_rust-rstest_reuse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest_reuse+default-devel-0.7.0-4.el10_1.noarch.rpm;name=aarch64_rust-rstest_reuse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest_reuse+default-devel}"
SRC_URI[aarch64_rust-rstest_reuse+default-devel.sha256sum] = "130b7e19af737fdc58c81c3570172766977f8345eb90ead041702345314ce01f"

URI_aarch64_rust-rstest_reuse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest_reuse-devel-0.7.0-4.el10_1.noarch.rpm;name=aarch64_rust-rstest_reuse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest_reuse-devel}"
SRC_URI[aarch64_rust-rstest_reuse-devel.sha256sum] = "d2ed49bae43e04a32385b258d6b12c5c8898c3ab7edc91778cb847ec3d2d2d24"

RDEPENDS:rust-rstest_reuse+default-devel = " \
 cargo \
 rust-rstest_reuse-devel \
 "
RDEPENDS:rust-rstest_reuse-devel = " \
 cargo \
 rust \
 rust-quote+default-devel \
 rust-rand0.8+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 "
