# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lorax-templates-rhel"
PV = "10.1"
PR = "3.el10"
PACKAGES = " \
 lorax-templates-rhel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lorax-templates-rhel-10.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99089acfb36b122ce21d0fb026ad57f1db4b463368282b25a164f569ceb6ee54"

URI_x86_64_v2_lorax-templates-rhel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-rhel-10.1-3.el10.noarch.rpm;name=x86_64_v2_lorax-templates-rhel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-templates-rhel}"
SRC_URI[x86_64_v2_lorax-templates-rhel.sha256sum] = "663bd050861b65191afb1bd0a0f3aa0c574680950b4e2c675d20ee3a69d89631"
RPROVIDES:lorax-templates-rhel:append:x86_64_v2 = " virtual/lorax-templates"

URI_aarch64_lorax-templates-rhel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-rhel-10.1-3.el10.noarch.rpm;name=aarch64_lorax-templates-rhel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-templates-rhel}"
SRC_URI[aarch64_lorax-templates-rhel.sha256sum] = "663bd050861b65191afb1bd0a0f3aa0c574680950b4e2c675d20ee3a69d89631"
RPROVIDES:lorax-templates-rhel:append:aarch64 = " virtual/lorax-templates"

RDEPENDS:lorax-templates-rhel = " \
 lorax \
 "
