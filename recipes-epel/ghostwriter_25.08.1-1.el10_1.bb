# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghostwriter"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 ghostwriter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghostwriter-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bff6d7a659aa44b58030a759641ffdf7809c6ef11efae9e96440b89d1eb9802c"

URI_x86_64_v2_ghostwriter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghostwriter-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghostwriter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghostwriter}"
SRC_URI[x86_64_v2_ghostwriter.sha256sum] = "4e8ebc748cee6c1bf3bba51f1369e25072c0c0f9a38c22833006c159e28da5d7"

URI_aarch64_ghostwriter = "${EPEL_MIRROR}/aarch64/Packages/g/ghostwriter-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ghostwriter;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghostwriter}"
SRC_URI[aarch64_ghostwriter.sha256sum] = "afda80d9b86f120e14ead7cd1da7a8576a7a2b7326d3c1f497187b0890270953"

RDEPENDS:ghostwriter = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
