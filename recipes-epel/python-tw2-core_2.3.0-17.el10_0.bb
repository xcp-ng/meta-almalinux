# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tw2-core"
PV = "2.3.0"
PR = "17.el10_0"
PACKAGES = " \
 python3-tw2-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tw2-core-2.3.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee58fad5c94f8ede659b7550df6628398f7a137d2118869f6c4e3e7e3e0f1a33"

URI_x86_64_v2_python3-tw2-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tw2-core-2.3.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tw2-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tw2-core}"
SRC_URI[x86_64_v2_python3-tw2-core.sha256sum] = "0fed587dd744d0ffbe2893d12709542412a55acbdb70f3538a78d958cc489f53"

URI_aarch64_python3-tw2-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tw2-core-2.3.0-17.el10_0.noarch.rpm;name=aarch64_python3-tw2-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tw2-core}"
SRC_URI[aarch64_python3-tw2-core.sha256sum] = "e0050c92d77a9d8cc5db84c1ac6410031b00190c8a4bda35f3cdc7c8e3c9575c"

RDEPENDS:python3-tw2-core = " \
 python3 \
 python3-decorator \
 python3-markupsafe \
 python3-paste-deploy \
 python3-simplejson \
 python3-six \
 python3-speaklater \
 python3-webob \
 "
