# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cmocka"
PV = "1.1.7"
PR = "6.el10"
PACKAGES = " \
 libcmocka \
 libcmocka-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/cmocka-1.1.7-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbcf0dc3e9ab68ffe30395c3e3b69c1585925d3878f02b2594f48066e9ebe985"

URI_x86_64_v2_libcmocka = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libcmocka-1.1.7-6.el10.x86_64_v2.rpm;name=x86_64_v2_libcmocka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcmocka}"
SRC_URI[x86_64_v2_libcmocka.sha256sum] = "79b36696d618399a77466ab3d0f64dbbd0c7c860c80a4bca63b7fe602917031c"

URI_x86_64_v2_libcmocka-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libcmocka-devel-1.1.7-6.el10.x86_64_v2.rpm;name=x86_64_v2_libcmocka-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcmocka-devel}"
SRC_URI[x86_64_v2_libcmocka-devel.sha256sum] = "40b1d11229aee661c02ee4d51d674fc36d67af0df2ed9de50ac0e824764ebe99"

URI_aarch64_libcmocka = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libcmocka-1.1.7-6.el10.aarch64.rpm;name=aarch64_libcmocka;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcmocka}"
SRC_URI[aarch64_libcmocka.sha256sum] = "726bc0e1af26947015b5221474ccd8766d3e2aae1870c588c5b91ebea2ef817d"

URI_aarch64_libcmocka-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libcmocka-devel-1.1.7-6.el10.aarch64.rpm;name=aarch64_libcmocka-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcmocka-devel}"
SRC_URI[aarch64_libcmocka-devel.sha256sum] = "16d3c9191fbc0b05703d9b51665b9f440ebd42b1d2cdeed7ad22fc4d62541d7d"

RDEPENDS:libcmocka = " \
 glibc \
 "
RDEPENDS:libcmocka-devel = " \
 cmake-filesystem \
 libcmocka \
 pkgconf-pkg-config \
 "
