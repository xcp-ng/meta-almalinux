# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-matchit"
PV = "0.9.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-matchit+default-devel \
 rust-matchit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-matchit-0.9.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c7240761b85c2d6225f0a7e7182029fad4cb5bb793fa985750312f88dccb594"

URI_x86_64_v2_rust-matchit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchit+default-devel-0.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchit+default-devel}"
SRC_URI[x86_64_v2_rust-matchit+default-devel.sha256sum] = "db30698d68839b9892dd8e8faa45440597103101e137ede4286b6ef2e65b388c"

URI_x86_64_v2_rust-matchit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchit-devel-0.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchit-devel}"
SRC_URI[x86_64_v2_rust-matchit-devel.sha256sum] = "d8e4d0aac41d6129c8dbd88752ebe6fbbb23de74af8f354f96efede0edd8c67c"

URI_aarch64_rust-matchit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchit+default-devel-0.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-matchit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchit+default-devel}"
SRC_URI[aarch64_rust-matchit+default-devel.sha256sum] = "8838a23a90c0c974b3429f121f7aa62a8e780215a85266def5bc1da0d414f90f"

URI_aarch64_rust-matchit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchit-devel-0.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-matchit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchit-devel}"
SRC_URI[aarch64_rust-matchit-devel.sha256sum] = "25afafb0a32d07ca811d20d17414841b10b5b7c1cb834e8eede79b2f72268831"

RDEPENDS:rust-matchit+default-devel = " \
 cargo \
 rust-matchit-devel \
 "
RDEPENDS:rust-matchit-devel = " \
 cargo \
 rust \
 "
