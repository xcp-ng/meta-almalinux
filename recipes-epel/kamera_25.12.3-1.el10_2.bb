# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kamera"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kamera \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kamera-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80a667ecf114128be2860bf87e94c8064822b5cedc95792aa2c0afa7d5bf7707"

URI_x86_64_v2_kamera = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kamera-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kamera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kamera}"
SRC_URI[x86_64_v2_kamera.sha256sum] = "105d8f83c90cc46a5e805689c56e01c045b32a3f6427171fc83c78b9a7540d13"

URI_aarch64_kamera = "${EPEL_MIRROR}/aarch64/Packages/k/kamera-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kamera;unpack=0"
SRC_URI:append = " ${URI_aarch64_kamera}"
SRC_URI[aarch64_kamera.sha256sum] = "14b33a4d3043bb961d2620ede2f44001837ea814b6a2b072ae682184bc0f7276"

RDEPENDS:kamera = " \
 glibc \
 kde-cli-tools \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgphoto2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
