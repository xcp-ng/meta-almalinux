# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-printer"
PV = "0.3.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-grep-printer+default-devel \
 rust-grep-printer+serde-devel \
 rust-grep-printer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-printer-0.3.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7781a534618784c9095c9bddbba9898de3dd516dda91cf1175059df7c8a89ab3"

URI_x86_64_v2_rust-grep-printer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-printer+default-devel-0.3.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-printer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-printer+default-devel}"
SRC_URI[x86_64_v2_rust-grep-printer+default-devel.sha256sum] = "b77f5e3fa876e6d105c4c2ba3f2ea12ace3a497660a21d6443e44bc0719326f4"

URI_x86_64_v2_rust-grep-printer+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-printer+serde-devel-0.3.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-printer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-printer+serde-devel}"
SRC_URI[x86_64_v2_rust-grep-printer+serde-devel.sha256sum] = "eff7902f579c0f110d3bb5d6d9ad8cd4bbbdaaff6f463f8bd1229093af1e194f"

URI_x86_64_v2_rust-grep-printer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-printer-devel-0.3.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-printer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-printer-devel}"
SRC_URI[x86_64_v2_rust-grep-printer-devel.sha256sum] = "0b798cba6693c3fffd4cbe06b1200483b86650a4c7d556ce2d18ccb864ee1b35"

URI_aarch64_rust-grep-printer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-printer+default-devel-0.3.1-1.el10_3.noarch.rpm;name=aarch64_rust-grep-printer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-printer+default-devel}"
SRC_URI[aarch64_rust-grep-printer+default-devel.sha256sum] = "1867fa48380703539e815cc2b68cccc946baea0a73853d681ac2bac731872b99"

URI_aarch64_rust-grep-printer+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-printer+serde-devel-0.3.1-1.el10_3.noarch.rpm;name=aarch64_rust-grep-printer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-printer+serde-devel}"
SRC_URI[aarch64_rust-grep-printer+serde-devel.sha256sum] = "03674fc60bf037680a738146ae232c8619c140d96ae008bd1628fb3434ef5a6e"

URI_aarch64_rust-grep-printer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-printer-devel-0.3.1-1.el10_3.noarch.rpm;name=aarch64_rust-grep-printer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-printer-devel}"
SRC_URI[aarch64_rust-grep-printer-devel.sha256sum] = "f387127d681a35d5c08f7789bb9423e3c42e5f5cc485489bdb3dae39d9d6f960"

RDEPENDS:rust-grep-printer+default-devel = " \
 cargo \
 rust-grep-printer+serde-devel \
 rust-grep-printer-devel \
 "
RDEPENDS:rust-grep-printer+serde-devel = " \
 cargo \
 rust-grep-printer-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-grep-printer-devel = " \
 cargo \
 rust-bstr+default-devel \
 rust-grep-matcher+default-devel \
 rust-grep-searcher+default-devel \
 rust-log+default-devel \
 rust-termcolor+default-devel \
 "
