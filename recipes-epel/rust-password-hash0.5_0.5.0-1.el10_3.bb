# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-password-hash0.5"
PV = "0.5.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-password-hash0.5+alloc-devel \
 rust-password-hash0.5+default-devel \
 rust-password-hash0.5+getrandom-devel \
 rust-password-hash0.5+rand_core-devel \
 rust-password-hash0.5+std-devel \
 rust-password-hash0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-password-hash0.5-0.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48c438698b2c7f7ccd57488af878774fca678774f269358f186b941f164347b5"

URI_x86_64_v2_rust-password-hash0.5+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash0.5+alloc-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash0.5+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash0.5+alloc-devel}"
SRC_URI[x86_64_v2_rust-password-hash0.5+alloc-devel.sha256sum] = "c35a8063cac1ce17e0df87bedd42fcf3c128d282b4202f53ff2f3dce0d1f5b15"

URI_x86_64_v2_rust-password-hash0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash0.5+default-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash0.5+default-devel}"
SRC_URI[x86_64_v2_rust-password-hash0.5+default-devel.sha256sum] = "8f916bda0351f5404fe4281d2f9fd15557a55900717f875c2dfb1c355f37f2b7"

URI_x86_64_v2_rust-password-hash0.5+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash0.5+getrandom-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash0.5+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash0.5+getrandom-devel}"
SRC_URI[x86_64_v2_rust-password-hash0.5+getrandom-devel.sha256sum] = "1bcfc129ff2cf1b9ed2ea065001fc6a674cbafc545c1f2715a4372b42a83dfc2"

URI_x86_64_v2_rust-password-hash0.5+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash0.5+rand_core-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash0.5+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash0.5+rand_core-devel}"
SRC_URI[x86_64_v2_rust-password-hash0.5+rand_core-devel.sha256sum] = "2b4939ab39b5c067d5313a0c60aeb7a15a3f427868c980d36a7f75d1866e7e7c"

URI_x86_64_v2_rust-password-hash0.5+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash0.5+std-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash0.5+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash0.5+std-devel}"
SRC_URI[x86_64_v2_rust-password-hash0.5+std-devel.sha256sum] = "c617cb5443713f415733ed0709a74d6cd4fbaa8b6545f1d7eb71c17e4e8167d9"

URI_x86_64_v2_rust-password-hash0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash0.5-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash0.5-devel}"
SRC_URI[x86_64_v2_rust-password-hash0.5-devel.sha256sum] = "bf2ce544d20bcbc4909ebdbcefc2087b42b7394b4a2cb54c91350fd66c3fa9d6"

URI_aarch64_rust-password-hash0.5+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash0.5+alloc-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-password-hash0.5+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash0.5+alloc-devel}"
SRC_URI[aarch64_rust-password-hash0.5+alloc-devel.sha256sum] = "d2c77578f6f7b4d301c960181f6b47b90df4331abb374a4c15c947466ea84c4a"

URI_aarch64_rust-password-hash0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash0.5+default-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-password-hash0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash0.5+default-devel}"
SRC_URI[aarch64_rust-password-hash0.5+default-devel.sha256sum] = "52b0e1bc12953a7d61a44cefb4917d8d4ccf382e06438d7655a7212bf460640b"

URI_aarch64_rust-password-hash0.5+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash0.5+getrandom-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-password-hash0.5+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash0.5+getrandom-devel}"
SRC_URI[aarch64_rust-password-hash0.5+getrandom-devel.sha256sum] = "29e88a3abeba5974c6a128eaf71fe6e652aef6ffed86d10083ab15d08d3ad430"

URI_aarch64_rust-password-hash0.5+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash0.5+rand_core-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-password-hash0.5+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash0.5+rand_core-devel}"
SRC_URI[aarch64_rust-password-hash0.5+rand_core-devel.sha256sum] = "c5277f868ef797c299a4c6e65a45dc4e609a78ebe8c2885f407b02d70ed9328f"

URI_aarch64_rust-password-hash0.5+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash0.5+std-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-password-hash0.5+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash0.5+std-devel}"
SRC_URI[aarch64_rust-password-hash0.5+std-devel.sha256sum] = "1e9f41ec755592c65da1f43934d89e3944f70f0be5003ca9ee637a9551e6d13c"

URI_aarch64_rust-password-hash0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash0.5-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-password-hash0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash0.5-devel}"
SRC_URI[aarch64_rust-password-hash0.5-devel.sha256sum] = "9f6d0b1e51cbbc2603e570caf7d15e42d63d264fcc0c81ea6917f011ff5c326f"

RDEPENDS:rust-password-hash0.5+alloc-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-password-hash0.5-devel \
 "
RDEPENDS:rust-password-hash0.5+default-devel = " \
 cargo \
 rust-password-hash0.5+rand_core-devel \
 rust-password-hash0.5-devel \
 "
RDEPENDS:rust-password-hash0.5+getrandom-devel = " \
 cargo \
 rust-password-hash0.5-devel \
 rust-rand_core0.6+getrandom-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-password-hash0.5+rand_core-devel = " \
 cargo \
 rust-password-hash0.5-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-password-hash0.5+std-devel = " \
 cargo \
 rust-base64ct+std-devel \
 rust-password-hash0.5+alloc-devel \
 rust-password-hash0.5-devel \
 rust-rand_core0.6+std-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-password-hash0.5-devel = " \
 cargo \
 rust \
 rust-base64ct+default-devel \
 rust-subtle-devel \
 "
