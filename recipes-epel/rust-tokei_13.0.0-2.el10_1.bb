# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokei"
PV = "13.0.0"
PR = "2.el10_1"
PACKAGES:x86_64_v2 = " \
 rust-tokei+cli-devel \
 tokei \
"
PACKAGES:aarch64 = " \
 rust-tokei+all-devel \
 rust-tokei+cbor-devel \
 rust-tokei+cli-devel \
 rust-tokei+default-devel \
 rust-tokei+yaml-devel \
 rust-tokei-devel \
 tokei \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokei-13.0.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b9d85269c8189995713eeafc82dbbd161468ca93d09984bfd53c4f12a57ce60"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-tokei+cli-devel: crate(tokei) = 13.0.0

URI_x86_64_v2_rust-tokei+cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+cli-devel-13.0.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+cli-devel}"
SRC_URI[x86_64_v2_rust-tokei+cli-devel.sha256sum] = "72b3b2f84c3df0124fd57c674e340502b21693cfa3c874461ba8fd6322a410ec"

URI_x86_64_v2_tokei = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tokei-13.0.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tokei;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tokei}"
SRC_URI[x86_64_v2_tokei.sha256sum] = "48cd4ab3df6706ac3b20b470c748766f297a7e77304821e86fa77354d6b5614a"

URI_aarch64_rust-tokei+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+all-devel-13.0.0-2.el10_1.noarch.rpm;name=aarch64_rust-tokei+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+all-devel}"
SRC_URI[aarch64_rust-tokei+all-devel.sha256sum] = "934138b44b987f12d629fcec6478d532bde39b7579a0db0f66537c5916221495"

URI_aarch64_rust-tokei+cbor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+cbor-devel-13.0.0-2.el10_1.noarch.rpm;name=aarch64_rust-tokei+cbor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+cbor-devel}"
SRC_URI[aarch64_rust-tokei+cbor-devel.sha256sum] = "f3376806597522bca0f85cf477c23c01d6920155f8acce3e3e1a6e90d0903da8"

URI_aarch64_rust-tokei+cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+cli-devel-13.0.0-2.el10_1.noarch.rpm;name=aarch64_rust-tokei+cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+cli-devel}"
SRC_URI[aarch64_rust-tokei+cli-devel.sha256sum] = "5f3f31b156e06799907168bedd89040b8e8ff5e4d289e80b22062d2afbaf3216"

URI_aarch64_rust-tokei+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+default-devel-13.0.0-2.el10_1.noarch.rpm;name=aarch64_rust-tokei+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+default-devel}"
SRC_URI[aarch64_rust-tokei+default-devel.sha256sum] = "380a927c8d34e2001d2f466ba50c05a942e7fe307e36f5cfc4b7b0d4666cf196"

URI_aarch64_rust-tokei+yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+yaml-devel-13.0.0-2.el10_1.noarch.rpm;name=aarch64_rust-tokei+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+yaml-devel}"
SRC_URI[aarch64_rust-tokei+yaml-devel.sha256sum] = "471e596813dba967d6488828b96b8a009c9eda0a8a4d83f914b287ea59556cd4"

URI_aarch64_rust-tokei-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei-devel-13.0.0-2.el10_1.noarch.rpm;name=aarch64_rust-tokei-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei-devel}"
SRC_URI[aarch64_rust-tokei-devel.sha256sum] = "70bdec590064ea7fc2197bd91870cb3da8d432c9c2687875a07ac45c8fea6e8a"

URI_aarch64_tokei = "${EPEL_MIRROR}/aarch64/Packages/t/tokei-13.0.0-2.el10_1.aarch64.rpm;name=aarch64_tokei;unpack=0"
SRC_URI:append = " ${URI_aarch64_tokei}"
SRC_URI[aarch64_tokei.sha256sum] = "72dda59b36345537b4a5403eb5a71254749c8dbdb9f7c787bd501c426a712fb0"

RDEPENDS:rust-tokei+cli-devel:x86_64_v2 = " \
 cargo \
 rust-clap+cargo-devel \
 rust-clap+default-devel \
 rust-clap+string-devel \
 rust-clap+wrap_help-devel \
 rust-colored2+default-devel \
 rust-env_logger+default-devel \
 rust-num-format+default-devel \
"
RDEPENDS:rust-tokei+cli-devel:aarch64 = " \
 cargo \
 rust-clap+cargo-devel \
 rust-clap+default-devel \
 rust-clap+string-devel \
 rust-clap+wrap_help-devel \
 rust-colored2+default-devel \
 rust-env_logger+default-devel \
 rust-num-format+default-devel \
 rust-tokei-devel \
"
RDEPENDS:tokei = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-tokei+all-devel = " \
 cargo \
 rust-tokei+cbor-devel \
 rust-tokei+yaml-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei+cbor-devel = " \
 cargo \
 rust-hex+default-devel \
 rust-serde_cbor+default-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei+default-devel = " \
 cargo \
 rust-tokei+cli-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei+yaml-devel = " \
 cargo \
 rust-serde_yaml+default-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei-devel = " \
 cargo \
 rust \
 rust-aho-corasick+default-devel \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-clap-cargo+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-dashmap+default-devel \
 rust-dashmap+serde-devel \
 rust-encoding_rs_io+default-devel \
 rust-etcetera+default-devel \
 rust-grep-searcher+default-devel \
 rust-ignore+default-devel \
 rust-json5+default-devel \
 rust-log+default-devel \
 rust-once_cell+default-devel \
 rust-parking_lot+default-devel \
 rust-rayon+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde_json+default-devel \
 rust-table_formatter+default-devel \
 rust-tera+default-devel \
 rust-term_size+default-devel \
 rust-toml0.8+default-devel \
 "
