# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbounce"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kbounce \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kbounce-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5c41ffdfc79257b27f419348e0ae2fd107942d85402a56931ba3e97848970c88"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbounce-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbounce;unpack=0"
SRC_URI[x86_64_v2_kbounce.sha256sum] = "0ea739607c342a9c857853bc6ce24e2ef070df29e1eb7631ee2bcc901ba36adb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kbounce-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kbounce;unpack=0"
SRC_URI[aarch64_kbounce.sha256sum] = "6e17cb4ab385161fc20375425fd9889c8db54b0c3f7e1d3571aac07c153cdac9"

RDEPENDS:kbounce = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
