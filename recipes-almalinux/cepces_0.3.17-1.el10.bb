# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cepces"
PV = "0.3.17"
PR = "1.el10"
PACKAGES = " \
 cepces \
 cepces-certmonger \
 cepces-selinux \
 python3-cepces \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cepces-0.3.17-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd39fe113a0525cc81f6c3a08cba86e6dce02cf3c45c0b81f27388ec59d769b3"

URI_x86_64_v2_cepces = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cepces-0.3.17-1.el10.noarch.rpm;name=x86_64_v2_cepces;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cepces}"
SRC_URI[x86_64_v2_cepces.sha256sum] = "0e55a9c223d10c807e643cc00a639fbd0316a9c3290616a71f86d5fefecb5b1a"

URI_x86_64_v2_cepces-certmonger = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cepces-certmonger-0.3.17-1.el10.noarch.rpm;name=x86_64_v2_cepces-certmonger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cepces-certmonger}"
SRC_URI[x86_64_v2_cepces-certmonger.sha256sum] = "013d2f169ba06124323fcf658dab10e9e2e203526e3dde77730df9c4defa6ee1"

URI_x86_64_v2_cepces-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cepces-selinux-0.3.17-1.el10.noarch.rpm;name=x86_64_v2_cepces-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cepces-selinux}"
SRC_URI[x86_64_v2_cepces-selinux.sha256sum] = "94192022d8484a08228467b8b18631ab7194591f98d3c1270a484305d139f514"

URI_x86_64_v2_python3-cepces = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-cepces-0.3.17-1.el10.noarch.rpm;name=x86_64_v2_python3-cepces;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cepces}"
SRC_URI[x86_64_v2_python3-cepces.sha256sum] = "b4fe39cc16aac698199c94013240353e852abad9352ef08286d19b402f03aa7f"

URI_aarch64_cepces = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cepces-0.3.17-1.el10.noarch.rpm;name=aarch64_cepces;unpack=0"
SRC_URI:append = " ${URI_aarch64_cepces}"
SRC_URI[aarch64_cepces.sha256sum] = "0e55a9c223d10c807e643cc00a639fbd0316a9c3290616a71f86d5fefecb5b1a"

URI_aarch64_cepces-certmonger = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cepces-certmonger-0.3.17-1.el10.noarch.rpm;name=aarch64_cepces-certmonger;unpack=0"
SRC_URI:append = " ${URI_aarch64_cepces-certmonger}"
SRC_URI[aarch64_cepces-certmonger.sha256sum] = "013d2f169ba06124323fcf658dab10e9e2e203526e3dde77730df9c4defa6ee1"

URI_aarch64_cepces-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cepces-selinux-0.3.17-1.el10.noarch.rpm;name=aarch64_cepces-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_cepces-selinux}"
SRC_URI[aarch64_cepces-selinux.sha256sum] = "94192022d8484a08228467b8b18631ab7194591f98d3c1270a484305d139f514"

URI_aarch64_python3-cepces = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-cepces-0.3.17-1.el10.noarch.rpm;name=aarch64_python3-cepces;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cepces}"
SRC_URI[aarch64_python3-cepces.sha256sum] = "b4fe39cc16aac698199c94013240353e852abad9352ef08286d19b402f03aa7f"

RDEPENDS:cepces = " \
 cepces-selinux \
 python3-cepces \
 "
RDEPENDS:cepces-certmonger = " \
 bash \
 cepces \
 certmonger \
 python3 \
 "
RDEPENDS:cepces-selinux = " \
 bash \
 cepces \
 selinux-policy-targeted \
 "
RDEPENDS:python3-cepces = " \
 krb5-libs \
 python3 \
 python3-cryptography \
 python3-requests \
 python3-requests-gssapi \
 "
