# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tagsoup"
PV = "1.2.1"
PR = "35.el10_1"
PACKAGES = " \
 tagsoup \
 tagsoup-javadoc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tagsoup-1.2.1-35.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5df9c182f9dedbce79b5067ee6bb07fb7a128f0ffec4f7b1c760ccedb1712dcb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tagsoup-1.2.1-35.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tagsoup;unpack=0"
SRC_URI[x86_64_v2_tagsoup.sha256sum] = "9c4970d9f9a117971d2cc32504e7163b736d0b760dde7402d4e89026a5770d4d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tagsoup-javadoc-1.2.1-35.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tagsoup-javadoc;unpack=0"
SRC_URI[x86_64_v2_tagsoup-javadoc.sha256sum] = "1e7f35986fcb153422b24c3e4375cfec44bf229752bb82ff04a697b3dfc4d432"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tagsoup-1.2.1-35.el10_1.noarch.rpm;name=aarch64_tagsoup;unpack=0"
SRC_URI[aarch64_tagsoup.sha256sum] = "c8a50ef8e994c5483b3f51cd71a04990613b865a7fd76d5a46a237db899523bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tagsoup-javadoc-1.2.1-35.el10_1.noarch.rpm;name=aarch64_tagsoup-javadoc;unpack=0"
SRC_URI[aarch64_tagsoup-javadoc.sha256sum] = "8973a0537cc0f9a81372aaaad213a18702611e70253d0c3855dfb90faea97c92"

RDEPENDS:tagsoup = " \
 javapackages-filesystem \
 "
RDEPENDS:tagsoup-javadoc = " \
 javapackages-tools \
 "
