# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-core"
PV = "0.20.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-core-0.20.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2794c2717df3e3a67a6da0cc05f3fd35204536140c35130e7c6036888551a9e0"

URI_x86_64_v2_python3-colcon-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-core-0.20.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-core}"
SRC_URI[x86_64_v2_python3-colcon-core.sha256sum] = "b0b97f847454b6b37d7a97bf98db11b87eaf0fb70bd51bb48a5979835a60b5d7"

URI_aarch64_python3-colcon-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-core-0.20.1-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-core}"
SRC_URI[aarch64_python3-colcon-core.sha256sum] = "a115faa94d76290cdef64f516f09199fa7872f7dba385375239f49a8148efcf0"

RDEPENDS:python3-colcon-core = " \
 python3 \
 python3-distlib \
 python3-empy \
 python3-packaging \
 python3-setuptools \
 "
