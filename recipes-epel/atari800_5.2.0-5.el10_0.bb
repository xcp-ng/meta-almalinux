# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "atari800"
PV = "5.2.0"
PR = "5.el10_0"
PACKAGES = " \
 atari800 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/atari800-5.2.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c692d663c5f39e9247587a3caf5098b86341969a64cb925497865694bdc13666"

URI_x86_64_v2_atari800 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/atari800-5.2.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_atari800;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atari800}"
SRC_URI[x86_64_v2_atari800.sha256sum] = "228f7d74b9150db48c64f92d0794595848989eafe22b4587805d7651a95f011a"

URI_aarch64_atari800 = "${EPEL_MIRROR}/aarch64/Packages/a/atari800-5.2.0-5.el10_0.aarch64.rpm;name=aarch64_atari800;unpack=0"
SRC_URI:append = " ${URI_aarch64_atari800}"
SRC_URI[aarch64_atari800.sha256sum] = "c04b06068019a38d7f69512238e1d82786f91622f3aec64022bc78150dbb3361"

RDEPENDS:atari800 = " \
 glibc \
 libpng \
 sdl12-compat \
 zlib-ng-compat \
 "
