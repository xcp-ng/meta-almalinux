# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iperf3"
PV = "3.17.1"
PR = "6.el10_2.1"
PACKAGES = " \
 iperf3 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/iperf3-3.17.1-6.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3ac6ccfc043b81af7d0afad925e9ffe5f2dac52efbed9e4a25c303c527cca18f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iperf3-3.17.1-6.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_iperf3;unpack=0"
SRC_URI[x86_64_v2_iperf3.sha256sum] = "2568b470c0cbf32ab51332433f7df6dab43c9b81599255272451da4cee4fde0e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iperf3-3.17.1-6.el10_2.1.aarch64.rpm;name=aarch64_iperf3;unpack=0"
SRC_URI[aarch64_iperf3.sha256sum] = "fee89832989a12016d46564674a5a9cc9795d69f58f8988f3d38baf76742b49f"

RDEPENDS:iperf3 = " \
 glibc \
 lksctp-tools \
 openssl-libs \
 "
