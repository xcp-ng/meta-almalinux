# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fields"
PV = "5.0.0"
PR = "22.el10_0"
PACKAGES = " \
 python-fields-doc \
 python3-fields \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fields-5.0.0-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3267f849a84ada6a36b0532b68b430f9f73f7b56a3fde2bd961cdf2aed3f8de7"

URI_x86_64_v2_python-fields-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-fields-doc-5.0.0-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-fields-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-fields-doc}"
SRC_URI[x86_64_v2_python-fields-doc.sha256sum] = "701b5376eed0a48b2f4b07d1a2023cac4ff9d5b42057f89ee01427cc851e103b"

URI_x86_64_v2_python3-fields = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fields-5.0.0-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fields;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fields}"
SRC_URI[x86_64_v2_python3-fields.sha256sum] = "6afbd39b674562059c068d5876a01816ee69837a98680dd5dba9bfa63b2c3b6f"

URI_aarch64_python-fields-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-fields-doc-5.0.0-22.el10_0.noarch.rpm;name=aarch64_python-fields-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-fields-doc}"
SRC_URI[aarch64_python-fields-doc.sha256sum] = "10201bf5a7576ab8722c2ab5216edb77ab826722c008cd918509e41a25d773ae"

URI_aarch64_python3-fields = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fields-5.0.0-22.el10_0.noarch.rpm;name=aarch64_python3-fields;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fields}"
SRC_URI[aarch64_python3-fields.sha256sum] = "cfdaee1a700f3ee214de4d01c7a1b18b7fdf41e3de0a14122684547e8a0dfc1f"

RDEPENDS:python-fields-doc = " \
 "
RDEPENDS:python3-fields = " \
 python3 \
 "
