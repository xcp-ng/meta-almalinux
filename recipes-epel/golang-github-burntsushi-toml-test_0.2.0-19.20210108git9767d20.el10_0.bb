# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-burntsushi-toml-test"
PV = "0.2.0"
PR = "19.20210108git9767d20.el10_0"
PACKAGES = " \
 golang-github-burntsushi-toml-test \
 golang-github-burntsushi-toml-test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-burntsushi-toml-test-0.2.0-19.20210108git9767d20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f602da0a48179b942f54fb120e94202e44faa66e44b901ec7068617bad10a653"

URI_aarch64_golang-github-burntsushi-toml-test = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-burntsushi-toml-test-0.2.0-19.20210108git9767d20.el10_0.aarch64.rpm;name=aarch64_golang-github-burntsushi-toml-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-burntsushi-toml-test}"
SRC_URI[aarch64_golang-github-burntsushi-toml-test.sha256sum] = "25223d07bdbab30c1959ebea1628b7d11d5e211d43c5b28eea7633bbd8d02b21"

URI_aarch64_golang-github-burntsushi-toml-test-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-burntsushi-toml-test-devel-0.2.0-19.20210108git9767d20.el10_0.noarch.rpm;name=aarch64_golang-github-burntsushi-toml-test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-burntsushi-toml-test-devel}"
SRC_URI[aarch64_golang-github-burntsushi-toml-test-devel.sha256sum] = "95955a0483302b0e98fadb658e752cc98f2edd81a896d34a6c1f712a506e2322"

RDEPENDS:golang-github-burntsushi-toml-test = " \
 glibc \
 "
RDEPENDS:golang-github-burntsushi-toml-test-devel = " \
 go-filesystem \
 golang-github-burntsushi-toml-devel \
 "
