# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "azure-vm-utils"
PV = "0.7.0"
PR = "1.el10"
PACKAGES = " \
 azure-vm-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/azure-vm-utils-0.7.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1be94ddfac5c29d74653f1fe375e786bed5ce9d848b4e8a8c6e6035b181a00b"

URI_x86_64_v2_azure-vm-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/azure-vm-utils-0.7.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_azure-vm-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_azure-vm-utils}"
SRC_URI[x86_64_v2_azure-vm-utils.sha256sum] = "19bcac2406212437c4e1fddc297dce71c5b5818d1243f3c112cf87943ae7a56f"

URI_aarch64_azure-vm-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/azure-vm-utils-0.7.0-1.el10.aarch64.rpm;name=aarch64_azure-vm-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_azure-vm-utils}"
SRC_URI[aarch64_azure-vm-utils.sha256sum] = "2a2949e66fe26843811e50eb26b8eb2120c7d295f71890dda8d18d403fce0a5d"

RDEPENDS:azure-vm-utils = " \
 bash \
 glibc \
 json-c \
 util-linux \
 "
