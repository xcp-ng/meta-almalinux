# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "koko"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 koko \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/koko-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb1a651c8a4809ee2c8d44fbf092501f4569340361885a3aee0e21c19889d4c0"

URI_x86_64_v2_koko = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koko-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_koko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koko}"
SRC_URI[x86_64_v2_koko.sha256sum] = "6cba392144897095edb6efaf784472a38c4b7f35d1be304864c77963ee0a5350"

URI_aarch64_koko = "${EPEL_MIRROR}/aarch64/Packages/k/koko-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_koko;unpack=0"
SRC_URI:append = " ${URI_aarch64_koko}"
SRC_URI[aarch64_koko.sha256sum] = "35b3a0e2e2aae9d62d573855291ea67b85e37881f3a357c938727eec92d2de14"

RDEPENDS:koko = " \
 exiv2-libs \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kwindowsystem \
 kf6-purpose \
 kquickimageeditor-qt6 \
 libgcc \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qt6-qtsvg \
 "
