# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Install-Repository"
PV = "0.06"
PR = "35.el10_0"
PACKAGES = " \
 perl-Module-Install-Repository \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Install-Repository-0.06-35.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d08293ce3c972fd6c133a8f3153409c50816f4241b2a7a1eda437d7fefb2d146"

URI_x86_64_v2_perl-Module-Install-Repository = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Install-Repository-0.06-35.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Install-Repository;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Install-Repository}"
SRC_URI[x86_64_v2_perl-Module-Install-Repository.sha256sum] = "45ff6d36043f61b62c7612fe9054c9a132d79d927581b8f7a1a624631848998a"

URI_aarch64_perl-Module-Install-Repository = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Install-Repository-0.06-35.el10_0.noarch.rpm;name=aarch64_perl-Module-Install-Repository;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Install-Repository}"
SRC_URI[aarch64_perl-Module-Install-Repository.sha256sum] = "db32adb1be97fceff57635a8eb16076f131734b81717e633f83d952096f136a0"

RDEPENDS:perl-Module-Install-Repository = " \
 perl-Module-Install \
 perl-base \
 perl-libs \
 perl-vars \
 "
