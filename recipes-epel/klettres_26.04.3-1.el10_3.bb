# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klettres"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 klettres \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/klettres-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00fdc238190fa14b40a05eb22190984d434e9e7a96cc8945b323bdf2d9037294"

URI_x86_64_v2_klettres = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klettres-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klettres;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_klettres}"
SRC_URI[x86_64_v2_klettres.sha256sum] = "22d7c14cd12bb233ac63ab302d0e746f373f84305db563fdb6e7007f8a097485"

URI_aarch64_klettres = "${EPEL_MIRROR}/aarch64/Packages/k/klettres-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_klettres;unpack=0"
SRC_URI:append = " ${URI_aarch64_klettres}"
SRC_URI[aarch64_klettres.sha256sum] = "73e687c6f5a13c8bae414f3e2a9dd2816bbfc5130bda1045998af9053cb01be2"

RDEPENDS:klettres = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
