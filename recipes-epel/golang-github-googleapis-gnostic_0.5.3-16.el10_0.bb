# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-googleapis-gnostic"
PV = "0.5.3"
PR = "16.el10_0"
PACKAGES = " \
 golang-github-googleapis-gnostic \
 golang-github-googleapis-gnostic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-googleapis-gnostic-0.5.3-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60f05044baf5f14ff9e6fb088fc7a34440f44b38e4653e8da208cb0b298e639e"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-github-googleapis-gnostic-devel: golang(github.com/docopt/docopt-go)
# - golang-github-googleapis-gnostic-devel: golang(google.golang.org/genproto/googleapis/api/annotations)

URI_x86_64_v2_golang-github-googleapis-gnostic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-googleapis-gnostic-0.5.3-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-googleapis-gnostic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-googleapis-gnostic}"
SRC_URI[x86_64_v2_golang-github-googleapis-gnostic.sha256sum] = "cc583947581224ab2d2bbc87b6346e4e364575f62fad9710993412f0b68e3c18"

URI_x86_64_v2_golang-github-googleapis-gnostic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-googleapis-gnostic-devel-0.5.3-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-googleapis-gnostic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-googleapis-gnostic-devel}"
SRC_URI[x86_64_v2_golang-github-googleapis-gnostic-devel.sha256sum] = "50207cb3f850a62ab1fbd3a2a27431ff6cd1bb177f48df20e8c5ea28964a3581"

URI_aarch64_golang-github-googleapis-gnostic = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-googleapis-gnostic-0.5.3-16.el10_0.aarch64.rpm;name=aarch64_golang-github-googleapis-gnostic;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-googleapis-gnostic}"
SRC_URI[aarch64_golang-github-googleapis-gnostic.sha256sum] = "6c63e5cd4ca288ccbf1fe5a526f768bca324f2d1971e827533200f4aa524c42a"

URI_aarch64_golang-github-googleapis-gnostic-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-googleapis-gnostic-devel-0.5.3-16.el10_0.noarch.rpm;name=aarch64_golang-github-googleapis-gnostic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-googleapis-gnostic-devel}"
SRC_URI[aarch64_golang-github-googleapis-gnostic-devel.sha256sum] = "ccdb11118ffb3791d83d4523c846d89d3ac37212157a7cd5ab75b5d6071d8e11"

RDEPENDS:golang-github-googleapis-gnostic = " \
 glibc \
 "
RDEPENDS:golang-github-googleapis-gnostic-devel:x86_64_v2 = " \
 go-filesystem \
 golang-github-protobuf-devel \
 golang-github-stoewer-strcase-devel \
 golang-google-protobuf-devel \
 golang-gopkg-yaml-3-devel \
"
RDEPENDS:golang-github-googleapis-gnostic-devel:aarch64 = " \
 compat-golang-github-docopt-devel \
 go-filesystem \
 golang-github-protobuf-devel \
 golang-github-stoewer-strcase-devel \
 golang-google-genproto-devel \
 golang-google-protobuf-devel \
 golang-gopkg-yaml-3-devel \
"
