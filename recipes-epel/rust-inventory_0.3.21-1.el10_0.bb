# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-inventory"
PV = "0.3.21"
PR = "1.el10_0"
PACKAGES = " \
 rust-inventory+default-devel \
 rust-inventory-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-inventory-0.3.21-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e13afa2d7456c73e804347b11b08405d3f2716a43ee91974a2b23f6030ebe9e"

URI_x86_64_v2_rust-inventory+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inventory+default-devel-0.3.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inventory+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inventory+default-devel}"
SRC_URI[x86_64_v2_rust-inventory+default-devel.sha256sum] = "7e22068108bdcf8d25946f1df508e8072f19c833aba1e91a109082fd936a3d08"

URI_x86_64_v2_rust-inventory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inventory-devel-0.3.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inventory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inventory-devel}"
SRC_URI[x86_64_v2_rust-inventory-devel.sha256sum] = "4de9a4a21702c6f673d4b7e2a308ddf1f499769e7f8fb3569226988a9cecb3f7"

URI_aarch64_rust-inventory+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inventory+default-devel-0.3.21-1.el10_0.noarch.rpm;name=aarch64_rust-inventory+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inventory+default-devel}"
SRC_URI[aarch64_rust-inventory+default-devel.sha256sum] = "d40589dc653831818684083e01156a3e15f482a3b43f7db348b8a5321bdd5f3e"

URI_aarch64_rust-inventory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inventory-devel-0.3.21-1.el10_0.noarch.rpm;name=aarch64_rust-inventory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inventory-devel}"
SRC_URI[aarch64_rust-inventory-devel.sha256sum] = "7c4bdf73544a9dc95c5ac48c6d655ed942727b792bf2c7bdff6af67df62b0642"

RDEPENDS:rust-inventory+default-devel = " \
 cargo \
 rust-inventory-devel \
 "
RDEPENDS:rust-inventory-devel = " \
 cargo \
 rust \
 "
