# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-b3sum"
PV = "1.8.7"
PR = "1.el10_3"
PACKAGES = " \
 b3sum \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-b3sum-1.8.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "00928e3acbdfbfab2c16f45e124d8039d408f81473900afb0aa628669c038edb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/b3sum-1.8.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_b3sum;unpack=0"
SRC_URI[x86_64_v2_b3sum.sha256sum] = "f69945449bf83ce9b27dd91e017afe3e133568c536cd4ebd5d5cf9223f3ad220"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/b3sum-1.8.7-1.el10_3.aarch64.rpm;name=aarch64_b3sum;unpack=0"
SRC_URI[aarch64_b3sum.sha256sum] = "e257c07225cf22c91e11c20ffffc6c83dbff3342db97351135354a21b7d98181"

RDEPENDS:b3sum = " \
 glibc \
 libgcc \
 "
