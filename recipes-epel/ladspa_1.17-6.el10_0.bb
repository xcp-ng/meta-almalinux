# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ladspa"
PV = "1.17"
PR = "6.el10_0"
PACKAGES = " \
 ladspa \
 ladspa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/ladspa-1.17-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39ecd550393244d32254addd5501129266566208e04e55063af82ac3e71b71bb"

URI_x86_64_v2_ladspa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ladspa-1.17-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ladspa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ladspa}"
SRC_URI[x86_64_v2_ladspa.sha256sum] = "baed96f93e71a78512f928d31ce4e9a19bce78a21c7a8ed4a3829cf7ea7ce1ab"

URI_x86_64_v2_ladspa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ladspa-devel-1.17-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ladspa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ladspa-devel}"
SRC_URI[x86_64_v2_ladspa-devel.sha256sum] = "99b694706182e8bb671dbfc2e50c793967e24785d0a92a210cb237b678cf0ce5"

URI_aarch64_ladspa = "${EPEL_MIRROR}/aarch64/Packages/l/ladspa-1.17-6.el10_0.aarch64.rpm;name=aarch64_ladspa;unpack=0"
SRC_URI:append = " ${URI_aarch64_ladspa}"
SRC_URI[aarch64_ladspa.sha256sum] = "3817c970ad3b88d5641f6322cce789ca9d9c852bb9a436cafcb3e08aaa0b16a3"

URI_aarch64_ladspa-devel = "${EPEL_MIRROR}/aarch64/Packages/l/ladspa-devel-1.17-6.el10_0.aarch64.rpm;name=aarch64_ladspa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ladspa-devel}"
SRC_URI[aarch64_ladspa-devel.sha256sum] = "e4a4be7ca33114035f18b3fe4a8637e1f251ad71278544a295ea9e7cf50fd645"

RDEPENDS:ladspa = " \
 glibc \
 libgcc \
 libsndfile \
 libstdc++ \
 "
RDEPENDS:ladspa-devel = " \
 ladspa \
 "
