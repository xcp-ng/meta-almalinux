# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-Format-Pg"
PV = "0.16014"
PR = "14.el10_2"
PACKAGES = " \
 perl-DateTime-Format-Pg \
 perl-DateTime-Format-Pg-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-Format-Pg-0.16014-14.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17e60d34113e0d6bd3aaac933a6cd3fe97ba460b5db3a2574c9aec80b9dee44d"

URI_x86_64_v2_perl-DateTime-Format-Pg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-Format-Pg-0.16014-14.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-Format-Pg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-Format-Pg}"
SRC_URI[x86_64_v2_perl-DateTime-Format-Pg.sha256sum] = "9b8ac465872aacc2c6968cd3f6a1a8e8fc7f961ff6bb0bd77d4bc897a1fca321"

URI_x86_64_v2_perl-DateTime-Format-Pg-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-Format-Pg-tests-0.16014-14.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-Format-Pg-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-Format-Pg-tests}"
SRC_URI[x86_64_v2_perl-DateTime-Format-Pg-tests.sha256sum] = "050fd14e0ce0fe88eafe5b67f77658fcf4ecb6914fc02afef88fc3812317185c"

URI_aarch64_perl-DateTime-Format-Pg = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-Format-Pg-0.16014-14.el10_2.noarch.rpm;name=aarch64_perl-DateTime-Format-Pg;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-Format-Pg}"
SRC_URI[aarch64_perl-DateTime-Format-Pg.sha256sum] = "5096029afcdd57b6b7aec971fd835ec719ede26ca2694a4167b9a203175ba002"

URI_aarch64_perl-DateTime-Format-Pg-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-Format-Pg-tests-0.16014-14.el10_2.noarch.rpm;name=aarch64_perl-DateTime-Format-Pg-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-Format-Pg-tests}"
SRC_URI[aarch64_perl-DateTime-Format-Pg-tests.sha256sum] = "17fb79c142de984c76efbff6d9717077a0853dd6e84dd9f3227aee37b4b3775c"

RDEPENDS:perl-DateTime-Format-Pg = " \
 perl-Carp \
 perl-DateTime \
 perl-DateTime-Format-Builder \
 perl-DateTime-TimeZone \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-DateTime-Format-Pg-tests = " \
 bash \
 perl-Data-Dumper \
 perl-DateTime \
 perl-DateTime-Format-Pg \
 perl-DateTime-TimeZone \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
