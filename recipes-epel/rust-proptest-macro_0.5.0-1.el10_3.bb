# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proptest-macro"
PV = "0.5.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-proptest-macro+default-devel \
 rust-proptest-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proptest-macro-0.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3de4296a30ece84941d2c51795aa93c3dfe26abe57d2672633c9eaced34b95a9"

URI_x86_64_v2_rust-proptest-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-macro+default-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-macro+default-devel}"
SRC_URI[x86_64_v2_rust-proptest-macro+default-devel.sha256sum] = "b883a080643ffd14038cc7575877abfeb2082f4df8d9ce713bd0b904e6248817"

URI_x86_64_v2_rust-proptest-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-macro-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-macro-devel}"
SRC_URI[x86_64_v2_rust-proptest-macro-devel.sha256sum] = "b7ebc1388eaf8ea61a2a9a721eb2b0964b3e988c057a412bc84fbd9b9c6addfe"

URI_aarch64_rust-proptest-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-macro+default-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-macro+default-devel}"
SRC_URI[aarch64_rust-proptest-macro+default-devel.sha256sum] = "6e9a3a5301f74def67ecf1bfc46020794f036adbf47b808081f9805dc2a77fe7"

URI_aarch64_rust-proptest-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-macro-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-macro-devel}"
SRC_URI[aarch64_rust-proptest-macro-devel.sha256sum] = "5b09e56707c1d3d35b4e9323933f02419d2289fb32d7cfae908708ecf71a9b2d"

RDEPENDS:rust-proptest-macro+default-devel = " \
 cargo \
 rust-proptest-macro-devel \
 "
RDEPENDS:rust-proptest-macro-devel = " \
 cargo \
 rust \
 rust-convert_case+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 "
