# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deflate64"
PV = "0.1.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-deflate64+default-devel \
 rust-deflate64-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deflate64-0.1.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56ffbd26d7ad3192bd48f4d35e8c17470f1ecdae912b766c86054701934e18eb"

URI_x86_64_v2_rust-deflate64+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deflate64+default-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deflate64+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deflate64+default-devel}"
SRC_URI[x86_64_v2_rust-deflate64+default-devel.sha256sum] = "5b7be14e01a04e9761db856579ddf4bc7d01b4ab7ae6f5fecea4ba7ef7829c01"

URI_x86_64_v2_rust-deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deflate64-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deflate64-devel}"
SRC_URI[x86_64_v2_rust-deflate64-devel.sha256sum] = "0884661c9692dcc5d3a77056213ca75a37b74f6d7af5954acb05dba6a35aa76c"

URI_aarch64_rust-deflate64+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deflate64+default-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-deflate64+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deflate64+default-devel}"
SRC_URI[aarch64_rust-deflate64+default-devel.sha256sum] = "777b3a28ccc3826dc9b93f85f44edb402e7274b6cbc426b6ef877d19a419fb27"

URI_aarch64_rust-deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deflate64-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deflate64-devel}"
SRC_URI[aarch64_rust-deflate64-devel.sha256sum] = "4da3c84a6dd1ec732fe2043681b583b61da7df5d83c244899e719262e10810e1"

RDEPENDS:rust-deflate64+default-devel = " \
 cargo \
 rust-deflate64-devel \
 "
RDEPENDS:rust-deflate64-devel = " \
 cargo \
 "
