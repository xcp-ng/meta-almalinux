# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Spelling"
PV = "0.25"
PR = "13.el10_0"
PACKAGES = " \
 perl-Test-Spelling \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-Spelling-0.25-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c39882b7011d637fc70728aa62627d7d8866c95b678154eecc1d722ce0600d8"

URI_x86_64_v2_perl-Test-Spelling = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Spelling-0.25-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Spelling;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Spelling}"
SRC_URI[x86_64_v2_perl-Test-Spelling.sha256sum] = "9fda81cafe6f468c39db9a824962bd1981ad74fe1506ad19958819201065b247"

URI_aarch64_perl-Test-Spelling = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Spelling-0.25-13.el10_0.noarch.rpm;name=aarch64_perl-Test-Spelling;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Spelling}"
SRC_URI[aarch64_perl-Test-Spelling.sha256sum] = "fec19377ee6d31f7cf66076a0342c51cbc2aa575a294c3b0905d1a4113000547"

RDEPENDS:perl-Test-Spelling = " \
 hunspell \
 perl-Carp \
 perl-Exporter \
 perl-IPC-Run3 \
 perl-PathTools \
 perl-Pod-Spell \
 perl-Symbol \
 perl-Test-Simple \
 perl-Text-Tabs+Wrap \
 perl-libs \
 "
