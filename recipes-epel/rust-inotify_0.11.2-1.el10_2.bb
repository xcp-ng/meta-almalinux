# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-inotify"
PV = "0.11.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-inotify+default-devel \
 rust-inotify+futures-util-devel \
 rust-inotify+stream-devel \
 rust-inotify+tokio-devel \
 rust-inotify-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-inotify-0.11.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cf9787f93daaf7c7b9d295a3aa4ecd9f38afbd758a075b973880115cedd8c9c"

URI_x86_64_v2_rust-inotify+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+default-devel-0.11.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+default-devel}"
SRC_URI[x86_64_v2_rust-inotify+default-devel.sha256sum] = "fcd31f6fb48ae45fb081912c3e4417320d25bde8ad99a3bd1780ecd9e9452fdb"

URI_x86_64_v2_rust-inotify+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+futures-util-devel-0.11.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+futures-util-devel}"
SRC_URI[x86_64_v2_rust-inotify+futures-util-devel.sha256sum] = "55a60a8d440885701271f291f9104d32b7fc50bdcde0c63735249ca142fce6c3"

URI_x86_64_v2_rust-inotify+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+stream-devel-0.11.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+stream-devel}"
SRC_URI[x86_64_v2_rust-inotify+stream-devel.sha256sum] = "545f6be04b732d67fcd860676025e7c079eb64685d0d1320d3a19d770a3354c6"

URI_x86_64_v2_rust-inotify+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+tokio-devel-0.11.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+tokio-devel}"
SRC_URI[x86_64_v2_rust-inotify+tokio-devel.sha256sum] = "26dae6047fb734b96ba0cc4c03b512e5155a70d823b08adc6ca7743a365c3a6f"

URI_x86_64_v2_rust-inotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify-devel-0.11.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify-devel}"
SRC_URI[x86_64_v2_rust-inotify-devel.sha256sum] = "db8b0c40f905a910811e158918984a7bf8d29e5c2ba4cc991394a4a72ff025fa"

URI_aarch64_rust-inotify+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+default-devel-0.11.2-1.el10_2.noarch.rpm;name=aarch64_rust-inotify+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+default-devel}"
SRC_URI[aarch64_rust-inotify+default-devel.sha256sum] = "7ad7eb263f6c62999fe5794fe7aced0316b1abcb15a7f1c54126c92741cd9b99"

URI_aarch64_rust-inotify+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+futures-util-devel-0.11.2-1.el10_2.noarch.rpm;name=aarch64_rust-inotify+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+futures-util-devel}"
SRC_URI[aarch64_rust-inotify+futures-util-devel.sha256sum] = "a294e240bb0a3166018e5c009b88fa37060347383800928340ae4093333501af"

URI_aarch64_rust-inotify+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+stream-devel-0.11.2-1.el10_2.noarch.rpm;name=aarch64_rust-inotify+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+stream-devel}"
SRC_URI[aarch64_rust-inotify+stream-devel.sha256sum] = "06b215a76b2d855dfb37685b771d83a74dda1aaba178455928c3c340bfad795b"

URI_aarch64_rust-inotify+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+tokio-devel-0.11.2-1.el10_2.noarch.rpm;name=aarch64_rust-inotify+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+tokio-devel}"
SRC_URI[aarch64_rust-inotify+tokio-devel.sha256sum] = "45f9ec4a21c14264367f93960341faa05f506cf9f496229d320cb34ca2763509"

URI_aarch64_rust-inotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify-devel-0.11.2-1.el10_2.noarch.rpm;name=aarch64_rust-inotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify-devel}"
SRC_URI[aarch64_rust-inotify-devel.sha256sum] = "4c7d11379148ac77f29eb8024669ce6cb2cbfed87067b2b3f4dc6c1456364f0f"

RDEPENDS:rust-inotify+default-devel = " \
 cargo \
 rust-inotify+stream-devel \
 rust-inotify-devel \
 "
RDEPENDS:rust-inotify+futures-util-devel = " \
 cargo \
 rust-futures-util+default-devel \
 rust-inotify-devel \
 "
RDEPENDS:rust-inotify+stream-devel = " \
 cargo \
 rust-inotify+futures-util-devel \
 rust-inotify+tokio-devel \
 rust-inotify-devel \
 "
RDEPENDS:rust-inotify+tokio-devel = " \
 cargo \
 rust-inotify-devel \
 rust-tokio+default-devel \
 rust-tokio+net-devel \
 "
RDEPENDS:rust-inotify-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-inotify-sys+default-devel \
 rust-libc+default-devel \
 "
