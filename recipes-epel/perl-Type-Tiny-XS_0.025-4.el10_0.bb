# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Type-Tiny-XS"
PV = "0.025"
PR = "4.el10_0"
PACKAGES = " \
 perl-Type-Tiny-XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Type-Tiny-XS-0.025-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c6c5bd75f107ca545f1b5d513c383adfe3ad83a19b8d5284209424129cfe9f5"

URI_x86_64_v2_perl-Type-Tiny-XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Type-Tiny-XS-0.025-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Type-Tiny-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Type-Tiny-XS}"
SRC_URI[x86_64_v2_perl-Type-Tiny-XS.sha256sum] = "07f87b646fe55bab88e9aba5c0219db16e7681a8a1f269225aceab8e019fc481"

URI_aarch64_perl-Type-Tiny-XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Type-Tiny-XS-0.025-4.el10_0.aarch64.rpm;name=aarch64_perl-Type-Tiny-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Type-Tiny-XS}"
SRC_URI[aarch64_perl-Type-Tiny-XS.sha256sum] = "73f21d12c8daba735e997c3bf9d0e981284dd1e1a08874e8603f8970cdb2b67a"

RDEPENDS:perl-Type-Tiny-XS = " \
 glibc \
 perl-Scalar-List-Utils \
 perl-Type-Tiny-XS \
 perl-libs \
 "
