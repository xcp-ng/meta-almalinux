# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quick-xml"
PV = "0.38.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-quick-xml+arbitrary-devel \
 rust-quick-xml+async-tokio-devel \
 rust-quick-xml+default-devel \
 rust-quick-xml+document-features-devel \
 rust-quick-xml+encoding-devel \
 rust-quick-xml+encoding_rs-devel \
 rust-quick-xml+escape-html-devel \
 rust-quick-xml+overlapped-lists-devel \
 rust-quick-xml+serde-devel \
 rust-quick-xml+serde-types-devel \
 rust-quick-xml+serialize-devel \
 rust-quick-xml+tokio-devel \
 rust-quick-xml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quick-xml-0.38.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4bab75cbe116d67610ac385c37869a73214a8c4264b2498a5bfd6d6db17e53a"

URI_x86_64_v2_rust-quick-xml+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+arbitrary-devel-0.38.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+arbitrary-devel.sha256sum] = "700641cfc9e1f49bb9574bc40ba02272d4702fc5b17674c32c71c1d70b36a1d7"

URI_x86_64_v2_rust-quick-xml+async-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+async-tokio-devel-0.38.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+async-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+async-tokio-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+async-tokio-devel.sha256sum] = "b084ae2aaa0da705cc2ba723ff8607fcd875f74c3bf98f55954d0e3f15a3b492"

URI_x86_64_v2_rust-quick-xml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+default-devel-0.38.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+default-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+default-devel.sha256sum] = "765143190d1456409789a2bea51b873a09687eba4f7abe1c510f2be4e14ea34e"

URI_x86_64_v2_rust-quick-xml+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+document-features-devel-0.38.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+document-features-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+document-features-devel.sha256sum] = "b9a80edc0e176fa008928fbcc7fe60524ed754faace2e2d1c74a6e857ef3164e"

URI_x86_64_v2_rust-quick-xml+encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+encoding-devel-0.38.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+encoding-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+encoding-devel.sha256sum] = "aa9daf4a8f9b8d1ba80f32d2ffb33bc9533a003e9f8d0fd7ce1b5c11e754d92b"

URI_x86_64_v2_rust-quick-xml+encoding_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+encoding_rs-devel-0.38.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+encoding_rs-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+encoding_rs-devel.sha256sum] = "c6a2d1905aac4e2f0c7d87f5d6aaee6660132253b82fbc551090399fe91dde2b"

URI_x86_64_v2_rust-quick-xml+escape-html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+escape-html-devel-0.38.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+escape-html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+escape-html-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+escape-html-devel.sha256sum] = "569523413065e2da5da7e0c82db4ae484b2d282d8e65d0a6793ece346749795a"

URI_x86_64_v2_rust-quick-xml+overlapped-lists-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+overlapped-lists-devel-0.38.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+overlapped-lists-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+overlapped-lists-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+overlapped-lists-devel.sha256sum] = "9b33591a35b1d0faa8f78bc6afb89d4438c7f49d0d7d51300b66847bea46b356"

URI_x86_64_v2_rust-quick-xml+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+serde-devel-0.38.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+serde-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+serde-devel.sha256sum] = "4fa534cef67a79cf11132c29fbf538b6edda38b932918d4c6a42f97bbdd67d55"

URI_x86_64_v2_rust-quick-xml+serde-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+serde-types-devel-0.38.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+serde-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+serde-types-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+serde-types-devel.sha256sum] = "238abf939b91381291cde529419e7afd69dea6e80528ad38f816a7ce2b4348e8"

URI_x86_64_v2_rust-quick-xml+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+serialize-devel-0.38.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+serialize-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+serialize-devel.sha256sum] = "b741ca562933129e39e539d8d79c3899b69ef3b033f5fb865779a60d685356ce"

URI_x86_64_v2_rust-quick-xml+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+tokio-devel-0.38.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+tokio-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+tokio-devel.sha256sum] = "be6ed0e092a86f6ed88f0f4a2e7bf1cb3b28e8744a154b7fc27e1bf70bfefcb5"

URI_x86_64_v2_rust-quick-xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml-devel-0.38.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml-devel}"
SRC_URI[x86_64_v2_rust-quick-xml-devel.sha256sum] = "3589bdd04a2dfb517c1cfc8326f19097bcdfe389515ae86ed89ffff63290eb63"

URI_aarch64_rust-quick-xml+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+arbitrary-devel-0.38.4-1.el10_1.noarch.rpm;name=aarch64_rust-quick-xml+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+arbitrary-devel}"
SRC_URI[aarch64_rust-quick-xml+arbitrary-devel.sha256sum] = "7c02b011bb1053dc9f6a25c5b132f6ba6af5191ae3f132bba6aa14bc4c2f2954"

URI_aarch64_rust-quick-xml+async-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+async-tokio-devel-0.38.4-1.el10_1.noarch.rpm;name=aarch64_rust-quick-xml+async-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+async-tokio-devel}"
SRC_URI[aarch64_rust-quick-xml+async-tokio-devel.sha256sum] = "341c5590a1ddfa2c3dd7b26a10a91ed14051eed5ba71071e0231f6a885946d72"

URI_aarch64_rust-quick-xml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+default-devel-0.38.4-1.el10_1.noarch.rpm;name=aarch64_rust-quick-xml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+default-devel}"
SRC_URI[aarch64_rust-quick-xml+default-devel.sha256sum] = "e369daa482fda3e3dcda8014c569d04d3b2e9145c2eeefee939c698e1d787e22"

URI_aarch64_rust-quick-xml+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+document-features-devel-0.38.4-1.el10_1.noarch.rpm;name=aarch64_rust-quick-xml+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+document-features-devel}"
SRC_URI[aarch64_rust-quick-xml+document-features-devel.sha256sum] = "ec665df2c177288429fb4a9d8622dbc6ab3648e832d30a2bc0303b40fde86b60"

URI_aarch64_rust-quick-xml+encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+encoding-devel-0.38.4-1.el10_1.noarch.rpm;name=aarch64_rust-quick-xml+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+encoding-devel}"
SRC_URI[aarch64_rust-quick-xml+encoding-devel.sha256sum] = "2019c301b15245372b11971d7d3f0521f937d0c23b88955f34f4882f905e2bf5"

URI_aarch64_rust-quick-xml+encoding_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+encoding_rs-devel-0.38.4-1.el10_1.noarch.rpm;name=aarch64_rust-quick-xml+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+encoding_rs-devel}"
SRC_URI[aarch64_rust-quick-xml+encoding_rs-devel.sha256sum] = "54f51828d1c377460f9244f061661b9cbc6bf99f8a5a8c34293942a0ea459a7b"

URI_aarch64_rust-quick-xml+escape-html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+escape-html-devel-0.38.4-1.el10_1.noarch.rpm;name=aarch64_rust-quick-xml+escape-html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+escape-html-devel}"
SRC_URI[aarch64_rust-quick-xml+escape-html-devel.sha256sum] = "d1786b4bfc295333b3eee7bbd6b2a6ebfb00d941acd87c491b5c6985032e9867"

URI_aarch64_rust-quick-xml+overlapped-lists-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+overlapped-lists-devel-0.38.4-1.el10_1.noarch.rpm;name=aarch64_rust-quick-xml+overlapped-lists-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+overlapped-lists-devel}"
SRC_URI[aarch64_rust-quick-xml+overlapped-lists-devel.sha256sum] = "0c63d16e5db548c3d31bc3a2f39f00c88022e909271d6849a2aff0f06642f258"

URI_aarch64_rust-quick-xml+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+serde-devel-0.38.4-1.el10_1.noarch.rpm;name=aarch64_rust-quick-xml+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+serde-devel}"
SRC_URI[aarch64_rust-quick-xml+serde-devel.sha256sum] = "12302bda656717874b010fc89cd72c4023ebd6a42e151c88ae813bfd597ea117"

URI_aarch64_rust-quick-xml+serde-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+serde-types-devel-0.38.4-1.el10_1.noarch.rpm;name=aarch64_rust-quick-xml+serde-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+serde-types-devel}"
SRC_URI[aarch64_rust-quick-xml+serde-types-devel.sha256sum] = "1f05d0becb1bfaebc9a0a4522b12d4c95d0f45b4bd2e676c7ed7773c33ef4e3a"

URI_aarch64_rust-quick-xml+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+serialize-devel-0.38.4-1.el10_1.noarch.rpm;name=aarch64_rust-quick-xml+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+serialize-devel}"
SRC_URI[aarch64_rust-quick-xml+serialize-devel.sha256sum] = "f394552ddc88f4d5e382c57be26d24352712ea51f79b6c7213fdf45b2af2ac38"

URI_aarch64_rust-quick-xml+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+tokio-devel-0.38.4-1.el10_1.noarch.rpm;name=aarch64_rust-quick-xml+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+tokio-devel}"
SRC_URI[aarch64_rust-quick-xml+tokio-devel.sha256sum] = "d7360baa16ace31fd06675f96257911477add6b88e9f2929c8a0809fb562629b"

URI_aarch64_rust-quick-xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml-devel-0.38.4-1.el10_1.noarch.rpm;name=aarch64_rust-quick-xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml-devel}"
SRC_URI[aarch64_rust-quick-xml-devel.sha256sum] = "3476a772dd991111c6e6116091f50cb8aabf26bcc6c18101cfae6cfa6c5ebd70"

RDEPENDS:rust-quick-xml+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+async-tokio-devel = " \
 cargo \
 rust-quick-xml+tokio-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+default-devel = " \
 cargo \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+encoding-devel = " \
 cargo \
 rust-quick-xml+encoding_rs-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+encoding_rs-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+escape-html-devel = " \
 cargo \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+overlapped-lists-devel = " \
 cargo \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+serde-devel = " \
 cargo \
 rust-quick-xml-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-quick-xml+serde-types-devel = " \
 cargo \
 rust-quick-xml-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-quick-xml+serialize-devel = " \
 cargo \
 rust-quick-xml+serde-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+tokio-devel = " \
 cargo \
 rust-quick-xml-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-quick-xml-devel = " \
 cargo \
 rust \
 rust-memchr+default-devel \
 "
