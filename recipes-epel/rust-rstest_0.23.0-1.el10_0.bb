# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rstest"
PV = "0.23.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-rstest+async-timeout-devel \
 rust-rstest+crate-name-devel \
 rust-rstest+default-devel \
 rust-rstest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rstest-0.23.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbf851732b4a56cb79f0c3ed4574838f5a49e0661bf1a41a534e119a0a195958"

URI_x86_64_v2_rust-rstest+async-timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest+async-timeout-devel-0.23.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest+async-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest+async-timeout-devel}"
SRC_URI[x86_64_v2_rust-rstest+async-timeout-devel.sha256sum] = "18ef804359bbfb74c92209a9dceb8efc0956f3868d8e4c1746766a8ac0ea9615"

URI_x86_64_v2_rust-rstest+crate-name-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest+crate-name-devel-0.23.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest+crate-name-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest+crate-name-devel}"
SRC_URI[x86_64_v2_rust-rstest+crate-name-devel.sha256sum] = "b33ab16b70a7d23a09367639ac4e6408e1790a8069fd3fec0c0440f7a077636f"

URI_x86_64_v2_rust-rstest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest+default-devel-0.23.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest+default-devel}"
SRC_URI[x86_64_v2_rust-rstest+default-devel.sha256sum] = "0a5c8f68bb4220377bb52606b5a945fabadd3f4e9445106182d14963e4242b10"

URI_x86_64_v2_rust-rstest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest-devel-0.23.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest-devel}"
SRC_URI[x86_64_v2_rust-rstest-devel.sha256sum] = "7bdce1493ab8a98073046300fec75bd6923fea5058d96d2c9df8f3ac8e1e5a6d"

URI_aarch64_rust-rstest+async-timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest+async-timeout-devel-0.23.0-1.el10_0.noarch.rpm;name=aarch64_rust-rstest+async-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest+async-timeout-devel}"
SRC_URI[aarch64_rust-rstest+async-timeout-devel.sha256sum] = "1495f12eb525a67f96a82d38d85a4e0962a0c865e669a3ae32e85c33615d009d"

URI_aarch64_rust-rstest+crate-name-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest+crate-name-devel-0.23.0-1.el10_0.noarch.rpm;name=aarch64_rust-rstest+crate-name-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest+crate-name-devel}"
SRC_URI[aarch64_rust-rstest+crate-name-devel.sha256sum] = "abde54d4529bf3f2d1ec4c111e337c9ab9c0f1364f4fed08b52197a3b8988a3d"

URI_aarch64_rust-rstest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest+default-devel-0.23.0-1.el10_0.noarch.rpm;name=aarch64_rust-rstest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest+default-devel}"
SRC_URI[aarch64_rust-rstest+default-devel.sha256sum] = "cec1e0cca18b39dde79c436b852df061ef42222f836c2dd76be46d0a4435de34"

URI_aarch64_rust-rstest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest-devel-0.23.0-1.el10_0.noarch.rpm;name=aarch64_rust-rstest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest-devel}"
SRC_URI[aarch64_rust-rstest-devel.sha256sum] = "7efc663b480b2eb6b5be24bac84c48dbe4d57d38f344e5bd0838677dea0a9905"

RDEPENDS:rust-rstest+async-timeout-devel = " \
 cargo \
 rust-futures+default-devel \
 rust-futures-timer+default-devel \
 rust-rstest-devel \
 rust-rstest_macros+async-timeout-devel \
 "
RDEPENDS:rust-rstest+crate-name-devel = " \
 cargo \
 rust-rstest-devel \
 rust-rstest_macros+crate-name-devel \
 "
RDEPENDS:rust-rstest+default-devel = " \
 cargo \
 rust-rstest+async-timeout-devel \
 rust-rstest+crate-name-devel \
 rust-rstest-devel \
 "
RDEPENDS:rust-rstest-devel = " \
 cargo \
 rust \
 rust-rstest_macros-devel \
 rust-rustc_version+default-devel \
 "
