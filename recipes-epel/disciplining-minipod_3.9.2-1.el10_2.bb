# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "disciplining-minipod"
PV = "3.9.2"
PR = "1.el10_2"
PACKAGES = " \
 liboscillator-disciplining \
 liboscillator-disciplining-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/disciplining-minipod-3.9.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbc0da80943ab03307501f2eab4b14ffdaa8aee1c0f96e5d7f3bc5627f6b70ac"

URI_x86_64_v2_liboscillator-disciplining = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liboscillator-disciplining-3.9.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liboscillator-disciplining;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liboscillator-disciplining}"
SRC_URI[x86_64_v2_liboscillator-disciplining.sha256sum] = "d9394aa4b3db3162b4d67e913c311efc02c4f89a787cae8e6bfe00bbc7d13604"

URI_x86_64_v2_liboscillator-disciplining-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liboscillator-disciplining-devel-3.9.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liboscillator-disciplining-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liboscillator-disciplining-devel}"
SRC_URI[x86_64_v2_liboscillator-disciplining-devel.sha256sum] = "4cac800a9399ad78c1628f13a0037ac068694280b0e1eccc2fd30d5ef4b0079d"

URI_aarch64_liboscillator-disciplining = "${EPEL_MIRROR}/aarch64/Packages/l/liboscillator-disciplining-3.9.2-1.el10_2.aarch64.rpm;name=aarch64_liboscillator-disciplining;unpack=0"
SRC_URI:append = " ${URI_aarch64_liboscillator-disciplining}"
SRC_URI[aarch64_liboscillator-disciplining.sha256sum] = "8a3a30675013ef213259792e53a9df323add17a3fa1b606c8d1a4a486b9a1c85"

URI_aarch64_liboscillator-disciplining-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liboscillator-disciplining-devel-3.9.2-1.el10_2.aarch64.rpm;name=aarch64_liboscillator-disciplining-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liboscillator-disciplining-devel}"
SRC_URI[aarch64_liboscillator-disciplining-devel.sha256sum] = "a5f81bbbd374f2a5ac8ac1f25b6abd52fc06cd19866ade35e14a9eace2ac2fbe"

RDEPENDS:liboscillator-disciplining = " \
 glibc \
 "
RDEPENDS:liboscillator-disciplining-devel = " \
 liboscillator-disciplining \
 pkgconf-pkg-config \
 "
