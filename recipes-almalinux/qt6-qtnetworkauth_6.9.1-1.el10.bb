# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtnetworkauth"
PV = "6.9.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtnetworkauth \
 qt6-qtnetworkauth-devel \
 qt6-qtnetworkauth-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtnetworkauth-6.9.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f78db887c12dabda098bf812899a65387b3a390d59bef4471dc5d2e469f93f6f"

URI_x86_64_v2_qt6-qtnetworkauth = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtnetworkauth-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtnetworkauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtnetworkauth}"
SRC_URI[x86_64_v2_qt6-qtnetworkauth.sha256sum] = "a05811f059c6fdcd54c547313f8bba46fe4a4a485821e4b5184c82a7b1418126"

URI_x86_64_v2_qt6-qtnetworkauth-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtnetworkauth-devel-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtnetworkauth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtnetworkauth-devel}"
SRC_URI[x86_64_v2_qt6-qtnetworkauth-devel.sha256sum] = "2a501f1eb0c6bff68c5a660704573ac8e77da12e3ce814fc3ee40df4713b5704"

URI_x86_64_v2_qt6-qtnetworkauth-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtnetworkauth-examples-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtnetworkauth-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtnetworkauth-examples}"
SRC_URI[x86_64_v2_qt6-qtnetworkauth-examples.sha256sum] = "568d6cec7963440f5036a6fc70dec5323cec17984167a5c70b8322401c1af3e8"

URI_aarch64_qt6-qtnetworkauth = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtnetworkauth-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtnetworkauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtnetworkauth}"
SRC_URI[aarch64_qt6-qtnetworkauth.sha256sum] = "37bedb3271e9f37ac15e5ffaaf415740887522a3a7b5fc8c69cf44ad8a5c133b"

URI_aarch64_qt6-qtnetworkauth-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtnetworkauth-devel-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtnetworkauth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtnetworkauth-devel}"
SRC_URI[aarch64_qt6-qtnetworkauth-devel.sha256sum] = "51cf4da79b978e5fffbe0f2a601335eb6887e11e497770f1faca021afbfef2d5"

URI_aarch64_qt6-qtnetworkauth-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtnetworkauth-examples-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtnetworkauth-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtnetworkauth-examples}"
SRC_URI[aarch64_qt6-qtnetworkauth-examples.sha256sum] = "92f73c000e23639bd5ec3b30f2486f190ba72c9565c7ee9c67c30b972ffccb66"

RDEPENDS:qt6-qtnetworkauth = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:qt6-qtnetworkauth-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtnetworkauth \
 "
RDEPENDS:qt6-qtnetworkauth-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtnetworkauth \
 "
