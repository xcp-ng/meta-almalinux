# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-totp-lite"
PV = "2.0.1"
PR = "3.el10_1"
PACKAGES = " \
 rust-totp-lite+default-devel \
 rust-totp-lite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-totp-lite-2.0.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fa1118aa7e0969e4352838488ece334c5751f01f31b27cee6a102c2195c24c2"

URI_x86_64_v2_rust-totp-lite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-totp-lite+default-devel-2.0.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-totp-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-totp-lite+default-devel}"
SRC_URI[x86_64_v2_rust-totp-lite+default-devel.sha256sum] = "ee03d3b9ff857d1214ea956072ac77a864ec22291d88b52418041257b44badfe"

URI_x86_64_v2_rust-totp-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-totp-lite-devel-2.0.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-totp-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-totp-lite-devel}"
SRC_URI[x86_64_v2_rust-totp-lite-devel.sha256sum] = "c218ba350403721d9a2abf5c3db37bfc3b0a4d15fb86e8edecdd57cd153bbfd6"

URI_aarch64_rust-totp-lite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-totp-lite+default-devel-2.0.1-3.el10_1.noarch.rpm;name=aarch64_rust-totp-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-totp-lite+default-devel}"
SRC_URI[aarch64_rust-totp-lite+default-devel.sha256sum] = "5b0c1c89dc2f51147c38d9ff004f9b3e56c241811bf9fbcca8ab9493496498bb"

URI_aarch64_rust-totp-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-totp-lite-devel-2.0.1-3.el10_1.noarch.rpm;name=aarch64_rust-totp-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-totp-lite-devel}"
SRC_URI[aarch64_rust-totp-lite-devel.sha256sum] = "fbd400d4bad13d92d673ea438b8656f14a3df08333021015978fd4439399b4ec"

RDEPENDS:rust-totp-lite+default-devel = " \
 cargo \
 rust-totp-lite-devel \
 "
RDEPENDS:rust-totp-lite-devel = " \
 cargo \
 rust-digest+default-devel \
 rust-hmac+default-devel \
 rust-sha1+default-devel \
 rust-sha2+default-devel \
 "
