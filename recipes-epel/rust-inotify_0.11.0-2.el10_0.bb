# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-inotify"
PV = "0.11.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-inotify+default-devel \
 rust-inotify+futures-core-devel \
 rust-inotify+stream-devel \
 rust-inotify+tokio-devel \
 rust-inotify-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-inotify-0.11.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "871c6e06c77357f90e7fa2797c0edc9a347ffc06c74bcaf4c5023ff2c24492b8"

URI_x86_64_v2_rust-inotify+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+default-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+default-devel}"
SRC_URI[x86_64_v2_rust-inotify+default-devel.sha256sum] = "32e7f054721d6e59732ffc8ceea29d73d9ee560f2997bc627eeb299e0577af5a"

URI_x86_64_v2_rust-inotify+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+futures-core-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+futures-core-devel}"
SRC_URI[x86_64_v2_rust-inotify+futures-core-devel.sha256sum] = "f62631bb71d6a0d7391e09c2b7767f9fe1bb4c8e975e34ee6149354ee95f0ec9"

URI_x86_64_v2_rust-inotify+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+stream-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+stream-devel}"
SRC_URI[x86_64_v2_rust-inotify+stream-devel.sha256sum] = "c94260afc89ffc7ea21290b0a513a7f7fc499382fd9346ea02039b1a81756604"

URI_x86_64_v2_rust-inotify+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+tokio-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+tokio-devel}"
SRC_URI[x86_64_v2_rust-inotify+tokio-devel.sha256sum] = "3fdd83776004bc9d603b33a218ba666483be92f965a07d57b9a73713a7f5296c"

URI_x86_64_v2_rust-inotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify-devel}"
SRC_URI[x86_64_v2_rust-inotify-devel.sha256sum] = "cf77830288f6537ece966b48699f4166986f0b104a2c835e8e4c21379d63a339"

URI_aarch64_rust-inotify+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+default-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-inotify+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+default-devel}"
SRC_URI[aarch64_rust-inotify+default-devel.sha256sum] = "6ffc1bd558ced5279a129c168ab087881bcfb804f218f4f730ca7df8fbc01b79"

URI_aarch64_rust-inotify+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+futures-core-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-inotify+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+futures-core-devel}"
SRC_URI[aarch64_rust-inotify+futures-core-devel.sha256sum] = "d3d6aae94d0a116398e264fc973b4a94e2191472959598183f627dcbf135eab3"

URI_aarch64_rust-inotify+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+stream-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-inotify+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+stream-devel}"
SRC_URI[aarch64_rust-inotify+stream-devel.sha256sum] = "17efac7a8e6cf45bd063d9722305fcd6a42aa298704e670995bd8899c34de811"

URI_aarch64_rust-inotify+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+tokio-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-inotify+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+tokio-devel}"
SRC_URI[aarch64_rust-inotify+tokio-devel.sha256sum] = "5c98fd1195e332eb753bc2eda3712f33fcc7177102b79899b93239e36dc1c441"

URI_aarch64_rust-inotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-inotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify-devel}"
SRC_URI[aarch64_rust-inotify-devel.sha256sum] = "e69a4de9c65d6f0a99acb6453622177f65963160965e387f55134ede7f0bece7"

RDEPENDS:rust-inotify+default-devel = " \
 cargo \
 rust-inotify+stream-devel \
 rust-inotify-devel \
 "
RDEPENDS:rust-inotify+futures-core-devel = " \
 cargo \
 rust-futures-core+default-devel \
 rust-inotify-devel \
 "
RDEPENDS:rust-inotify+stream-devel = " \
 cargo \
 rust-inotify+futures-core-devel \
 rust-inotify+tokio-devel \
 rust-inotify-devel \
 "
RDEPENDS:rust-inotify+tokio-devel = " \
 cargo \
 rust-inotify-devel \
 rust-tokio+default-devel \
 rust-tokio+net-devel \
 "
RDEPENDS:rust-inotify-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-inotify-sys+default-devel \
 rust-libc+default-devel \
 "
