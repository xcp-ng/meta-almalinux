# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-activities-stats"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 plasma-activities-stats \
 plasma-activities-stats-devel \
 plasma-activities-stats-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-activities-stats-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e0331922a01c1925896ba5344c5f2e602ad424ac35e044379f3532e3a47f771"

URI_x86_64_v2_plasma-activities-stats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-stats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-stats}"
SRC_URI[x86_64_v2_plasma-activities-stats.sha256sum] = "4102b868880939f70da4f6af132c08579963e3a6f7158d0b00a21d531502f5d9"

URI_x86_64_v2_plasma-activities-stats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-devel-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-stats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-stats-devel}"
SRC_URI[x86_64_v2_plasma-activities-stats-devel.sha256sum] = "622d258d555c48dcd8f5d66bbe0ca55d858c2434afafd5cb60be6b929b7cd9a8"

URI_x86_64_v2_plasma-activities-stats-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-doc-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-activities-stats-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-stats-doc}"
SRC_URI[x86_64_v2_plasma-activities-stats-doc.sha256sum] = "da4208f62005ab0cf35686762a805247bcbb5b258141bb0a5fa9c567187aaa9e"

URI_aarch64_plasma-activities-stats = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-activities-stats;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-stats}"
SRC_URI[aarch64_plasma-activities-stats.sha256sum] = "09c45f0658905e578b2024c1b8b010e2bdd8a70ee00c9f6e29aecdc00b582ec9"

URI_aarch64_plasma-activities-stats-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-devel-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-activities-stats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-stats-devel}"
SRC_URI[aarch64_plasma-activities-stats-devel.sha256sum] = "0f9c73d74f3d24a3c03aaae4e37725d7552f717742895fa7ccabcf85524b3218"

URI_aarch64_plasma-activities-stats-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-doc-6.4.5-1.el10_1.noarch.rpm;name=aarch64_plasma-activities-stats-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-stats-doc}"
SRC_URI[aarch64_plasma-activities-stats-doc.sha256sum] = "60c4da970ff2eef7e8094c37398b1323a00ecd4c00b8274bf61502ad85baf6cb"

RDEPENDS:plasma-activities-stats = " \
 glibc \
 kf6-kconfig \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 "
RDEPENDS:plasma-activities-stats-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 plasma-activities-stats \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma-activities-stats-doc = " \
 "
