# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fat-macho"
PV = "0.4.12"
PR = "1.el10_3"
PACKAGES = " \
 rust-fat-macho+bitcode-devel \
 rust-fat-macho+default-devel \
 rust-fat-macho+llvm-bitcode-devel \
 rust-fat-macho-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-fat-macho-0.4.12-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9f40463e38bb661d6625a227fda6b79af147632c7aff56d5e6b5b89a02144ef0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+bitcode-devel-0.4.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+bitcode-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fat-macho+bitcode-devel.sha256sum] = "cdc12bdc4825e6f785218f4d270715240f9416e63f6164fdba53878730529420"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+default-devel-0.4.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fat-macho+default-devel.sha256sum] = "1fa8f164c556c338ad6a23c2a583fb55c0825fe6d3b2642ffb41036a9bc9e75e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+llvm-bitcode-devel-0.4.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+llvm-bitcode-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fat-macho+llvm-bitcode-devel.sha256sum] = "3a1fed68c575ad13e99e76a9cc9bf6dece7e3763019df7a4c8d6c8aa799ab494"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho-devel-0.4.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fat-macho-devel.sha256sum] = "54597a6ff5711b272708c6c37b9047363ac15959d02190720b8239cf291888fd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+bitcode-devel-0.4.12-1.el10_3.noarch.rpm;name=aarch64_rust-fat-macho+bitcode-devel;unpack=0"
SRC_URI[aarch64_rust-fat-macho+bitcode-devel.sha256sum] = "ed27906275600733a504e51383328dd6e8c3c9942deddd279b13d325d3a3ac32"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+default-devel-0.4.12-1.el10_3.noarch.rpm;name=aarch64_rust-fat-macho+default-devel;unpack=0"
SRC_URI[aarch64_rust-fat-macho+default-devel.sha256sum] = "7d1ac2e9c184e5c13d4e14b29ff1ed735d6b84a8ce230412b5f3e0b47cefc5a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+llvm-bitcode-devel-0.4.12-1.el10_3.noarch.rpm;name=aarch64_rust-fat-macho+llvm-bitcode-devel;unpack=0"
SRC_URI[aarch64_rust-fat-macho+llvm-bitcode-devel.sha256sum] = "7de2af48a1a0d6466c2d105596912e689cabe063eef136634e6fb3a83f4766b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho-devel-0.4.12-1.el10_3.noarch.rpm;name=aarch64_rust-fat-macho-devel;unpack=0"
SRC_URI[aarch64_rust-fat-macho-devel.sha256sum] = "7f79fbc8be4c523863232f8f63403d9f83700b837725bd42bbaa7f766fc26307"

RDEPENDS:rust-fat-macho+bitcode-devel = " \
 cargo \
 rust-fat-macho+llvm-bitcode-devel \
 rust-fat-macho-devel \
 "
RDEPENDS:rust-fat-macho+default-devel = " \
 cargo \
 rust-fat-macho+bitcode-devel \
 rust-fat-macho-devel \
 "
RDEPENDS:rust-fat-macho+llvm-bitcode-devel = " \
 cargo \
 rust-fat-macho-devel \
 rust-llvm-bitcode+default-devel \
 "
RDEPENDS:rust-fat-macho-devel = " \
 cargo \
 rust-goblin+default-devel \
 "
