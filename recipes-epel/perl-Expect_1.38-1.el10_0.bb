# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Expect"
PV = "1.38"
PR = "1.el10_0"
PACKAGES = " \
 perl-Expect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Expect-1.38-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d31dab18527ab7d651f9c0411437621b0af6d4ff99bece342998560c301e58c"

URI_x86_64_v2_perl-Expect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Expect-1.38-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Expect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Expect}"
SRC_URI[x86_64_v2_perl-Expect.sha256sum] = "de1e0472962efd332aed8d59bfc13855352ab99c8ed534b8d6bdd5f9afe15c57"

URI_aarch64_perl-Expect = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Expect-1.38-1.el10_0.noarch.rpm;name=aarch64_perl-Expect;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Expect}"
SRC_URI[aarch64_perl-Expect.sha256sum] = "396ec670bd21540d9a4426ea809ed728d7c782ea07b0beb49c6dd8c7029f188f"

RDEPENDS:perl-Expect = " \
 perl-Carp \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-IO \
 perl-IO-Tty \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-vars \
 "
