# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit"
PV = "356.3"
PR = "1.el10_2"
PACKAGES = " \
 cockpit \
 cockpit-bridge \
 cockpit-doc \
 cockpit-packagekit \
 cockpit-storaged \
 cockpit-system \
 cockpit-ws \
 cockpit-ws-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cockpit-356.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "de10ab670dab24067b101a787bbc5cc03a4392ad6024229593b09a8fdc4f5419"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-356.3-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_cockpit;unpack=0"
SRC_URI[x86_64_v2_cockpit.sha256sum] = "dcc34497a34fca457d5af52113f36ec43e50de33cff99583dc554239f415445f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-bridge-356.3-1.el10_2.noarch.rpm;name=x86_64_v2_cockpit-bridge;unpack=0"
SRC_URI[x86_64_v2_cockpit-bridge.sha256sum] = "fe0eb843054e9c7db1f9d83adc96b62f4ce22e420396db45f24266423d571d29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-doc-356.3-1.el10_2.noarch.rpm;name=x86_64_v2_cockpit-doc;unpack=0"
SRC_URI[x86_64_v2_cockpit-doc.sha256sum] = "b13b24341977e34a90cb2688ff7d0de7e98fe71370e3d79c52edab666214e1f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-packagekit-356.3-1.el10_2.noarch.rpm;name=x86_64_v2_cockpit-packagekit;unpack=0"
SRC_URI[x86_64_v2_cockpit-packagekit.sha256sum] = "edcf10f41eded163fe200f7a2dfd5f014a0f6769a98946aed6f19d127b83d402"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-storaged-356.3-1.el10_2.noarch.rpm;name=x86_64_v2_cockpit-storaged;unpack=0"
SRC_URI[x86_64_v2_cockpit-storaged.sha256sum] = "314d864699f744ac2d861dffb716f0a1daff7831058c5e9cfd88bbbb6a74a237"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-system-356.3-1.el10_2.noarch.rpm;name=x86_64_v2_cockpit-system;unpack=0"
SRC_URI[x86_64_v2_cockpit-system.sha256sum] = "c5271d50c1b16687b7625988bc0e80297ec9e255cd59d42a83936dfcd18a4327"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-ws-356.3-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_cockpit-ws;unpack=0"
SRC_URI[x86_64_v2_cockpit-ws.sha256sum] = "c5bf58dd9a70f9254565f382893eab3b9b5845873d610dcf79694e8791488b3a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-ws-selinux-356.3-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_cockpit-ws-selinux;unpack=0"
SRC_URI[x86_64_v2_cockpit-ws-selinux.sha256sum] = "8ab860960e09b27cfdd0646eca597b36d8b0ded7ea3a6755e557866700088352"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-356.3-1.el10_2.aarch64.rpm;name=aarch64_cockpit;unpack=0"
SRC_URI[aarch64_cockpit.sha256sum] = "7d870eadd3c67083eba757ee4116e490d1750215ec2b729ff600876da7e04fbc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-bridge-356.3-1.el10_2.noarch.rpm;name=aarch64_cockpit-bridge;unpack=0"
SRC_URI[aarch64_cockpit-bridge.sha256sum] = "fe0eb843054e9c7db1f9d83adc96b62f4ce22e420396db45f24266423d571d29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-doc-356.3-1.el10_2.noarch.rpm;name=aarch64_cockpit-doc;unpack=0"
SRC_URI[aarch64_cockpit-doc.sha256sum] = "b13b24341977e34a90cb2688ff7d0de7e98fe71370e3d79c52edab666214e1f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-packagekit-356.3-1.el10_2.noarch.rpm;name=aarch64_cockpit-packagekit;unpack=0"
SRC_URI[aarch64_cockpit-packagekit.sha256sum] = "edcf10f41eded163fe200f7a2dfd5f014a0f6769a98946aed6f19d127b83d402"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-storaged-356.3-1.el10_2.noarch.rpm;name=aarch64_cockpit-storaged;unpack=0"
SRC_URI[aarch64_cockpit-storaged.sha256sum] = "314d864699f744ac2d861dffb716f0a1daff7831058c5e9cfd88bbbb6a74a237"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-system-356.3-1.el10_2.noarch.rpm;name=aarch64_cockpit-system;unpack=0"
SRC_URI[aarch64_cockpit-system.sha256sum] = "c5271d50c1b16687b7625988bc0e80297ec9e255cd59d42a83936dfcd18a4327"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-ws-356.3-1.el10_2.aarch64.rpm;name=aarch64_cockpit-ws;unpack=0"
SRC_URI[aarch64_cockpit-ws.sha256sum] = "27a242f7b316957af651d61bf81c2d3ae11fdba8d04b810156de6601976237e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-ws-selinux-356.3-1.el10_2.aarch64.rpm;name=aarch64_cockpit-ws-selinux;unpack=0"
SRC_URI[aarch64_cockpit-ws-selinux.sha256sum] = "a6f7a29fe09174f77bb806dbf19fef94ae035d6e46752290aa839c17495d56f8"

RDEPENDS:cockpit = " \
 cockpit-bridge \
 cockpit-system \
 cockpit-ws \
 "
RDEPENDS:cockpit-bridge = " \
 python3 \
 "
RDEPENDS:cockpit-doc = " \
 "
RDEPENDS:cockpit-packagekit = " \
 PackageKit \
 cockpit-bridge \
 polkit \
 "
RDEPENDS:cockpit-storaged = " \
 bash \
 cockpit-system \
 python3 \
 python3-dbus \
 udisks2 \
 "
RDEPENDS:cockpit-system = " \
 NetworkManager \
 cockpit-bridge \
 grep \
 libpwquality \
 shadow-utils \
 sos \
 sudo \
 virtual//usr/bin/date \
 "
RDEPENDS:cockpit-ws = " \
 bash \
 cockpit-ws-selinux \
 glib2 \
 glibc \
 gnutls \
 json-glib \
 krb5-libs \
 libgcc \
 openssl \
 pam-libs \
 systemd-libs \
 "
RDEPENDS:cockpit-ws-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 selinux-policy-targeted \
 "
