# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtermkey"
PV = "0.22"
PR = "2.el10_0"
PACKAGES = " \
 libtermkey \
 libtermkey-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libtermkey-0.22-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a5f62eaccd1676ee09b98f3084bd063239b04b98e6ff1d059bc240291bf2186"

URI_x86_64_v2_libtermkey = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtermkey-0.22-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtermkey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtermkey}"
SRC_URI[x86_64_v2_libtermkey.sha256sum] = "c44cafeaa5e5b1cf6cae451205d009ddf228f05d7713e234c86cd273dea6af5b"

URI_x86_64_v2_libtermkey-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtermkey-devel-0.22-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtermkey-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtermkey-devel}"
SRC_URI[x86_64_v2_libtermkey-devel.sha256sum] = "3faa4c15ee9c7f215ab76e32279ccaaa55227276f4892a9f3d6900356e3e6a07"

URI_aarch64_libtermkey = "${EPEL_MIRROR}/aarch64/Packages/l/libtermkey-0.22-2.el10_0.aarch64.rpm;name=aarch64_libtermkey;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtermkey}"
SRC_URI[aarch64_libtermkey.sha256sum] = "054c9cd7b8e1a2c6f7664f13c8cec2e0b978e702f0e85200d83b49d58f804569"

URI_aarch64_libtermkey-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libtermkey-devel-0.22-2.el10_0.aarch64.rpm;name=aarch64_libtermkey-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtermkey-devel}"
SRC_URI[aarch64_libtermkey-devel.sha256sum] = "1b91eccbcca0ff3759e114a1f25b1e6e3de6f374e97c201a5a79af6a23d3501a"

RDEPENDS:libtermkey = " \
 glibc \
 unibilium \
 "
RDEPENDS:libtermkey-devel = " \
 libtermkey \
 pkgconf-pkg-config \
 "
