# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bpfilter"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 bpfilter \
 bpfilter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bpfilter-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a6f2e7cd01c5c75f8b5843c711d4b9eeee51547da6640ae4185926cde38f8ea"

URI_x86_64_v2_bpfilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bpfilter-0.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bpfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bpfilter}"
SRC_URI[x86_64_v2_bpfilter.sha256sum] = "e79e7c09a29457c70800bb98a69f2e593b424add49742e82e36645956e23ff5b"

URI_x86_64_v2_bpfilter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bpfilter-devel-0.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bpfilter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bpfilter-devel}"
SRC_URI[x86_64_v2_bpfilter-devel.sha256sum] = "b4e0ee5ac20d04ea6213534f79f30826a83066b01872f7c04b8e107c9bbeed27"

URI_aarch64_bpfilter = "${EPEL_MIRROR}/aarch64/Packages/b/bpfilter-0.6.0-1.el10_2.aarch64.rpm;name=aarch64_bpfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_bpfilter}"
SRC_URI[aarch64_bpfilter.sha256sum] = "093ea3f509308d10338504be2ddf16eba6b76f9981a06a96bf6d2ce9cf710e19"

URI_aarch64_bpfilter-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bpfilter-devel-0.6.0-1.el10_2.aarch64.rpm;name=aarch64_bpfilter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bpfilter-devel}"
SRC_URI[aarch64_bpfilter-devel.sha256sum] = "c0bf52694b2e0e1cee2ed05912ac0e6af20b7642b9da55c9703b27b4b3b24390"

RDEPENDS:bpfilter = " \
 bash \
 glibc \
 libbpf \
 libgcc \
 "
RDEPENDS:bpfilter-devel = " \
 bpfilter \
 pkgconf-pkg-config \
 "
