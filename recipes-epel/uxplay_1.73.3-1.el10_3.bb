# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uxplay"
PV = "1.73.3"
PR = "1.el10_3"
PACKAGES = " \
 uxplay \
 uxplay-beacon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uxplay-1.73.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c616f6bcd08259b50c6e65ee28d3c6e684315918a8faa70abcd0215c286477fe"

URI_x86_64_v2_uxplay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uxplay-1.73.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uxplay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uxplay}"
SRC_URI[x86_64_v2_uxplay.sha256sum] = "a5077149d9936f789321a3f85adfc31732acda6770398b6b292c3b62dc099a14"

URI_x86_64_v2_uxplay-beacon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uxplay-beacon-1.73.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uxplay-beacon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uxplay-beacon}"
SRC_URI[x86_64_v2_uxplay-beacon.sha256sum] = "8ccbfd205dbb3a185291dfb5e8ecd4fc71d0ba033c20c28a5a68a1c6ac7fd905"

URI_aarch64_uxplay = "${EPEL_MIRROR}/aarch64/Packages/u/uxplay-1.73.3-1.el10_3.aarch64.rpm;name=aarch64_uxplay;unpack=0"
SRC_URI:append = " ${URI_aarch64_uxplay}"
SRC_URI[aarch64_uxplay.sha256sum] = "774b9488e16cd73d3265566ecb02419f8a4b072217a3dd962f37b162dbb34b01"

URI_aarch64_uxplay-beacon = "${EPEL_MIRROR}/aarch64/Packages/u/uxplay-beacon-1.73.3-1.el10_3.aarch64.rpm;name=aarch64_uxplay-beacon;unpack=0"
SRC_URI:append = " ${URI_aarch64_uxplay-beacon}"
SRC_URI[aarch64_uxplay-beacon.sha256sum] = "f8806e12b2076e422ea8e21f62452d3e3b8fb9cad302f34d44957f9f9c5f94c3"

RDEPENDS:uxplay = " \
 avahi-compat-libdns_sd \
 dbus-libs \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libX11 \
 libgcc \
 libplist \
 libstdc++ \
 llhttp \
 openssl-libs \
 "
RDEPENDS:uxplay-beacon = " \
 python3 \
 python3-gobject \
 python3-psutil \
 "
