# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-zstd"
PV = "0.15.2"
PR = "1.el10_1"
PACKAGES = " \
 php-zstd \
 php-zstd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-zstd-0.15.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "286419d4b0f34a698628317c280f2e127775bb500400cd2edb2880af84284df5"

URI_x86_64_v2_php-zstd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-zstd-0.15.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-zstd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-zstd}"
SRC_URI[x86_64_v2_php-zstd.sha256sum] = "3548d1370158f919e4ad64fc718ebd4a68947e08424e126c801c309b6cc623e4"

URI_x86_64_v2_php-zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-zstd-devel-0.15.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-zstd-devel}"
SRC_URI[x86_64_v2_php-zstd-devel.sha256sum] = "af465d0d456e437eea97d744a1cb7f9b3404abd68fad79157309efca17563423"

URI_aarch64_php-zstd = "${EPEL_MIRROR}/aarch64/Packages/p/php-zstd-0.15.2-1.el10_1.aarch64.rpm;name=aarch64_php-zstd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-zstd}"
SRC_URI[aarch64_php-zstd.sha256sum] = "91c71622671caff05648a22b9c6f996760464d9b93ddbbc3156052bacabcdafc"

URI_aarch64_php-zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-zstd-devel-0.15.2-1.el10_1.aarch64.rpm;name=aarch64_php-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-zstd-devel}"
SRC_URI[aarch64_php-zstd-devel.sha256sum] = "8697af0d79fb037fb3409f2a2638ebb8b7fa2d1c76883f14abc41988ccab263e"

RDEPENDS:php-zstd = " \
 glibc \
 libzstd \
 php-common \
 "
RDEPENDS:php-zstd-devel = " \
 php-devel \
 php-zstd \
 "
