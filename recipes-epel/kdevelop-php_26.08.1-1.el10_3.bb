# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdevelop-php"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdevelop-php \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdevelop-php-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f526cd5c2eacdf8b2d82654d79227d219ab242d2eea14a6e0c33d909bc23083e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdevelop-php-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdevelop-php;unpack=0"
SRC_URI[x86_64_v2_kdevelop-php.sha256sum] = "bb8cd27f78b8df7ec3ba4c7e68e333f9b8f2e9f6814ff28293049f3a0b8f1206"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdevelop-php-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdevelop-php;unpack=0"
SRC_URI[aarch64_kdevelop-php.sha256sum] = "e596bb36e4a9ab5d0c23aa301bc22a93652d5230f18ca09e70bbeb9e1be33bfe"

RDEPENDS:kdevelop-php = " \
 cmake-filesystem \
 glibc \
 kdevelop \
 kdevelop-libs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-threadweaver \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
