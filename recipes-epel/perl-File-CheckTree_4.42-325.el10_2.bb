# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-CheckTree"
PV = "4.42"
PR = "325.el10_2"
PACKAGES = " \
 perl-File-CheckTree \
 perl-File-CheckTree-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-File-CheckTree-4.42-325.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d8f3849ae62bba685d4f69545ea9e011590dd1ac73d048e6b04736e7c5e3aef0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-CheckTree-4.42-325.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-CheckTree;unpack=0"
SRC_URI[x86_64_v2_perl-File-CheckTree.sha256sum] = "fe609c3969e9e76ff0cc7bd72556d7d5f4759cb9bafc777e9dffbc1e30a7a515"
RPROVIDES:perl-File-CheckTree:append:x86_64_v2 = " virtual/perl_File__CheckTree_"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-CheckTree-tests-4.42-325.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-CheckTree-tests;unpack=0"
SRC_URI[x86_64_v2_perl-File-CheckTree-tests.sha256sum] = "3aa58ea5e0623da0e6e02ad4fe76c7cc6434457e85a89b4eb2479940e8a6146a"
RPROVIDES:perl-File-CheckTree-tests:append:x86_64_v2 = " virtual/perl_File__CheckTree_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-File-CheckTree-4.42-325.el10_2.noarch.rpm;name=aarch64_perl-File-CheckTree;unpack=0"
SRC_URI[aarch64_perl-File-CheckTree.sha256sum] = "224c7b95bf33c250a435ae93abc3a388322702653973816b33fb556c0d0057fc"
RPROVIDES:perl-File-CheckTree:append:aarch64 = " virtual/perl_File__CheckTree_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-File-CheckTree-tests-4.42-325.el10_2.noarch.rpm;name=aarch64_perl-File-CheckTree-tests;unpack=0"
SRC_URI[aarch64_perl-File-CheckTree-tests.sha256sum] = "289312da5483ea97a4a71f43889d78d27ada9c7040fc756c091b4eac3d52dde9"
RPROVIDES:perl-File-CheckTree-tests:append:aarch64 = " virtual/perl_File__CheckTree_"

RDEPENDS:perl-File-CheckTree = " \
 perl-Exporter \
 perl-PathTools \
 perl-deprecate \
 perl-if \
 perl-libs \
 "
RDEPENDS:perl-File-CheckTree-tests = " \
 bash \
 perl-Exporter \
 perl-File-CheckTree \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-if \
 perl-interpreter \
 perl-libs \
 perl-overload \
 virtual/perl_File__CheckTree_ \
 "
