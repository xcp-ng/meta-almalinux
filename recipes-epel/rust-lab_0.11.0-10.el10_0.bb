# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lab"
PV = "0.11.0"
PR = "10.el10_0"
PACKAGES = " \
 rust-lab+default-devel \
 rust-lab-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lab-0.11.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2713b9f6e47825306fae5de5d61edda21b904ad7edae69718c42e67aa2950efe"

URI_x86_64_v2_rust-lab+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lab+default-devel-0.11.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lab+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lab+default-devel}"
SRC_URI[x86_64_v2_rust-lab+default-devel.sha256sum] = "d69153d1b1eba79b4ea649ccddef947b5954851c73a6c1b397903d55c536921f"

URI_x86_64_v2_rust-lab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lab-devel-0.11.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lab-devel}"
SRC_URI[x86_64_v2_rust-lab-devel.sha256sum] = "7146bc14882e382dddcbbad1a6681294ba00f780c0e607710892af036bd22ef7"

URI_aarch64_rust-lab+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lab+default-devel-0.11.0-10.el10_0.noarch.rpm;name=aarch64_rust-lab+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lab+default-devel}"
SRC_URI[aarch64_rust-lab+default-devel.sha256sum] = "809333cc22462f4bf527308b143860ad862d46993e0edb61c12190365518560c"

URI_aarch64_rust-lab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lab-devel-0.11.0-10.el10_0.noarch.rpm;name=aarch64_rust-lab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lab-devel}"
SRC_URI[aarch64_rust-lab-devel.sha256sum] = "692de7ff672e7d8b42295edef9f88018a36f2746a510263271c6996994ef779e"

RDEPENDS:rust-lab+default-devel = " \
 cargo \
 rust-lab-devel \
 "
RDEPENDS:rust-lab-devel = " \
 cargo \
 "
