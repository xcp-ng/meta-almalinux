# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cpanel-JSON-XS"
PV = "4.41"
PR = "1.el10_2"
PACKAGES = " \
 perl-Cpanel-JSON-XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Cpanel-JSON-XS-4.41-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f7f52df0850835f1f5490143cc5cb5c64e024ac2f1bbccb541e6dfdaee15b96"

URI_x86_64_v2_perl-Cpanel-JSON-XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cpanel-JSON-XS-4.41-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Cpanel-JSON-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cpanel-JSON-XS}"
SRC_URI[x86_64_v2_perl-Cpanel-JSON-XS.sha256sum] = "a0043901875c63adc6be901e3b9d638ad4889c3de9356eea59e25fade597dacd"

URI_aarch64_perl-Cpanel-JSON-XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cpanel-JSON-XS-4.41-1.el10_2.aarch64.rpm;name=aarch64_perl-Cpanel-JSON-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cpanel-JSON-XS}"
SRC_URI[aarch64_perl-Cpanel-JSON-XS.sha256sum] = "7ed36b76cd3e81cf68fc6edd10e6344a57c051cb9f6bc4689f6764e68808241c"

RDEPENDS:perl-Cpanel-JSON-XS = " \
 glibc \
 perl-Carp \
 perl-Cpanel-JSON-XS \
 perl-Encode \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-overload \
 "
