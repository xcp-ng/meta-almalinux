# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-msgpack"
PV = "3.0.1"
PR = "2.el10_3"
PACKAGES = " \
 php-pecl-msgpack \
 php-pecl-msgpack-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-pecl-msgpack-3.0.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b1a0af6e6fe5aea8284d4fafbba3d298b33e56e0688ea45921d1d9539b32c478"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-msgpack-3.0.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-msgpack;unpack=0"
SRC_URI[x86_64_v2_php-pecl-msgpack.sha256sum] = "e63b45bff6a2da05f2f06aff87ef5aabec33c2f45cddc566f8ebcf6a03c58a61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-msgpack-devel-3.0.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-msgpack-devel;unpack=0"
SRC_URI[x86_64_v2_php-pecl-msgpack-devel.sha256sum] = "6013ec161c992b283a87087895515c154a6004d82e02d8e43699bb90ced7db04"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-msgpack-3.0.1-2.el10_3.aarch64.rpm;name=aarch64_php-pecl-msgpack;unpack=0"
SRC_URI[aarch64_php-pecl-msgpack.sha256sum] = "1b95d3d60809b516480852985f2167ade324319f847d90b9378567fe784f3a50"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-msgpack-devel-3.0.1-2.el10_3.aarch64.rpm;name=aarch64_php-pecl-msgpack-devel;unpack=0"
SRC_URI[aarch64_php-pecl-msgpack-devel.sha256sum] = "abba6df8fece316d8244d0bed3256e8a918c5256cb3b732f7643c34a795ef446"

RDEPENDS:php-pecl-msgpack = " \
 glibc \
 php-common \
 "
RDEPENDS:php-pecl-msgpack-devel = " \
 php-devel \
 php-pecl-msgpack \
 "
