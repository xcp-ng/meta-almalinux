# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-rchardet"
PV = "1.10.0"
PR = "1.el10_2"
PACKAGES = " \
 rubygem-rchardet \
 rubygem-rchardet-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rubygem-rchardet-1.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ab14418665731b86c161e67e60f3f517b6d47bb058095db85eb04be8966f3c8d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-rchardet-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-rchardet;unpack=0"
SRC_URI[x86_64_v2_rubygem-rchardet.sha256sum] = "7506c37b25214757d8a36f86ad60294967679439ffe30687ed41705c49a86c66"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-rchardet-doc-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-rchardet-doc;unpack=0"
SRC_URI[x86_64_v2_rubygem-rchardet-doc.sha256sum] = "a3ca1511969d94f07befc9b24f90ba67fb62a02adb7263e957fd117724cea10b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rubygem-rchardet-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rubygem-rchardet;unpack=0"
SRC_URI[aarch64_rubygem-rchardet.sha256sum] = "a0f3505f5c2db68a3e431585d4fd00a0151510f9fb2ba52603c35c99c6524dda"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rubygem-rchardet-doc-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rubygem-rchardet-doc;unpack=0"
SRC_URI[aarch64_rubygem-rchardet-doc.sha256sum] = "b5304aa3f768c74b272ebd4463e701aad8cf0f33c8c654361a2439adc075e31c"

RDEPENDS:rubygem-rchardet = " \
 rubygems \
 "
RDEPENDS:rubygem-rchardet-doc = " \
 rubygem-rchardet \
 "
