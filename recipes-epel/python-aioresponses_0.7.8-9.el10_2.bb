# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aioresponses"
PV = "0.7.8"
PR = "9.el10_2"
PACKAGES = " \
 python-aioresponses-doc \
 python3-aioresponses \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aioresponses-0.7.8-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "866f20694f3be382c732893db5f7eed93d4752d85c95f7bae12cb0836bdb0abc"

URI_x86_64_v2_python-aioresponses-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-aioresponses-doc-0.7.8-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-aioresponses-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-aioresponses-doc}"
SRC_URI[x86_64_v2_python-aioresponses-doc.sha256sum] = "ab044a0051ee567e6d6f248e73144f8276c87b97756eb363a12b23d4db262b98"

URI_x86_64_v2_python3-aioresponses = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aioresponses-0.7.8-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aioresponses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aioresponses}"
SRC_URI[x86_64_v2_python3-aioresponses.sha256sum] = "500aea17986e608f52b0f5d342d1b6af3c22337ca09c45703752c8c839a98d7f"

URI_aarch64_python-aioresponses-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-aioresponses-doc-0.7.8-9.el10_2.noarch.rpm;name=aarch64_python-aioresponses-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-aioresponses-doc}"
SRC_URI[aarch64_python-aioresponses-doc.sha256sum] = "408bebac73ed4eb504f3414b5ea173a85a00551245954fe45e530071adae411d"

URI_aarch64_python3-aioresponses = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aioresponses-0.7.8-9.el10_2.noarch.rpm;name=aarch64_python3-aioresponses;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aioresponses}"
SRC_URI[aarch64_python3-aioresponses.sha256sum] = "76292e593a684922ec5c20b8c611bbf709a30c89dc1724abc56e4b4f5fbb0a97"

RDEPENDS:python-aioresponses-doc = " \
 python3-aioresponses \
 "
RDEPENDS:python3-aioresponses = " \
 python3 \
 python3-aiohttp \
 python3-packaging \
 "
