# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "t1utils"
PV = "1.42"
PR = "9.el10_0"
PACKAGES = " \
 t1utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/t1utils-1.42-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d0aedacdb2e107c7263361d201b8d319a0973ae4f5ca6a9f57f6c8c578d59bc"

URI_x86_64_v2_t1utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/t1utils-1.42-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_t1utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_t1utils}"
SRC_URI[x86_64_v2_t1utils.sha256sum] = "41abee78e0b8a0c60619b53ee6e4566108da37169b005459b79777b51310226e"

URI_aarch64_t1utils = "${EPEL_MIRROR}/aarch64/Packages/t/t1utils-1.42-9.el10_0.aarch64.rpm;name=aarch64_t1utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_t1utils}"
SRC_URI[aarch64_t1utils.sha256sum] = "8026f2d201bafeeaa861989da78e4237d079273867a55b5ebc899947742966fd"

RDEPENDS:t1utils = " \
 glibc \
 "
