# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-backend"
PV = "0.3.15"
PR = "1.el10_3"
PACKAGES = " \
 rust-wayland-backend+client_system-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-backend+dlopen-devel \
 rust-wayland-backend+libwayland_client_1_23-devel \
 rust-wayland-backend+libwayland_server_1_22-devel \
 rust-wayland-backend+libwayland_server_1_23-devel \
 rust-wayland-backend+log-devel \
 rust-wayland-backend+raw-window-handle-devel \
 rust-wayland-backend+rwh_06-devel \
 rust-wayland-backend+server_system-devel \
 rust-wayland-backend-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-backend-0.3.15-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbb570f9bcdfbbe279690e0cd376ef4d5eea9c46f3a3da6d50725f42cabe55b9"

URI_x86_64_v2_rust-wayland-backend+client_system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+client_system-devel-0.3.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+client_system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+client_system-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+client_system-devel.sha256sum] = "15e7fe6536444519e44785dd7b92777434d0a97957d6ad9e57d90ff74dcc6b7d"

URI_x86_64_v2_rust-wayland-backend+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+default-devel-0.3.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+default-devel.sha256sum] = "aebcf80da8ef3088259146b45974ef3004602161c9c95a9261cdf79f00faebb6"

URI_x86_64_v2_rust-wayland-backend+dlopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+dlopen-devel-0.3.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+dlopen-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+dlopen-devel.sha256sum] = "d5aba7d82347b6020f591cd0e3e45a9b2a1bd62180342ee800d1e62b4b4f8994"

URI_x86_64_v2_rust-wayland-backend+libwayland_client_1_23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+libwayland_client_1_23-devel-0.3.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+libwayland_client_1_23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+libwayland_client_1_23-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+libwayland_client_1_23-devel.sha256sum] = "605332c5660778f0d134d52c2c2ebb860d7efa79e2bba47de1673cce14c5e173"

URI_x86_64_v2_rust-wayland-backend+libwayland_server_1_22-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+libwayland_server_1_22-devel-0.3.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+libwayland_server_1_22-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+libwayland_server_1_22-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+libwayland_server_1_22-devel.sha256sum] = "e1d015eb21ab9ebfe88dcfcf8e64a6b63bd844c5d240b3fc3a021717845a9c3e"

URI_x86_64_v2_rust-wayland-backend+libwayland_server_1_23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+libwayland_server_1_23-devel-0.3.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+libwayland_server_1_23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+libwayland_server_1_23-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+libwayland_server_1_23-devel.sha256sum] = "6efad5189c7f715ec68d7ef596568f642ab68bf899d96d39f91b3db90871f379"

URI_x86_64_v2_rust-wayland-backend+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+log-devel-0.3.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+log-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+log-devel.sha256sum] = "cb93e4576c6d771cd5e490534014641632c241b02db0a4ef403bdf03c96a502b"

URI_x86_64_v2_rust-wayland-backend+raw-window-handle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+raw-window-handle-devel-0.3.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+raw-window-handle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+raw-window-handle-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+raw-window-handle-devel.sha256sum] = "aad1ca82a59280e579b35be01a1e7c2853d9447613e95e2022dea95b9a6ccdec"

URI_x86_64_v2_rust-wayland-backend+rwh_06-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+rwh_06-devel-0.3.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+rwh_06-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+rwh_06-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+rwh_06-devel.sha256sum] = "54d1e4f5fc508a60b56ff65f5ed6981aa98b64ca6169dc08c2430ee22b5f1778"

URI_x86_64_v2_rust-wayland-backend+server_system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+server_system-devel-0.3.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+server_system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+server_system-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+server_system-devel.sha256sum] = "bba2ee1763b2d19d68cceee66679896e6235a828dc67101b2443639763b31ab1"

URI_x86_64_v2_rust-wayland-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend-devel-0.3.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend-devel.sha256sum] = "0334526a8bc8857e0bb58e1101dc4eba126796f27b8f232bce8aa8413971ca06"

URI_aarch64_rust-wayland-backend+client_system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+client_system-devel-0.3.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+client_system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+client_system-devel}"
SRC_URI[aarch64_rust-wayland-backend+client_system-devel.sha256sum] = "70fa7df1801c04884244cf43ad4238871217575077177f747907f4156d4f8d39"

URI_aarch64_rust-wayland-backend+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+default-devel-0.3.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+default-devel}"
SRC_URI[aarch64_rust-wayland-backend+default-devel.sha256sum] = "0feb74f88bb51ef7ebbb37dc7d630e4b4506d052b9517197d04f50507e5518a3"

URI_aarch64_rust-wayland-backend+dlopen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+dlopen-devel-0.3.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+dlopen-devel}"
SRC_URI[aarch64_rust-wayland-backend+dlopen-devel.sha256sum] = "b77cb1db2294ce8b16119e0932f71c9f2891f9ff65a3cf858e81da735beeaa62"

URI_aarch64_rust-wayland-backend+libwayland_client_1_23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+libwayland_client_1_23-devel-0.3.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+libwayland_client_1_23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+libwayland_client_1_23-devel}"
SRC_URI[aarch64_rust-wayland-backend+libwayland_client_1_23-devel.sha256sum] = "a84c01a999fb679966fdc0fb6b8a98247f460486b495e4d315d09bd342514eb5"

URI_aarch64_rust-wayland-backend+libwayland_server_1_22-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+libwayland_server_1_22-devel-0.3.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+libwayland_server_1_22-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+libwayland_server_1_22-devel}"
SRC_URI[aarch64_rust-wayland-backend+libwayland_server_1_22-devel.sha256sum] = "d8e1db96596ec01307f7d134d3fb7e45365fe1c4614bc85e99ae7e251d6d3864"

URI_aarch64_rust-wayland-backend+libwayland_server_1_23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+libwayland_server_1_23-devel-0.3.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+libwayland_server_1_23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+libwayland_server_1_23-devel}"
SRC_URI[aarch64_rust-wayland-backend+libwayland_server_1_23-devel.sha256sum] = "ccfc3a68fb0eaa0f1b9ee6c23bb275c1f8400e5d58f0cea99b27ec08583fc52c"

URI_aarch64_rust-wayland-backend+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+log-devel-0.3.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+log-devel}"
SRC_URI[aarch64_rust-wayland-backend+log-devel.sha256sum] = "14d842a779fb35266541e32ba7b380eaedc3568a3c32552f64e2160646b4dcd3"

URI_aarch64_rust-wayland-backend+raw-window-handle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+raw-window-handle-devel-0.3.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+raw-window-handle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+raw-window-handle-devel}"
SRC_URI[aarch64_rust-wayland-backend+raw-window-handle-devel.sha256sum] = "577e64b4b131a38770ecb976d45e313ef10792fc6416fae041b9ee3d3d91f64c"

URI_aarch64_rust-wayland-backend+rwh_06-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+rwh_06-devel-0.3.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+rwh_06-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+rwh_06-devel}"
SRC_URI[aarch64_rust-wayland-backend+rwh_06-devel.sha256sum] = "c45ee7064c2e0d28da0b32b1e5fa10762086337cc68a06cf4afebd3c206f82b4"

URI_aarch64_rust-wayland-backend+server_system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+server_system-devel-0.3.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+server_system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+server_system-devel}"
SRC_URI[aarch64_rust-wayland-backend+server_system-devel.sha256sum] = "dbf7fa47a52c4716df04d68f7d386aad13cb7e3fbf759266c1a6f9468d96c928"

URI_aarch64_rust-wayland-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend-devel-0.3.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend-devel}"
SRC_URI[aarch64_rust-wayland-backend-devel.sha256sum] = "7487d7d8d60a0b6206c9419ce851276f264af4d4d4b8afdc01cbfd56e5a3b668"

RDEPENDS:rust-wayland-backend+client_system-devel = " \
 cargo \
 rust-scoped-tls+default-devel \
 rust-wayland-backend-devel \
 rust-wayland-sys+client-devel \
 "
RDEPENDS:rust-wayland-backend+default-devel = " \
 cargo \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+dlopen-devel = " \
 cargo \
 rust-wayland-backend-devel \
 rust-wayland-sys+dlopen-devel \
 "
RDEPENDS:rust-wayland-backend+libwayland_client_1_23-devel = " \
 cargo \
 rust-wayland-backend-devel \
 rust-wayland-sys+libwayland_client_1_23-devel \
 "
RDEPENDS:rust-wayland-backend+libwayland_server_1_22-devel = " \
 cargo \
 rust-wayland-backend-devel \
 rust-wayland-sys+libwayland_server_1_22-devel \
 "
RDEPENDS:rust-wayland-backend+libwayland_server_1_23-devel = " \
 cargo \
 rust-wayland-backend+libwayland_server_1_22-devel \
 rust-wayland-backend-devel \
 rust-wayland-sys+libwayland_server_1_23-devel \
 "
RDEPENDS:rust-wayland-backend+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+raw-window-handle-devel = " \
 cargo \
 rust-raw-window-handle0.5+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+rwh_06-devel = " \
 cargo \
 rust-raw-window-handle+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+server_system-devel = " \
 cargo \
 rust-scoped-tls+default-devel \
 rust-wayland-backend-devel \
 rust-wayland-sys+server-devel \
 "
RDEPENDS:rust-wayland-backend-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-downcast-rs1+default-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+process-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 rust-wayland-sys+default-devel \
 "
