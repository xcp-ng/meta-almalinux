# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert_fs"
PV = "1.1.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-assert_fs+color-auto-devel \
 rust-assert_fs+color-devel \
 rust-assert_fs+default-devel \
 rust-assert_fs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-assert_fs-1.1.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19e4cc9e431df571ef5405d522b198cb6ff8bb2f1497a77b9cdb780597bfc130"

URI_x86_64_v2_rust-assert_fs+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs+color-auto-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs+color-auto-devel}"
SRC_URI[x86_64_v2_rust-assert_fs+color-auto-devel.sha256sum] = "8bbd0387c5eaab43fc4a2e74fe0c91c33ce22de0936aac7289e6fb98711cbc75"

URI_x86_64_v2_rust-assert_fs+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs+color-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs+color-devel}"
SRC_URI[x86_64_v2_rust-assert_fs+color-devel.sha256sum] = "9f5646df34052c1b5c0033989e085210d506bf27d90bfd6d4f3bb333e06f9fd7"

URI_x86_64_v2_rust-assert_fs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs+default-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs+default-devel}"
SRC_URI[x86_64_v2_rust-assert_fs+default-devel.sha256sum] = "4e1f0edb8e6c898d7b5ae7a45f0df43ed0f7744389452df8254daf8aec6bde96"

URI_x86_64_v2_rust-assert_fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs-devel}"
SRC_URI[x86_64_v2_rust-assert_fs-devel.sha256sum] = "82c9b42ef8c043dd957af583dc4a507ab5ea055536c5220d28119dfeb7dde6d3"

URI_aarch64_rust-assert_fs+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs+color-auto-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-assert_fs+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs+color-auto-devel}"
SRC_URI[aarch64_rust-assert_fs+color-auto-devel.sha256sum] = "d81c364435ce6845ed18c0400a8399674368167ec41b5eba4b2bb5f829e53f32"

URI_aarch64_rust-assert_fs+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs+color-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-assert_fs+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs+color-devel}"
SRC_URI[aarch64_rust-assert_fs+color-devel.sha256sum] = "5130ca669f0ad9fc6ecd42599eaf966ae5a4b0503be7f9d068d879d14902be4f"

URI_aarch64_rust-assert_fs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs+default-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-assert_fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs+default-devel}"
SRC_URI[aarch64_rust-assert_fs+default-devel.sha256sum] = "b3db7fa6c989c5800e1000e3ad17e8264c4d8578be5853f0f5188781520a1fa6"

URI_aarch64_rust-assert_fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-assert_fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs-devel}"
SRC_URI[aarch64_rust-assert_fs-devel.sha256sum] = "a27117118477056fd6cb4155301365f0e8b0092171a633def0346da4a7f203d3"

RDEPENDS:rust-assert_fs+color-auto-devel = " \
 cargo \
 rust-assert_fs+color-devel \
 rust-assert_fs-devel \
 "
RDEPENDS:rust-assert_fs+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-assert_fs-devel \
 rust-predicates+color-devel \
 "
RDEPENDS:rust-assert_fs+default-devel = " \
 cargo \
 rust-assert_fs-devel \
 "
RDEPENDS:rust-assert_fs-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-globwalk+default-devel \
 rust-predicates+diff-devel \
 rust-predicates-core+default-devel \
 rust-predicates-devel \
 rust-predicates-tree+default-devel \
 rust-tempfile-devel \
 "
