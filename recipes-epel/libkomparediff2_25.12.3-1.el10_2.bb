# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkomparediff2"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 libkomparediff2 \
 libkomparediff2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkomparediff2-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e2ebf8e3b78c5bae5261a1ad14194b239781fef0a6d33526de3b81a42178807"

URI_x86_64_v2_libkomparediff2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkomparediff2-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkomparediff2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkomparediff2}"
SRC_URI[x86_64_v2_libkomparediff2.sha256sum] = "5572decddc97ed713906af33b5ca4f0e22e7ad3eddf5637246a1f6d27c13690c"

URI_x86_64_v2_libkomparediff2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkomparediff2-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkomparediff2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkomparediff2-devel}"
SRC_URI[x86_64_v2_libkomparediff2-devel.sha256sum] = "e33026fd27db23f988fe341fd48603f9b7b8b61b75fbf31732d458b4dba6164c"

URI_aarch64_libkomparediff2 = "${EPEL_MIRROR}/aarch64/Packages/l/libkomparediff2-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkomparediff2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkomparediff2}"
SRC_URI[aarch64_libkomparediff2.sha256sum] = "a61476776ad42a2426adb39163e852a7fbb5bf97544c847e5d3e94014f3395c6"

URI_aarch64_libkomparediff2-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkomparediff2-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkomparediff2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkomparediff2-devel}"
SRC_URI[aarch64_libkomparediff2-devel.sha256sum] = "cd2f2576976e25490843a88bdf272ec212b7611cd42c3f85eee6786404adac9e"

RDEPENDS:libkomparediff2 = " \
 diffutils \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkomparediff2-devel = " \
 cmake \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kxmlgui-devel \
 libkomparediff2 \
 qt6-qtbase-devel \
 "
