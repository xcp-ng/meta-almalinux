# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-aiohttp"
PV = "1.1.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-pytest-aiohttp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-aiohttp-1.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c88dad816c32d745f189daf8342404f4bc185f20edfaec00c709d3c554f91e4d"

URI_x86_64_v2_python3-pytest-aiohttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-aiohttp-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-aiohttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-aiohttp}"
SRC_URI[x86_64_v2_python3-pytest-aiohttp.sha256sum] = "211031c11ec750f737d3d54dfedb678ba01ff5cc817c6166f5532cabe095c0c8"

URI_aarch64_python3-pytest-aiohttp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-aiohttp-1.1.1-1.el10_2.noarch.rpm;name=aarch64_python3-pytest-aiohttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-aiohttp}"
SRC_URI[aarch64_python3-pytest-aiohttp.sha256sum] = "25ffc99420606ec723adc54bf26cb1df0c00cfe5bcc7d430216a681f68d04824"

RDEPENDS:python3-pytest-aiohttp = " \
 python3 \
 python3-aiohttp \
 python3-pytest \
 python3-pytest-asyncio \
 "
