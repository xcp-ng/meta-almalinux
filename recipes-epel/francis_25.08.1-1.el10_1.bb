# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "francis"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 francis \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/francis-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f92849cee2b574daf9852f0e8b2d501a066261ffe8aa6ec97c8d6916f794bc9"

URI_x86_64_v2_francis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/francis-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_francis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_francis}"
SRC_URI[x86_64_v2_francis.sha256sum] = "1ac9bcc8cb2891bd6ec249a0450ec6d6991dbbd83dad4e139b0f516e2bc25e99"

URI_aarch64_francis = "${EPEL_MIRROR}/aarch64/Packages/f/francis-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_francis;unpack=0"
SRC_URI:append = " ${URI_aarch64_francis}"
SRC_URI[aarch64_francis.sha256sum] = "6e7498c5bf90fac0e0b1793c22ba6c916b346b96e0cdb5716e07ef3310926a2a"

RDEPENDS:francis = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
