# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pulldown-cmark-escape"
PV = "0.11.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-pulldown-cmark-escape+default-devel \
 rust-pulldown-cmark-escape+simd-devel \
 rust-pulldown-cmark-escape-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pulldown-cmark-escape-0.11.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "308645f4597df9d48f328c3782ba86a3210b4ba8ac67c893016ac84ef469b17f"

URI_x86_64_v2_rust-pulldown-cmark-escape+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark-escape+default-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark-escape+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark-escape+default-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark-escape+default-devel.sha256sum] = "ba6e9a036277154fdbd294b8678512b5cd07e4eed9371d47af2138e53ff00651"

URI_x86_64_v2_rust-pulldown-cmark-escape+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark-escape+simd-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark-escape+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark-escape+simd-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark-escape+simd-devel.sha256sum] = "133cf929336a476075799779abacca37f1b9a107c264a7d43d22856166cbea2f"

URI_x86_64_v2_rust-pulldown-cmark-escape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark-escape-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark-escape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark-escape-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark-escape-devel.sha256sum] = "93febbb41c4698ce8310214ea59a7e40cfce59d7d677e1dbc749a9a42c6592ef"

URI_aarch64_rust-pulldown-cmark-escape+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark-escape+default-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark-escape+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark-escape+default-devel}"
SRC_URI[aarch64_rust-pulldown-cmark-escape+default-devel.sha256sum] = "47a08ee9914adc62dcbfa498cb1604b5aae945008ac2e3d8415e943eca2c2206"

URI_aarch64_rust-pulldown-cmark-escape+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark-escape+simd-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark-escape+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark-escape+simd-devel}"
SRC_URI[aarch64_rust-pulldown-cmark-escape+simd-devel.sha256sum] = "0449725e928d347bdd33dc2f76e6b33a12ec3839e90085d8a9e65e7929e1478b"

URI_aarch64_rust-pulldown-cmark-escape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark-escape-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark-escape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark-escape-devel}"
SRC_URI[aarch64_rust-pulldown-cmark-escape-devel.sha256sum] = "fef20dca4bc427966ba480e6355be834b4241725e03cea53aec0ba629837a8da"

RDEPENDS:rust-pulldown-cmark-escape+default-devel = " \
 cargo \
 rust-pulldown-cmark-escape-devel \
 "
RDEPENDS:rust-pulldown-cmark-escape+simd-devel = " \
 cargo \
 rust-pulldown-cmark-escape-devel \
 "
RDEPENDS:rust-pulldown-cmark-escape-devel = " \
 cargo \
 rust \
 "
