# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Carton"
PV = "1.0.35"
PR = "9.el10_0"
PACKAGES = " \
 perl-Carton \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Carton-1.0.35-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "067804aaee4f83a1243d5c366614d56df80f8b6485bd522ebef755499322f75e"

URI_x86_64_v2_perl-Carton = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Carton-1.0.35-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Carton;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Carton}"
SRC_URI[x86_64_v2_perl-Carton.sha256sum] = "fe356aac61b10751c932b8e62e3220438756e1f9b66ad7e772e043915dbd71bc"

URI_aarch64_perl-Carton = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Carton-1.0.35-9.el10_0.noarch.rpm;name=aarch64_perl-Carton;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Carton}"
SRC_URI[aarch64_perl-Carton.sha256sum] = "0c21541f0f97e19eee869db3ea196bfcbd82145fed3c5b670e1f62099edd4682"

RDEPENDS:perl-Carton = " \
 perl-App-FatPacker \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-Carp \
 perl-Carton \
 perl-Class-Tiny \
 perl-File-Find \
 perl-File-pushd \
 perl-Getopt-Long \
 perl-JSON-PP \
 perl-Menlo-Legacy \
 perl-Module-CPANfile \
 perl-Module-CoreList \
 perl-Path-Tiny \
 perl-Scalar-List-Utils \
 perl-Try-Tiny \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-parent \
 perl-subs \
 perl-version \
 "
