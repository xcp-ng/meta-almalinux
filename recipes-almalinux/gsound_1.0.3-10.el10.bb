# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gsound"
PV = "1.0.3"
PR = "10.el10"
PACKAGES = " \
 gsound \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gsound-1.0.3-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9e9558b1e9a6d692f4614d7b482ed18465ba7082c9357af51e3125fa62125c5"

URI_x86_64_v2_gsound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gsound-1.0.3-10.el10.x86_64_v2.rpm;name=x86_64_v2_gsound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsound}"
SRC_URI[x86_64_v2_gsound.sha256sum] = "41b3aa4f46b3266b5b2bfa410696d3173653cfdfa033375e2d2cc800c4502b57"

URI_aarch64_gsound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gsound-1.0.3-10.el10.aarch64.rpm;name=aarch64_gsound;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsound}"
SRC_URI[aarch64_gsound.sha256sum] = "5a77b8af984b7d456f32490a85f62c186694a62eff6045d5b3ff916f70995613"

RDEPENDS:gsound = " \
 glib2 \
 glibc \
 libcanberra \
 "
