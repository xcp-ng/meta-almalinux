# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ramalama"
PV = "0.24.0"
PR = "1.el10_3"
PACKAGES = " \
 ramalama \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/ramalama-0.24.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a2a4c850f0325ed973286976720167ae5f39647937b002552792d881dbc1d8c5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ramalama-0.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ramalama;unpack=0"
SRC_URI[x86_64_v2_ramalama.sha256sum] = "7d90267ecfa55e45071981034546a8e3adff5339ad798137af8c4ebf42d01e13"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ramalama-0.24.0-1.el10_3.noarch.rpm;name=aarch64_ramalama;unpack=0"
SRC_URI[aarch64_ramalama.sha256sum] = "c9ddc56e945759e2149572db5ad43b711358d9e6d4760063e9d708467aed52e2"

RDEPENDS:ramalama = " \
 podman \
 python3 \
 python3-argcomplete \
 python3-jinja2 \
 python3-pyyaml \
 "
