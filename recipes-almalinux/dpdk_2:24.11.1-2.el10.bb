# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dpdk"
PE = "2"
PV = "24.11.1"
PR = "2.el10"
PACKAGES = " \
 dpdk \
 dpdk-devel \
 dpdk-doc \
 dpdk-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dpdk-24.11.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5027fafd5ab0cf46867a58d62be1d5a4b41171e566462edca8b32c2abf86419e"

URI_x86_64_v2_dpdk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dpdk-24.11.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_dpdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpdk}"
SRC_URI[x86_64_v2_dpdk.sha256sum] = "1c9af2893505f7a07459a1696b2396f0f2db0ad940618057605c0741830bfaca"

URI_x86_64_v2_dpdk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dpdk-devel-24.11.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_dpdk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpdk-devel}"
SRC_URI[x86_64_v2_dpdk-devel.sha256sum] = "d2b717f596b9340b649e56f8e5802929245dc42f3ce57e1f3e76d72019914481"

URI_x86_64_v2_dpdk-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dpdk-doc-24.11.1-2.el10.noarch.rpm;name=x86_64_v2_dpdk-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpdk-doc}"
SRC_URI[x86_64_v2_dpdk-doc.sha256sum] = "0a6523b6c0c901d7e16b29ab6192b6ffa5c4bed0da6bb0f4e44dc75bc29681fc"

URI_x86_64_v2_dpdk-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dpdk-tools-24.11.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_dpdk-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpdk-tools}"
SRC_URI[x86_64_v2_dpdk-tools.sha256sum] = "fce313c786aa0c2d14ebf5ad7849bdecb919f466d7e14f146612d59a45a9ef3c"

URI_aarch64_dpdk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dpdk-24.11.1-2.el10.aarch64.rpm;name=aarch64_dpdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpdk}"
SRC_URI[aarch64_dpdk.sha256sum] = "3af95de71d213b4f46d6603baa9a95332481b661a43a0022c9fc5a8ecdd91e1d"

URI_aarch64_dpdk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dpdk-devel-24.11.1-2.el10.aarch64.rpm;name=aarch64_dpdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpdk-devel}"
SRC_URI[aarch64_dpdk-devel.sha256sum] = "060bd278827ad5f6694a21f3d4514112ec8680af5fc24e1fecc5bbfd3852a9ea"

URI_aarch64_dpdk-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dpdk-doc-24.11.1-2.el10.noarch.rpm;name=aarch64_dpdk-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpdk-doc}"
SRC_URI[aarch64_dpdk-doc.sha256sum] = "0a6523b6c0c901d7e16b29ab6192b6ffa5c4bed0da6bb0f4e44dc75bc29681fc"

URI_aarch64_dpdk-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dpdk-tools-24.11.1-2.el10.aarch64.rpm;name=aarch64_dpdk-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpdk-tools}"
SRC_URI[aarch64_dpdk-tools.sha256sum] = "b15f28a7b03318a871eca142960ddccd7877ab5801be25b856abcec0c5aae9a8"

RDEPENDS:dpdk:x86_64_v2 = " \
 glibc \
 libarchive \
 libibverbs \
 numactl-libs \
"
RDEPENDS:dpdk:aarch64 = " \
 glibc \
 libarchive \
 numactl-libs \
"
RDEPENDS:dpdk-devel:x86_64_v2 = " \
 bash \
 dpdk \
 dpdk-devel \
 libarchive-devel \
 pkgconf-pkg-config \
 python3 \
 rdma-core-devel \
"
RDEPENDS:dpdk-devel:aarch64 = " \
 bash \
 dpdk \
 dpdk-devel \
 libarchive-devel \
 pkgconf-pkg-config \
 python3 \
"
RDEPENDS:dpdk-doc = " \
 "
RDEPENDS:dpdk-tools = " \
 dpdk \
 findutils \
 iproute \
 kmod \
 pciutils \
 python3 \
 "
