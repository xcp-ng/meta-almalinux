# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-GIS-Distance"
PV = "0.20"
PR = "6.el10_0"
PACKAGES = " \
 perl-GIS-Distance \
 perl-GIS-Distance-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-GIS-Distance-0.20-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30a1941952f703b2c95b30947521cb836cb67b1ba73ad545a720230823734d34"

URI_x86_64_v2_perl-GIS-Distance = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GIS-Distance-0.20-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GIS-Distance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GIS-Distance}"
SRC_URI[x86_64_v2_perl-GIS-Distance.sha256sum] = "266e2dfbf32beba8a81a5dd2366e9aa5a7b3a1d2523777062778bae56a97e924"

URI_x86_64_v2_perl-GIS-Distance-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GIS-Distance-tests-0.20-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GIS-Distance-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GIS-Distance-tests}"
SRC_URI[x86_64_v2_perl-GIS-Distance-tests.sha256sum] = "27d254c5d1c60e99ed797e89c21e24bba573f988eff7ddce8f5ce1ed3b009685"

URI_aarch64_perl-GIS-Distance = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GIS-Distance-0.20-6.el10_0.noarch.rpm;name=aarch64_perl-GIS-Distance;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GIS-Distance}"
SRC_URI[aarch64_perl-GIS-Distance.sha256sum] = "bf61a21401877484782d661c553c0e69e1713c2dc5778634ccf14103345dea50"

URI_aarch64_perl-GIS-Distance-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GIS-Distance-tests-0.20-6.el10_0.noarch.rpm;name=aarch64_perl-GIS-Distance-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GIS-Distance-tests}"
SRC_URI[aarch64_perl-GIS-Distance-tests.sha256sum] = "8ce9b56153da62a9e8358786c6920e7ad35f9c956400cc6102738c03c4225608"

RDEPENDS:perl-GIS-Distance = " \
 perl-Carp \
 perl-Class-Measure \
 perl-Const-Fast \
 perl-Exporter \
 perl-GIS-Distance \
 perl-Math-Complex \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-namespace-clean \
 perl-parent \
 perl-strictures \
 "
RDEPENDS:perl-GIS-Distance-tests = " \
 bash \
 perl-GIS-Distance \
 perl-Test-Harness \
 perl-Test2-Suite \
 perl-interpreter \
 perl-libs \
 perl-strictures \
 "
