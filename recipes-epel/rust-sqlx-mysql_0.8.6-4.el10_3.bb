# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sqlx-mysql"
PV = "0.8.6"
PR = "4.el10_3"
PACKAGES = " \
 rust-sqlx-mysql+any-devel \
 rust-sqlx-mysql+bigdecimal-devel \
 rust-sqlx-mysql+chrono-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+json-devel \
 rust-sqlx-mysql+migrate-devel \
 rust-sqlx-mysql+offline-devel \
 rust-sqlx-mysql+rust_decimal-devel \
 rust-sqlx-mysql+serde-devel \
 rust-sqlx-mysql+time-devel \
 rust-sqlx-mysql+uuid-devel \
 rust-sqlx-mysql-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sqlx-mysql-0.8.6-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad5d1aecbbe5ab37b274ef5782de0555633ed65e4ae1049d42205f8aebc9ef35"

URI_x86_64_v2_rust-sqlx-mysql+any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+any-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+any-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+any-devel.sha256sum] = "a3fa8883d329677aebc62381858f63d84d744f12ea5592b3888599dec3e424ce"

URI_x86_64_v2_rust-sqlx-mysql+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+bigdecimal-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+bigdecimal-devel.sha256sum] = "4b7e384f61388caf9f85401d303703a36f06253ef1f64c3ae7e065d42f07008d"

URI_x86_64_v2_rust-sqlx-mysql+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+chrono-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+chrono-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+chrono-devel.sha256sum] = "1e5b47e02d776b5b4fe208cc83fe74e26b9318a18cc2df4f0ebb4e1b80bca8bb"

URI_x86_64_v2_rust-sqlx-mysql+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+default-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+default-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+default-devel.sha256sum] = "5a613c042346d3006b0af917881bae092bfa8565b6c2f666885f72f81c2cb84d"

URI_x86_64_v2_rust-sqlx-mysql+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+json-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+json-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+json-devel.sha256sum] = "9325244260a8bca15d5c6af4c897cfc2a0479348fb81adc54f90f34a11aa13bc"

URI_x86_64_v2_rust-sqlx-mysql+migrate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+migrate-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+migrate-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+migrate-devel.sha256sum] = "115ca01bb1ea9f7cee315d858966a83dae169f7a5b0103ee0abcc48ccb36a5c0"

URI_x86_64_v2_rust-sqlx-mysql+offline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+offline-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+offline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+offline-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+offline-devel.sha256sum] = "ed8a81b9da481376748ed2f51fab6b28a2c689a2de8a672e15d56697eefe08d8"

URI_x86_64_v2_rust-sqlx-mysql+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+rust_decimal-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+rust_decimal-devel.sha256sum] = "1df3b84db4b72c8bfc21b74d6e07311f1a3db6da5114ff13728b7a86842c33c7"

URI_x86_64_v2_rust-sqlx-mysql+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+serde-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+serde-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+serde-devel.sha256sum] = "e5b3bd0ed2cddbb520875dcca9e32eb37a7a90b7d414a680d906e5d4a1858201"

URI_x86_64_v2_rust-sqlx-mysql+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+time-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+time-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+time-devel.sha256sum] = "d448b9e5d1487f0bdccb8db6dc4f6ad0cf4104e1e797dabf7472a19410b99af0"

URI_x86_64_v2_rust-sqlx-mysql+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql+uuid-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql+uuid-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql+uuid-devel.sha256sum] = "98fa22dbfef717b0a7d6beabb90a15c41acfb4d48d94157beb3dcf6ee7d8ac91"

URI_x86_64_v2_rust-sqlx-mysql-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-mysql-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-mysql-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-mysql-devel}"
SRC_URI[x86_64_v2_rust-sqlx-mysql-devel.sha256sum] = "188cf36bfc4b2f6e60f2abaa1d9b1bff79e285e601cc898a81347280d8a4429d"

URI_aarch64_rust-sqlx-mysql+any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+any-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-mysql+any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+any-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+any-devel.sha256sum] = "6649826c04d49e1e4462117ee011328f9dcb81a3e13c4e2d3a79f653152520ce"

URI_aarch64_rust-sqlx-mysql+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+bigdecimal-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-mysql+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+bigdecimal-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+bigdecimal-devel.sha256sum] = "fcda972dc08ea2ce45b679c060ff30603ad694704b8aa3885ebd91470ec83352"

URI_aarch64_rust-sqlx-mysql+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+chrono-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-mysql+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+chrono-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+chrono-devel.sha256sum] = "49ad32e0cb70014d152586815a34f040c749bdeea75a5b3e1a557e4327c768df"

URI_aarch64_rust-sqlx-mysql+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+default-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-mysql+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+default-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+default-devel.sha256sum] = "051ef693fe841e35ea3e84ce8c8d72e8dc6cb422315630c4f863ec2e4690096f"

URI_aarch64_rust-sqlx-mysql+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+json-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-mysql+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+json-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+json-devel.sha256sum] = "3ff24e4c385b4c7d95b46a46d785d95fcdc46fbcaf79532c53d9bd70f51d1260"

URI_aarch64_rust-sqlx-mysql+migrate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+migrate-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-mysql+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+migrate-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+migrate-devel.sha256sum] = "57eb582cf78263249f32ed5ad8333fad9a09fb713a10fd2094d53f38cefd67e0"

URI_aarch64_rust-sqlx-mysql+offline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+offline-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-mysql+offline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+offline-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+offline-devel.sha256sum] = "8c89ea9beced4b5d36a6e4edb440c39491bb7dd385017a0a1b07df344b549d0c"

URI_aarch64_rust-sqlx-mysql+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+rust_decimal-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-mysql+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+rust_decimal-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+rust_decimal-devel.sha256sum] = "27fb3f6e37e3b0e6e9ac246d4987279567bf97e92c86b5d1f3d02c21b4fca76a"

URI_aarch64_rust-sqlx-mysql+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+serde-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-mysql+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+serde-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+serde-devel.sha256sum] = "3982cb9406822d7c2d79683d7e94b05391c4400fdc816cb12c69d7b5b22dae64"

URI_aarch64_rust-sqlx-mysql+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+time-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-mysql+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+time-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+time-devel.sha256sum] = "ed12ae6cd1de9c24a8fd340cddeaf44872318813a5f556c465bc5bd8a7e3616a"

URI_aarch64_rust-sqlx-mysql+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql+uuid-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-mysql+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql+uuid-devel}"
SRC_URI[aarch64_rust-sqlx-mysql+uuid-devel.sha256sum] = "541ffc66060f8282742caaa8b757169a2a821b300427fce068d01b71cf4cd6e7"

URI_aarch64_rust-sqlx-mysql-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-mysql-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-mysql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-mysql-devel}"
SRC_URI[aarch64_rust-sqlx-mysql-devel.sha256sum] = "522a545d3f52c7265df8241272adf3d02d904c962bc8f82c4dc3f70e170cc190"

RDEPENDS:rust-sqlx-mysql+any-devel = " \
 cargo \
 rust-sqlx-core+any-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+bigdecimal-devel = " \
 cargo \
 rust-bigdecimal+default-devel \
 rust-sqlx-core+bigdecimal-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-sqlx-core+chrono-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+default-devel = " \
 cargo \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+json-devel = " \
 cargo \
 rust-sqlx-core+json-devel \
 rust-sqlx-mysql+serde-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+migrate-devel = " \
 cargo \
 rust-sqlx-core+migrate-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+offline-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-sqlx-core+offline-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+rust_decimal-devel = " \
 cargo \
 rust-rust_decimal+maths-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 rust-sqlx-core+rust_decimal-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-sqlx-mysql-devel \
 "
RDEPENDS:rust-sqlx-mysql+time-devel = " \
 cargo \
 rust-sqlx-core+time-devel \
 rust-sqlx-mysql-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-sqlx-mysql+uuid-devel = " \
 cargo \
 rust-sqlx-core+uuid-devel \
 rust-sqlx-mysql-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-sqlx-mysql-devel = " \
 cargo \
 rust-atoi+default-devel \
 rust-base64_0.22+std-devel \
 rust-base64_0.22-devel \
 rust-bitflags+serde-devel \
 rust-bitflags-devel \
 rust-byteorder+std-devel \
 rust-byteorder-devel \
 rust-bytes+default-devel \
 rust-crc+default-devel \
 rust-digest0.10+std-devel \
 rust-digest0.10-devel \
 rust-dotenvy+default-devel \
 rust-either+default-devel \
 rust-futures-channel+alloc-devel \
 rust-futures-channel+sink-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-core-devel \
 rust-futures-io+default-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util+io-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 rust-generic-array-devel \
 rust-hex+default-devel \
 rust-hkdf0.12+default-devel \
 rust-hmac0.12-devel \
 rust-itoa+default-devel \
 rust-log+default-devel \
 rust-md-5_0.10-devel \
 rust-memchr-devel \
 rust-once_cell+default-devel \
 rust-percent-encoding+default-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 rust-rsa+default-devel \
 rust-sha1_0.10-devel \
 rust-sha2_0.10-devel \
 rust-smallvec+default-devel \
 rust-sqlx-core+default-devel \
 rust-stringprep+default-devel \
 rust-thiserror+default-devel \
 rust-tracing+default-devel \
 rust-tracing+log-devel \
 "
