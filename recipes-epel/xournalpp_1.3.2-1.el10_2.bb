# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xournalpp"
PV = "1.3.2"
PR = "1.el10_2"
PACKAGES = " \
 xournalpp \
 xournalpp-plugins \
 xournalpp-ui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xournalpp-1.3.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8409f767ee316700a496bfda14c314c43d2e1cfbe50b16adbad8597becdd0a7"

URI_x86_64_v2_xournalpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xournalpp-1.3.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xournalpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xournalpp}"
SRC_URI[x86_64_v2_xournalpp.sha256sum] = "51cfa742db0ccd9a446fb5b8fef64ce2bf34a01a58357d16f19623b00037717b"

URI_x86_64_v2_xournalpp-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xournalpp-plugins-1.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_xournalpp-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xournalpp-plugins}"
SRC_URI[x86_64_v2_xournalpp-plugins.sha256sum] = "5d9a09ab1ebf18c6e6951d2c2c8eb882e7ce3b7fb0f02d16540419bc00e747b6"

URI_x86_64_v2_xournalpp-ui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xournalpp-ui-1.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_xournalpp-ui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xournalpp-ui}"
SRC_URI[x86_64_v2_xournalpp-ui.sha256sum] = "f9f5b35d08d2377dc599174d68ff0bf4070d233d043dfd487661fb7a306554ab"

URI_aarch64_xournalpp = "${EPEL_MIRROR}/aarch64/Packages/x/xournalpp-1.3.2-1.el10_2.aarch64.rpm;name=aarch64_xournalpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_xournalpp}"
SRC_URI[aarch64_xournalpp.sha256sum] = "062b4680e6c957d043a23d30ce7ed4bea1cef4ef28adcd91a813e98fa3c5f330"

URI_aarch64_xournalpp-plugins = "${EPEL_MIRROR}/aarch64/Packages/x/xournalpp-plugins-1.3.2-1.el10_2.noarch.rpm;name=aarch64_xournalpp-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_xournalpp-plugins}"
SRC_URI[aarch64_xournalpp-plugins.sha256sum] = "173e78acedcf05cc62656d6a31e566653041070e416ef9cbbc300bd82d4ad86a"

URI_aarch64_xournalpp-ui = "${EPEL_MIRROR}/aarch64/Packages/x/xournalpp-ui-1.3.2-1.el10_2.noarch.rpm;name=aarch64_xournalpp-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_xournalpp-ui}"
SRC_URI[aarch64_xournalpp-ui.sha256sum] = "e1a4ed3d5e8126ac6dd6237780fda25dcdf6e74ae620d146386086eae9484841"

RDEPENDS:xournalpp = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gperftools-libs \
 gtk3 \
 gtksourceview4 \
 hicolor-icon-theme \
 libX11 \
 libXi \
 libgcc \
 librsvg2 \
 libsndfile \
 libstdc++ \
 libxml2 \
 libzip \
 lua-libs \
 pango \
 poppler-glib \
 portaudio \
 qpdf-libs \
 xournalpp-plugins \
 xournalpp-ui \
 zlib-ng-compat \
 "
RDEPENDS:xournalpp-plugins = " \
 "
RDEPENDS:xournalpp-ui = " \
 "
