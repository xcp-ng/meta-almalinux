# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-Builder-Compiler"
PV = "0.037"
PR = "1.el10_2"
PACKAGES = " \
 perl-ExtUtils-Builder-Compiler \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-Builder-Compiler-0.037-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "716e406743d88f6e220d70f2b59db415f11ba271e62d63c1f14d35042e8d6e5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-Builder-Compiler-0.037-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Builder-Compiler;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Builder-Compiler.sha256sum] = "e6bece08367717894c9a5dd97f1e2fc996e8be49f0b539c1cfb0076c89318e95"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-Builder-Compiler-0.037-1.el10_2.noarch.rpm;name=aarch64_perl-ExtUtils-Builder-Compiler;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Builder-Compiler.sha256sum] = "1132c811ef427d2d69436cffef30bb43e21507e779873f079f30a9c6f618f0ed"

RDEPENDS:perl-ExtUtils-Builder-Compiler = " \
 perl-Carp \
 perl-DynaLoader \
 perl-ExtUtils-Builder \
 perl-ExtUtils-Builder-Compiler \
 perl-ExtUtils-Config \
 perl-File-Basename \
 perl-File-Temp \
 perl-PathTools \
 perl-Perl-OSType \
 perl-libs \
 perl-parent \
 perl-sort \
 "
