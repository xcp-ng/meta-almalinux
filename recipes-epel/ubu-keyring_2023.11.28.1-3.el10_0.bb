# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ubu-keyring"
PV = "2023.11.28.1"
PR = "3.el10_0"
PACKAGES = " \
 ubu-keyring \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/ubu-keyring-2023.11.28.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55c9a5dd3c62a6b8d8d5016733dc4de8e292a98bbd95e1ac2efa4944f7cd772a"

URI_x86_64_v2_ubu-keyring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ubu-keyring-2023.11.28.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ubu-keyring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ubu-keyring}"
SRC_URI[x86_64_v2_ubu-keyring.sha256sum] = "9d260f08f883fb300b56ec46ed1e373c00f564811ba3fede3e9980270cc38362"

URI_aarch64_ubu-keyring = "${EPEL_MIRROR}/aarch64/Packages/u/ubu-keyring-2023.11.28.1-3.el10_0.noarch.rpm;name=aarch64_ubu-keyring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ubu-keyring}"
SRC_URI[aarch64_ubu-keyring.sha256sum] = "1021eb4e2df613a2bae743b159da00d863ab3f3c7d737e6f89698c315d2eb54e"

RDEPENDS:ubu-keyring = " \
 keyrings-filesystem \
 "
