# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aes"
PV = "0.9.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-aes+default-devel \
 rust-aes+hazmat-devel \
 rust-aes+zeroize-devel \
 rust-aes-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-aes-0.9.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "49c082a5fa985d8b339d2671cb6e59324ff77f24372b9bbc7c7b091902984d7b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes+default-devel-0.9.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-aes+default-devel.sha256sum] = "41d4deab37a9119530b7c9a5f338234f4d219d1d4b190ae6ba0c15fec624a649"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes+hazmat-devel-0.9.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes+hazmat-devel;unpack=0"
SRC_URI[x86_64_v2_rust-aes+hazmat-devel.sha256sum] = "a9ca2fa674797c4c37643ebd9490fea78dbbee124451b616080417f48caa5e31"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes+zeroize-devel-0.9.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes+zeroize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-aes+zeroize-devel.sha256sum] = "eaf95e0faae2f271167d620208b11e5874334c6b13f236973fa1c498158ec70e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-devel-0.9.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-devel;unpack=0"
SRC_URI[x86_64_v2_rust-aes-devel.sha256sum] = "84c14b9527cf19307163ad3ab1610f7407b1fd0da0d8a4f7e29efbce6367c054"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-aes+default-devel-0.9.3-1.el10_3.noarch.rpm;name=aarch64_rust-aes+default-devel;unpack=0"
SRC_URI[aarch64_rust-aes+default-devel.sha256sum] = "6795482f182e8a74c4c6d0faad1884fb758ece70d038d28a5729eec5824844b8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-aes+hazmat-devel-0.9.3-1.el10_3.noarch.rpm;name=aarch64_rust-aes+hazmat-devel;unpack=0"
SRC_URI[aarch64_rust-aes+hazmat-devel.sha256sum] = "f8dcf3e3c563ca2c19fb76dd5a18acbed81822fa0f0618d4d8d8dd16d6cb8733"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-aes+zeroize-devel-0.9.3-1.el10_3.noarch.rpm;name=aarch64_rust-aes+zeroize-devel;unpack=0"
SRC_URI[aarch64_rust-aes+zeroize-devel.sha256sum] = "0e5e8f11913e6d9199e2f77aa9592392808bd20b52d2ee10de404867127a0782"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-devel-0.9.3-1.el10_3.noarch.rpm;name=aarch64_rust-aes-devel;unpack=0"
SRC_URI[aarch64_rust-aes-devel.sha256sum] = "85488781832c8c1936f120a02ed4df8b96f6a8437bb7088b81a7e95a7e301ac9"

RDEPENDS:rust-aes+default-devel = " \
 cargo \
 rust-aes-devel \
 "
RDEPENDS:rust-aes+hazmat-devel = " \
 cargo \
 rust-aes-devel \
 "
RDEPENDS:rust-aes+zeroize-devel = " \
 cargo \
 rust-aes-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-aes-devel = " \
 cargo \
 rust \
 rust-cipher+default-devel \
 rust-cpubits+default-devel \
 rust-cpufeatures+default-devel \
 "
