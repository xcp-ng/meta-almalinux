# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "offlineimap"
PV = "8.0.0"
PR = "18.el10_1"
PACKAGES = " \
 offlineimap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/offlineimap-8.0.0-18.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14f0c94ad6b54a8cde22dff448aec348c7a7e1690a1ba6b3201037678c1d3eb1"

URI_x86_64_v2_offlineimap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/offlineimap-8.0.0-18.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_offlineimap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_offlineimap}"
SRC_URI[x86_64_v2_offlineimap.sha256sum] = "90ddf421a1dccf2fb55233c6832b3b75612fd0538a04d04a8a5f0e3933a19e36"

URI_aarch64_offlineimap = "${EPEL_MIRROR}/aarch64/Packages/o/offlineimap-8.0.0-18.el10_1.noarch.rpm;name=aarch64_offlineimap;unpack=0"
SRC_URI:append = " ${URI_aarch64_offlineimap}"
SRC_URI[aarch64_offlineimap.sha256sum] = "f673641245752646352e3216631fd397cec76bb08041900c9b810254919196ee"

RDEPENDS:offlineimap = " \
 python3 \
 python3-distro \
 sqlite \
 "
