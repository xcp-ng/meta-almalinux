# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fallible-iterator"
PV = "0.3.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-fallible-iterator+alloc-devel \
 rust-fallible-iterator+default-devel \
 rust-fallible-iterator+std-devel \
 rust-fallible-iterator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fallible-iterator-0.3.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a219ccc990aa9e67b86ee26d046b18dbfe1cdb5cb64186cd6e22671896477c50"

URI_x86_64_v2_rust-fallible-iterator+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fallible-iterator+alloc-devel-0.3.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fallible-iterator+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fallible-iterator+alloc-devel}"
SRC_URI[x86_64_v2_rust-fallible-iterator+alloc-devel.sha256sum] = "7926a1fb797db501dd7ff76595253ae80c64b30768181c894887f3f0ad158815"

URI_x86_64_v2_rust-fallible-iterator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fallible-iterator+default-devel-0.3.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fallible-iterator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fallible-iterator+default-devel}"
SRC_URI[x86_64_v2_rust-fallible-iterator+default-devel.sha256sum] = "da6452660216dedb224c1a5d84d924e832d485f8c0f2f4c81c62bb7418a817ab"

URI_x86_64_v2_rust-fallible-iterator+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fallible-iterator+std-devel-0.3.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fallible-iterator+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fallible-iterator+std-devel}"
SRC_URI[x86_64_v2_rust-fallible-iterator+std-devel.sha256sum] = "c4e6e707064c6dc25ce32a19e3e018e4c8b8ee0fa9b1eca97e12bea50b32dd06"

URI_x86_64_v2_rust-fallible-iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fallible-iterator-devel-0.3.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fallible-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fallible-iterator-devel}"
SRC_URI[x86_64_v2_rust-fallible-iterator-devel.sha256sum] = "dc08459d6dd56bc667e8b9b25ab9c81012ddf958f5eaf8d494016988eb6c5dd2"

URI_aarch64_rust-fallible-iterator+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fallible-iterator+alloc-devel-0.3.0-3.el10_0.noarch.rpm;name=aarch64_rust-fallible-iterator+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fallible-iterator+alloc-devel}"
SRC_URI[aarch64_rust-fallible-iterator+alloc-devel.sha256sum] = "fbea02eb578880f0a6e629c3287b2d125e26c0ab4d842085222967bcbc6062b7"

URI_aarch64_rust-fallible-iterator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fallible-iterator+default-devel-0.3.0-3.el10_0.noarch.rpm;name=aarch64_rust-fallible-iterator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fallible-iterator+default-devel}"
SRC_URI[aarch64_rust-fallible-iterator+default-devel.sha256sum] = "206bda10baad4832f94f8544c2a356533d6fe49abb256471f636bdc2a306882d"

URI_aarch64_rust-fallible-iterator+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fallible-iterator+std-devel-0.3.0-3.el10_0.noarch.rpm;name=aarch64_rust-fallible-iterator+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fallible-iterator+std-devel}"
SRC_URI[aarch64_rust-fallible-iterator+std-devel.sha256sum] = "9ca21a0be8001fe5739451b94cf006e23986aeff34a68483dd4e88e5383bab9e"

URI_aarch64_rust-fallible-iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fallible-iterator-devel-0.3.0-3.el10_0.noarch.rpm;name=aarch64_rust-fallible-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fallible-iterator-devel}"
SRC_URI[aarch64_rust-fallible-iterator-devel.sha256sum] = "65f6236bf881128ce4816398ca78211fc28ffa815c4a198d4fbb412cf1f1579a"

RDEPENDS:rust-fallible-iterator+alloc-devel = " \
 cargo \
 rust-fallible-iterator-devel \
 "
RDEPENDS:rust-fallible-iterator+default-devel = " \
 cargo \
 rust-fallible-iterator+alloc-devel \
 rust-fallible-iterator-devel \
 "
RDEPENDS:rust-fallible-iterator+std-devel = " \
 cargo \
 rust-fallible-iterator+alloc-devel \
 rust-fallible-iterator-devel \
 "
RDEPENDS:rust-fallible-iterator-devel = " \
 cargo \
 "
