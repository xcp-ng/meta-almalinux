# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kurchu"
PV = "0.4.3"
PR = "1.el10_1"
PACKAGES = " \
 kurchu \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kurchu-0.4.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f8c1fb41b6f03d684e476ed5667589273ca45c35650510e639e60b7f6b540e9"

URI_x86_64_v2_kurchu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kurchu-0.4.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kurchu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kurchu}"
SRC_URI[x86_64_v2_kurchu.sha256sum] = "3a09e0dae8046bb832aa571e5ec1424195ece5eecf045f8b5141e13375d15701"

URI_aarch64_kurchu = "${EPEL_MIRROR}/aarch64/Packages/k/kurchu-0.4.3-1.el10_1.noarch.rpm;name=aarch64_kurchu;unpack=0"
SRC_URI:append = " ${URI_aarch64_kurchu}"
SRC_URI[aarch64_kurchu.sha256sum] = "1e9c35d547fa3adc60a5a74727f25e6450e3e05c1a3343eae762eb594186ef47"

RDEPENDS:kurchu = " \
 git-core \
 koji \
 lftp \
 python3 \
 python3-koji-cli-plugins \
 s3cmd \
 tree \
 "
