# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "copr-cli"
PV = "2.6"
PR = "1.el10_2"
PACKAGES = " \
 copr-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/copr-cli-2.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a63f7cf29e6c9b3f8e6198f56f3cd6d4c649b60a9e9461f3b04d577f1b1d284"

URI_x86_64_v2_copr-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/copr-cli-2.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_copr-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_copr-cli}"
SRC_URI[x86_64_v2_copr-cli.sha256sum] = "0de4f47ee6248de420cd4e877d60856a52f39d850a47aa43d63e0af6ff106106"

URI_aarch64_copr-cli = "${EPEL_MIRROR}/aarch64/Packages/c/copr-cli-2.6-1.el10_2.noarch.rpm;name=aarch64_copr-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_copr-cli}"
SRC_URI[aarch64_copr-cli.sha256sum] = "ca64186226d2b0262f308ba5c89cb099291473715e98d8e81d9518cdf55057a6"

RDEPENDS:copr-cli = " \
 python3 \
 python3-copr \
 python3-humanize \
 python3-jinja2 \
 python3-koji \
 python3-rich \
 python3-setuptools \
 python3-typing-extensions \
 wget \
 "
