# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-data-default-instances-containers"
PV = "0.0.1"
PR = "29.el10_0"
PACKAGES = " \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-containers-devel \
 ghc-data-default-instances-containers-doc \
 ghc-data-default-instances-containers-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-data-default-instances-containers-0.0.1-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53315db688bd5078894e11ef792a3b3a4836c2046634e1a42f1d0489c011bd63"

URI_x86_64_v2_ghc-data-default-instances-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-instances-containers-0.0.1-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default-instances-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-instances-containers}"
SRC_URI[x86_64_v2_ghc-data-default-instances-containers.sha256sum] = "10ca611881feef3dbcd7d03f04e88a836e098fdcf4507dcea6772def206b17db"

URI_x86_64_v2_ghc-data-default-instances-containers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-instances-containers-devel-0.0.1-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default-instances-containers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-instances-containers-devel}"
SRC_URI[x86_64_v2_ghc-data-default-instances-containers-devel.sha256sum] = "0b7fda57f995e39a5171eb17e02c656c233271fd01b4705bb63cf1d43b7e9f03"

URI_x86_64_v2_ghc-data-default-instances-containers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-instances-containers-doc-0.0.1-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-data-default-instances-containers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-instances-containers-doc}"
SRC_URI[x86_64_v2_ghc-data-default-instances-containers-doc.sha256sum] = "632936b78dc729ed4c2cf2eef64d257e90183321cc674e4fd19987004a6312f0"

URI_x86_64_v2_ghc-data-default-instances-containers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-instances-containers-prof-0.0.1-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default-instances-containers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-instances-containers-prof}"
SRC_URI[x86_64_v2_ghc-data-default-instances-containers-prof.sha256sum] = "00424e11d96f96848a9884fc2e97b6a5f419a45ca0bd1b57cc050c52dc80d7b0"

URI_aarch64_ghc-data-default-instances-containers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-instances-containers-0.0.1-29.el10_0.aarch64.rpm;name=aarch64_ghc-data-default-instances-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-instances-containers}"
SRC_URI[aarch64_ghc-data-default-instances-containers.sha256sum] = "b2e7c766f3fb61cbdb9fc5052c48d3acb71d7cd9637003e5be09965fa9ca726a"

URI_aarch64_ghc-data-default-instances-containers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-instances-containers-devel-0.0.1-29.el10_0.aarch64.rpm;name=aarch64_ghc-data-default-instances-containers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-instances-containers-devel}"
SRC_URI[aarch64_ghc-data-default-instances-containers-devel.sha256sum] = "df8cb1846f4d94051da6bcb537029d23c7cb2b137021679c7b443862ef40c32f"

URI_aarch64_ghc-data-default-instances-containers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-instances-containers-doc-0.0.1-29.el10_0.noarch.rpm;name=aarch64_ghc-data-default-instances-containers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-instances-containers-doc}"
SRC_URI[aarch64_ghc-data-default-instances-containers-doc.sha256sum] = "2888dc058821b0f8f05742699b49d723d0951b37a7cc46b52d1fe6692c2d784d"

URI_aarch64_ghc-data-default-instances-containers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-instances-containers-prof-0.0.1-29.el10_0.aarch64.rpm;name=aarch64_ghc-data-default-instances-containers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-instances-containers-prof}"
SRC_URI[aarch64_ghc-data-default-instances-containers-prof.sha256sum] = "32277deb5ceb1d0ed013804a801726ecf11b35a3c5e0b32605517f2c1a7155d1"

RDEPENDS:ghc-data-default-instances-containers = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-data-default-instances-containers-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-data-default-class-devel \
 ghc-data-default-instances-containers \
 "
RDEPENDS:ghc-data-default-instances-containers-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-data-default-instances-containers-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-data-default-class-prof \
 ghc-data-default-instances-containers-devel \
 "
