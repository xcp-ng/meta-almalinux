# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SDL2_image"
PV = "2.8.2"
PR = "7.el10_0"
PACKAGES = " \
 SDL2_image \
 SDL2_image-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/SDL2_image-2.8.2-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5dab047eb2738eb047aba82573b23694b74f7bb47513c500ac2e9819963e1452"

URI_x86_64_v2_SDL2_image = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SDL2_image-2.8.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SDL2_image;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2_image}"
SRC_URI[x86_64_v2_SDL2_image.sha256sum] = "a284a5561d2fc300d3a380a8d3001d1a0d0f6f355260e7e858893593055cda48"

URI_x86_64_v2_SDL2_image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SDL2_image-devel-2.8.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SDL2_image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2_image-devel}"
SRC_URI[x86_64_v2_SDL2_image-devel.sha256sum] = "b9250f9b4862e94aa101a74db3a7814f8f4b061aa88f01f3a73a8c0156cb6b15"

URI_aarch64_SDL2_image = "${EPEL_MIRROR}/aarch64/Packages/s/SDL2_image-2.8.2-7.el10_0.aarch64.rpm;name=aarch64_SDL2_image;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2_image}"
SRC_URI[aarch64_SDL2_image.sha256sum] = "9c28d93a983a3abf5144ecdbfd1ca11c89888eec6450db9a1e68eb6b6773c913"

URI_aarch64_SDL2_image-devel = "${EPEL_MIRROR}/aarch64/Packages/s/SDL2_image-devel-2.8.2-7.el10_0.aarch64.rpm;name=aarch64_SDL2_image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2_image-devel}"
SRC_URI[aarch64_SDL2_image-devel.sha256sum] = "1220810ea1d941ecb3c22e544cba9af008b189fe4e32d33d5e62d4d5acdf8b25"

RDEPENDS:SDL2_image = " \
 glibc \
 libavif \
 libjxl \
 libtiff \
 libwebp \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:SDL2_image-devel = " \
 SDL2-devel \
 SDL2_image \
 libavif-devel \
 libjxl-devel \
 libtiff-devel \
 libwebp-devel \
 pkgconf-pkg-config \
 "
