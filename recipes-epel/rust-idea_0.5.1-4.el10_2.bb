# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-idea"
PV = "0.5.1"
PR = "4.el10_2"
PACKAGES = " \
 rust-idea+default-devel \
 rust-idea+zeroize-devel \
 rust-idea-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-idea-0.5.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcb25967e3b6d550c7f92b5b314725ae92fb2179b8184ef9a16a935b1c2d01af"

URI_x86_64_v2_rust-idea+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idea+default-devel-0.5.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idea+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idea+default-devel}"
SRC_URI[x86_64_v2_rust-idea+default-devel.sha256sum] = "f711e9c681dca8a25edcefb7105e8e38df8ab7febda45c7da97dcbc145a88251"

URI_x86_64_v2_rust-idea+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idea+zeroize-devel-0.5.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idea+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idea+zeroize-devel}"
SRC_URI[x86_64_v2_rust-idea+zeroize-devel.sha256sum] = "e7c34823b82825891258107d4701f50accd45aeb5144416171366256276dfb76"

URI_x86_64_v2_rust-idea-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idea-devel-0.5.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idea-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idea-devel}"
SRC_URI[x86_64_v2_rust-idea-devel.sha256sum] = "64174cb6739c59119d296a939d8b9cf0b5d3f31801ff39f2d2fd2f2e0a7d0977"

URI_aarch64_rust-idea+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idea+default-devel-0.5.1-4.el10_2.noarch.rpm;name=aarch64_rust-idea+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idea+default-devel}"
SRC_URI[aarch64_rust-idea+default-devel.sha256sum] = "6459a9b2721552237cf1a95a76e92a4a8643d5c6276771e85333af9821558d11"

URI_aarch64_rust-idea+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idea+zeroize-devel-0.5.1-4.el10_2.noarch.rpm;name=aarch64_rust-idea+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idea+zeroize-devel}"
SRC_URI[aarch64_rust-idea+zeroize-devel.sha256sum] = "8c6d1899bf5673ef4d682f2ec41606b5c8bb339155eb98578b0c12c12a8861a3"

URI_aarch64_rust-idea-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idea-devel-0.5.1-4.el10_2.noarch.rpm;name=aarch64_rust-idea-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idea-devel}"
SRC_URI[aarch64_rust-idea-devel.sha256sum] = "2be50c22e2032fc1a8ba989a4c7aa6e21c97b730572214e48cfb556829177179"

RDEPENDS:rust-idea+default-devel = " \
 cargo \
 rust-idea-devel \
 "
RDEPENDS:rust-idea+zeroize-devel = " \
 cargo \
 rust-cipher0.4+zeroize-devel \
 rust-idea-devel \
 "
RDEPENDS:rust-idea-devel = " \
 cargo \
 rust \
 rust-cipher0.4+default-devel \
 "
