# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Validate-IP"
PV = "0.31"
PR = "6.el10_0"
PACKAGES = " \
 perl-Data-Validate-IP \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Validate-IP-0.31-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97ddf421a7e32dd3936ff9221cf8b6385e443336d78fd4b959ca78375750f681"

URI_x86_64_v2_perl-Data-Validate-IP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Validate-IP-0.31-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Validate-IP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Validate-IP}"
SRC_URI[x86_64_v2_perl-Data-Validate-IP.sha256sum] = "79148284a1b238081b18dec9f795b25fc5e776c7007961c0efc74d2c76c8fc8a"

URI_aarch64_perl-Data-Validate-IP = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Validate-IP-0.31-6.el10_0.noarch.rpm;name=aarch64_perl-Data-Validate-IP;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Validate-IP}"
SRC_URI[aarch64_perl-Data-Validate-IP.sha256sum] = "59447fcc21b99d877304a13cba653d6cdbde3ef0fbd4d9a147c859171e01d682"

RDEPENDS:perl-Data-Validate-IP = " \
 perl-Exporter \
 perl-NetAddr-IP \
 perl-Scalar-List-Utils \
 perl-base \
 perl-libs \
 "
