# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-orion"
PV = "0.17.15"
PR = "1.el10_2"
PACKAGES = " \
 rust-orion+alloc-devel \
 rust-orion+ct-codecs-devel \
 rust-orion+default-devel \
 rust-orion+experimental-devel \
 rust-orion+getrandom-devel \
 rust-orion+safe_api-devel \
 rust-orion+serde-devel \
 rust-orion+zeroize-devel \
 rust-orion-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-orion-0.17.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9e41b88d018abf7bf9061281dd9580252c82b74b8e12452d59b52f9057eb82de"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+alloc-devel-0.17.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+alloc-devel.sha256sum] = "18d21971e89594add1f8dcb6116c4791fcff622c67294dd3fa2ec1ee8871829b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+ct-codecs-devel-0.17.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+ct-codecs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+ct-codecs-devel.sha256sum] = "c77400577d7c3ad9bbd6bcd9abd7057ebf4be7764cd3fe50b8237a046d7b83b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+default-devel-0.17.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+default-devel.sha256sum] = "5c11cd1cd484e09759e59f1f6204075fb42b9c7add552fc917c147e53f6ffb10"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+experimental-devel-0.17.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+experimental-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+experimental-devel.sha256sum] = "49bad588bff77fc0359faa1719abee9ba5b9dcac9bfc2be690d7acb44c80dd41"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+getrandom-devel-0.17.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+getrandom-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+getrandom-devel.sha256sum] = "3073f01b0a4ec3dffae40d3cf5e4fcee80b1bb4dc0b6422e7467c2780aeeae3d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+safe_api-devel-0.17.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+safe_api-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+safe_api-devel.sha256sum] = "02ea4a4030e8ea25910d9320223b6eb39b65788a8f13f657aa1de2a3bf37ead4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+serde-devel-0.17.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+serde-devel.sha256sum] = "c6aa67309f268f2b68bea5028738b83aeadeba0cb4a01f1c8962bf3c8bf37cbe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+zeroize-devel-0.17.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+zeroize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+zeroize-devel.sha256sum] = "1e417321c22835daf0030ebb14f6c7aa0aa8f161374174573344686b8ab9e816"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion-devel-0.17.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion-devel.sha256sum] = "8e9bf2f84af5726e0d509c8e6c31376aa80de878d2a4df28725d3c5c8cf5c20b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+alloc-devel-0.17.15-1.el10_2.noarch.rpm;name=aarch64_rust-orion+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-orion+alloc-devel.sha256sum] = "e77dcc2ae398ae648370af10d31855ec10b17d04e4b1852bd7fb9dd87b5742f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+ct-codecs-devel-0.17.15-1.el10_2.noarch.rpm;name=aarch64_rust-orion+ct-codecs-devel;unpack=0"
SRC_URI[aarch64_rust-orion+ct-codecs-devel.sha256sum] = "01b2feeba96fc4e54e3f5a2aee5a429b3bf1ee54b9cb92fbd8a5b84ca92ac8a5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+default-devel-0.17.15-1.el10_2.noarch.rpm;name=aarch64_rust-orion+default-devel;unpack=0"
SRC_URI[aarch64_rust-orion+default-devel.sha256sum] = "3bd1897777f64acfb749098834e3ae5aa065c46bd35a644657d1ebb829ac3671"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+experimental-devel-0.17.15-1.el10_2.noarch.rpm;name=aarch64_rust-orion+experimental-devel;unpack=0"
SRC_URI[aarch64_rust-orion+experimental-devel.sha256sum] = "e70c4252695a2a87dc73091347360b96c021bb2d41f09e8f0c0161bed6714daa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+getrandom-devel-0.17.15-1.el10_2.noarch.rpm;name=aarch64_rust-orion+getrandom-devel;unpack=0"
SRC_URI[aarch64_rust-orion+getrandom-devel.sha256sum] = "f7a48d5b048aa77042b0e6cce47ab1ed32c4114b022e67bbb2e63dcf46705c7d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+safe_api-devel-0.17.15-1.el10_2.noarch.rpm;name=aarch64_rust-orion+safe_api-devel;unpack=0"
SRC_URI[aarch64_rust-orion+safe_api-devel.sha256sum] = "4971bfb79f6cae212b705d01d1d7a8c91860a416f5eee4bd0e588e5847501ada"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+serde-devel-0.17.15-1.el10_2.noarch.rpm;name=aarch64_rust-orion+serde-devel;unpack=0"
SRC_URI[aarch64_rust-orion+serde-devel.sha256sum] = "1ccd1d5f38d1a83cc29404095bc7a63d801392c12b302577c9aca3a23f942913"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+zeroize-devel-0.17.15-1.el10_2.noarch.rpm;name=aarch64_rust-orion+zeroize-devel;unpack=0"
SRC_URI[aarch64_rust-orion+zeroize-devel.sha256sum] = "396508aad5ea059d281e905ec1df80ef2c4e270ce96dba40e22b9c290113a541"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion-devel-0.17.15-1.el10_2.noarch.rpm;name=aarch64_rust-orion-devel;unpack=0"
SRC_URI[aarch64_rust-orion-devel.sha256sum] = "3e5692915c69c230546c3f295983711fe9071fdcf2166410bd1973a7537bb117"

RDEPENDS:rust-orion+alloc-devel = " \
 cargo \
 rust-orion-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-orion+ct-codecs-devel = " \
 cargo \
 rust-ct-codecs+default-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+default-devel = " \
 cargo \
 rust-orion+safe_api-devel \
 rust-orion+zeroize-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+experimental-devel = " \
 cargo \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+safe_api-devel = " \
 cargo \
 rust-orion+ct-codecs-devel \
 rust-orion+getrandom-devel \
 rust-orion-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-orion+serde-devel = " \
 cargo \
 rust-orion+alloc-devel \
 rust-orion-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-orion+zeroize-devel = " \
 cargo \
 rust-orion-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-orion-devel = " \
 cargo \
 rust \
 rust-fiat-crypto-devel \
 rust-subtle-devel \
 "
