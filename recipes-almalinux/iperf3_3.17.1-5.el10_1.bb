# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iperf3"
PV = "3.17.1"
PR = "5.el10_1"
PACKAGES = " \
 iperf3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/iperf3-3.17.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "598fc9c3e0b70f0a968d5b27f36971fe6e25c991ea12f737f774e4b9263b15f0"

URI_x86_64_v2_iperf3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iperf3-3.17.1-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_iperf3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iperf3}"
SRC_URI[x86_64_v2_iperf3.sha256sum] = "daf6ad5bb792aa3e7c5334f763e00dc71b26dc6c8270b0069515ef4b4181b492"

URI_aarch64_iperf3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iperf3-3.17.1-5.el10_1.aarch64.rpm;name=aarch64_iperf3;unpack=0"
SRC_URI:append = " ${URI_aarch64_iperf3}"
SRC_URI[aarch64_iperf3.sha256sum] = "6b2f179de74eaa61ec0c1acf145bfb475462fa06c54407a9df35b29d2563686f"

RDEPENDS:iperf3 = " \
 glibc \
 lksctp-tools \
 openssl-libs \
 "
