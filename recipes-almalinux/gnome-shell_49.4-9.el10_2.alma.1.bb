# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell"
PV = "49.4"
PR = "9.el10_2.alma.1"
PACKAGES = " \
 gnome-shell \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-shell-49.4-9.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "30183a63c174499ed267b8f0d9e93e3e9e1ecaa7d58679a0cb2b780fe607e55a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-49.4-9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_gnome-shell;unpack=0"
SRC_URI[x86_64_v2_gnome-shell.sha256sum] = "9b7c7d201428d1cf1f450bd37de60b3b6b3200858552124a842cd69973ea08e4"
RPROVIDES:gnome-shell:append:x86_64_v2 = " virtual/PolicyKit-authentication-agent"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-49.4-9.el10_2.alma.1.aarch64.rpm;name=aarch64_gnome-shell;unpack=0"
SRC_URI[aarch64_gnome-shell.sha256sum] = "fb2fa1202dd7ceaee57676437885b93023fc71cf0fdb60702986253b23ae84fe"
RPROVIDES:gnome-shell:append:aarch64 = " virtual/PolicyKit-authentication-agent"

RDEPENDS:gnome-shell = " \
 NetworkManager-libnm \
 accountsservice-libs \
 at-spi2-atk \
 atk \
 cairo \
 evolution-data-server \
 gcr \
 gcr-libs \
 gdk-pixbuf2 \
 gdm \
 geoclue2-libs \
 gettext \
 gjs \
 glib2 \
 glibc \
 gnome-autoar \
 gnome-control-center \
 gnome-desktop4 \
 gnome-settings-daemon \
 gobject-introspection \
 graphene \
 gsettings-desktop-schemas \
 gstreamer1 \
 gstreamer1-plugins-good \
 gtk4 \
 ibus-libs \
 json-glib \
 libX11 \
 libXext \
 libXfixes \
 libadwaita \
 libgcc \
 libglvnd-gles \
 libgweather \
 libical-glib \
 libnma-gtk4 \
 librsvg2 \
 libsecret \
 libsoup3 \
 mutter \
 pango \
 pipewire-gstreamer \
 pipewire-libs \
 polkit \
 polkit-libs \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 python3 \
 python3-argcomplete \
 switcheroo-control \
 systemd-libs \
 tecla \
 upower \
 xdg-desktop-portal-gnome \
 xdg-desktop-portal-gtk \
 xdg-user-dirs-gtk \
 "
