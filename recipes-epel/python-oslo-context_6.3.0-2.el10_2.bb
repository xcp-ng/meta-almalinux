# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslo-context"
PV = "6.3.0"
PR = "2.el10_2"
PACKAGES = " \
 python-oslo-context-doc \
 python3-oslo-context \
 python3-oslo-context-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-oslo-context-6.3.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1542f5b3b60c5882030c31ba32c66959e11332d7f41a2cde90107cc784de61e"

URI_x86_64_v2_python-oslo-context-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-context-doc-6.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-context-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-context-doc}"
SRC_URI[x86_64_v2_python-oslo-context-doc.sha256sum] = "ceefe2260e93f00693b555cd747fec13b0952b1aee142955b4ac788bcbb7e32c"

URI_x86_64_v2_python3-oslo-context = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-context-6.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-context;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-context}"
SRC_URI[x86_64_v2_python3-oslo-context.sha256sum] = "410bf04302af665ef6d405578d8decb11c02f76408f4e0bb0c12c525145a179e"

URI_x86_64_v2_python3-oslo-context-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-context-tests-6.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-context-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-context-tests}"
SRC_URI[x86_64_v2_python3-oslo-context-tests.sha256sum] = "fffab59b25a0f80e09437fd56b52a2a5f6de0957a954484366849a5ec4586fa3"

URI_aarch64_python-oslo-context-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-context-doc-6.3.0-2.el10_2.noarch.rpm;name=aarch64_python-oslo-context-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-context-doc}"
SRC_URI[aarch64_python-oslo-context-doc.sha256sum] = "debfbe10d94e0a734ec169c2c06c2dc8f2c6c2142a7cb375d6d564adbb4b4433"

URI_aarch64_python3-oslo-context = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-context-6.3.0-2.el10_2.noarch.rpm;name=aarch64_python3-oslo-context;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-context}"
SRC_URI[aarch64_python3-oslo-context.sha256sum] = "3070ba4dffce1af788a8bd8264f3ec5235cee14b50bc4aa2165b3a33545f9412"

URI_aarch64_python3-oslo-context-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-context-tests-6.3.0-2.el10_2.noarch.rpm;name=aarch64_python3-oslo-context-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-context-tests}"
SRC_URI[aarch64_python3-oslo-context-tests.sha256sum] = "134df17cb1911372b7fe79165bf836a6ea07c5d7c7b9e0bfc41f53b914bc9904"

RDEPENDS:python-oslo-context-doc = " \
 "
RDEPENDS:python3-oslo-context = " \
 python3 \
 python3-pbr \
 python3-typing-extensions \
 "
RDEPENDS:python3-oslo-context-tests = " \
 python3 \
 python3-oslo-context \
 "
