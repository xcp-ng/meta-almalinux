# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Log-Contextual"
PV = "0.009001"
PR = "6.el10_3"
PACKAGES = " \
 perl-Log-Contextual \
 perl-Log-Contextual-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Log-Contextual-0.009001-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7afd36b6171dedcb285d1b272f54e8825bbd7f43e4be6c7d03210d7af851950e"

URI_x86_64_v2_perl-Log-Contextual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Contextual-0.009001-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Contextual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Contextual}"
SRC_URI[x86_64_v2_perl-Log-Contextual.sha256sum] = "8880b596697d21c3a229cb31fec096b3a942adbecfad97161170b537899214d8"

URI_x86_64_v2_perl-Log-Contextual-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Contextual-tests-0.009001-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Contextual-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Contextual-tests}"
SRC_URI[x86_64_v2_perl-Log-Contextual-tests.sha256sum] = "950a74226fde672576a10ea9b58468bb8d94ed7839cee96c3675549053e5f129"

URI_aarch64_perl-Log-Contextual = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Contextual-0.009001-6.el10_3.noarch.rpm;name=aarch64_perl-Log-Contextual;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Contextual}"
SRC_URI[aarch64_perl-Log-Contextual.sha256sum] = "594dd1e8b6b4e555927e807420cbc65a67f32b1acb1509e35fc4434adabb4ad2"

URI_aarch64_perl-Log-Contextual-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Contextual-tests-0.009001-6.el10_3.noarch.rpm;name=aarch64_perl-Log-Contextual-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Contextual-tests}"
SRC_URI[aarch64_perl-Log-Contextual-tests.sha256sum] = "a28d7847432d7b73bc07f1063b5a94984b9a53901361d6ae08829462bb0888a8"

RDEPENDS:perl-Log-Contextual = " \
 perl-B \
 perl-Carp \
 perl-Data-Dumper-Concise \
 perl-Log-Contextual \
 perl-Moo \
 perl-Scalar-List-Utils \
 perl-libs \
 "
RDEPENDS:perl-Log-Contextual-tests = " \
 bash \
 perl-ExtUtils-MakeMaker \
 perl-File-Temp \
 perl-IO \
 perl-IPC-Open3 \
 perl-Log-Contextual \
 perl-Log-Log4perl \
 perl-PathTools \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Needs \
 perl-Test-Simple \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
