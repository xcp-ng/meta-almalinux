# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unit-prefix"
PV = "0.5.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-unit-prefix+default-devel \
 rust-unit-prefix+std-devel \
 rust-unit-prefix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unit-prefix-0.5.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1a3ea9f8487625b6302f8c3986935a73a071334097d4506105e9b5a33ff0c1a"

URI_x86_64_v2_rust-unit-prefix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unit-prefix+default-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unit-prefix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unit-prefix+default-devel}"
SRC_URI[x86_64_v2_rust-unit-prefix+default-devel.sha256sum] = "e4edf871bb326d6fe167f90402a61248ac722f1da7cdc28a02cf325e2082ca69"

URI_x86_64_v2_rust-unit-prefix+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unit-prefix+std-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unit-prefix+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unit-prefix+std-devel}"
SRC_URI[x86_64_v2_rust-unit-prefix+std-devel.sha256sum] = "ac439fed46d7f17ac8b9924cc4159c3216bb3e6abdfcdadafc37b9e37f999155"

URI_x86_64_v2_rust-unit-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unit-prefix-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unit-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unit-prefix-devel}"
SRC_URI[x86_64_v2_rust-unit-prefix-devel.sha256sum] = "257537906be4fd6fdcf4b77065c6ec94d8be77546e3f99d71b07704282303ded"

URI_aarch64_rust-unit-prefix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unit-prefix+default-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-unit-prefix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unit-prefix+default-devel}"
SRC_URI[aarch64_rust-unit-prefix+default-devel.sha256sum] = "3b23dc6a3d6e5bc3a713f1af5c3fe0e0152404fd0c51ac1f165d4b4b7b6cd0a6"

URI_aarch64_rust-unit-prefix+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unit-prefix+std-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-unit-prefix+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unit-prefix+std-devel}"
SRC_URI[aarch64_rust-unit-prefix+std-devel.sha256sum] = "a0c555f455dc496f8876146039911d7ca1ba3d6e1d0630ab6197e841fa6aa025"

URI_aarch64_rust-unit-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unit-prefix-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-unit-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unit-prefix-devel}"
SRC_URI[aarch64_rust-unit-prefix-devel.sha256sum] = "6030be17aa70b2d7feba22c364ca8ced73bc216ddb29dc8dd02f1f4376de900d"

RDEPENDS:rust-unit-prefix+default-devel = " \
 cargo \
 rust-unit-prefix+std-devel \
 rust-unit-prefix-devel \
 "
RDEPENDS:rust-unit-prefix+std-devel = " \
 cargo \
 rust-unit-prefix-devel \
 "
RDEPENDS:rust-unit-prefix-devel = " \
 cargo \
 rust \
 "
