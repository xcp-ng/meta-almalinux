# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-filesystem"
PV = "5"
PR = "3.el10_0"
PACKAGES = " \
 kde-filesystem \
 kde3-filesystem \
 kde4-filesystem \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-filesystem-5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2ee021d3f492bec9600b4d7892ce2e67f11f5cee7df542ea0a39cbcc69b0429"

URI_x86_64_v2_kde-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-filesystem-5-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-filesystem}"
SRC_URI[x86_64_v2_kde-filesystem.sha256sum] = "bdfc078013ca586dea208fdf0fef218e490a13f39037b03b2cdb52fd88864f0d"

URI_x86_64_v2_kde3-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde3-filesystem-5-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde3-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde3-filesystem}"
SRC_URI[x86_64_v2_kde3-filesystem.sha256sum] = "faf5f5d107c6da5aac3b050dd3b1abe8d769488816810efbd418eb141552890b"

URI_x86_64_v2_kde4-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde4-filesystem-5-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde4-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde4-filesystem}"
SRC_URI[x86_64_v2_kde4-filesystem.sha256sum] = "8aeec9d0ca53490d11271500ac50a539deaa3d42b8929eac4b5bd8177affc521"

URI_aarch64_kde-filesystem = "${EPEL_MIRROR}/aarch64/Packages/k/kde-filesystem-5-3.el10_0.aarch64.rpm;name=aarch64_kde-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-filesystem}"
SRC_URI[aarch64_kde-filesystem.sha256sum] = "c9d8a2388acc2e869259ce3a902096ec890cd494e1fdb3a196d7b868528c9187"

URI_aarch64_kde3-filesystem = "${EPEL_MIRROR}/aarch64/Packages/k/kde3-filesystem-5-3.el10_0.aarch64.rpm;name=aarch64_kde3-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde3-filesystem}"
SRC_URI[aarch64_kde3-filesystem.sha256sum] = "d78174e0ed7828926674e00de901726a4bfb69fb2254594ac230048d468c8368"

URI_aarch64_kde4-filesystem = "${EPEL_MIRROR}/aarch64/Packages/k/kde4-filesystem-5-3.el10_0.aarch64.rpm;name=aarch64_kde4-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde4-filesystem}"
SRC_URI[aarch64_kde4-filesystem.sha256sum] = "7e9052697ab416222eb099c288a55e5727247c7efd43db0568df22ab20466c8b"

RDEPENDS:kde-filesystem = " \
 filesystem \
 rpm \
 "
RDEPENDS:kde3-filesystem = " \
 kde-filesystem \
 "
RDEPENDS:kde4-filesystem = " \
 kde-filesystem \
 "
