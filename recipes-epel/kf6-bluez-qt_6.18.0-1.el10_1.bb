# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-bluez-qt"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-bluez-qt \
 kf6-bluez-qt-devel \
 kf6-bluez-qt-doc \
 kf6-bluez-qt-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-bluez-qt-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b57e332283b1c92d200c1245b2709e206e63bdb134ceccc033a67f9e88748a46"

URI_x86_64_v2_kf6-bluez-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-bluez-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt}"
SRC_URI[x86_64_v2_kf6-bluez-qt.sha256sum] = "d2f52b812ac2c61dd0799cddd62b906f0e649399f85df7a2b694fb5ca57bbc9e"

URI_x86_64_v2_kf6-bluez-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-bluez-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt-devel}"
SRC_URI[x86_64_v2_kf6-bluez-qt-devel.sha256sum] = "bfbdf90beb161e50be55423e19a729e3feff2ad2badc94334951c7021839b58d"

URI_x86_64_v2_kf6-bluez-qt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-bluez-qt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt-doc}"
SRC_URI[x86_64_v2_kf6-bluez-qt-doc.sha256sum] = "9cb6b9b02f2ef13ef89cb284164db7ad05710068de9610d241ecfb6b2ef75eeb"

URI_x86_64_v2_kf6-bluez-qt-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-bluez-qt-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt-html}"
SRC_URI[x86_64_v2_kf6-bluez-qt-html.sha256sum] = "6877107fb73241da3aa059652da75300d905cde12977c6f9e60f741cc67d3d81"

URI_aarch64_kf6-bluez-qt = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-bluez-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt}"
SRC_URI[aarch64_kf6-bluez-qt.sha256sum] = "026c0d29e2ae4708c4cfd5a266fd6ccbe56a27d44862dcd13736fa4ad4738d5f"

URI_aarch64_kf6-bluez-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-bluez-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt-devel}"
SRC_URI[aarch64_kf6-bluez-qt-devel.sha256sum] = "6687486c91a39498411a004e88b35c74cd6f5cb8b24b64453e4e614433fcd34e"

URI_aarch64_kf6-bluez-qt-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-bluez-qt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt-doc}"
SRC_URI[aarch64_kf6-bluez-qt-doc.sha256sum] = "7d97661d1e28e51eee1d496b86f41aaa5046613743d646493db9e4fe70f06c4a"

URI_aarch64_kf6-bluez-qt-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-bluez-qt-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt-html}"
SRC_URI[aarch64_kf6-bluez-qt-html.sha256sum] = "e750061074c4100a288ea5965162f84ff5d3cf67f18ed1613c37e66d469af77c"

RDEPENDS:kf6-bluez-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-bluez-qt-devel = " \
 cmake-filesystem \
 kf6-bluez-qt \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-bluez-qt-doc = " \
 "
RDEPENDS:kf6-bluez-qt-html = " \
 "
