# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-print-manager"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-print-manager \
 plasma-print-manager-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-print-manager-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d735398370967e9edc251c15986220a14e7a006f3b8f11180b55bf242fd3d192"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-print-manager-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-print-manager;unpack=0"
SRC_URI[x86_64_v2_plasma-print-manager.sha256sum] = "c016d2117e83fb38cf1e44e932e712fd59a14f89a5eb0f5d1eefb28e59e02d45"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-print-manager-libs-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-print-manager-libs;unpack=0"
SRC_URI[x86_64_v2_plasma-print-manager-libs.sha256sum] = "1cef2a22d6f0b409ba1f42e19e983560e3ddf75065a7af8e963b93e04835dd45"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-print-manager-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-print-manager;unpack=0"
SRC_URI[aarch64_plasma-print-manager.sha256sum] = "b1d0457107f7dcc9da2b15f3131dd77865100d88a672173a2de92286551da2e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-print-manager-libs-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-print-manager-libs;unpack=0"
SRC_URI[aarch64_plasma-print-manager-libs.sha256sum] = "38441e08ece4b4ac8beb781a54117fd0008f473f3d7591efdc6e8688f510c7ce"

RDEPENDS:plasma-print-manager = " \
 PackageKit-Qt6 \
 cups \
 cups-libs \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 plasma-print-manager-libs \
 plasma-workspace \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 system-config-printer-libs \
 "
RDEPENDS:plasma-print-manager-libs = " \
 cups-libs \
 glibc \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libplasma \
 libstdc++ \
 plasma-print-manager \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
