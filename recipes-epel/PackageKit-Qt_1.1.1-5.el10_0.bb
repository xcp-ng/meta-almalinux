# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "PackageKit-Qt"
PV = "1.1.1"
PR = "5.el10_0"
PACKAGES = " \
 PackageKit-Qt5 \
 PackageKit-Qt5-devel \
 PackageKit-Qt6 \
 PackageKit-Qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/PackageKit-Qt-1.1.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27d63150f3d97a6ca63191fd99c35edfbc6faf4242fcd1373f70347de9fdaa6b"

URI_x86_64_v2_PackageKit-Qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/PackageKit-Qt5-1.1.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_PackageKit-Qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-Qt5}"
SRC_URI[x86_64_v2_PackageKit-Qt5.sha256sum] = "62bea0bef959e9fe97701a5ba754b43b331198ebf634b2af06cb1896f0660266"

URI_x86_64_v2_PackageKit-Qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/PackageKit-Qt5-devel-1.1.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_PackageKit-Qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-Qt5-devel}"
SRC_URI[x86_64_v2_PackageKit-Qt5-devel.sha256sum] = "988ab0bcfa7b8fdf3f9f864ed92a981d39640d16cc5c7af08dff91d5316aef62"

URI_x86_64_v2_PackageKit-Qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/PackageKit-Qt6-1.1.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_PackageKit-Qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-Qt6}"
SRC_URI[x86_64_v2_PackageKit-Qt6.sha256sum] = "faaa0ce3959b8a63fc9b77a5a6ad99d0d9f119bac135f1baa955e56886ecbeff"

URI_x86_64_v2_PackageKit-Qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/PackageKit-Qt6-devel-1.1.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_PackageKit-Qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-Qt6-devel}"
SRC_URI[x86_64_v2_PackageKit-Qt6-devel.sha256sum] = "cbb32060a3e4946f5f5006ea923d3ca699ba7d46a860f513cd2abd853f74b493"

URI_aarch64_PackageKit-Qt5 = "${EPEL_MIRROR}/aarch64/Packages/p/PackageKit-Qt5-1.1.1-5.el10_0.aarch64.rpm;name=aarch64_PackageKit-Qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-Qt5}"
SRC_URI[aarch64_PackageKit-Qt5.sha256sum] = "152dc56dfa07f9c5413df327d19a8939f6952c4d8ab1febc5293f6648671ef74"

URI_aarch64_PackageKit-Qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/p/PackageKit-Qt5-devel-1.1.1-5.el10_0.aarch64.rpm;name=aarch64_PackageKit-Qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-Qt5-devel}"
SRC_URI[aarch64_PackageKit-Qt5-devel.sha256sum] = "bc34e4fa9598d2e895742e56a286b3a171b7b112aff67fad9a42898f9da64d36"

URI_aarch64_PackageKit-Qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/PackageKit-Qt6-1.1.1-5.el10_0.aarch64.rpm;name=aarch64_PackageKit-Qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-Qt6}"
SRC_URI[aarch64_PackageKit-Qt6.sha256sum] = "4eb424afd4024729f8d72f470f59234f3ab03c873db5337c231555e31a04bd50"

URI_aarch64_PackageKit-Qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/PackageKit-Qt6-devel-1.1.1-5.el10_0.aarch64.rpm;name=aarch64_PackageKit-Qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-Qt6-devel}"
SRC_URI[aarch64_PackageKit-Qt6-devel.sha256sum] = "fbbd0c4805c72e2ace26ee3ab6cb6f7af614fd1caea8188823be4fb50870500e"

RDEPENDS:PackageKit-Qt5 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:PackageKit-Qt5-devel = " \
 PackageKit-Qt5 \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 "
RDEPENDS:PackageKit-Qt6 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:PackageKit-Qt6-devel = " \
 PackageKit-Qt6 \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
