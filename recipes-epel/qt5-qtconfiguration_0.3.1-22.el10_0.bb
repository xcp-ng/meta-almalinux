# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtconfiguration"
PV = "0.3.1"
PR = "22.el10_0"
PACKAGES = " \
 qt5-qtconfiguration \
 qt5-qtconfiguration-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtconfiguration-0.3.1-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3dde063e4dcadc320428aa16a784afa5524fe1707d657f1ea387c3410a3a058d"

URI_x86_64_v2_qt5-qtconfiguration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtconfiguration-0.3.1-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtconfiguration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtconfiguration}"
SRC_URI[x86_64_v2_qt5-qtconfiguration.sha256sum] = "fd92a2f0e21e6816877ac3fa4721f17fc2817792ab1567ff4a1fd86e89e1fe67"

URI_x86_64_v2_qt5-qtconfiguration-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtconfiguration-devel-0.3.1-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtconfiguration-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtconfiguration-devel}"
SRC_URI[x86_64_v2_qt5-qtconfiguration-devel.sha256sum] = "18ac0d160b593251901027d2edd02518d62ddbb313f0ec1e3253272f6b7cdf1e"

URI_aarch64_qt5-qtconfiguration = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtconfiguration-0.3.1-22.el10_0.aarch64.rpm;name=aarch64_qt5-qtconfiguration;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtconfiguration}"
SRC_URI[aarch64_qt5-qtconfiguration.sha256sum] = "8be44828912729d483197ecfb995fafb452bca92d58451325f98429f99611cd1"

URI_aarch64_qt5-qtconfiguration-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtconfiguration-devel-0.3.1-22.el10_0.aarch64.rpm;name=aarch64_qt5-qtconfiguration-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtconfiguration-devel}"
SRC_URI[aarch64_qt5-qtconfiguration-devel.sha256sum] = "93d5cd387ed349d1715602f203ca519a744b7bbd9c35a4143e31f4c9a58c934e"

RDEPENDS:qt5-qtconfiguration = " \
 dconf \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtconfiguration-devel = " \
 cmake-filesystem \
 qt5-qtbase-devel \
 qt5-qtconfiguration \
 "
