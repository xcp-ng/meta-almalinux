# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jupyterlab-server"
PV = "2.27.3"
PR = "4.el10_1"
PACKAGES = " \
 python3-jupyterlab-server \
 python3-jupyterlab-server+test \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jupyterlab-server-2.27.3-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "094bdd2f676a27ad57baf3e6ee1e2c9b46379e36039b606791efb30924c57637"

URI_x86_64_v2_python3-jupyterlab-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jupyterlab-server-2.27.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jupyterlab-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jupyterlab-server}"
SRC_URI[x86_64_v2_python3-jupyterlab-server.sha256sum] = "1ab836b44d8fb6b0eff399de4171cd43d773baff29d6106d113ad579fdbc491b"

URI_x86_64_v2_python3-jupyterlab-server+test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jupyterlab-server+test-2.27.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jupyterlab-server+test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jupyterlab-server+test}"
SRC_URI[x86_64_v2_python3-jupyterlab-server+test.sha256sum] = "f1cde25f10a31d37c9ab585dcd00fdca50333bf1c76f12d3b03efdc833133bb9"

URI_aarch64_python3-jupyterlab-server = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jupyterlab-server-2.27.3-4.el10_1.noarch.rpm;name=aarch64_python3-jupyterlab-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jupyterlab-server}"
SRC_URI[aarch64_python3-jupyterlab-server.sha256sum] = "5b2fd480ef125b8064b19832350caf14b299c61191dc2ef528f35c89670ef9fa"

URI_aarch64_python3-jupyterlab-server+test = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jupyterlab-server+test-2.27.3-4.el10_1.noarch.rpm;name=aarch64_python3-jupyterlab-server+test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jupyterlab-server+test}"
SRC_URI[aarch64_python3-jupyterlab-server+test.sha256sum] = "704c03c40a2d85513a8f856b2062abc29ed7bd8ff48fdc24a90fb3b509a1704d"

RDEPENDS:python3-jupyterlab-server = " \
 python3 \
 python3-babel \
 python3-jinja2 \
 python3-json5 \
 python3-jsonschema \
 python3-jupyter-server \
 python3-packaging \
 python3-requests \
 "
RDEPENDS:python3-jupyterlab-server+test = " \
 python3 \
 python3-ipykernel \
 python3-jupyterlab-server \
 python3-pytest \
 python3-pytest-console-scripts \
 python3-pytest-jupyter \
 python3-pytest-jupyter+server \
 python3-pytest-timeout \
 python3-requests-mock \
 python3-ruamel-yaml \
 python3-strict-rfc3339 \
 python3-werkzeug \
 "
