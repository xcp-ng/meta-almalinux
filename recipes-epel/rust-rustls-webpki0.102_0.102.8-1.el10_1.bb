# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-webpki0.102"
PV = "0.102.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-rustls-webpki0.102+alloc-devel \
 rust-rustls-webpki0.102+default-devel \
 rust-rustls-webpki0.102+ring-devel \
 rust-rustls-webpki0.102+std-devel \
 rust-rustls-webpki0.102-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-webpki0.102-0.102.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1cac07e8f13412fb812ef505045c4a2f6b0cb84a8e25cf25a60f0c8e709c2e2f"

URI_x86_64_v2_rust-rustls-webpki0.102+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki0.102+alloc-devel-0.102.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki0.102+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki0.102+alloc-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki0.102+alloc-devel.sha256sum] = "0ed1f55d5e921402e6b7250afca9614e1e8d817499c55bb22b593e9ea21be432"

URI_x86_64_v2_rust-rustls-webpki0.102+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki0.102+default-devel-0.102.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki0.102+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki0.102+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki0.102+default-devel.sha256sum] = "84a6929bbb685d6444e68be6b4393a267b45020636fd84d82f36b2d7e6636b5e"

URI_x86_64_v2_rust-rustls-webpki0.102+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki0.102+ring-devel-0.102.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki0.102+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki0.102+ring-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki0.102+ring-devel.sha256sum] = "70a5b520db840dea80082e09c3fbf0fd08d33bb45a9d17c8d059882c8556f0c8"

URI_x86_64_v2_rust-rustls-webpki0.102+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki0.102+std-devel-0.102.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki0.102+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki0.102+std-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki0.102+std-devel.sha256sum] = "c4c71052cb95f4ca8bc6140bdd96ff40608254e12d3938c49235892c8654e0a5"

URI_x86_64_v2_rust-rustls-webpki0.102-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki0.102-devel-0.102.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki0.102-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki0.102-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki0.102-devel.sha256sum] = "5d3310559d29906b34766e105b3830ffb33d6b27b510883c580b2a2ec3b1bad0"

URI_aarch64_rust-rustls-webpki0.102+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki0.102+alloc-devel-0.102.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-webpki0.102+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki0.102+alloc-devel}"
SRC_URI[aarch64_rust-rustls-webpki0.102+alloc-devel.sha256sum] = "d8d268996b0b93aa45fdb6d21fe9aa86d09f65bb02b6002484d408fc250b4f01"

URI_aarch64_rust-rustls-webpki0.102+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki0.102+default-devel-0.102.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-webpki0.102+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki0.102+default-devel}"
SRC_URI[aarch64_rust-rustls-webpki0.102+default-devel.sha256sum] = "63f03ab21bdb823041309f1b1a339d881b654b43a7c4fa81ef949d49f9473bb1"

URI_aarch64_rust-rustls-webpki0.102+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki0.102+ring-devel-0.102.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-webpki0.102+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki0.102+ring-devel}"
SRC_URI[aarch64_rust-rustls-webpki0.102+ring-devel.sha256sum] = "da07ebfab0641e5e7c2f321b4506e5dd427b280b3ced1b5dc6747f829b6cc76c"

URI_aarch64_rust-rustls-webpki0.102+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki0.102+std-devel-0.102.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-webpki0.102+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki0.102+std-devel}"
SRC_URI[aarch64_rust-rustls-webpki0.102+std-devel.sha256sum] = "2b4e8e43dc94980c893b5b0dd5c88ee84318dc458073737dec1b76666f28e5f9"

URI_aarch64_rust-rustls-webpki0.102-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki0.102-devel-0.102.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-webpki0.102-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki0.102-devel}"
SRC_URI[aarch64_rust-rustls-webpki0.102-devel.sha256sum] = "172a09214beb318f1d70cea7a3695061832ab6f97d3df412b470ccd09dde12fc"

RDEPENDS:rust-rustls-webpki0.102+alloc-devel = " \
 cargo \
 rust-ring+alloc-devel \
 rust-ring-devel \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-webpki0.102-devel \
 "
RDEPENDS:rust-rustls-webpki0.102+default-devel = " \
 cargo \
 rust-rustls-webpki0.102+ring-devel \
 rust-rustls-webpki0.102+std-devel \
 rust-rustls-webpki0.102-devel \
 "
RDEPENDS:rust-rustls-webpki0.102+ring-devel = " \
 cargo \
 rust-ring-devel \
 rust-rustls-webpki0.102-devel \
 "
RDEPENDS:rust-rustls-webpki0.102+std-devel = " \
 cargo \
 rust-rustls-pki-types+std-devel \
 rust-rustls-webpki0.102+alloc-devel \
 rust-rustls-webpki0.102-devel \
 "
RDEPENDS:rust-rustls-webpki0.102-devel = " \
 cargo \
 rust \
 rust-rustls-pki-types-devel \
 rust-untrusted+default-devel \
 "
