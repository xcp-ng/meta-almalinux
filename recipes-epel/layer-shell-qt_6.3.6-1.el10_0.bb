# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "layer-shell-qt"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 layer-shell-qt \
 layer-shell-qt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/layer-shell-qt-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6c7fcfb021f005e0109342b142c9821da04dff0aea3674c0ef6b11f35e93258"

URI_x86_64_v2_layer-shell-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/layer-shell-qt-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_layer-shell-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_layer-shell-qt}"
SRC_URI[x86_64_v2_layer-shell-qt.sha256sum] = "7acdc1db43ba05a0bfddccc63c0b1f48635ff576ea94bf2129e2640af4a17042"

URI_x86_64_v2_layer-shell-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/layer-shell-qt-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_layer-shell-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_layer-shell-qt-devel}"
SRC_URI[x86_64_v2_layer-shell-qt-devel.sha256sum] = "7c452775d55dde66b23c758db513d53609b864d3ca8b1aaea31f428d8d91dc47"

URI_aarch64_layer-shell-qt = "${EPEL_MIRROR}/aarch64/Packages/l/layer-shell-qt-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_layer-shell-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_layer-shell-qt}"
SRC_URI[aarch64_layer-shell-qt.sha256sum] = "14d7b8be58eb48d64d5df89699485fa1616c742a10b6f7262e1020e692835b1d"

URI_aarch64_layer-shell-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/layer-shell-qt-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_layer-shell-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_layer-shell-qt-devel}"
SRC_URI[aarch64_layer-shell-qt-devel.sha256sum] = "3dc747bcdbc49c5dafbe49c988eb5f47026f9ad7e3e68bb4b529bf8df302a0ee"

RDEPENDS:layer-shell-qt = " \
 glibc \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
RDEPENDS:layer-shell-qt-devel = " \
 cmake-filesystem \
 layer-shell-qt \
 qt6-qtbase-devel \
 "
