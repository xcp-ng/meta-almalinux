# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-socket2"
PV = "0.6.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 rust-socket2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-socket2-0.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a09c8c9c9945a1f894db06492bed0a93b177e2d69405eed15d9e98723a69cf3"

URI_x86_64_v2_rust-socket2+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2+all-devel-0.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2+all-devel}"
SRC_URI[x86_64_v2_rust-socket2+all-devel.sha256sum] = "4fcff27a0c6a594118db738ae30b8ad5bbf620d0eaf5c4b9f7d74df09046f5b9"
RPROVIDES:rust-socket2+all-devel:x86_64_v2 = "virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~"

URI_x86_64_v2_rust-socket2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2+default-devel-0.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2+default-devel}"
SRC_URI[x86_64_v2_rust-socket2+default-devel.sha256sum] = "b1aeea87ff5cf3b2e410d8a74b86a0cb08697055ef1b4a4bb5778444d8396855"
RPROVIDES:rust-socket2+default-devel:x86_64_v2 = "virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"

URI_x86_64_v2_rust-socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2-devel-0.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2-devel}"
SRC_URI[x86_64_v2_rust-socket2-devel.sha256sum] = "d9d1d7bb7f68cc5a4c386c22e84681a4cebfeb5fa1ae2a803c297619ffc95d9a"

URI_aarch64_rust-socket2+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2+all-devel-0.6.4-1.el10_2.noarch.rpm;name=aarch64_rust-socket2+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2+all-devel}"
SRC_URI[aarch64_rust-socket2+all-devel.sha256sum] = "2e66e62fd4476f3f58a7ca07de6777646a253a5cca1a3680ae18e17a56a4b655"
RPROVIDES:rust-socket2+all-devel:aarch64 = "virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~"

URI_aarch64_rust-socket2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2+default-devel-0.6.4-1.el10_2.noarch.rpm;name=aarch64_rust-socket2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2+default-devel}"
SRC_URI[aarch64_rust-socket2+default-devel.sha256sum] = "9338dfbfe9e2d97b03964395ab2f392ead25ea6e614bd860bae729dcc490f388"
RPROVIDES:rust-socket2+default-devel:aarch64 = "virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"

URI_aarch64_rust-socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2-devel-0.6.4-1.el10_2.noarch.rpm;name=aarch64_rust-socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2-devel}"
SRC_URI[aarch64_rust-socket2-devel.sha256sum] = "af1f0a00f1a9aab5e1e311f9f3497ac40303c311cc3964ab0faf058377f13d46"

RDEPENDS:rust-socket2+all-devel = " \
 cargo \
 rust-socket2-devel \
 "
RDEPENDS:rust-socket2+default-devel = " \
 cargo \
 rust-socket2-devel \
 "
RDEPENDS:rust-socket2-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~ rpm/virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~ rpm/virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"
