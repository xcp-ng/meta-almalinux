# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "node-exporter"
PV = "1.12.1"
PR = "1.el10_2"
PACKAGES = " \
 node-exporter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/node-exporter-1.12.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8188b029d43680ae2ebb477d00abd1fc2818f527329975ff590f8acb54a0c085"

URI_x86_64_v2_node-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/node-exporter-1.12.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_node-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_node-exporter}"
SRC_URI[x86_64_v2_node-exporter.sha256sum] = "d3e70f1959e60081fdd537e54a1af77574814c0d3f19a0098af018d61f6e933b"

URI_aarch64_node-exporter = "${EPEL_MIRROR}/aarch64/Packages/n/node-exporter-1.12.1-1.el10_2.aarch64.rpm;name=aarch64_node-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_node-exporter}"
SRC_URI[aarch64_node-exporter.sha256sum] = "e6d89555b48d7f77152c048303087a1299781dba2e71f7132518eac623571574"

RDEPENDS:node-exporter = " \
 bash \
 glibc \
 shadow-utils \
 "
