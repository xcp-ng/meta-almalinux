# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dtor"
PV = "1.0.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-dtor+default-devel \
 rust-dtor+proc_macro-devel \
 rust-dtor+std-devel \
 rust-dtor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dtor-1.0.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb9422c50f210065552a9a1431dcb59ae88a1e1a42c665b4cefdab2b1c384618"

URI_x86_64_v2_rust-dtor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dtor+default-devel-1.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dtor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dtor+default-devel}"
SRC_URI[x86_64_v2_rust-dtor+default-devel.sha256sum] = "efc7455a8a40b74bef20b48f2844bce58fc07c3f7173e5ed8c1d6c4d782d9543"

URI_x86_64_v2_rust-dtor+proc_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dtor+proc_macro-devel-1.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dtor+proc_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dtor+proc_macro-devel}"
SRC_URI[x86_64_v2_rust-dtor+proc_macro-devel.sha256sum] = "2736a33f78954225775deff00ac000b336c436ee6822ead7730aa3f62352a747"

URI_x86_64_v2_rust-dtor+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dtor+std-devel-1.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dtor+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dtor+std-devel}"
SRC_URI[x86_64_v2_rust-dtor+std-devel.sha256sum] = "f9da0bfb8c47b059de33735ede3efd4af61d677a88d1c5cfba67c0f6a031843e"

URI_x86_64_v2_rust-dtor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dtor-devel-1.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dtor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dtor-devel}"
SRC_URI[x86_64_v2_rust-dtor-devel.sha256sum] = "299465e6e7ca8e37386ea3c117a451022549de9602019a2b2a7e96a5dfca777c"

URI_aarch64_rust-dtor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dtor+default-devel-1.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-dtor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dtor+default-devel}"
SRC_URI[aarch64_rust-dtor+default-devel.sha256sum] = "c4cac387ad72b1ee900a558276865b3bcbeccfc7677c2509546bd42165abc2e4"

URI_aarch64_rust-dtor+proc_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dtor+proc_macro-devel-1.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-dtor+proc_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dtor+proc_macro-devel}"
SRC_URI[aarch64_rust-dtor+proc_macro-devel.sha256sum] = "e462d9939b6337d44084df1b367786fa33a7508fbcc9ebe50be176f4e40117e0"

URI_aarch64_rust-dtor+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dtor+std-devel-1.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-dtor+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dtor+std-devel}"
SRC_URI[aarch64_rust-dtor+std-devel.sha256sum] = "69541dbca7ad7e9c0da6927a61334479b2cbe66bc6382e872266271716a64546"

URI_aarch64_rust-dtor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dtor-devel-1.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-dtor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dtor-devel}"
SRC_URI[aarch64_rust-dtor-devel.sha256sum] = "5499167dcea9c80b255f249e55d2375ca7db63a2dee8d0eb13c1d00e02807ac4"

RDEPENDS:rust-dtor+default-devel = " \
 cargo \
 rust-dtor+proc_macro-devel \
 rust-dtor+std-devel \
 rust-dtor-devel \
 "
RDEPENDS:rust-dtor+proc_macro-devel = " \
 cargo \
 rust-dtor-devel \
 rust-linktime-proc-macro+default-devel \
 rust-linktime-proc-macro+dtor-devel \
 "
RDEPENDS:rust-dtor+std-devel = " \
 cargo \
 rust-dtor-devel \
 "
RDEPENDS:rust-dtor-devel = " \
 cargo \
 rust \
 "
