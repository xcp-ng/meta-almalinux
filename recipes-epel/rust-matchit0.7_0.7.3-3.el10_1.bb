# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-matchit0.7"
PV = "0.7.3"
PR = "3.el10_1"
PACKAGES = " \
 rust-matchit0.7+default-devel \
 rust-matchit0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-matchit0.7-0.7.3-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5208a22a831078d95668d8e1089355894fb45c22d56ffc3877b51f14b848d47d"

URI_x86_64_v2_rust-matchit0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchit0.7+default-devel-0.7.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchit0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchit0.7+default-devel}"
SRC_URI[x86_64_v2_rust-matchit0.7+default-devel.sha256sum] = "7431b36c331e607d851f6183385be7e176b0a30ecc17f7579c43cff84c011230"

URI_x86_64_v2_rust-matchit0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchit0.7-devel-0.7.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchit0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchit0.7-devel}"
SRC_URI[x86_64_v2_rust-matchit0.7-devel.sha256sum] = "619fedc53f769adb60b9798310a1fe1f724e054e6b4cbba18abfa15fedf3cbd5"

URI_aarch64_rust-matchit0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchit0.7+default-devel-0.7.3-3.el10_1.noarch.rpm;name=aarch64_rust-matchit0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchit0.7+default-devel}"
SRC_URI[aarch64_rust-matchit0.7+default-devel.sha256sum] = "8de7c202fffbbb3a952882d3efd87a7343358c5c984831c94ad5a7c7297dd5e5"

URI_aarch64_rust-matchit0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchit0.7-devel-0.7.3-3.el10_1.noarch.rpm;name=aarch64_rust-matchit0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchit0.7-devel}"
SRC_URI[aarch64_rust-matchit0.7-devel.sha256sum] = "43c7d2fb77ae7ee00431313c411f017c1a5577b21fd425a8cb52825de6985060"

RDEPENDS:rust-matchit0.7+default-devel = " \
 cargo \
 rust-matchit0.7-devel \
 "
RDEPENDS:rust-matchit0.7-devel = " \
 cargo \
 "
