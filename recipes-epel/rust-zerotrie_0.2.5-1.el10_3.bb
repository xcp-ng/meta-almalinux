# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerotrie"
PV = "0.2.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-zerotrie+alloc-devel \
 rust-zerotrie+databake-devel \
 rust-zerotrie+default-devel \
 rust-zerotrie+dense-devel \
 rust-zerotrie+litemap-devel \
 rust-zerotrie+serde-devel \
 rust-zerotrie+yoke-devel \
 rust-zerotrie+zerofrom-devel \
 rust-zerotrie+zerovec-devel \
 rust-zerotrie-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-zerotrie-0.2.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "971e0cf64539e72187ae72030c08aa3d1f52b75a53ee2d1ea3d6ed31f67f9ed8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+alloc-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerotrie+alloc-devel.sha256sum] = "d94f125c53426ff37be4d7a4714ca5bfe7fc0b0663df6254aae8fc99062be3b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+databake-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+databake-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerotrie+databake-devel.sha256sum] = "466c26fec65b2f49cc55b8a0281bb83f7670d61aaea35e5df4b83eef4cfc5211"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+default-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerotrie+default-devel.sha256sum] = "d573ea1da68911db87164dc5479c99d8336da7f6e4748756d577c7326934745e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+dense-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+dense-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerotrie+dense-devel.sha256sum] = "487220953bed4344b6d030dbf936cacfbf1746282dadbc4b91dcc2b021ac8d35"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+litemap-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+litemap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerotrie+litemap-devel.sha256sum] = "6218bb131acf605f2ddbdcaa23a8f80f1b770b6bd3e83018ac07c03d1850ce09"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+serde-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerotrie+serde-devel.sha256sum] = "1fe828c206fefb2f07ca523ee2a06f5f1ec3dcdc2f728ac96d2bbf77f767df3c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+yoke-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+yoke-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerotrie+yoke-devel.sha256sum] = "f62cec9da84f18054861dcd13a716686e451d749562f206b1d9b5b906277db6a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+zerofrom-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+zerofrom-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerotrie+zerofrom-devel.sha256sum] = "88fa0129cd53abe614a51a43f4ddb548d1a12efaa1b3f84fa964329d1c24b63b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+zerovec-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+zerovec-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerotrie+zerovec-devel.sha256sum] = "b7dfe9da6467d66bce79df2b9649c9f6c4088e1d81deeb02192cf34c89200f49"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerotrie-devel.sha256sum] = "804534e4b7741a9b09ce87768c01058272e6d2a8bf7b451a05d207dc1d6ed32d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+alloc-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-zerotrie+alloc-devel.sha256sum] = "a451b88fa38ffba31a59dadc4aa71c719e371d955425320d665aea56c3faf468"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+databake-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+databake-devel;unpack=0"
SRC_URI[aarch64_rust-zerotrie+databake-devel.sha256sum] = "a43cc750f03fe3511814766c014dc9cdcd3e2f69d9f1f0e385015a883a058579"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+default-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+default-devel;unpack=0"
SRC_URI[aarch64_rust-zerotrie+default-devel.sha256sum] = "7f70ae9a163636526a067282e2d3defbbd2044ad46f41b7d1af0eb5d4bbbf7c7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+dense-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+dense-devel;unpack=0"
SRC_URI[aarch64_rust-zerotrie+dense-devel.sha256sum] = "3d3d9ca08bfda8816d2da2636d44607482e68040463962e0a1d2029fdffebe82"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+litemap-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+litemap-devel;unpack=0"
SRC_URI[aarch64_rust-zerotrie+litemap-devel.sha256sum] = "9cc6e797507b88acc52f0498c92da503c7e5939002233b02ee8d2b43dadac60c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+serde-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+serde-devel;unpack=0"
SRC_URI[aarch64_rust-zerotrie+serde-devel.sha256sum] = "fbee5b0bdcd51ec4729d6b46605cb73f0c578503337c9d4ab16e244ab973f8af"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+yoke-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+yoke-devel;unpack=0"
SRC_URI[aarch64_rust-zerotrie+yoke-devel.sha256sum] = "de0122616c26b76130089d07a2afc701cc6775fb9af3aaca4bd4fc1bdbce83fb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+zerofrom-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+zerofrom-devel;unpack=0"
SRC_URI[aarch64_rust-zerotrie+zerofrom-devel.sha256sum] = "11023ead1df68102408f7ea7c9881978dbc1504cce660c92852b2ca2f7b8d44c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+zerovec-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie+zerovec-devel;unpack=0"
SRC_URI[aarch64_rust-zerotrie+zerovec-devel.sha256sum] = "3ab78d9596d153954c06f5cb62963900cd27dae587212fec40218e3b0ceb336c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-zerotrie-devel;unpack=0"
SRC_URI[aarch64_rust-zerotrie-devel.sha256sum] = "7056bc36ffd8ffe3350d9539ba5a72e0a8b77abdd21fd96fd287cc3e3532de1c"

RDEPENDS:rust-zerotrie+alloc-devel = " \
 cargo \
 rust-zerotrie-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-zerotrie-devel \
 rust-zerovec+databake-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie+default-devel = " \
 cargo \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+dense-devel = " \
 cargo \
 rust-zerotrie-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie+litemap-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 rust-zerotrie+alloc-devel \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+serde-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap+serde-devel \
 rust-litemap-devel \
 rust-serde_core-devel \
 rust-zerotrie+alloc-devel \
 rust-zerotrie-devel \
 rust-zerovec+serde-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie+yoke-devel = " \
 cargo \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+zerofrom-devel = " \
 cargo \
 rust-zerofrom-devel \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+zerovec-devel = " \
 cargo \
 rust-zerotrie-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 "
