# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tox-uv"
PV = "1.28.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-tox-uv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tox-uv-1.28.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf7975d218fa0673be79e23cff77cb6d95f984f8c222e55a7dda25324fdc08ec"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3-tox-uv: (python3.12dist(uv) < 1~~ with python3.12dist(uv) >= 0.5.31)

URI_x86_64_v2_python3-tox-uv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tox-uv-1.28.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tox-uv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tox-uv}"
SRC_URI[x86_64_v2_python3-tox-uv.sha256sum] = "9d0c1712d9501be5c06f873df89de580aa337d9f2fa994f3424ad294f58535eb"

URI_aarch64_python3-tox-uv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tox-uv-1.28.0-1.el10_1.noarch.rpm;name=aarch64_python3-tox-uv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tox-uv}"
SRC_URI[aarch64_python3-tox-uv.sha256sum] = "c167351a32405595ec09f43e51c70ebd453676382be8c573ec681388c3bf59f8"

RDEPENDS:python3-tox-uv:x86_64_v2 = " \
 python3 \
 python3-packaging \
 tox \
"
RDEPENDS:python3-tox-uv:aarch64 = " \
 python3 \
 python3-packaging \
 python3-uv \
 tox \
"
