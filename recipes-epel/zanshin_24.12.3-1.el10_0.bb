# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zanshin"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 zanshin \
 zanshin-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zanshin-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2316abebfe175145fbcb2186bab0394ce756b6fa62559d8497cec7c8431a08d0"

URI_x86_64_v2_zanshin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zanshin-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zanshin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zanshin}"
SRC_URI[x86_64_v2_zanshin.sha256sum] = "47b5b69d4f4bd1c87796b180b962b17e74888c13f6a713b27e620a2b06d43459"

URI_x86_64_v2_zanshin-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zanshin-common-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_zanshin-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zanshin-common}"
SRC_URI[x86_64_v2_zanshin-common.sha256sum] = "20633d90107d9ab1babbb37fe508fcdf2fca8b3b94cf3f9aeb07584035cae904"

URI_aarch64_zanshin = "${EPEL_MIRROR}/aarch64/Packages/z/zanshin-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_zanshin;unpack=0"
SRC_URI:append = " ${URI_aarch64_zanshin}"
SRC_URI[aarch64_zanshin.sha256sum] = "19a3a308942c089cc5117e223935852bf87693f64c7aca207a10b397b5263301"

URI_aarch64_zanshin-common = "${EPEL_MIRROR}/aarch64/Packages/z/zanshin-common-24.12.3-1.el10_0.noarch.rpm;name=aarch64_zanshin-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_zanshin-common}"
SRC_URI[aarch64_zanshin-common.sha256sum] = "21cba070749e170ccc99fdf828f96aab049570e01aacc6aadb7930e8e727c666"

RDEPENDS:zanshin = " \
 akonadi-server \
 glibc \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kparts \
 kf6-krunner \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kontactinterface \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 zanshin-common \
 "
RDEPENDS:zanshin-common = " \
 zanshin \
 "
