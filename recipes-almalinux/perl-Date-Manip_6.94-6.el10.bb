# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Date-Manip"
PV = "6.94"
PR = "6.el10"
PACKAGES = " \
 perl-Date-Manip \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Date-Manip-6.94-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1a1e6c66e77c332405c0f4e61385b8cb546bb6473e443bbf76f6ef96da285a49"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Date-Manip-6.94-6.el10.noarch.rpm;name=x86_64_v2_perl-Date-Manip;unpack=0"
SRC_URI[x86_64_v2_perl-Date-Manip.sha256sum] = "2e7218b1788c80a8419188eca69438af08e6f23a46a5c1286602096db969240f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Date-Manip-6.94-6.el10.noarch.rpm;name=aarch64_perl-Date-Manip;unpack=0"
SRC_URI[aarch64_perl-Date-Manip.sha256sum] = "2e7218b1788c80a8419188eca69438af08e6f23a46a5c1286602096db969240f"

RDEPENDS:perl-Date-Manip = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Date-Manip \
 perl-Encode \
 perl-Exporter \
 perl-File-Find \
 perl-IO \
 perl-PathTools \
 perl-Storable \
 perl-interpreter \
 perl-libs \
 "
