# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "autoconf-archive"
PV = "2023.02.20"
PR = "8.el10"
PACKAGES = " \
 autoconf-archive \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/autoconf-archive-2023.02.20-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d63c19b45670b3f20c0607311841e1d9918380b002b0c7b05d1b5363cab4f051"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/autoconf-archive-2023.02.20-8.el10.noarch.rpm;name=x86_64_v2_autoconf-archive;unpack=0"
SRC_URI[x86_64_v2_autoconf-archive.sha256sum] = "1ba12d0315140800c0b07b419f3322dbeb78313faf6875a4957bede453e423b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/autoconf-archive-2023.02.20-8.el10.noarch.rpm;name=aarch64_autoconf-archive;unpack=0"
SRC_URI[aarch64_autoconf-archive.sha256sum] = "1ba12d0315140800c0b07b419f3322dbeb78313faf6875a4957bede453e423b4"

RDEPENDS:autoconf-archive = " \
 autoconf \
 "
