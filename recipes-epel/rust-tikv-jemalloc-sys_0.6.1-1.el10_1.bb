# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tikv-jemalloc-sys"
PV = "0.6.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-tikv-jemalloc-sys+background_threads-devel \
 rust-tikv-jemalloc-sys+background_threads_runtime_support-devel \
 rust-tikv-jemalloc-sys+debug-devel \
 rust-tikv-jemalloc-sys+default-devel \
 rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel \
 rust-tikv-jemalloc-sys+profiling-devel \
 rust-tikv-jemalloc-sys+stats-devel \
 rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemalloc-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tikv-jemalloc-sys-0.6.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "988fd0bdc7c0e275c133b5dad317f8fcafd025df52b5a1112826a32de78c8207"

URI_x86_64_v2_rust-tikv-jemalloc-sys+background_threads-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+background_threads-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+background_threads-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+background_threads-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+background_threads-devel.sha256sum] = "616bbfddc39d026b4ebb224403803ab5b147479278ec732e6baa9604696647e4"

URI_x86_64_v2_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+background_threads_runtime_support-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel.sha256sum] = "fcd8128060e641a19e84aa16cb1caa040be431f5a0fccd230b9285bbb4360099"

URI_x86_64_v2_rust-tikv-jemalloc-sys+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+debug-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+debug-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+debug-devel.sha256sum] = "0e26919e29c4681d6238a1fe3dc931bf174635707067a4da03eca9d9fb3b410d"

URI_x86_64_v2_rust-tikv-jemalloc-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+default-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+default-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+default-devel.sha256sum] = "c063c5e315ffeca72583acc26d0dd047d6681582323f4c6eaa586062bb3efb8e"

URI_x86_64_v2_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel.sha256sum] = "099322c1b61b0356c7e642db17d4cc4cf3775775fbd055627ddbc3e1313b90df"

URI_x86_64_v2_rust-tikv-jemalloc-sys+profiling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+profiling-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+profiling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+profiling-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+profiling-devel.sha256sum] = "2428c80f20b2855fb0e6e1939057e23bcb3786b39746002853435ba967288070"

URI_x86_64_v2_rust-tikv-jemalloc-sys+stats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+stats-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+stats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+stats-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+stats-devel.sha256sum] = "74984a03de9bf1f2c042b8c65d6d7a78d8823379953f3d2f2dd9c94190cc6ecc"

URI_x86_64_v2_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel.sha256sum] = "eef312d258c2f59221e2a8e400314f44946edde2aafcf63e1982679c433a17ad"

URI_x86_64_v2_rust-tikv-jemalloc-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys-devel.sha256sum] = "a78cbecb3e5bee80b3450b98c20e3ca5d345ad8e3bce368820b8204348a4bed1"

URI_aarch64_rust-tikv-jemalloc-sys+background_threads-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+background_threads-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+background_threads-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+background_threads-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+background_threads-devel.sha256sum] = "97e6c1549f7d242f873d180af0c0ffd46a5204d07d383d264edb050d7b0f1b27"

URI_aarch64_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+background_threads_runtime_support-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel.sha256sum] = "3592f82140af3c987a4c94e5b2b16a2cd307cf3cd812edaa4f21b259729701a0"

URI_aarch64_rust-tikv-jemalloc-sys+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+debug-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+debug-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+debug-devel.sha256sum] = "584c9ffa593954c67c0c553eb3d6b3142b4409d3d51799c2930b8202ee3d0090"

URI_aarch64_rust-tikv-jemalloc-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+default-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+default-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+default-devel.sha256sum] = "bcef3083c5d922e1d3e82bfa61401a23d387634fa711582b23d3002de7698ddc"

URI_aarch64_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel.sha256sum] = "0160fa6fccf95d7aeeaed7a208eacaf0cd3978cd81a1d78385e324b5c1358f75"

URI_aarch64_rust-tikv-jemalloc-sys+profiling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+profiling-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+profiling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+profiling-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+profiling-devel.sha256sum] = "3c33464816cc2a69097f67aa4449fd73005ca322d31a646c9709411779ab8a63"

URI_aarch64_rust-tikv-jemalloc-sys+stats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+stats-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+stats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+stats-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+stats-devel.sha256sum] = "6ede12a30d49f61fde1ef9e614b8674438fb4c64517a41c9228c7332c43c7001"

URI_aarch64_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel.sha256sum] = "6c6121ef1f1db5c93eee8dcc075178264e29c1c07e31e2ae2cf67ed8a83369be"

URI_aarch64_rust-tikv-jemalloc-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys-devel.sha256sum] = "0eda11e7145267a591476320652376802a83a04599a4609209079f9737c45bb4"

RDEPENDS:rust-tikv-jemalloc-sys+background_threads-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+background_threads_runtime_support-devel \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+background_threads_runtime_support-devel = " \
 cargo \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+debug-devel = " \
 cargo \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+default-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+background_threads_runtime_support-devel \
 rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+profiling-devel = " \
 cargo \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+stats-devel = " \
 cargo \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel = " \
 cargo \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys-devel = " \
 cargo \
 jemalloc-devel \
 rust \
 rust-cc+default-devel \
 rust-libc-devel \
 "
