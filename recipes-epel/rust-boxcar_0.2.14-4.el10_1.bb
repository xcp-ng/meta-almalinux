# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-boxcar"
PV = "0.2.14"
PR = "4.el10_1"
PACKAGES = " \
 rust-boxcar+default-devel \
 rust-boxcar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-boxcar-0.2.14-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26d667826dc00725b0a485c44c1cb3f2dc26336dc332ec305a5c69794ac9ffcb"

URI_x86_64_v2_rust-boxcar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-boxcar+default-devel-0.2.14-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-boxcar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-boxcar+default-devel}"
SRC_URI[x86_64_v2_rust-boxcar+default-devel.sha256sum] = "cdf693d854a4e61e1be81609c60fd353302f76fda1510bc16100267fe10fa474"

URI_x86_64_v2_rust-boxcar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-boxcar-devel-0.2.14-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-boxcar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-boxcar-devel}"
SRC_URI[x86_64_v2_rust-boxcar-devel.sha256sum] = "a48040439496f5d04180c56c781cb51acdc81431f7bd022c5d64e6bca36b76ce"

URI_aarch64_rust-boxcar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-boxcar+default-devel-0.2.14-4.el10_1.noarch.rpm;name=aarch64_rust-boxcar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-boxcar+default-devel}"
SRC_URI[aarch64_rust-boxcar+default-devel.sha256sum] = "d8217f7a0d38503bc173c05ed034f4ef424b8002d6f7d67cfcf8b5ca8d708fe9"

URI_aarch64_rust-boxcar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-boxcar-devel-0.2.14-4.el10_1.noarch.rpm;name=aarch64_rust-boxcar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-boxcar-devel}"
SRC_URI[aarch64_rust-boxcar-devel.sha256sum] = "eb63cdae6f8a70d3d0bb65079665b37eb2379e7e59f72bb4ac9a5faf46c6cf8d"

RDEPENDS:rust-boxcar+default-devel = " \
 cargo \
 rust-boxcar-devel \
 "
RDEPENDS:rust-boxcar-devel = " \
 cargo \
 rust \
 "
