# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ntpd-rs"
PV = "1.7.1"
PR = "1.el10_1"
PACKAGES = " \
 ntpd-rs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ntpd-rs-1.7.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84a29aaecef815289c4220c3ad37d4d50c3656c5e4e9f31f09281a1e1a7e8b14"

URI_x86_64_v2_ntpd-rs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntpd-rs-1.7.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntpd-rs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntpd-rs}"
SRC_URI[x86_64_v2_ntpd-rs.sha256sum] = "68afc664e71b23fb9565871d1442b4ad3a54c6af6099df963c2e7b02deb1b7c6"

URI_aarch64_ntpd-rs = "${EPEL_MIRROR}/aarch64/Packages/n/ntpd-rs-1.7.1-1.el10_1.aarch64.rpm;name=aarch64_ntpd-rs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntpd-rs}"
SRC_URI[aarch64_ntpd-rs.sha256sum] = "929ba855ec968f1b75300b083b98ef122eba976c4f6dbb1f1cc493efda2a1f7d"

RDEPENDS:ntpd-rs = " \
 bash \
 glibc \
 libgcc \
 systemd \
 "
