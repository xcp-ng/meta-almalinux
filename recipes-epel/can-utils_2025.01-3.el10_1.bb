# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "can-utils"
PV = "2025.01"
PR = "3.el10_1"
PACKAGES = " \
 can-utils \
 can-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/can-utils-2025.01-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a052620095022caba9cea9755ba4a1b2ca30bedd010f201f9be41cca05fa73f"

URI_x86_64_v2_can-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/can-utils-2025.01-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_can-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_can-utils}"
SRC_URI[x86_64_v2_can-utils.sha256sum] = "33fad643b19c879f569a0578044794eff4d461156a05d9f8a5115890654ddd5f"

URI_x86_64_v2_can-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/can-utils-devel-2025.01-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_can-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_can-utils-devel}"
SRC_URI[x86_64_v2_can-utils-devel.sha256sum] = "dd7274ba331a75573a801d380eec7464ba13f84320d55f36437ee48a1e33fcc0"

URI_aarch64_can-utils = "${EPEL_MIRROR}/aarch64/Packages/c/can-utils-2025.01-3.el10_1.aarch64.rpm;name=aarch64_can-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_can-utils}"
SRC_URI[aarch64_can-utils.sha256sum] = "246945ae6e144173fba1e4c187022967c23d3f0ba1a283476f083d839cd15d37"

URI_aarch64_can-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/c/can-utils-devel-2025.01-3.el10_1.aarch64.rpm;name=aarch64_can-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_can-utils-devel}"
SRC_URI[aarch64_can-utils-devel.sha256sum] = "05839abbfb255788e5befda82e3638d84eab0e33cb178f372a6c7cd45b62f489"

RDEPENDS:can-utils = " \
 glibc \
 "
RDEPENDS:can-utils-devel = " \
 can-utils \
 glibc \
 "
