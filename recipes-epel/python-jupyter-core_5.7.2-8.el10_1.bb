# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jupyter-core"
PV = "5.7.2"
PR = "8.el10_1"
PACKAGES = " \
 python-jupyter-filesystem \
 python3-jupyter-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jupyter-core-5.7.2-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f0abbfdd1d132646054bdb16e8e528ccaa3948c67639bb8d81a86b16deb2cdb"

URI_x86_64_v2_python-jupyter-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-jupyter-filesystem-5.7.2-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-jupyter-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-jupyter-filesystem}"
SRC_URI[x86_64_v2_python-jupyter-filesystem.sha256sum] = "2a3074c05e08e61dffb77607a66ac7298effbbcea84df0ed578934dadc59d733"

URI_x86_64_v2_python3-jupyter-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jupyter-core-5.7.2-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jupyter-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jupyter-core}"
SRC_URI[x86_64_v2_python3-jupyter-core.sha256sum] = "ca8997998e187c70d08b3d3b29b4e16069f37a182d9720a9541de791f49075b0"

URI_aarch64_python-jupyter-filesystem = "${EPEL_MIRROR}/aarch64/Packages/p/python-jupyter-filesystem-5.7.2-8.el10_1.noarch.rpm;name=aarch64_python-jupyter-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-jupyter-filesystem}"
SRC_URI[aarch64_python-jupyter-filesystem.sha256sum] = "bf383bce8f5f800eb73430680600ca25ab10218d20f6a7899adffb80063f595d"

URI_aarch64_python3-jupyter-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jupyter-core-5.7.2-8.el10_1.noarch.rpm;name=aarch64_python3-jupyter-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jupyter-core}"
SRC_URI[aarch64_python3-jupyter-core.sha256sum] = "5d4f33bf35fd6a244dd4fc1c807070a8d6dabfb604e29736f8d274550a8810d9"

RDEPENDS:python-jupyter-filesystem = " \
 "
RDEPENDS:python3-jupyter-core = " \
 python3 \
 python3-platformdirs \
 python3-traitlets \
 "
