# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "f42-backgrounds"
PV = "42.0.0"
PR = "4.el10_0"
PACKAGES = " \
 f42-backgrounds \
 f42-backgrounds-base \
 f42-backgrounds-budgie \
 f42-backgrounds-gnome \
 f42-backgrounds-kde \
 f42-backgrounds-mate \
 f42-backgrounds-xfce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/f42-backgrounds-42.0.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4e7453f35441e332d9b479c8f787fcb42de6fbcf890ea19bf158f5ae7097d3e"

URI_x86_64_v2_f42-backgrounds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f42-backgrounds-42.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f42-backgrounds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f42-backgrounds}"
SRC_URI[x86_64_v2_f42-backgrounds.sha256sum] = "ea373e48a64798acaa5da3551b956a90f403d7c9001f2eecb84e61fe33c5b91e"

URI_x86_64_v2_f42-backgrounds-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f42-backgrounds-base-42.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f42-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f42-backgrounds-base}"
SRC_URI[x86_64_v2_f42-backgrounds-base.sha256sum] = "6d9e3ad5e925bceed67a68e707aa1c5bc2e9a2eb7a821108ea3c5db100454e71"

URI_x86_64_v2_f42-backgrounds-budgie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f42-backgrounds-budgie-42.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f42-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f42-backgrounds-budgie}"
SRC_URI[x86_64_v2_f42-backgrounds-budgie.sha256sum] = "d7cfb3bcb90604bbe1ea755d843f0117daa65ddb73ed91b24f9173ebf0fa60f3"

URI_x86_64_v2_f42-backgrounds-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f42-backgrounds-gnome-42.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f42-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f42-backgrounds-gnome}"
SRC_URI[x86_64_v2_f42-backgrounds-gnome.sha256sum] = "41bcf4b30e06eb0f281522c1df4d71030aadaac5e9c31fbf33edd39a4d455ae8"

URI_x86_64_v2_f42-backgrounds-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f42-backgrounds-kde-42.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f42-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f42-backgrounds-kde}"
SRC_URI[x86_64_v2_f42-backgrounds-kde.sha256sum] = "9e5218962bf339b9167aa64d26fe9452d2a570ee58c2a16d3c497bb5dc35a110"

URI_x86_64_v2_f42-backgrounds-mate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f42-backgrounds-mate-42.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f42-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f42-backgrounds-mate}"
SRC_URI[x86_64_v2_f42-backgrounds-mate.sha256sum] = "45293fc733517041fe2e5e40ca195c09c7650459b7b31e830eda7e3dd37f471a"

URI_x86_64_v2_f42-backgrounds-xfce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f42-backgrounds-xfce-42.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f42-backgrounds-xfce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f42-backgrounds-xfce}"
SRC_URI[x86_64_v2_f42-backgrounds-xfce.sha256sum] = "fc84df1aea2573e46079cd26a6f458bf122bd96e1c686c475dc15ecf1de105d0"

URI_aarch64_f42-backgrounds = "${EPEL_MIRROR}/aarch64/Packages/f/f42-backgrounds-42.0.0-4.el10_0.noarch.rpm;name=aarch64_f42-backgrounds;unpack=0"
SRC_URI:append = " ${URI_aarch64_f42-backgrounds}"
SRC_URI[aarch64_f42-backgrounds.sha256sum] = "df13095e2c56cc1677fbe8395eddfd68fc2c376b0a0c7608a84d0c775a69fde4"

URI_aarch64_f42-backgrounds-base = "${EPEL_MIRROR}/aarch64/Packages/f/f42-backgrounds-base-42.0.0-4.el10_0.noarch.rpm;name=aarch64_f42-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_f42-backgrounds-base}"
SRC_URI[aarch64_f42-backgrounds-base.sha256sum] = "9db439c28266774fee76aec8ae25d721da88efcfb84b5eb39dd0ed2b70e16afc"

URI_aarch64_f42-backgrounds-budgie = "${EPEL_MIRROR}/aarch64/Packages/f/f42-backgrounds-budgie-42.0.0-4.el10_0.noarch.rpm;name=aarch64_f42-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_aarch64_f42-backgrounds-budgie}"
SRC_URI[aarch64_f42-backgrounds-budgie.sha256sum] = "5c20fea9bf710baa9939676d5c0c66e63266323b57e063af0d126242e9dbd9da"

URI_aarch64_f42-backgrounds-gnome = "${EPEL_MIRROR}/aarch64/Packages/f/f42-backgrounds-gnome-42.0.0-4.el10_0.noarch.rpm;name=aarch64_f42-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_f42-backgrounds-gnome}"
SRC_URI[aarch64_f42-backgrounds-gnome.sha256sum] = "5291d80fdc7292bd17a0d160da57be405083e6e079ca08bf70256a8da1fe732b"

URI_aarch64_f42-backgrounds-kde = "${EPEL_MIRROR}/aarch64/Packages/f/f42-backgrounds-kde-42.0.0-4.el10_0.noarch.rpm;name=aarch64_f42-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_f42-backgrounds-kde}"
SRC_URI[aarch64_f42-backgrounds-kde.sha256sum] = "2b11d3c6c85bac1debe5902a70af82a4db74358769e3b50a4aa532a73aa0dd9b"

URI_aarch64_f42-backgrounds-mate = "${EPEL_MIRROR}/aarch64/Packages/f/f42-backgrounds-mate-42.0.0-4.el10_0.noarch.rpm;name=aarch64_f42-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_aarch64_f42-backgrounds-mate}"
SRC_URI[aarch64_f42-backgrounds-mate.sha256sum] = "2d0432e06c60f85255936030c289f20aee136dfd4023e667373be1c2947e042e"

URI_aarch64_f42-backgrounds-xfce = "${EPEL_MIRROR}/aarch64/Packages/f/f42-backgrounds-xfce-42.0.0-4.el10_0.noarch.rpm;name=aarch64_f42-backgrounds-xfce;unpack=0"
SRC_URI:append = " ${URI_aarch64_f42-backgrounds-xfce}"
SRC_URI[aarch64_f42-backgrounds-xfce.sha256sum] = "4eef15a9bcc9cd532d59c639d078e0261cf0a9be6ed3221b2058437692e2ca2a"

RDEPENDS:f42-backgrounds = " \
 f42-backgrounds-budgie \
 f42-backgrounds-gnome \
 f42-backgrounds-kde \
 f42-backgrounds-mate \
 f42-backgrounds-xfce \
 "
RDEPENDS:f42-backgrounds-base = " \
 jxl-pixbuf-loader \
 kf6-kimageformats \
 "
RDEPENDS:f42-backgrounds-budgie = " \
 f42-backgrounds-base \
 "
RDEPENDS:f42-backgrounds-gnome = " \
 f42-backgrounds-base \
 "
RDEPENDS:f42-backgrounds-kde = " \
 f42-backgrounds-base \
 kde-filesystem \
 "
RDEPENDS:f42-backgrounds-mate = " \
 f42-backgrounds-base \
 "
RDEPENDS:f42-backgrounds-xfce = " \
 f42-backgrounds-base \
 "
