# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-utf8-width"
PV = "0.1.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-utf8-width+default-devel \
 rust-utf8-width-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-utf8-width-0.1.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55c0d3283b16ffb1609453f621a9a8174c1da4c726b8f6a283bc0d2bf397fdd9"

URI_x86_64_v2_rust-utf8-width+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf8-width+default-devel-0.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf8-width+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf8-width+default-devel}"
SRC_URI[x86_64_v2_rust-utf8-width+default-devel.sha256sum] = "10f3bd23a455cd4bdea09d543def18be6ec17b861e8610b32cd47cdf25ed8759"

URI_x86_64_v2_rust-utf8-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf8-width-devel-0.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf8-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf8-width-devel}"
SRC_URI[x86_64_v2_rust-utf8-width-devel.sha256sum] = "37a87df4feacb13be1ed2690d8462d12d0edb3e785f21a050905fd8239590e8c"

URI_aarch64_rust-utf8-width+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf8-width+default-devel-0.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-utf8-width+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf8-width+default-devel}"
SRC_URI[aarch64_rust-utf8-width+default-devel.sha256sum] = "ff7b3949b42e05ebff18884b00fd10431e3175b9b3357dfda8b3447fecc78b06"

URI_aarch64_rust-utf8-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf8-width-devel-0.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-utf8-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf8-width-devel}"
SRC_URI[aarch64_rust-utf8-width-devel.sha256sum] = "50cb2737dd19a9f02e0a165cbf0bb3b637b2285dd3ca3f6b889a770dd07344ba"

RDEPENDS:rust-utf8-width+default-devel = " \
 cargo \
 rust-utf8-width-devel \
 "
RDEPENDS:rust-utf8-width-devel = " \
 cargo \
 rust \
 "
