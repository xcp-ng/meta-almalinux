# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-ShareDir-Install"
PV = "0.14"
PR = "3.el10_0"
PACKAGES = " \
 perl-File-ShareDir-Install \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-ShareDir-Install-0.14-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "418a873a2f8265d856d2289b312159faeaa3c303863c3c48792db1dbb1fc7a99"

URI_x86_64_v2_perl-File-ShareDir-Install = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-ShareDir-Install-0.14-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-ShareDir-Install;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-ShareDir-Install}"
SRC_URI[x86_64_v2_perl-File-ShareDir-Install.sha256sum] = "73dc8fe921e0d29392b2342c377233a7e0567fa9db494b7f2e2304b319273a4f"

URI_aarch64_perl-File-ShareDir-Install = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-ShareDir-Install-0.14-3.el10_0.noarch.rpm;name=aarch64_perl-File-ShareDir-Install;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-ShareDir-Install}"
SRC_URI[aarch64_perl-File-ShareDir-Install.sha256sum] = "43f7c2d5447f572bf796c80d6e1d4ec8f18556c977d5267e9725845df7d9d503"

RDEPENDS:perl-File-ShareDir-Install = " \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-PathTools \
 perl-libs \
 "
