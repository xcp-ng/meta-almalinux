# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-workspace-wallpapers"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-workspace-wallpapers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-workspace-wallpapers-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1cdfc3d092ff670f491a266272d8f52b051125ba996a8c94aed495793a6f177e"

URI_x86_64_v2_plasma-workspace-wallpapers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-wallpapers-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-workspace-wallpapers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-wallpapers}"
SRC_URI[x86_64_v2_plasma-workspace-wallpapers.sha256sum] = "67e861ae1ac2fd75ed01fbbc5e9fd527ac40a74924fd4eceac1b50ce29fcabae"

URI_aarch64_plasma-workspace-wallpapers = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-wallpapers-6.6.4-1.el10_2.noarch.rpm;name=aarch64_plasma-workspace-wallpapers;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-wallpapers}"
SRC_URI[aarch64_plasma-workspace-wallpapers.sha256sum] = "db38cc628a5343a148b97087ca6e2c80146e729e917ca98e198f6e3213acc7ef"

RDEPENDS:plasma-workspace-wallpapers = " \
 kde-filesystem \
 "
