# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-maybe-async"
PV = "0.2.11"
PR = "1.el10_3"
PACKAGES = " \
 rust-maybe-async+default-devel \
 rust-maybe-async+is_sync-devel \
 rust-maybe-async-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-maybe-async-0.2.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f45f35ba99359db6d64fb068e3c67129137ef85f006f4654f64dfdfc68cf83c"

URI_x86_64_v2_rust-maybe-async+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maybe-async+default-devel-0.2.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maybe-async+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-maybe-async+default-devel}"
SRC_URI[x86_64_v2_rust-maybe-async+default-devel.sha256sum] = "8ca01af807e21925c371a798c64c9a67a7f6203ad8e8ca228eaefc36343642c0"

URI_x86_64_v2_rust-maybe-async+is_sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maybe-async+is_sync-devel-0.2.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maybe-async+is_sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-maybe-async+is_sync-devel}"
SRC_URI[x86_64_v2_rust-maybe-async+is_sync-devel.sha256sum] = "9c49fcf31904ad18151bb6f73079f2b49713e56711be2eb53047b86308398cea"

URI_x86_64_v2_rust-maybe-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maybe-async-devel-0.2.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maybe-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-maybe-async-devel}"
SRC_URI[x86_64_v2_rust-maybe-async-devel.sha256sum] = "06cc56e3d3f4d814eb0303ca52b5db44e3a8cad90a902df69895e5a8695f143b"

URI_aarch64_rust-maybe-async+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-maybe-async+default-devel-0.2.11-1.el10_3.noarch.rpm;name=aarch64_rust-maybe-async+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-maybe-async+default-devel}"
SRC_URI[aarch64_rust-maybe-async+default-devel.sha256sum] = "af4982b451faa98d296c9ce79742a3fb59d716d0174f0a33f96a2bb061336384"

URI_aarch64_rust-maybe-async+is_sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-maybe-async+is_sync-devel-0.2.11-1.el10_3.noarch.rpm;name=aarch64_rust-maybe-async+is_sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-maybe-async+is_sync-devel}"
SRC_URI[aarch64_rust-maybe-async+is_sync-devel.sha256sum] = "d37db289c166ccd72d0afe31440f65609557539710df8a4de54a1cae941ba04a"

URI_aarch64_rust-maybe-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-maybe-async-devel-0.2.11-1.el10_3.noarch.rpm;name=aarch64_rust-maybe-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-maybe-async-devel}"
SRC_URI[aarch64_rust-maybe-async-devel.sha256sum] = "006e73b8b1f53d6a356ee0831df3c84409c1ba6c4674250d2c62441fce388ed9"

RDEPENDS:rust-maybe-async+default-devel = " \
 cargo \
 rust-maybe-async-devel \
 "
RDEPENDS:rust-maybe-async+is_sync-devel = " \
 cargo \
 rust-maybe-async-devel \
 "
RDEPENDS:rust-maybe-async-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 rust-syn2+visit-mut-devel \
 "
