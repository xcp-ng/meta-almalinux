# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dvblast"
PV = "3.5"
PR = "1.el10_2"
PACKAGES = " \
 dvblast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dvblast-3.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0435067be4edc9abb41eec79530c06fb4e7d5383eaec653112de2532ffa86d89"

URI_x86_64_v2_dvblast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dvblast-3.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dvblast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dvblast}"
SRC_URI[x86_64_v2_dvblast.sha256sum] = "9e3d77b83c2e23f08f92f9fa1a6b9d901ec83b09e100b7652682f63e2908f47f"

URI_aarch64_dvblast = "${EPEL_MIRROR}/aarch64/Packages/d/dvblast-3.5-1.el10_2.aarch64.rpm;name=aarch64_dvblast;unpack=0"
SRC_URI:append = " ${URI_aarch64_dvblast}"
SRC_URI[aarch64_dvblast.sha256sum] = "ed370eda1cb76ef5b93af0a679e661c62eb9323c2e58a5f593059a7340a83188"

RDEPENDS:dvblast = " \
 bash \
 glibc \
 libev \
 "
