# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_wc"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_wc+default-devel \
 rust-uu_wc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_wc-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb8fb3952b7ffb6f8b69778343a7d8379c527ad1915cea5996fd620874c68196"

URI_x86_64_v2_rust-uu_wc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_wc+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_wc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_wc+default-devel}"
SRC_URI[x86_64_v2_rust-uu_wc+default-devel.sha256sum] = "5e6e7b5dbc1f4b3158cf576f22fa140b45b49c6b985b9f9c3b5cfa61c2ef952b"

URI_x86_64_v2_rust-uu_wc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_wc-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_wc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_wc-devel}"
SRC_URI[x86_64_v2_rust-uu_wc-devel.sha256sum] = "45c0ec0dbcb0e664b642a083ccc7ff7b66cbfb0ffd4026268b3235257fc1b072"

URI_aarch64_rust-uu_wc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_wc+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_wc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_wc+default-devel}"
SRC_URI[aarch64_rust-uu_wc+default-devel.sha256sum] = "add1184991fe15a4ba60783fcbe3833bf32d94c6970242d7a7414904ccf1ccb0"

URI_aarch64_rust-uu_wc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_wc-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_wc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_wc-devel}"
SRC_URI[aarch64_rust-uu_wc-devel.sha256sum] = "7d2e8401b2b992c824be9e3f0b551e54e2c050d5fde32a5362850772b13e870c"

RDEPENDS:rust-uu_wc+default-devel = " \
 cargo \
 rust-uu_wc-devel \
 "
RDEPENDS:rust-uu_wc-devel = " \
 cargo \
 rust \
 rust-bytecount+default-devel \
 rust-bytecount+runtime-dispatch-simd-devel \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-libc+default-devel \
 rust-nix0.30-devel \
 rust-thiserror+default-devel \
 rust-unicode-width+default-devel \
 rust-uucore+default-devel \
 rust-uucore+hardware-devel \
 rust-uucore+parser-devel \
 rust-uucore+pipes-devel \
 rust-uucore+quoting-style-devel \
 "
