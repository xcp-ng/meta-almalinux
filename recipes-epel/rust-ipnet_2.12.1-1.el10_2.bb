# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ipnet"
PV = "2.12.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-ipnet+default-devel \
 rust-ipnet+heapless-devel \
 rust-ipnet+schemars08-devel \
 rust-ipnet+schemars1-devel \
 rust-ipnet+ser_as_str-devel \
 rust-ipnet+serde-devel \
 rust-ipnet+std-devel \
 rust-ipnet-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ipnet-2.12.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a335bcbea7b588fd42d2bd7ed68bce71022a36f554db474dbbe408793a9a7590"

URI_x86_64_v2_rust-ipnet+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+default-devel-2.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+default-devel}"
SRC_URI[x86_64_v2_rust-ipnet+default-devel.sha256sum] = "ed630ad6dea7871d10a8a24ef5c8c02432f62d384a946d005342fbf9ead0af2d"

URI_x86_64_v2_rust-ipnet+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+heapless-devel-2.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+heapless-devel}"
SRC_URI[x86_64_v2_rust-ipnet+heapless-devel.sha256sum] = "557fefd538dca20afdec8115d5b92f494300cd43f0a8a253f172eb91af7539cf"

URI_x86_64_v2_rust-ipnet+schemars08-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+schemars08-devel-2.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+schemars08-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+schemars08-devel}"
SRC_URI[x86_64_v2_rust-ipnet+schemars08-devel.sha256sum] = "6f2a5bf20161c44c58febdf2727cf04f222f7eb0a028e499c05aa7d792ce2702"

URI_x86_64_v2_rust-ipnet+schemars1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+schemars1-devel-2.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+schemars1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+schemars1-devel}"
SRC_URI[x86_64_v2_rust-ipnet+schemars1-devel.sha256sum] = "9882661cdd4ac733e26ce87ceddec46e8523ef368b3888a7cfee1cf7df0e3e52"

URI_x86_64_v2_rust-ipnet+ser_as_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+ser_as_str-devel-2.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+ser_as_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+ser_as_str-devel}"
SRC_URI[x86_64_v2_rust-ipnet+ser_as_str-devel.sha256sum] = "34b3d6e5bdc6bdeff97545a17c8f3037529d63b35cf945b0d485608b11c4e9a1"

URI_x86_64_v2_rust-ipnet+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+serde-devel-2.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+serde-devel}"
SRC_URI[x86_64_v2_rust-ipnet+serde-devel.sha256sum] = "b78a37064f8ffe5414941fae592301731beedc006d44d59a78dc4924ea7bccee"

URI_x86_64_v2_rust-ipnet+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+std-devel-2.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+std-devel}"
SRC_URI[x86_64_v2_rust-ipnet+std-devel.sha256sum] = "304bfe0684285796c52e1ee9ff96b8d5efc88d8e48677e68569b7e29fa57b099"

URI_x86_64_v2_rust-ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet-devel-2.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet-devel}"
SRC_URI[x86_64_v2_rust-ipnet-devel.sha256sum] = "60ab8ee11f500b13c6e5ba193cd603d2612176e916efe30a4f1a6bfffe7e1802"

URI_aarch64_rust-ipnet+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+default-devel-2.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+default-devel}"
SRC_URI[aarch64_rust-ipnet+default-devel.sha256sum] = "3515e2c78a5f660ce60b7e09d67197ba985e82a1049000521f1644175b2a4d41"

URI_aarch64_rust-ipnet+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+heapless-devel-2.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+heapless-devel}"
SRC_URI[aarch64_rust-ipnet+heapless-devel.sha256sum] = "61ee88f8b93f70c0df6497eb3db38173574d017f63b1f365cfbb6a21bb76b728"

URI_aarch64_rust-ipnet+schemars08-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+schemars08-devel-2.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet+schemars08-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+schemars08-devel}"
SRC_URI[aarch64_rust-ipnet+schemars08-devel.sha256sum] = "46707816161fad4b6d804a8db1c31cee1aee084601f7ec2a8c7a0eafd0c9d207"

URI_aarch64_rust-ipnet+schemars1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+schemars1-devel-2.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet+schemars1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+schemars1-devel}"
SRC_URI[aarch64_rust-ipnet+schemars1-devel.sha256sum] = "02b31c527c701e32f0a23c6e334b236c0f6fdce9e4435b15b6341ffc02ab918a"

URI_aarch64_rust-ipnet+ser_as_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+ser_as_str-devel-2.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet+ser_as_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+ser_as_str-devel}"
SRC_URI[aarch64_rust-ipnet+ser_as_str-devel.sha256sum] = "15d7c33b7a77ae3cb35747a52afa3881039858e74f9a086b33abe96ddfee7890"

URI_aarch64_rust-ipnet+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+serde-devel-2.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+serde-devel}"
SRC_URI[aarch64_rust-ipnet+serde-devel.sha256sum] = "5041b31c04227c6a24d38ca35550718c292013ce03d05e010634dd111df07b6c"

URI_aarch64_rust-ipnet+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+std-devel-2.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+std-devel}"
SRC_URI[aarch64_rust-ipnet+std-devel.sha256sum] = "c961c15daa17ec2e032aeb0539a06f7eb91188eb06b6734f16e62048c993f2f0"

URI_aarch64_rust-ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet-devel-2.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet-devel}"
SRC_URI[aarch64_rust-ipnet-devel.sha256sum] = "9c79398a127791054d0a253189e98ca643766cab20fa442e06ef4713b3fffaf7"

RDEPENDS:rust-ipnet+default-devel = " \
 cargo \
 rust-ipnet+std-devel \
 rust-ipnet-devel \
 "
RDEPENDS:rust-ipnet+heapless-devel = " \
 cargo \
 rust-ipnet+serde-devel \
 rust-ipnet-devel \
 virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~ \
 "
RDEPENDS:rust-ipnet+schemars08-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-ipnet+schemars1-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-ipnet+ser_as_str-devel = " \
 cargo \
 rust-ipnet-devel \
 virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~ \
 "
RDEPENDS:rust-ipnet+serde-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ipnet+std-devel = " \
 cargo \
 rust-ipnet-devel \
 "
RDEPENDS:rust-ipnet-devel = " \
 cargo \
 "
