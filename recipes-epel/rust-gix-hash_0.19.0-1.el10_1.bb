# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-hash"
PV = "0.19.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-hash+default-devel \
 rust-gix-hash+document-features-devel \
 rust-gix-hash+serde-devel \
 rust-gix-hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-hash-0.19.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6da63d7bced01461c36b52392d19959818a7c9d9fb24b5914a0ae886d918035"

URI_x86_64_v2_rust-gix-hash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+default-devel-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+default-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+default-devel.sha256sum] = "a699af5976901f07b090f101b922918a5907e9f8bf69f0b238581e8577fa1ed7"

URI_x86_64_v2_rust-gix-hash+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+document-features-devel-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+document-features-devel.sha256sum] = "22323ff079e1ffb448a7798fbf59026c5ee80aa8e9f0632b79fa79ac0371458e"

URI_x86_64_v2_rust-gix-hash+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+serde-devel-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+serde-devel.sha256sum] = "65b2e5e9746b7e02983efb2bbc79631a36ab7c3e1aae19cdd08cb599314fa6ba"

URI_x86_64_v2_rust-gix-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash-devel-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash-devel}"
SRC_URI[x86_64_v2_rust-gix-hash-devel.sha256sum] = "1f2ede6e049125e722d9fe06204b8bfe5bb1e98bc90a45db577ca80ee48b6253"

URI_aarch64_rust-gix-hash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+default-devel-0.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+default-devel}"
SRC_URI[aarch64_rust-gix-hash+default-devel.sha256sum] = "e90cadb9b7853f7e9f3fec614338ad556942444722ffe8631973a2841686f375"

URI_aarch64_rust-gix-hash+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+document-features-devel-0.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-hash+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+document-features-devel}"
SRC_URI[aarch64_rust-gix-hash+document-features-devel.sha256sum] = "dd9361a3c56e43a7614fe5830f3630f3667f0bdc0a9ec854458862739e5a3e8e"

URI_aarch64_rust-gix-hash+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+serde-devel-0.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-hash+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+serde-devel}"
SRC_URI[aarch64_rust-gix-hash+serde-devel.sha256sum] = "3d2c3c2530ecf398e17e67f03873b3dc73a1c3da48828f3ce9352316cc32362e"

URI_aarch64_rust-gix-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash-devel-0.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash-devel}"
SRC_URI[aarch64_rust-gix-hash-devel.sha256sum] = "c36d9902a4a89d5b46989633d3d7224e416e5cec251ef6a75e1a57c08b26f05c"

RDEPENDS:rust-gix-hash+default-devel = " \
 cargo \
 rust-gix-hash-devel \
 "
RDEPENDS:rust-gix-hash+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-hash-devel \
 "
RDEPENDS:rust-gix-hash+serde-devel = " \
 cargo \
 rust-faster-hex+serde-devel \
 rust-gix-hash-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-hash-devel = " \
 cargo \
 rust \
 rust-faster-hex+std-devel \
 rust-faster-hex-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-sha1-checked-devel \
 rust-thiserror+default-devel \
 "
