# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-azure-core"
PE = "2"
PV = "1.35.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-azure-core \
 python3-azure-core+aio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-azure-core-1.35.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f9110acb3f2ba2f6f71fed3c053ff4f0d7494d3c026630be137f23d298beb54"

URI_x86_64_v2_python3-azure-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-azure-core-1.35.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-azure-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-azure-core}"
SRC_URI[x86_64_v2_python3-azure-core.sha256sum] = "d8f2147a4a155d9a12a16815434bf13ea8995970e95e9da4eff3c56b2da0bc4b"

URI_x86_64_v2_python3-azure-core+aio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-azure-core+aio-1.35.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-azure-core+aio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-azure-core+aio}"
SRC_URI[x86_64_v2_python3-azure-core+aio.sha256sum] = "461e496dde88a47492a2acf559c696b18bb453590546167fe88160a349cb4bc9"

URI_aarch64_python3-azure-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-azure-core-1.35.1-1.el10_2.noarch.rpm;name=aarch64_python3-azure-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-azure-core}"
SRC_URI[aarch64_python3-azure-core.sha256sum] = "dc4d9a79cda21c6c718a9c2934000cc92e962832f9cc20f62dcdcfa5c5da1917"

URI_aarch64_python3-azure-core+aio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-azure-core+aio-1.35.1-1.el10_2.noarch.rpm;name=aarch64_python3-azure-core+aio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-azure-core+aio}"
SRC_URI[aarch64_python3-azure-core+aio.sha256sum] = "bd5f32720aa63931653b3d86aa89b6bda49f3279e234395521a0b8dab01ff611"

RDEPENDS:python3-azure-core = " \
 python3 \
 python3-requests \
 python3-six \
 python3-typing-extensions \
 "
RDEPENDS:python3-azure-core+aio = " \
 python3 \
 python3-aiohttp \
 python3-azure-core \
 "
