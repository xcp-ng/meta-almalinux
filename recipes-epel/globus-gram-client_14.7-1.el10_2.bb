# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-client"
PV = "14.7"
PR = "1.el10_2"
PACKAGES = " \
 globus-gram-client \
 globus-gram-client-devel \
 globus-gram-client-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-client-14.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "161938ba2c08afa89f5da00c96f923d467585dcefdf2ffb6fe8d0a416b06c139"

URI_x86_64_v2_globus-gram-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-client-14.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-client}"
SRC_URI[x86_64_v2_globus-gram-client.sha256sum] = "62d8c02938c55e850d297874605f459f7632efc333989af5878dbaeb14e9b7af"

URI_x86_64_v2_globus-gram-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-client-devel-14.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-client-devel}"
SRC_URI[x86_64_v2_globus-gram-client-devel.sha256sum] = "c11caba36883a99c75ec9ffb2d2128c658ebfa13e20ab6e32e7b2fcacc49f212"

URI_x86_64_v2_globus-gram-client-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-client-doc-14.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-client-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-client-doc}"
SRC_URI[x86_64_v2_globus-gram-client-doc.sha256sum] = "4c10b0cfe752c0a8f19e4d9f1281f44807955bb91c4f891e98f38262be067439"

URI_aarch64_globus-gram-client = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-client-14.7-1.el10_2.aarch64.rpm;name=aarch64_globus-gram-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-client}"
SRC_URI[aarch64_globus-gram-client.sha256sum] = "a94555dd7a7bd2d2e0c5897ca418d2f2ee88ff3d05b96129a6cdc684cc3a1dbb"

URI_aarch64_globus-gram-client-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-client-devel-14.7-1.el10_2.aarch64.rpm;name=aarch64_globus-gram-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-client-devel}"
SRC_URI[aarch64_globus-gram-client-devel.sha256sum] = "39276db98dcae2d55025fe6b083a88e84b15beaeed9adde2f44add655470d177"

URI_aarch64_globus-gram-client-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-client-doc-14.7-1.el10_2.noarch.rpm;name=aarch64_globus-gram-client-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-client-doc}"
SRC_URI[aarch64_globus-gram-client-doc.sha256sum] = "6fd62a9604c738b2c091c305a6d8947baa8671110eb6919e6d0317896af4a904"

RDEPENDS:globus-gram-client = " \
 glibc \
 globus-common \
 globus-gram-protocol \
 globus-gss-assist \
 globus-io \
 globus-rsl \
 "
RDEPENDS:globus-gram-client-devel = " \
 globus-common-devel \
 globus-gram-client \
 globus-gram-protocol-devel \
 globus-gss-assist-devel \
 globus-io-devel \
 globus-rsl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gram-client-doc = " \
 "
