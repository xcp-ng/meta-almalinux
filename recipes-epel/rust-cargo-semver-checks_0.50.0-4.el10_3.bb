# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-semver-checks"
PV = "0.50.0"
PR = "4.el10_3"
PACKAGES = " \
 cargo-semver-checks \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-semver-checks-0.50.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dbf90f560664439c0e2b2aac89f0e47e80c42839fea43b45a3fda3a6c91d9ecd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cargo-semver-checks-0.50.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cargo-semver-checks;unpack=0"
SRC_URI[x86_64_v2_cargo-semver-checks.sha256sum] = "4ccf3fbff102d93b880893c2c5544ff5c7bf81f511f010ed8cbd8da622c22fbc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cargo-semver-checks-0.50.0-4.el10_3.aarch64.rpm;name=aarch64_cargo-semver-checks;unpack=0"
SRC_URI[aarch64_cargo-semver-checks.sha256sum] = "21517e1b14655af91512b26e1d09005f81321ef7d1716b5dd308010e9cabe29d"

RDEPENDS:cargo-semver-checks = " \
 glibc \
 libgcc \
 "
