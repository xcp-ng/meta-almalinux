# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hex-literal"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-hex-literal+default-devel \
 rust-hex-literal-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-hex-literal-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "df3060f8eb89c1bc2596be5ef604b11fc56683fe57e68ddfe033ed848a5bf59f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex-literal+default-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex-literal+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hex-literal+default-devel.sha256sum] = "f6bee9cec67225813eb44ecbb347ba9640e037fc475cd880f367285ee79fbfc1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex-literal-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex-literal-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hex-literal-devel.sha256sum] = "3b32718d69721ef2e72bdcf0771251372adc708f8292a8d36d50e654604cd4bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hex-literal+default-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-hex-literal+default-devel;unpack=0"
SRC_URI[aarch64_rust-hex-literal+default-devel.sha256sum] = "0aae1cac34299306bb6e3fd1078c0d69d113d99a275124c73ea3e0907af1e737"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hex-literal-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-hex-literal-devel;unpack=0"
SRC_URI[aarch64_rust-hex-literal-devel.sha256sum] = "ec9c0c2c0852e9b4e51fa6ac8d475d962d6cbf1960fabfccb822d68ec82b93cf"

RDEPENDS:rust-hex-literal+default-devel = " \
 cargo \
 rust-hex-literal-devel \
 "
RDEPENDS:rust-hex-literal-devel = " \
 cargo \
 rust \
 "
