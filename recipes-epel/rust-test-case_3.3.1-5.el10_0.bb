# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-test-case"
PV = "3.3.1"
PR = "5.el10_0"
PACKAGES = " \
 rust-test-case+default-devel \
 rust-test-case+regex-devel \
 rust-test-case+with-regex-devel \
 rust-test-case-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-test-case-3.3.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad762163fbd566cd7422a3369417157795db76baea59dc052b31591a233b374d"

URI_x86_64_v2_rust-test-case+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-case+default-devel-3.3.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-case+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-case+default-devel}"
SRC_URI[x86_64_v2_rust-test-case+default-devel.sha256sum] = "7387068114e641f560a1ae13e1b8603588f2b03bde59c4bac723f80b3e966450"

URI_x86_64_v2_rust-test-case+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-case+regex-devel-3.3.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-case+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-case+regex-devel}"
SRC_URI[x86_64_v2_rust-test-case+regex-devel.sha256sum] = "94c90d433465c34ee02de2f70a17879ef87785b901ab72fa1e0e7ab2960690d2"

URI_x86_64_v2_rust-test-case+with-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-case+with-regex-devel-3.3.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-case+with-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-case+with-regex-devel}"
SRC_URI[x86_64_v2_rust-test-case+with-regex-devel.sha256sum] = "4a53ade0dbfd3928418a500d4158ac4845f847ae0f8b3d3c88f3703bc238ca54"

URI_x86_64_v2_rust-test-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-case-devel-3.3.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-case-devel}"
SRC_URI[x86_64_v2_rust-test-case-devel.sha256sum] = "fa8fcf26b046d5bca9171f274e963340425deb742dda5457204104e9e84edee9"

URI_aarch64_rust-test-case+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-case+default-devel-3.3.1-5.el10_0.noarch.rpm;name=aarch64_rust-test-case+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-case+default-devel}"
SRC_URI[aarch64_rust-test-case+default-devel.sha256sum] = "3ecba0df6d092ca8a32a6fdb9bece4076b77417de6f880419419f3d535687f60"

URI_aarch64_rust-test-case+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-case+regex-devel-3.3.1-5.el10_0.noarch.rpm;name=aarch64_rust-test-case+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-case+regex-devel}"
SRC_URI[aarch64_rust-test-case+regex-devel.sha256sum] = "c2f631ca9ac169b7d3d22936dbf3cf4a5c5f847d1721a4b1cccdb2a2c976f034"

URI_aarch64_rust-test-case+with-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-case+with-regex-devel-3.3.1-5.el10_0.noarch.rpm;name=aarch64_rust-test-case+with-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-case+with-regex-devel}"
SRC_URI[aarch64_rust-test-case+with-regex-devel.sha256sum] = "c8094eccbe955db5d54a378309968af7735cbf6ca3cb936671f928841397ecde"

URI_aarch64_rust-test-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-case-devel-3.3.1-5.el10_0.noarch.rpm;name=aarch64_rust-test-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-case-devel}"
SRC_URI[aarch64_rust-test-case-devel.sha256sum] = "f92625dc5d2902c750933d3426f9a67ee9999083a92e73f45ac9b250a4413cd9"

RDEPENDS:rust-test-case+default-devel = " \
 cargo \
 rust-test-case-devel \
 "
RDEPENDS:rust-test-case+regex-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-test-case-devel \
 "
RDEPENDS:rust-test-case+with-regex-devel = " \
 cargo \
 rust-test-case+regex-devel \
 rust-test-case-devel \
 rust-test-case-macros+with-regex-devel \
 "
RDEPENDS:rust-test-case-devel = " \
 cargo \
 rust \
 rust-test-case-macros-devel \
 "
