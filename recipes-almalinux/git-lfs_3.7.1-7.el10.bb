# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-lfs"
PV = "3.7.1"
PR = "7.el10"
PACKAGES = " \
 git-lfs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/git-lfs-3.7.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d9763e8434bb2f5a5a830b142978cd18cfffe4d2a5ad84372bfce6f29f9e4c41"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-lfs-3.7.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_git-lfs;unpack=0"
SRC_URI[x86_64_v2_git-lfs.sha256sum] = "308a929b542ae781a6d054dff0c666c800aa80cd8a4d08163442cb1dd9f22b91"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-lfs-3.7.1-7.el10.aarch64.rpm;name=aarch64_git-lfs;unpack=0"
SRC_URI[aarch64_git-lfs.sha256sum] = "80ffef9f5fea36122219ef16b3e63ca42433a3da6365388a94d53fdb3ed0fde7"

RDEPENDS:git-lfs = " \
 bash \
 git-core \
 glibc \
 "
