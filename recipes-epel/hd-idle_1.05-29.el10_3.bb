# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hd-idle"
PV = "1.05"
PR = "29.el10_3"
PACKAGES = " \
 hd-idle \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/h/hd-idle-1.05-29.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9b0f2f42af0156497e3be720816842a6c2c573164bbc0ad1c48dcf0756a0ce13"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hd-idle-1.05-29.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hd-idle;unpack=0"
SRC_URI[x86_64_v2_hd-idle.sha256sum] = "5659dd8c6a9e442e5a501b8db99d61a4792adbbd868ea68a3a03d43fd0a260a4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hd-idle-1.05-29.el10_3.aarch64.rpm;name=aarch64_hd-idle;unpack=0"
SRC_URI[aarch64_hd-idle.sha256sum] = "6565dff82f7a9219d6e5cb9ffbbf3b39e205a18f6875f15e09e52ea6a64c1a13"

RDEPENDS:hd-idle = " \
 bash \
 glibc \
 "
