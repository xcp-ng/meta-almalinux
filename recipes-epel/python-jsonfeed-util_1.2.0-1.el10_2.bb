# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jsonfeed-util"
PV = "1.2.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-jsonfeed-util \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jsonfeed-util-1.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc75b1cca7eb67d71c22e62cfa56be678901b62a5574bd82a08e103d61fc82cc"

URI_x86_64_v2_python3-jsonfeed-util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jsonfeed-util-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jsonfeed-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jsonfeed-util}"
SRC_URI[x86_64_v2_python3-jsonfeed-util.sha256sum] = "a37543c1f679d809ead19a8bfd8a2ab4d5d282ba2f679af280f931084c4adb39"

URI_aarch64_python3-jsonfeed-util = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jsonfeed-util-1.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-jsonfeed-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jsonfeed-util}"
SRC_URI[aarch64_python3-jsonfeed-util.sha256sum] = "7551477bfb7bc116c5e58ab9b6c4d3a3b38c90e8b25a1b2baab018ed64b57e20"

RDEPENDS:python3-jsonfeed-util = " \
 python3 \
 "
