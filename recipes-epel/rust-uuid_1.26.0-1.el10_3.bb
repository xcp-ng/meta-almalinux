# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uuid"
PV = "1.26.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uuid+arbitrary-devel \
 rust-uuid+atomic-devel \
 rust-uuid+bytemuck-devel \
 rust-uuid+default-devel \
 rust-uuid+fast-rng-devel \
 rust-uuid+md5-devel \
 rust-uuid+rng-devel \
 rust-uuid+rng-getrandom-devel \
 rust-uuid+rng-rand-devel \
 rust-uuid+serde-devel \
 rust-uuid+sha1-devel \
 rust-uuid+slog-devel \
 rust-uuid+std-devel \
 rust-uuid+v1-devel \
 rust-uuid+v3-devel \
 rust-uuid+v4-devel \
 rust-uuid+v5-devel \
 rust-uuid+v6-devel \
 rust-uuid+v7-devel \
 rust-uuid+v8-devel \
 rust-uuid-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-uuid-1.26.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fe72a2ec55067d0eaa21daf1c9a4b003e300f136af719a7c9c17d6d733affe9b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+arbitrary-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+arbitrary-devel.sha256sum] = "1e70ae158ee980a7e35acf6f39277c93d94ac30160bee0b7da7e257f801107b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+atomic-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+atomic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+atomic-devel.sha256sum] = "de1e2d766a752be4c5983e9e4cf531602ac20c5ba1b67d922dfbec9c2f63293c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+bytemuck-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+bytemuck-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+bytemuck-devel.sha256sum] = "33df9713e28fa71acee836805fbf3d9b094c6b6dbf1dda499a50a780c368041b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+default-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+default-devel.sha256sum] = "3b315b13f3c04d5648d1ecd577f05971d96288f2f75f7749e838d43064438ae2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+fast-rng-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+fast-rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+fast-rng-devel.sha256sum] = "8395d49ace77c705aac2ebf895b31570a6e9296e713dc25bed672b4094b10600"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+md5-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+md5-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+md5-devel.sha256sum] = "4803f9e444e9f14e26e5fef52812f24a1d8eb4c835ad5ad75e0e615dd217d9fc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+rng-devel.sha256sum] = "11c889c91619b8a9f39631e131f4bc7aade7644262ddfb9d685e6b5172717e52"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-getrandom-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-getrandom-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+rng-getrandom-devel.sha256sum] = "8be00c5af2099247c8646232bcdcfdf81e9f7906592adc79419177cc98fa493d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-rand-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-rand-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+rng-rand-devel.sha256sum] = "aecd4642abe64cb6227f9a840d1bdef877955a4efbbda5ba87c0e8f71c347aa5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+serde-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+serde-devel.sha256sum] = "d1b31b807df2b11286549609f452268121761c78b1b9ea1bf6a4bb2263e5e89e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+sha1-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+sha1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+sha1-devel.sha256sum] = "0f2d9941d09f2f7fc95254018c20df0004a735c2a0c79a923c89f7a45289b7c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+slog-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+slog-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+slog-devel.sha256sum] = "17a4e2f2c83e15e8c8d7299dac3e2ac2a4a598a1f9dd0e7b90edf4eddc522630"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+std-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+std-devel.sha256sum] = "c56fdb42c296c8e932376fc4d7316086c8e34edbe472bffc1fd36c4910d857a3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v1-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+v1-devel.sha256sum] = "92d6bac0e11e63a99ffed07bf3e73150781930a35a30d6a55e5c8c3cd1c2803e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v3-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v3-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+v3-devel.sha256sum] = "2f2968e19d2c6c3d939e53cf0dade6d194e6752b9868dae987b26f2e3d6896b1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v4-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v4-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+v4-devel.sha256sum] = "852aa0dab9673e1740d65deebc80077581842030d54d42465f0e2b852e071498"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v5-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v5-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+v5-devel.sha256sum] = "2211f55f41a61fae7c334570d94e24ee9c701adb592dba6f98a4d44bdf0d2b1c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v6-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v6-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+v6-devel.sha256sum] = "6d51165733b1d8d19171b7c78a17cfd81b354cdb0dd0713f3cda2936825773f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v7-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v7-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+v7-devel.sha256sum] = "dcaefe5c913e8ce141a91f5b72358bc0d53f9afbc258b1b650e5bef618bde23c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v8-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v8-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid+v8-devel.sha256sum] = "b1c1efb8f30e400091984505e4239dfe40ffee1797fa6d4f6707ecb10d6351e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid-devel-1.26.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uuid-devel.sha256sum] = "e5b3346beaa237231593aa0383a62430e301cf7781588e9e876daff12f2eaa36"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+arbitrary-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+arbitrary-devel.sha256sum] = "640f8585ca50a051c4625c81f78bd5b2fab15586afb21f081b45d8094a579213"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+atomic-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+atomic-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+atomic-devel.sha256sum] = "b5407417bf3ab95231c3d8f8fafc1ba61c48f8453a47e53377133eff8d044a4a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+bytemuck-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+bytemuck-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+bytemuck-devel.sha256sum] = "706fccee476587bc53816f8c37e113fcdcc4af21d280deac7e8ca9b1ebc8ebe2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+default-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+default-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+default-devel.sha256sum] = "c62229728586de732aac519c761e76fd7827558205ce2f951fa078592de1b38e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+fast-rng-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+fast-rng-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+fast-rng-devel.sha256sum] = "3ad22466b586bed2216cc104604ad854ee7bee48b5b64429f22c70bb85807ebb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+md5-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+md5-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+md5-devel.sha256sum] = "321f07a3a8aa0cb45c9c5975a7041c3565d6ec69dc0d493b32d639e36e4d7194"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+rng-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+rng-devel.sha256sum] = "35a181305c9180799b494ad4e7fd44e8b5013e112ba67dc84ed705d275b638dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-getrandom-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+rng-getrandom-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+rng-getrandom-devel.sha256sum] = "daf68688f82ae39ce0962712b41f14644abeb3b09258a454b106bcde85625605"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-rand-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+rng-rand-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+rng-rand-devel.sha256sum] = "4bb2753b5856206c38bfe249dd03145b032da009727fd119907efab1091d05a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+serde-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+serde-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+serde-devel.sha256sum] = "620ad3b0cc989687861046bd71be0701507887fcd0cbb39efe076e39b6854002"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+sha1-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+sha1-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+sha1-devel.sha256sum] = "e6255c1c2c008743cc64ced249f2037be3269cbbe4eea8ebb81f1540be41f178"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+slog-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+slog-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+slog-devel.sha256sum] = "598494c9d5d9bce8a2d5839286ab084043807a66ee3cdbd42d2c0de9a883ea94"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+std-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+std-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+std-devel.sha256sum] = "493039383a3980bfad1da6e2513891853c54c80a06b120ff0361ed7a03ab66f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v1-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+v1-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+v1-devel.sha256sum] = "41056db05a69050a12c3d687071b16a016374676fd617e569e8774be00e0c9a1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v3-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+v3-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+v3-devel.sha256sum] = "6073ac3bec7661ed87996657ddc10b70841982b72dfde105a3105aa58fe72a9d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v4-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+v4-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+v4-devel.sha256sum] = "1989746e6068246186f3971af063aec2f96f566b3acca5ef636b6ea7a3aa2c86"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v5-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+v5-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+v5-devel.sha256sum] = "5effc5e15e3e5980d255dc0640bd7636f7f36c9690ae90107940c7be4a6cfeba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v6-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+v6-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+v6-devel.sha256sum] = "44d193db64623cbc8b6082c2e384a26a5bcedfe257c02a52adda10f96f149ef7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v7-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+v7-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+v7-devel.sha256sum] = "fcae48e1e0e9e5d2b96b1ee677c837a36cf08965a49fff059fbff65c58c2a692"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v8-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid+v8-devel;unpack=0"
SRC_URI[aarch64_rust-uuid+v8-devel.sha256sum] = "6465291031702d381172318928f09cd7917d77ef1a51ce43bfd79bd3a98c10b5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid-devel-1.26.0-1.el10_3.noarch.rpm;name=aarch64_rust-uuid-devel;unpack=0"
SRC_URI[aarch64_rust-uuid-devel.sha256sum] = "cfee00eb83a1caa5dd1b0dd84154502772e6e66f6f0445bfed2e23a67a1932bb"

RDEPENDS:rust-uuid+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+atomic-devel = " \
 cargo \
 rust-atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-bytemuck+derive-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+default-devel = " \
 cargo \
 rust-uuid+std-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+fast-rng-devel = " \
 cargo \
 rust-rand+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+md5-devel = " \
 cargo \
 rust-md-5_0.10-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-rand-devel = " \
 cargo \
 rust-rand+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+sha1-devel = " \
 cargo \
 rust-sha1_smol-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+slog-devel = " \
 cargo \
 rust-slog+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+std-devel = " \
 cargo \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v1-devel = " \
 cargo \
 rust-uuid+atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v3-devel = " \
 cargo \
 rust-uuid+md5-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v4-devel = " \
 cargo \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v5-devel = " \
 cargo \
 rust-uuid+sha1-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v6-devel = " \
 cargo \
 rust-uuid+atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v7-devel = " \
 cargo \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v8-devel = " \
 cargo \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid-devel = " \
 cargo \
 rust \
 "
