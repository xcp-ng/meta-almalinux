# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-either"
PV = "1.16.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-either+default-devel \
 rust-either+serde-devel \
 rust-either+std-devel \
 rust-either+use_std-devel \
 rust-either-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-either-1.16.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b8bd6bbd029e3322d989fedcf25135f6a563dd21c5b744651e5bb8f7eebab96"

URI_x86_64_v2_rust-either+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+default-devel-1.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+default-devel}"
SRC_URI[x86_64_v2_rust-either+default-devel.sha256sum] = "bcc16144a6189f3122299e00a351213590ca51a867a9512bc229f91d261220ea"

URI_x86_64_v2_rust-either+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+serde-devel-1.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+serde-devel}"
SRC_URI[x86_64_v2_rust-either+serde-devel.sha256sum] = "e38f36256a445296e7077d025731458220c10282e1c7d1e2ad4655c140675faa"

URI_x86_64_v2_rust-either+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+std-devel-1.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+std-devel}"
SRC_URI[x86_64_v2_rust-either+std-devel.sha256sum] = "c1ebd11aab6df3214bc594b2546eac21457d2ce2c3e7a013004045cd7963a106"

URI_x86_64_v2_rust-either+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+use_std-devel-1.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+use_std-devel}"
SRC_URI[x86_64_v2_rust-either+use_std-devel.sha256sum] = "1bc39c9cf3c0dd2d72754762b8826c41660427a47ee50cdaedb880c05f199e8d"

URI_x86_64_v2_rust-either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either-devel-1.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either-devel}"
SRC_URI[x86_64_v2_rust-either-devel.sha256sum] = "c3a31979016e9b16b896b51f616376daa450e5b5e57992b387990ff3eb20b237"

URI_aarch64_rust-either+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+default-devel-1.16.0-1.el10_2.noarch.rpm;name=aarch64_rust-either+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+default-devel}"
SRC_URI[aarch64_rust-either+default-devel.sha256sum] = "be624aac718fcb8644ffcaf47e7ccbab64064dd9460c36e1577d045ae746c98e"

URI_aarch64_rust-either+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+serde-devel-1.16.0-1.el10_2.noarch.rpm;name=aarch64_rust-either+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+serde-devel}"
SRC_URI[aarch64_rust-either+serde-devel.sha256sum] = "bbecebf93c0435cf74f049b762de10704d48566e83f6999074bd847067687574"

URI_aarch64_rust-either+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+std-devel-1.16.0-1.el10_2.noarch.rpm;name=aarch64_rust-either+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+std-devel}"
SRC_URI[aarch64_rust-either+std-devel.sha256sum] = "774f2f3318a504e0a4346ebda7b30ed8ff80b28bc5dbd5520f29f315156fc63b"

URI_aarch64_rust-either+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+use_std-devel-1.16.0-1.el10_2.noarch.rpm;name=aarch64_rust-either+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+use_std-devel}"
SRC_URI[aarch64_rust-either+use_std-devel.sha256sum] = "4ae954f52b6997d017c7509a510ad32aad45f20bd004b689c0f199a7c26c65eb"

URI_aarch64_rust-either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either-devel-1.16.0-1.el10_2.noarch.rpm;name=aarch64_rust-either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either-devel}"
SRC_URI[aarch64_rust-either-devel.sha256sum] = "1807fda6dd4920f656a29a04db3d25ba59e2223eed8b2fd689733799929019a9"

RDEPENDS:rust-either+default-devel = " \
 cargo \
 rust-either+std-devel \
 rust-either-devel \
 "
RDEPENDS:rust-either+serde-devel = " \
 cargo \
 rust-either-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-either+std-devel = " \
 cargo \
 rust-either-devel \
 "
RDEPENDS:rust-either+use_std-devel = " \
 cargo \
 rust-either+std-devel \
 rust-either-devel \
 "
RDEPENDS:rust-either-devel = " \
 cargo \
 rust \
 "
