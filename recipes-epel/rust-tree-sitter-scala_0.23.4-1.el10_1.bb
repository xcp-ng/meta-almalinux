# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-scala"
PV = "0.23.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-scala+default-devel \
 rust-tree-sitter-scala-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-scala-0.23.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a81bdf3c9a599fb7d9cae353d7c654dc6530cb165a57e2692a4998e7b2b5188a"

URI_x86_64_v2_rust-tree-sitter-scala+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-scala+default-devel-0.23.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-scala+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-scala+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-scala+default-devel.sha256sum] = "7950edeefdc71bd3de98a5d3579df58a53b4ed7ed053e9715cf61e79cbb6d252"

URI_x86_64_v2_rust-tree-sitter-scala-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-scala-devel-0.23.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-scala-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-scala-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-scala-devel.sha256sum] = "9b3c812cd24b74b6eae071110e026ef0a78b6193b3b4adf6d754d2b5705a9bd5"

URI_aarch64_rust-tree-sitter-scala+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-scala+default-devel-0.23.4-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-scala+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-scala+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-scala+default-devel.sha256sum] = "3d85a377f49ca17356e79c21d5dce0770defd12a56d4c98d3783dbff49c26833"

URI_aarch64_rust-tree-sitter-scala-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-scala-devel-0.23.4-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-scala-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-scala-devel}"
SRC_URI[aarch64_rust-tree-sitter-scala-devel.sha256sum] = "0b668121eae661824fecc7f423117b9c10e091933649d5721b9999d1f6e33c57"

RDEPENDS:rust-tree-sitter-scala+default-devel = " \
 cargo \
 rust-tree-sitter-scala-devel \
 "
RDEPENDS:rust-tree-sitter-scala-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
