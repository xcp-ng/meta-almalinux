# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex"
PV = "1.11.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-regex+default-devel \
 rust-regex+logging-devel \
 rust-regex+pattern-devel \
 rust-regex+perf-backtrack-devel \
 rust-regex+perf-cache-devel \
 rust-regex+perf-devel \
 rust-regex+perf-dfa-devel \
 rust-regex+perf-dfa-full-devel \
 rust-regex+perf-inline-devel \
 rust-regex+perf-literal-devel \
 rust-regex+perf-onepass-devel \
 rust-regex+std-devel \
 rust-regex+unicode-age-devel \
 rust-regex+unicode-bool-devel \
 rust-regex+unicode-case-devel \
 rust-regex+unicode-devel \
 rust-regex+unicode-gencat-devel \
 rust-regex+unicode-perl-devel \
 rust-regex+unicode-script-devel \
 rust-regex+unicode-segment-devel \
 rust-regex+unstable-devel \
 rust-regex+use_std-devel \
 rust-regex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-1.11.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96478bce555485dd2a13685495bc8c4492433065cad7a60cb23c08d8bf8f4319"

URI_x86_64_v2_rust-regex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+default-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+default-devel}"
SRC_URI[x86_64_v2_rust-regex+default-devel.sha256sum] = "c0d593d9e1f06e38fdade12e107a106d14d3fcff8544eda815ae6acb988ffb07"

URI_x86_64_v2_rust-regex+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+logging-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+logging-devel}"
SRC_URI[x86_64_v2_rust-regex+logging-devel.sha256sum] = "8aca9e6daa524fcfb686ed6095d27b38f6bff96ec5e01c9f701eb3d400ea4fd7"

URI_x86_64_v2_rust-regex+pattern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+pattern-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+pattern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+pattern-devel}"
SRC_URI[x86_64_v2_rust-regex+pattern-devel.sha256sum] = "f3ff07a5d6c58857caa542c8786eea1fff85d6f265ca17518d5f54112bbdaf19"

URI_x86_64_v2_rust-regex+perf-backtrack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-backtrack-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-backtrack-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-backtrack-devel.sha256sum] = "d688e28047bebb4d8641307be89cb482e75dfafc25031db609ffbf1bad4a4af8"

URI_x86_64_v2_rust-regex+perf-cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-cache-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-cache-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-cache-devel.sha256sum] = "dd4fe286be23d4e3d71a5c536799a6c9c257e9767ae50665be1e3b0012af4cf3"

URI_x86_64_v2_rust-regex+perf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-devel.sha256sum] = "be8e959b3c18b47a798aef5027bcf7748a5da6757906789e656bb1019fc3d299"

URI_x86_64_v2_rust-regex+perf-dfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-dfa-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-dfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-dfa-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-dfa-devel.sha256sum] = "25e84b373e6ec9c59cc7f08b40f82767104d4370d436d7f768f426ce6b9d931c"

URI_x86_64_v2_rust-regex+perf-dfa-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-dfa-full-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-dfa-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-dfa-full-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-dfa-full-devel.sha256sum] = "cc8ff5523b436f2f33e3c08f0d06bd163253dcefeff21b4e3b220230c8f648cf"

URI_x86_64_v2_rust-regex+perf-inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-inline-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-inline-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-inline-devel.sha256sum] = "98c2eec0e58f69f8dd838cadc2281837be6fabc311b1475c46b6a2017851332b"

URI_x86_64_v2_rust-regex+perf-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-literal-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-literal-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-literal-devel.sha256sum] = "3f4fc06317d27dbf16bf387fb6f767f01ae4c3948b4ff787a3f2f4b6349e993e"

URI_x86_64_v2_rust-regex+perf-onepass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-onepass-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-onepass-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-onepass-devel.sha256sum] = "7f05dba614a3fa8f1ba19864fbd0ac8c85cb7c08f672678d0a615dcea911e38f"

URI_x86_64_v2_rust-regex+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+std-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+std-devel}"
SRC_URI[x86_64_v2_rust-regex+std-devel.sha256sum] = "431e50b62ad3ad0410651764cfc62d8f4ea087880c612eb90d56035ec62107e1"

URI_x86_64_v2_rust-regex+unicode-age-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-age-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-age-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-age-devel.sha256sum] = "10f9844d4f2f2c1fde151f0d8a0392c106fa2625be43dec83d65c88c0161fe36"

URI_x86_64_v2_rust-regex+unicode-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-bool-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-bool-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-bool-devel.sha256sum] = "86937cd82cbee51f7596638f80d2d50eb5f487236b6140e2ac336363871c62be"

URI_x86_64_v2_rust-regex+unicode-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-case-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-case-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-case-devel.sha256sum] = "dffae1ed8f7650ac5334ca01a00edb0938c2ffdd5357a47fea7c120a03592e68"

URI_x86_64_v2_rust-regex+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-devel.sha256sum] = "bf2ee9abbad3aec90e33ab7dd9ba2b16b10dadc2c4cf1a89ae623c6c1578c507"

URI_x86_64_v2_rust-regex+unicode-gencat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-gencat-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-gencat-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-gencat-devel.sha256sum] = "75f1657d440220bea17ace595e7b1f8f198a16d4f96c0d700a0c70205701db35"

URI_x86_64_v2_rust-regex+unicode-perl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-perl-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-perl-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-perl-devel.sha256sum] = "6d3e45097dd2ccd49e095fd7c663dc4890b727e80e868baf9a7781236ca7e8b6"

URI_x86_64_v2_rust-regex+unicode-script-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-script-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-script-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-script-devel.sha256sum] = "1ccd39c6d7b4dfe16417149825096abb7b4cb7d4e44fa4756d67bbe63713eeae"

URI_x86_64_v2_rust-regex+unicode-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-segment-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-segment-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-segment-devel.sha256sum] = "4f50c00acda9c34a0813402580e3102053ae8f906ef8026fafd8e320bc78572d"

URI_x86_64_v2_rust-regex+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unstable-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unstable-devel}"
SRC_URI[x86_64_v2_rust-regex+unstable-devel.sha256sum] = "8b85c976671ccd59af4fa132c532b03fff806a782ed75ada07c6363d4f7cc4e2"

URI_x86_64_v2_rust-regex+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+use_std-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+use_std-devel}"
SRC_URI[x86_64_v2_rust-regex+use_std-devel.sha256sum] = "7d28dddf2986a426a38b8b545d455a6c71ef02c1615fe461d5ecc4f4c51b896f"

URI_x86_64_v2_rust-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-devel-1.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-devel}"
SRC_URI[x86_64_v2_rust-regex-devel.sha256sum] = "bc5fa1654f298b1c3f47916d9477db9b3db69f29abfebe98998125098f7ce83d"

URI_aarch64_rust-regex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+default-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+default-devel}"
SRC_URI[aarch64_rust-regex+default-devel.sha256sum] = "5c05da75ed67a307deb7d94a2f6303899b3e4b7e546ee5494caa131b2ee2c304"

URI_aarch64_rust-regex+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+logging-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+logging-devel}"
SRC_URI[aarch64_rust-regex+logging-devel.sha256sum] = "75f9af7d5dc4e24e7ac731adf052b205335b59e70a76ad7cc960f387b1bcb888"

URI_aarch64_rust-regex+pattern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+pattern-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+pattern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+pattern-devel}"
SRC_URI[aarch64_rust-regex+pattern-devel.sha256sum] = "12935160d3982d98d3de4e6149bdc0f1b8144e56153b5b6b8ff0b8a6db608d18"

URI_aarch64_rust-regex+perf-backtrack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-backtrack-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+perf-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-backtrack-devel}"
SRC_URI[aarch64_rust-regex+perf-backtrack-devel.sha256sum] = "133b471e2c0a8a9e81e17985405d0e1bff4d4ba6fbc17d7ef6c6bfd4c78665f6"

URI_aarch64_rust-regex+perf-cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-cache-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+perf-cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-cache-devel}"
SRC_URI[aarch64_rust-regex+perf-cache-devel.sha256sum] = "214a27fd1d301eda06be6348a138e77bd32646fd1659801ebb32e62c981a5964"

URI_aarch64_rust-regex+perf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+perf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-devel}"
SRC_URI[aarch64_rust-regex+perf-devel.sha256sum] = "094c3055005b17eadbac877baa42dd2d823d90ac6834e998e01c2dfdec25eb35"

URI_aarch64_rust-regex+perf-dfa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-dfa-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+perf-dfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-dfa-devel}"
SRC_URI[aarch64_rust-regex+perf-dfa-devel.sha256sum] = "62ed92828bc0ecbfb2b591687a481d1e29676debdf7c7caa9f72173397c66cf8"

URI_aarch64_rust-regex+perf-dfa-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-dfa-full-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+perf-dfa-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-dfa-full-devel}"
SRC_URI[aarch64_rust-regex+perf-dfa-full-devel.sha256sum] = "f42522504c2b0541f02853f8f423dbfa4072c97d8558858eea5a428c86910e8d"

URI_aarch64_rust-regex+perf-inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-inline-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-inline-devel}"
SRC_URI[aarch64_rust-regex+perf-inline-devel.sha256sum] = "d021d4a6f25cf738b9504e22126f20e0619fd6cfc4ecb4eac3d68903e007c874"

URI_aarch64_rust-regex+perf-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-literal-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-literal-devel}"
SRC_URI[aarch64_rust-regex+perf-literal-devel.sha256sum] = "dd4dd1c1b901b2e14c0bd6f45956cdf6413892434b752338a0aaee1eaed27a7a"

URI_aarch64_rust-regex+perf-onepass-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-onepass-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+perf-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-onepass-devel}"
SRC_URI[aarch64_rust-regex+perf-onepass-devel.sha256sum] = "54201d853229a0b2c1846b7c27e86f4075d44f7df4268a07c7b302224e55b827"

URI_aarch64_rust-regex+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+std-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+std-devel}"
SRC_URI[aarch64_rust-regex+std-devel.sha256sum] = "8584add8fcfd03c2766c9e2a31ae806792ac101710d56cd440df7b2a16c75862"

URI_aarch64_rust-regex+unicode-age-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-age-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-age-devel}"
SRC_URI[aarch64_rust-regex+unicode-age-devel.sha256sum] = "f1b3d49b433c6f0117cee5f8b4fdd3c8e5eb9f97889dfd1ee6cd1ac20ea89475"

URI_aarch64_rust-regex+unicode-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-bool-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-bool-devel}"
SRC_URI[aarch64_rust-regex+unicode-bool-devel.sha256sum] = "2993ec50d5e824b028e93d9907ad94bed246d3c3c80e9657aad9755933b4ac45"

URI_aarch64_rust-regex+unicode-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-case-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-case-devel}"
SRC_URI[aarch64_rust-regex+unicode-case-devel.sha256sum] = "27652c414b060c823083a4ff4ecec990d46e51105677f5e748abed4ad79a603f"

URI_aarch64_rust-regex+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-devel}"
SRC_URI[aarch64_rust-regex+unicode-devel.sha256sum] = "7a34bf660325fab4c410f4fe93ac5afdbe84a4666ece6d1d41b61b01d480c854"

URI_aarch64_rust-regex+unicode-gencat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-gencat-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-gencat-devel}"
SRC_URI[aarch64_rust-regex+unicode-gencat-devel.sha256sum] = "1dfc8c64ca0dc7f952edc59209d86f8bf609ff69043cb329c6a83343a176f08f"

URI_aarch64_rust-regex+unicode-perl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-perl-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-perl-devel}"
SRC_URI[aarch64_rust-regex+unicode-perl-devel.sha256sum] = "bbc7fe6d3c60188fbae9671675233cf54b99bb4739b555a9db8dfbb048ce967f"

URI_aarch64_rust-regex+unicode-script-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-script-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-script-devel}"
SRC_URI[aarch64_rust-regex+unicode-script-devel.sha256sum] = "53840339739476363259a4f20601134b4faf351b620a9030219cff12a1176736"

URI_aarch64_rust-regex+unicode-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-segment-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-segment-devel}"
SRC_URI[aarch64_rust-regex+unicode-segment-devel.sha256sum] = "5e8bc0dead6e9f1277d74b35fea9e795bd5a1505ee6efbe5074d4c2da711f0a4"

URI_aarch64_rust-regex+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unstable-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unstable-devel}"
SRC_URI[aarch64_rust-regex+unstable-devel.sha256sum] = "116b50d5233a17e34e53165d1d51475926192bd64ee97080272ac275ebd0b783"

URI_aarch64_rust-regex+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+use_std-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+use_std-devel}"
SRC_URI[aarch64_rust-regex+use_std-devel.sha256sum] = "4e4bee3d21fb6214e3adeb5754680004fbe44abbf047641101ddb3a4f5111c23"

URI_aarch64_rust-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-devel-1.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-devel}"
SRC_URI[aarch64_rust-regex-devel.sha256sum] = "1ea9dec3d7b582e2999af0628f604aa7b61a6d7452fe5a289d96ad6e4a4e6752"

RDEPENDS:rust-regex+default-devel = " \
 cargo \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax+default-devel \
 "
RDEPENDS:rust-regex+logging-devel = " \
 cargo \
 rust-aho-corasick+logging-devel \
 rust-aho-corasick-devel \
 rust-memchr+logging-devel \
 rust-memchr-devel \
 rust-regex-automata+logging-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+pattern-devel = " \
 cargo \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-backtrack-devel = " \
 cargo \
 rust-regex-automata+nfa-backtrack-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-cache-devel = " \
 cargo \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-devel = " \
 cargo \
 rust-regex+perf-backtrack-devel \
 rust-regex+perf-cache-devel \
 rust-regex+perf-dfa-devel \
 rust-regex+perf-inline-devel \
 rust-regex+perf-literal-devel \
 rust-regex+perf-onepass-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-dfa-devel = " \
 cargo \
 rust-regex-automata+hybrid-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-dfa-full-devel = " \
 cargo \
 rust-regex-automata+dfa-build-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-inline-devel = " \
 cargo \
 rust-regex-automata+perf-inline-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-literal-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-memchr-devel \
 rust-regex-automata+perf-literal-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-onepass-devel = " \
 cargo \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+std-devel = " \
 cargo \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-regex-automata+std-devel \
 rust-regex-devel \
 rust-regex-syntax+std-devel \
 "
RDEPENDS:rust-regex+unicode-age-devel = " \
 cargo \
 rust-regex-automata+unicode-age-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-age-devel \
 "
RDEPENDS:rust-regex+unicode-bool-devel = " \
 cargo \
 rust-regex-automata+unicode-bool-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-bool-devel \
 "
RDEPENDS:rust-regex+unicode-case-devel = " \
 cargo \
 rust-regex-automata+unicode-case-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-case-devel \
 "
RDEPENDS:rust-regex+unicode-devel = " \
 cargo \
 rust-regex+unicode-age-devel \
 rust-regex+unicode-bool-devel \
 rust-regex+unicode-case-devel \
 rust-regex+unicode-gencat-devel \
 rust-regex+unicode-perl-devel \
 rust-regex+unicode-script-devel \
 rust-regex+unicode-segment-devel \
 rust-regex-automata+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-devel \
 "
RDEPENDS:rust-regex+unicode-gencat-devel = " \
 cargo \
 rust-regex-automata+unicode-gencat-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-gencat-devel \
 "
RDEPENDS:rust-regex+unicode-perl-devel = " \
 cargo \
 rust-regex-automata+unicode-perl-devel \
 rust-regex-automata+unicode-word-boundary-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-perl-devel \
 "
RDEPENDS:rust-regex+unicode-script-devel = " \
 cargo \
 rust-regex-automata+unicode-script-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-script-devel \
 "
RDEPENDS:rust-regex+unicode-segment-devel = " \
 cargo \
 rust-regex-automata+unicode-segment-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-segment-devel \
 "
RDEPENDS:rust-regex+unstable-devel = " \
 cargo \
 rust-regex+pattern-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+use_std-devel = " \
 cargo \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex-devel = " \
 bash \
 cargo \
 rust \
 rust-regex-automata+alloc-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 rust-regex-syntax-devel \
 "
