# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "brise"
PV = "0.38.20180515"
PR = "16.el10_3"
PACKAGES = " \
 brise \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/brise-0.38.20180515-16.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b0a8cfa1b3d38256034b3459a5789b5c127500ea02e47acf3fc6a0d897cc086"

URI_x86_64_v2_brise = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/brise-0.38.20180515-16.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_brise;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brise}"
SRC_URI[x86_64_v2_brise.sha256sum] = "b55a91ccd9fa95585f34574ad8772963a50c029785641e1227dc93817161956e"

URI_aarch64_brise = "${EPEL_MIRROR}/aarch64/Packages/b/brise-0.38.20180515-16.el10_3.aarch64.rpm;name=aarch64_brise;unpack=0"
SRC_URI:append = " ${URI_aarch64_brise}"
SRC_URI[aarch64_brise.sha256sum] = "a6175558bddae638eb0141f7a3b8503e72f9ac86090a69091469cf1e178aa7bb"

RDEPENDS:brise = " \
 "
