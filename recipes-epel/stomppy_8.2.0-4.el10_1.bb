# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stomppy"
PV = "8.2.0"
PR = "4.el10_1"
PACKAGES = " \
 python3-stomppy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stomppy-8.2.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "021cf88df4f77727b3e578ec3ca3340a9f21b6fa8b2e2310afb624fb1f3901ae"

URI_x86_64_v2_python3-stomppy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-stomppy-8.2.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-stomppy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-stomppy}"
SRC_URI[x86_64_v2_python3-stomppy.sha256sum] = "6a614e7cf9d3b976b3f04156ba5cdb81e7647c6a4ccca838d6e143ff2063c4b0"

URI_aarch64_python3-stomppy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-stomppy-8.2.0-4.el10_1.noarch.rpm;name=aarch64_python3-stomppy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-stomppy}"
SRC_URI[aarch64_python3-stomppy.sha256sum] = "2191528846c7d44a8caeb6d9542d149637f9dc44197e354bac66de70d950d994"

RDEPENDS:python3-stomppy = " \
 python3 \
 python3-docopt \
 python3-websocket-client \
 "
