# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nghttp2"
PV = "1.64.0"
PR = "2.el10_1.1"
PACKAGES = " \
 libnghttp2 \
 libnghttp2-devel \
 nghttp2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nghttp2-1.64.0-2.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb1143125786927ca29b875663dd6403ee9c404319a5d53f411c6fcc7f63ee93"

URI_x86_64_v2_libnghttp2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnghttp2-1.64.0-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_libnghttp2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnghttp2}"
SRC_URI[x86_64_v2_libnghttp2.sha256sum] = "8032790a1bca0f8425c8766201ee0b4b4572e1b2378b978c6bf754374afb8ce1"

URI_x86_64_v2_libnghttp2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnghttp2-devel-1.64.0-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_libnghttp2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnghttp2-devel}"
SRC_URI[x86_64_v2_libnghttp2-devel.sha256sum] = "f8ac4f168868dcd60dd04ac2745dd37153630d31771efcb7b9730bb6ee880385"

URI_x86_64_v2_nghttp2 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nghttp2-1.64.0-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_nghttp2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nghttp2}"
SRC_URI[x86_64_v2_nghttp2.sha256sum] = "7aa83e2468d5d67f760dcfb91ad15b02a243957e27cfff49b36d694b59a12a5f"

URI_aarch64_libnghttp2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnghttp2-1.64.0-2.el10_1.1.aarch64.rpm;name=aarch64_libnghttp2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnghttp2}"
SRC_URI[aarch64_libnghttp2.sha256sum] = "78ae3aed70220ac0af4d16ccfe38827c55e8b89ceb9e5088b52471b46dbf817c"

URI_aarch64_libnghttp2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnghttp2-devel-1.64.0-2.el10_1.1.aarch64.rpm;name=aarch64_libnghttp2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnghttp2-devel}"
SRC_URI[aarch64_libnghttp2-devel.sha256sum] = "54c2ce7eb1b056530e60d6d3ee6a904e3df7d7918e50d1c6cb6306677ff2b6fb"

URI_aarch64_nghttp2 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nghttp2-1.64.0-2.el10_1.1.aarch64.rpm;name=aarch64_nghttp2;unpack=0"
SRC_URI:append = " ${URI_aarch64_nghttp2}"
SRC_URI[aarch64_nghttp2.sha256sum] = "11b800fcbdfe815c8604125e68c7c304369b4c38fbb88249de0b41248be059ac"

RDEPENDS:libnghttp2 = " \
 glibc \
 "
RDEPENDS:libnghttp2-devel = " \
 libnghttp2 \
 pkgconf-pkg-config \
 "
RDEPENDS:nghttp2 = " \
 bash \
 c-ares \
 glibc \
 libev \
 libgcc \
 libnghttp2 \
 libstdc++ \
 libxml2 \
 openssl-libs \
 python3 \
 systemd \
 zlib-ng-compat \
 "
