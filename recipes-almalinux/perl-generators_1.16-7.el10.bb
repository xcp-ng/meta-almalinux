# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-generators"
PV = "1.16"
PR = "7.el10"
PACKAGES = " \
 perl-generators \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-generators-1.16-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "459b710bbb40108e7f53a6e842dca2126ef1e1364f3dfef875332f2f40f9db14"

URI_x86_64_v2_perl-generators = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-generators-1.16-7.el10.noarch.rpm;name=x86_64_v2_perl-generators;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-generators}"
SRC_URI[x86_64_v2_perl-generators.sha256sum] = "7f7a1d8f0f601a748f7f184b31894447ffd03be71735a0648514a015654a0be7"

URI_aarch64_perl-generators = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-generators-1.16-7.el10.noarch.rpm;name=aarch64_perl-generators;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-generators}"
SRC_URI[aarch64_perl-generators.sha256sum] = "7f7a1d8f0f601a748f7f184b31894447ffd03be71735a0648514a015654a0be7"

RDEPENDS:perl-generators = " \
 perl-Fedora-VSP \
 perl-File-Basename \
 perl-interpreter \
 perl-macros \
 "
