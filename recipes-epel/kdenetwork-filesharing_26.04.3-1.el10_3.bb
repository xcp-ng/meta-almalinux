# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdenetwork-filesharing"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdenetwork-filesharing \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdenetwork-filesharing-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "762848189b4b8941fcd5a548d934f9edbba1d266be32afd338bddab300b7fc58"

URI_x86_64_v2_kdenetwork-filesharing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdenetwork-filesharing-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdenetwork-filesharing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdenetwork-filesharing}"
SRC_URI[x86_64_v2_kdenetwork-filesharing.sha256sum] = "3e5d8dafd742e2b8d1c9a943f06480676adc312811e46254ca67063ba6d1a093"

URI_aarch64_kdenetwork-filesharing = "${EPEL_MIRROR}/aarch64/Packages/k/kdenetwork-filesharing-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdenetwork-filesharing;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdenetwork-filesharing}"
SRC_URI[aarch64_kdenetwork-filesharing.sha256sum] = "9c1b33d5f97846284030f1b507c083ac511b220c9cf56c554414df5c8ab059c7"

RDEPENDS:kdenetwork-filesharing = " \
 PackageKit-Qt6 \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 libstdc++ \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
