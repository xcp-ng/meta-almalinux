# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bridge-utils"
PV = "1.7.1"
PR = "11.el10_0"
PACKAGES = " \
 bridge-utils \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bridge-utils-1.7.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "95186e662532dacc27499a140f3fb49c7b97cfc928e2fb14b4771676b3ff6a8b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bridge-utils-1.7.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bridge-utils;unpack=0"
SRC_URI[x86_64_v2_bridge-utils.sha256sum] = "95e79ac43d48ff01c5608ebf80282c2fd17871f04208ad463b1c3d7afb99ce40"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bridge-utils-1.7.1-11.el10_0.aarch64.rpm;name=aarch64_bridge-utils;unpack=0"
SRC_URI[aarch64_bridge-utils.sha256sum] = "475e805b0f01e66348f4af4c5181f7d9907a9a3373d5f6e3dd9c8f1e0963fbd1"

RDEPENDS:bridge-utils = " \
 glibc \
 "
