# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "systemd"
PV = "257"
PR = "13.el10_1.3.alma.1"
PACKAGES = " \
 systemd \
 systemd-boot-unsigned \
 systemd-container \
 systemd-devel \
 systemd-journal-remote \
 systemd-libs \
 systemd-oomd \
 systemd-pam \
 systemd-resolved \
 systemd-rpm-macros \
 systemd-udev \
 systemd-ukify \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/systemd-257-13.el10_1.3.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb8f4ebb3d36b047e2903d7a2741111d400f15f33d140af4b762f9bc1d0f32a1"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - systemd-udev: (sdubby > 1.0-3 if sdubby)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - systemd-udev: (sdubby > 1.0-3 if sdubby)

URI_x86_64_v2_systemd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-257-13.el10_1.3.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd}"
SRC_URI[x86_64_v2_systemd.sha256sum] = "baf6b8c801a2985d6c024dcad899becc39e990890010aeb3c08f3abb8e1d3936"
RPROVIDES:systemd:append:x86_64_v2 = " virtual/syslog"

URI_x86_64_v2_systemd-boot-unsigned = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-boot-unsigned-257-13.el10_1.3.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-boot-unsigned;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-boot-unsigned}"
SRC_URI[x86_64_v2_systemd-boot-unsigned.sha256sum] = "708db0ba95aceb7b8c35e856285fa807ecb5690ecb353056d63531468b2eb173"

URI_x86_64_v2_systemd-container = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-container-257-13.el10_1.3.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-container;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-container}"
SRC_URI[x86_64_v2_systemd-container.sha256sum] = "0fbd3d2a3080ccf2951dc89a0eed4b2ab8a9f86d01293c592b912014bd932ead"

URI_x86_64_v2_systemd-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-devel-257-13.el10_1.3.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-devel}"
SRC_URI[x86_64_v2_systemd-devel.sha256sum] = "d57443e94c1d91e9f284afc51775a82be5b7ca8a85810993e112cea72c491dc7"

URI_x86_64_v2_systemd-journal-remote = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-journal-remote-257-13.el10_1.3.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-journal-remote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-journal-remote}"
SRC_URI[x86_64_v2_systemd-journal-remote.sha256sum] = "7a7e96ceaa96f9246b7eb37d574ba92b6df86b3e9981385c9b6a7ed25611d2b0"

URI_x86_64_v2_systemd-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-libs-257-13.el10_1.3.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-libs}"
SRC_URI[x86_64_v2_systemd-libs.sha256sum] = "6f806a3ed5f66aa781eb0b77bc88387a62dfc48783f994029a7b0fa5c769a07b"

URI_x86_64_v2_systemd-oomd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-oomd-257-13.el10_1.3.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-oomd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-oomd}"
SRC_URI[x86_64_v2_systemd-oomd.sha256sum] = "8d0c30a0207a16d6e8423ca3b43fee7924bad1d91972fd524f20b3a0af6966d5"

URI_x86_64_v2_systemd-pam = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-pam-257-13.el10_1.3.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-pam}"
SRC_URI[x86_64_v2_systemd-pam.sha256sum] = "de620cbd6ad4b2053b70e9aa6a5e6a8c08e460a09ea355956e9ee6db26c8e80a"

URI_x86_64_v2_systemd-resolved = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-resolved-257-13.el10_1.3.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-resolved;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-resolved}"
SRC_URI[x86_64_v2_systemd-resolved.sha256sum] = "0c253288078c1259efff2423810aec627058ce153c2b7c184c163902bcb750d3"

URI_x86_64_v2_systemd-rpm-macros = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-rpm-macros-257-13.el10_1.3.alma.1.noarch.rpm;name=x86_64_v2_systemd-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-rpm-macros}"
SRC_URI[x86_64_v2_systemd-rpm-macros.sha256sum] = "7c4f0bc1ebd1e6801c0c207a85e0ca231aeaace72c7cc8b3d9e99d05ad964baa"

URI_x86_64_v2_systemd-udev = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-udev-257-13.el10_1.3.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-udev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-udev}"
SRC_URI[x86_64_v2_systemd-udev.sha256sum] = "07103934dd4916a7a1fab006e4e6be5fde89cf7ee72457df3cc7f83f2e5f50e0"

URI_x86_64_v2_systemd-ukify = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-ukify-257-13.el10_1.3.alma.1.noarch.rpm;name=x86_64_v2_systemd-ukify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-ukify}"
SRC_URI[x86_64_v2_systemd-ukify.sha256sum] = "549e8876de2ad2c824454bdc1e31b897e78889749319a5136420c61671293bb9"

URI_aarch64_systemd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-257-13.el10_1.3.alma.1.aarch64.rpm;name=aarch64_systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd}"
SRC_URI[aarch64_systemd.sha256sum] = "a1aba0b8be3cc74dd193c6d488ca7b8b61a627f57a5dda7b3c539c0ba5c212ae"
RPROVIDES:systemd:append:aarch64 = " virtual/syslog"

URI_aarch64_systemd-boot-unsigned = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-boot-unsigned-257-13.el10_1.3.alma.1.aarch64.rpm;name=aarch64_systemd-boot-unsigned;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-boot-unsigned}"
SRC_URI[aarch64_systemd-boot-unsigned.sha256sum] = "77eaa3fead31c9787c0d036b6a5aeff7bbb6d2cd52e785706916b337582a6b49"

URI_aarch64_systemd-container = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-container-257-13.el10_1.3.alma.1.aarch64.rpm;name=aarch64_systemd-container;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-container}"
SRC_URI[aarch64_systemd-container.sha256sum] = "a21fc12d5b002d6d03fcb2195ee335f73b3a18f2b2138c3d7b83e1f8ad574116"

URI_aarch64_systemd-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-devel-257-13.el10_1.3.alma.1.aarch64.rpm;name=aarch64_systemd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-devel}"
SRC_URI[aarch64_systemd-devel.sha256sum] = "49b3f57a9b35e2b17ea2df0ea786a8bd95a8ff41a42476b81809128338fc13fe"

URI_aarch64_systemd-journal-remote = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-journal-remote-257-13.el10_1.3.alma.1.aarch64.rpm;name=aarch64_systemd-journal-remote;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-journal-remote}"
SRC_URI[aarch64_systemd-journal-remote.sha256sum] = "7d6b1072af07093a070ef67020b77e810a880d17e7bf9cc1c85103d8fdb579ac"

URI_aarch64_systemd-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-libs-257-13.el10_1.3.alma.1.aarch64.rpm;name=aarch64_systemd-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-libs}"
SRC_URI[aarch64_systemd-libs.sha256sum] = "b610a240846e4ac5a2b0c6e87002036e1bad9807a1437f8015cb6c8c1e944250"

URI_aarch64_systemd-oomd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-oomd-257-13.el10_1.3.alma.1.aarch64.rpm;name=aarch64_systemd-oomd;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-oomd}"
SRC_URI[aarch64_systemd-oomd.sha256sum] = "bfc44d08ed06d36e3954c72599c45d6611f563277f288fb7d680214cf4246c18"

URI_aarch64_systemd-pam = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-pam-257-13.el10_1.3.alma.1.aarch64.rpm;name=aarch64_systemd-pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-pam}"
SRC_URI[aarch64_systemd-pam.sha256sum] = "c3c4c02d9eef8090147e05def803b65a1386fa4bac3a2284f5302fe9c590f096"

URI_aarch64_systemd-resolved = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-resolved-257-13.el10_1.3.alma.1.aarch64.rpm;name=aarch64_systemd-resolved;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-resolved}"
SRC_URI[aarch64_systemd-resolved.sha256sum] = "cfb7b394bfc0fb2fb877d5ab9db34c94ad8610199e3d778fd31ae0f3f29cb190"

URI_aarch64_systemd-rpm-macros = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-rpm-macros-257-13.el10_1.3.alma.1.noarch.rpm;name=aarch64_systemd-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-rpm-macros}"
SRC_URI[aarch64_systemd-rpm-macros.sha256sum] = "7c4f0bc1ebd1e6801c0c207a85e0ca231aeaace72c7cc8b3d9e99d05ad964baa"

URI_aarch64_systemd-udev = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-udev-257-13.el10_1.3.alma.1.aarch64.rpm;name=aarch64_systemd-udev;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-udev}"
SRC_URI[aarch64_systemd-udev.sha256sum] = "fe7d4d73001d724a424dc0cb9539c6f8826cdf76d23ebb15a672ef6bbdde6ff7"

URI_aarch64_systemd-ukify = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-ukify-257-13.el10_1.3.alma.1.noarch.rpm;name=aarch64_systemd-ukify;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-ukify}"
SRC_URI[aarch64_systemd-ukify.sha256sum] = "549e8876de2ad2c824454bdc1e31b897e78889749319a5136420c61671293bb9"

RDEPENDS:systemd = " \
 audit-libs \
 bash \
 bzip2-libs \
 dbus \
 glibc \
 grep \
 libacl \
 libblkid \
 libcap \
 libfdisk \
 libgcc \
 libmount \
 libseccomp \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 systemd-libs \
 systemd-pam \
 systemd-rpm-macros \
 virtual/coreutils \
 virtual/util-linux-core_or_util-linux \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:systemd-boot-unsigned = " \
 "
RDEPENDS:systemd-container = " \
 bzip2-libs \
 glibc \
 libacl \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:systemd-devel = " \
 systemd-libs \
 systemd-rpm-macros \
 "
RDEPENDS:systemd-journal-remote = " \
 bash \
 firewalld-filesystem \
 glibc \
 libgcc \
 libmicrohttpd \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:systemd-libs = " \
 glibc \
 libcap \
 libgcc \
 "
RDEPENDS:systemd-oomd = " \
 bash \
 glibc \
 libgcc \
 systemd \
 systemd-udev \
 "
RDEPENDS:systemd-pam = " \
 glibc \
 libcap \
 libgcc \
 pam-libs \
 systemd \
 "
RDEPENDS:systemd-resolved = " \
 bash \
 glibc \
 grep \
 libgcc \
 libidn2 \
 openssl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:systemd-rpm-macros = " \
 bash \
 "
RDEPENDS:systemd-udev = " \
 bash \
 cryptsetup-libs \
 glibc \
 grep \
 grubby \
 kbd \
 kmod \
 kmod-libs \
 libblkid \
 libfdisk \
 libgcc \
 openssl-libs \
 systemd \
 "
RDEPENDS:systemd-ukify = " \
 python3 \
 python3-cryptography \
 python3-pefile \
 python3-zstd \
 systemd \
 systemd-boot-unsigned \
 "
