# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jinja2"
PV = "3.1.6"
PR = "1.el10_0"
PACKAGES = " \
 python3-jinja2 \
 python3-jinja2+i18n \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-jinja2-3.1.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "644e51b6d4eb15dae88ead82c181b6b0f002521aa6d36f5ab898d9a2ea317795"

URI_x86_64_v2_python3-jinja2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-jinja2-3.1.6-1.el10_0.noarch.rpm;name=x86_64_v2_python3-jinja2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jinja2}"
SRC_URI[x86_64_v2_python3-jinja2.sha256sum] = "049439c17cc14c2cdcb1a4d90204a1b6e43f171ac87c0713a705c8b0a27a5e34"

URI_x86_64_v2_python3-jinja2+i18n = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-jinja2+i18n-3.1.6-1.el10_0.noarch.rpm;name=x86_64_v2_python3-jinja2+i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jinja2+i18n}"
SRC_URI[x86_64_v2_python3-jinja2+i18n.sha256sum] = "6bd90207abbdf3bb264dc23ac2482839e4ac76fb6a8e92806be447af6fd06be0"

URI_aarch64_python3-jinja2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-jinja2-3.1.6-1.el10_0.noarch.rpm;name=aarch64_python3-jinja2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jinja2}"
SRC_URI[aarch64_python3-jinja2.sha256sum] = "049439c17cc14c2cdcb1a4d90204a1b6e43f171ac87c0713a705c8b0a27a5e34"

URI_aarch64_python3-jinja2+i18n = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-jinja2+i18n-3.1.6-1.el10_0.noarch.rpm;name=aarch64_python3-jinja2+i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jinja2+i18n}"
SRC_URI[aarch64_python3-jinja2+i18n.sha256sum] = "6bd90207abbdf3bb264dc23ac2482839e4ac76fb6a8e92806be447af6fd06be0"

RDEPENDS:python3-jinja2 = " \
 python3 \
 python3-markupsafe \
 "
RDEPENDS:python3-jinja2+i18n = " \
 python3 \
 python3-babel \
 python3-jinja2 \
 "
