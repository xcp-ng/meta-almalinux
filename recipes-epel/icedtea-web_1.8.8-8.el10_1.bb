# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "icedtea-web"
PV = "1.8.8"
PR = "8.el10_1"
PACKAGES = " \
 icedtea-web \
 icedtea-web-devel \
 icedtea-web-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/icedtea-web-1.8.8-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11f23f7af3c5fcf65c368a97cbbbfefac841181e0173bb26feef558033833e36"

URI_x86_64_v2_icedtea-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icedtea-web-1.8.8-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_icedtea-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icedtea-web}"
SRC_URI[x86_64_v2_icedtea-web.sha256sum] = "77820b1058153bb5e9b96d7857243687fb7f555ea9a9c326364a7391faadb485"

URI_x86_64_v2_icedtea-web-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icedtea-web-devel-1.8.8-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_icedtea-web-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icedtea-web-devel}"
SRC_URI[x86_64_v2_icedtea-web-devel.sha256sum] = "91d39e423ff6cb8beca7ef4c2b156d1c5516062550b91f9fa31dba6e34ae0ae8"

URI_x86_64_v2_icedtea-web-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icedtea-web-javadoc-1.8.8-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_icedtea-web-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icedtea-web-javadoc}"
SRC_URI[x86_64_v2_icedtea-web-javadoc.sha256sum] = "8f35133df9112a0fc31566c4d3a58bd22d690c7a7c5bbc40159eccacd2880486"

URI_aarch64_icedtea-web = "${EPEL_MIRROR}/aarch64/Packages/i/icedtea-web-1.8.8-8.el10_1.aarch64.rpm;name=aarch64_icedtea-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_icedtea-web}"
SRC_URI[aarch64_icedtea-web.sha256sum] = "4d0ca77ead69b489e5f4052323203765e04b09001339e81f5ca71cf822b92be5"

URI_aarch64_icedtea-web-devel = "${EPEL_MIRROR}/aarch64/Packages/i/icedtea-web-devel-1.8.8-8.el10_1.noarch.rpm;name=aarch64_icedtea-web-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_icedtea-web-devel}"
SRC_URI[aarch64_icedtea-web-devel.sha256sum] = "9d3d04055821a51f9b59a24d79d46cea530fd12ff059a61e134f947457d6350b"

URI_aarch64_icedtea-web-javadoc = "${EPEL_MIRROR}/aarch64/Packages/i/icedtea-web-javadoc-1.8.8-8.el10_1.noarch.rpm;name=aarch64_icedtea-web-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_icedtea-web-javadoc}"
SRC_URI[aarch64_icedtea-web-javadoc.sha256sum] = "25c2120ba527002d0fdca172dfe2b84c362aa9ef311b6198f8bd1fae10657242"

RDEPENDS:icedtea-web = " \
 GConf2 \
 alternatives \
 bash \
 glibc \
 java-21-openjdk \
 javapackages-tools \
 libgcc \
 tagsoup \
 "
RDEPENDS:icedtea-web-devel = " \
 icedtea-web \
 "
RDEPENDS:icedtea-web-javadoc = " \
 icedtea-web \
 javapackages-filesystem \
 "
