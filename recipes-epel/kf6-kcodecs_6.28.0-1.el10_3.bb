# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcodecs"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcodecs \
 kf6-kcodecs-devel \
 kf6-kcodecs-doc \
 kf6-kcodecs-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcodecs-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5e3cff01e6b54f12594a8c306878b6499afb61a9da874d314a33bfa392fa231"

URI_x86_64_v2_kf6-kcodecs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcodecs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs}"
SRC_URI[x86_64_v2_kf6-kcodecs.sha256sum] = "22a00d093a95a7dcab3fffb334d9f095ca7fa78bcaab6da15e773a5c826e6d17"

URI_x86_64_v2_kf6-kcodecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcodecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs-devel}"
SRC_URI[x86_64_v2_kf6-kcodecs-devel.sha256sum] = "c442c9c148fef891c7c9b382cb46323bf1691599d8e431f81f0faf9f434b11ff"

URI_x86_64_v2_kf6-kcodecs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcodecs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs-doc}"
SRC_URI[x86_64_v2_kf6-kcodecs-doc.sha256sum] = "9aa351f94b0960dba8bdce22f245f45299bf53ed2ef4477c6ef18b41a8762c7a"

URI_x86_64_v2_kf6-kcodecs-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcodecs-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs-html}"
SRC_URI[x86_64_v2_kf6-kcodecs-html.sha256sum] = "b25e233642e50fd2aece2e89e153e87aef64ef996413b593181e943aaf696d1c"

URI_aarch64_kf6-kcodecs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcodecs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs}"
SRC_URI[aarch64_kf6-kcodecs.sha256sum] = "d8de1b3c6a1f6acf3e24a9ffa5c322ac14d07a408642a5d6e1020d597b6adb3d"

URI_aarch64_kf6-kcodecs-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcodecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs-devel}"
SRC_URI[aarch64_kf6-kcodecs-devel.sha256sum] = "bf1804fd213752b611def9865469b8f0ea7513fd4294d725e961c5835a93e555"

URI_aarch64_kf6-kcodecs-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcodecs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs-doc}"
SRC_URI[aarch64_kf6-kcodecs-doc.sha256sum] = "9515732ad145b61bb8521f4723e89dfdf7678d0b012d52ba28c4a5627fba113d"

URI_aarch64_kf6-kcodecs-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcodecs-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs-html}"
SRC_URI[aarch64_kf6-kcodecs-html.sha256sum] = "0dd963fef2bf114d89f0ad288435af5a5b2a978a93f280b17f2c04990e395575"

RDEPENDS:kf6-kcodecs = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kcodecs-devel = " \
 cmake-filesystem \
 kf6-kcodecs \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcodecs-doc = " \
 "
RDEPENDS:kf6-kcodecs-html = " \
 "
