# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6ct"
PV = "0.9"
PR = "13.el10_1"
PACKAGES = " \
 qt6ct \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6ct-0.9-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "caf1ea313fe19e66f76d60d3824196899057a3f083025354743759d57cfe6746"

URI_x86_64_v2_qt6ct = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6ct-0.9-13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6ct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6ct}"
SRC_URI[x86_64_v2_qt6ct.sha256sum] = "6152e50691c70b653bebc87478160568b95900ce0457733bc4e306eddf5a6a03"

URI_aarch64_qt6ct = "${EPEL_MIRROR}/aarch64/Packages/q/qt6ct-0.9-13.el10_1.aarch64.rpm;name=aarch64_qt6ct;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6ct}"
SRC_URI[aarch64_qt6ct.sha256sum] = "2417d1182efd48cf024928a2a6d7adbcfa7bf3059ee6e9429a14129ded68d2f3"

RDEPENDS:qt6ct = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
