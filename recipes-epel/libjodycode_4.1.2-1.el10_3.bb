# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libjodycode"
PV = "4.1.2"
PR = "1.el10_3"
PACKAGES = " \
 libjodycode \
 libjodycode-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libjodycode-4.1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33055a788990318df3acd46c9a71c4c166b7ef5d5cb059a5456bd7e683555806"

URI_x86_64_v2_libjodycode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjodycode-4.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjodycode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjodycode}"
SRC_URI[x86_64_v2_libjodycode.sha256sum] = "82e0e3a60e8c36e62f20ae886193f92eb4d6f5e069f969e2273b0129bd69f7c0"

URI_x86_64_v2_libjodycode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjodycode-devel-4.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjodycode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjodycode-devel}"
SRC_URI[x86_64_v2_libjodycode-devel.sha256sum] = "cec2e639d95bf741096aa0acba1aad55eb9b66b6f053a2382756b10fb139e67b"

URI_aarch64_libjodycode = "${EPEL_MIRROR}/aarch64/Packages/l/libjodycode-4.1.2-1.el10_3.aarch64.rpm;name=aarch64_libjodycode;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjodycode}"
SRC_URI[aarch64_libjodycode.sha256sum] = "01f4176ba8f62402694a47f429e2ef7f0b9f44cac90944b2d9e14bbe6b541760"

URI_aarch64_libjodycode-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libjodycode-devel-4.1.2-1.el10_3.aarch64.rpm;name=aarch64_libjodycode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjodycode-devel}"
SRC_URI[aarch64_libjodycode-devel.sha256sum] = "57a135a82a830700d9682743b99a6c1c73dce841feabf51707f1b06e2c6cb626"

RDEPENDS:libjodycode = " \
 glibc \
 "
RDEPENDS:libjodycode-devel = " \
 libjodycode \
 "
