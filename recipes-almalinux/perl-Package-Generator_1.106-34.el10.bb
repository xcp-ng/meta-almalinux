# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Package-Generator"
PV = "1.106"
PR = "34.el10"
PACKAGES = " \
 perl-Package-Generator \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Package-Generator-1.106-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4139e1ce08674be380b506c6291e0d8cb0f1e3b04ebbf27a8cb21689f9b5b573"

URI_x86_64_v2_perl-Package-Generator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Package-Generator-1.106-34.el10.noarch.rpm;name=x86_64_v2_perl-Package-Generator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Package-Generator}"
SRC_URI[x86_64_v2_perl-Package-Generator.sha256sum] = "be2738fd1b0a14b5b170ccbf076391568d764bef5e6330cb9a361fa81ae006f9"

URI_aarch64_perl-Package-Generator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Package-Generator-1.106-34.el10.noarch.rpm;name=aarch64_perl-Package-Generator;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Package-Generator}"
SRC_URI[aarch64_perl-Package-Generator.sha256sum] = "be2738fd1b0a14b5b170ccbf076391568d764bef5e6330cb9a361fa81ae006f9"

RDEPENDS:perl-Package-Generator = " \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-libs \
 "
