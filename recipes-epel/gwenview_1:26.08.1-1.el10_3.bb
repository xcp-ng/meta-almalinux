# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gwenview"
PE = "1"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 gwenview \
 gwenview-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gwenview-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1a90059cbee1371eb2bfd89897fe25509f9caef5a47ef0d5a49d59df17c0251e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gwenview-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gwenview;unpack=0"
SRC_URI[x86_64_v2_gwenview.sha256sum] = "603503fcd7d895c00bc3d9727fac947939b2c72b59c04c0f7636ac8ce4223556"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gwenview-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gwenview-libs;unpack=0"
SRC_URI[x86_64_v2_gwenview-libs.sha256sum] = "e1055e45e2ca5af410ba5f420034e4c26da5c4eca443ca9756f55b91927add41"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gwenview-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_gwenview;unpack=0"
SRC_URI[aarch64_gwenview.sha256sum] = "13e247699ed4b99fb3ac6167a3d203c3e34dece4c873212e316e0eba440c57a8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gwenview-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_gwenview-libs;unpack=0"
SRC_URI[aarch64_gwenview-libs.sha256sum] = "bc9b00fe79311eb9a2e947709dab68b24800c6a6eb081ebc11616e66103274df"

RDEPENDS:gwenview = " \
 exiv2-libs \
 glibc \
 gwenview-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 kf6-solid \
 kimageannotator-qt6 \
 libgcc \
 libstdc++ \
 libtiff \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:gwenview-libs = " \
 cfitsio \
 exiv2-libs \
 glibc \
 gwenview \
 kf6-baloo-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kimageannotator-qt6 \
 lcms2 \
 libX11 \
 libgcc \
 libjpeg-turbo \
 libkdcraw \
 libpng \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
