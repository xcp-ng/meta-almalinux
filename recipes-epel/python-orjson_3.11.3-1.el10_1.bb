# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-orjson"
PV = "3.11.3"
PR = "1.el10_1"
PACKAGES = " \
 python3-orjson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-orjson-3.11.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe944d0b27d49e56326c1443a8bfd209715e2af924e7703dec54a2783a5302a2"

URI_x86_64_v2_python3-orjson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-orjson-3.11.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-orjson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-orjson}"
SRC_URI[x86_64_v2_python3-orjson.sha256sum] = "0f25e508d62a6c3ec4d5e8e72fbbf761c620582af978adef38e4164a091f1e3a"

URI_aarch64_python3-orjson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-orjson-3.11.3-1.el10_1.aarch64.rpm;name=aarch64_python3-orjson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-orjson}"
SRC_URI[aarch64_python3-orjson.sha256sum] = "59b80534e0fce8f01c142d0c66e0a192e976af2980157897cc7fd73168bb7b9a"

RDEPENDS:python3-orjson = " \
 glibc \
 libgcc \
 python3 \
 "
