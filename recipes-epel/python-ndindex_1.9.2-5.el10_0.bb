# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ndindex"
PV = "1.9.2"
PR = "5.el10_0"
PACKAGES = " \
 python3-ndindex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ndindex-1.9.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c84393ea362325fea895603946baabf2b236133e45719ce5db66becd707760e4"

URI_x86_64_v2_python3-ndindex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ndindex-1.9.2-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-ndindex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ndindex}"
SRC_URI[x86_64_v2_python3-ndindex.sha256sum] = "9840354f181c06fb83d03c3e48eed94378fd3a8ee5c39262200845f51b007f4c"

URI_aarch64_python3-ndindex = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ndindex-1.9.2-5.el10_0.aarch64.rpm;name=aarch64_python3-ndindex;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ndindex}"
SRC_URI[aarch64_python3-ndindex.sha256sum] = "5c95c2eebf94d1426814b2160d39984fba71959f793c3bf24139c28e63fe8207"

RDEPENDS:python3-ndindex = " \
 glibc \
 python3 \
 python3-numpy \
 "
