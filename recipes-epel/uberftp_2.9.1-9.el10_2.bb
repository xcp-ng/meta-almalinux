# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uberftp"
PV = "2.9.1"
PR = "9.el10_2"
PACKAGES = " \
 uberftp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uberftp-2.9.1-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99a606df5f72bc13f8528ffe95d451baabf5816a00c8c318b856b1e31a7479a4"

URI_x86_64_v2_uberftp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uberftp-2.9.1-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uberftp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uberftp}"
SRC_URI[x86_64_v2_uberftp.sha256sum] = "eccbbae11c7f0a3add1579a7a42197e36d30e828d21d89e452c079ae5a24a664"

URI_aarch64_uberftp = "${EPEL_MIRROR}/aarch64/Packages/u/uberftp-2.9.1-9.el10_2.aarch64.rpm;name=aarch64_uberftp;unpack=0"
SRC_URI:append = " ${URI_aarch64_uberftp}"
SRC_URI[aarch64_uberftp.sha256sum] = "f1e8af80b893fecf892e08d313800f9aa851d408769cd635ff3defbe1b61f7b0"

RDEPENDS:uberftp = " \
 glibc \
 globus-common \
 globus-gssapi-gsi \
 "
