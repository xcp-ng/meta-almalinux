# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "g2clib"
PV = "2.2.0"
PR = "1.el10_1"
PACKAGES = " \
 g2clib \
 g2clib-devel \
 g2clib-static \
 g2clib-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/g2clib-2.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08e4f0f24ef7cc082636753131554df015fa0d9b3b766beccd736d3879c5daf2"

URI_x86_64_v2_g2clib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/g2clib-2.2.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_g2clib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_g2clib}"
SRC_URI[x86_64_v2_g2clib.sha256sum] = "c99ab42535f1dd3cbf33869f53bc559e0c62b31e559ca613b6466d4a09634c34"

URI_x86_64_v2_g2clib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/g2clib-devel-2.2.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_g2clib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_g2clib-devel}"
SRC_URI[x86_64_v2_g2clib-devel.sha256sum] = "a815ead2f6dd28a7ed915b7e765c8425215f20d5e7e1d29110be613fb13d1aad"

URI_x86_64_v2_g2clib-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/g2clib-static-2.2.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_g2clib-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_g2clib-static}"
SRC_URI[x86_64_v2_g2clib-static.sha256sum] = "865d535b19cea568642def6ef6cdf5f08b514dcdf2b21ebc049aed39f658b8c5"

URI_x86_64_v2_g2clib-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/g2clib-utils-2.2.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_g2clib-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_g2clib-utils}"
SRC_URI[x86_64_v2_g2clib-utils.sha256sum] = "3f3cb185b8e6e66f7df43122954089f3d99837fe0d819299ec65d87b271c5c41"

URI_aarch64_g2clib = "${EPEL_MIRROR}/aarch64/Packages/g/g2clib-2.2.0-1.el10_1.aarch64.rpm;name=aarch64_g2clib;unpack=0"
SRC_URI:append = " ${URI_aarch64_g2clib}"
SRC_URI[aarch64_g2clib.sha256sum] = "60333c3d40bfc22f75641b73939eab1471ffe5a3ce2f23611976d5637673c741"

URI_aarch64_g2clib-devel = "${EPEL_MIRROR}/aarch64/Packages/g/g2clib-devel-2.2.0-1.el10_1.aarch64.rpm;name=aarch64_g2clib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_g2clib-devel}"
SRC_URI[aarch64_g2clib-devel.sha256sum] = "253ba697ad4dfa05275d01095700a25cf0c211f1e939d8b56539dd154b28a021"

URI_aarch64_g2clib-static = "${EPEL_MIRROR}/aarch64/Packages/g/g2clib-static-2.2.0-1.el10_1.aarch64.rpm;name=aarch64_g2clib-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_g2clib-static}"
SRC_URI[aarch64_g2clib-static.sha256sum] = "f21399feb885e8e92a9a07e8d818e5bc1dcfb55bb9f40a3d804d6f2294a0922b"

URI_aarch64_g2clib-utils = "${EPEL_MIRROR}/aarch64/Packages/g/g2clib-utils-2.2.0-1.el10_1.aarch64.rpm;name=aarch64_g2clib-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_g2clib-utils}"
SRC_URI[aarch64_g2clib-utils.sha256sum] = "f915426b43d8eb9f9e7d69f433d8264ee75bea8bf99c721fd913a2416db11f9b"

RDEPENDS:g2clib = " \
 glibc \
 jasper-libs \
 libaec \
 libpng \
 "
RDEPENDS:g2clib-devel = " \
 cmake-filesystem \
 g2clib \
 g2clib-static \
 jasper-devel \
 libpng-devel \
 "
RDEPENDS:g2clib-static = " \
 g2clib-devel \
 "
RDEPENDS:g2clib-utils = " \
 g2clib \
 glibc \
 jasper-libs \
 libaec \
 libpng \
 "
