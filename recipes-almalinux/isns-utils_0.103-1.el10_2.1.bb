# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "isns-utils"
PV = "0.103"
PR = "1.el10_2.1"
PACKAGES = " \
 isns-utils \
 isns-utils-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/isns-utils-0.103-1.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f966546e840210faab929f0aadb96b9e6593b0a418fdc6500c4d24dcf434caaf"

URI_x86_64_v2_isns-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/isns-utils-0.103-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_isns-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isns-utils}"
SRC_URI[x86_64_v2_isns-utils.sha256sum] = "3372a7f50991e3052a17524d876d62ec5dd598c19da2a6fe4ba57fde1cd1ab4c"

URI_x86_64_v2_isns-utils-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/isns-utils-libs-0.103-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_isns-utils-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isns-utils-libs}"
SRC_URI[x86_64_v2_isns-utils-libs.sha256sum] = "a929058067b0a6d054ef5a043dd833149bde13955ae08b9d72ada4849ffd70fa"

URI_aarch64_isns-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/isns-utils-0.103-1.el10_2.1.aarch64.rpm;name=aarch64_isns-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_isns-utils}"
SRC_URI[aarch64_isns-utils.sha256sum] = "b677136950d742f2e6afb489d639657805c81e7a21df6b3272107a1fe6f43962"

URI_aarch64_isns-utils-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/isns-utils-libs-0.103-1.el10_2.1.aarch64.rpm;name=aarch64_isns-utils-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_isns-utils-libs}"
SRC_URI[aarch64_isns-utils-libs.sha256sum] = "f383badd98519fcaf401aeeee2b28ff66c79bd8e07ff5be973ba48dd37ec1146"

RDEPENDS:isns-utils = " \
 bash \
 glibc \
 isns-utils-libs \
 systemd \
 "
RDEPENDS:isns-utils-libs = " \
 glibc \
 "
