# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-pathspec"
PV = "0.12.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-pathspec+default-devel \
 rust-gix-pathspec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-pathspec-0.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41e21e1edec9802709aea7042f4b1844b1c821ffb9e5c43adbd172eac3ace41e"

URI_x86_64_v2_rust-gix-pathspec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pathspec+default-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pathspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pathspec+default-devel}"
SRC_URI[x86_64_v2_rust-gix-pathspec+default-devel.sha256sum] = "4c481ee06bfa66e350fce01250febd69163a9a66c2aaf2a65bb5ea26d09fdcd1"

URI_x86_64_v2_rust-gix-pathspec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pathspec-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pathspec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pathspec-devel}"
SRC_URI[x86_64_v2_rust-gix-pathspec-devel.sha256sum] = "0d2001f26733e7d42cd5038c0925319532423265cdbb952c41ea7e7222acd133"

URI_aarch64_rust-gix-pathspec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pathspec+default-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-pathspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pathspec+default-devel}"
SRC_URI[aarch64_rust-gix-pathspec+default-devel.sha256sum] = "f82ad05a769a9135c37716aff345c0043c87fe49fe9e996a129493c0cfbe6f62"

URI_aarch64_rust-gix-pathspec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pathspec-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-pathspec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pathspec-devel}"
SRC_URI[aarch64_rust-gix-pathspec-devel.sha256sum] = "0916cbbeb751aab33518f7e50e72e3bd36a6ba56e59d898eea48f784c08c0924"

RDEPENDS:rust-gix-pathspec+default-devel = " \
 cargo \
 rust-gix-pathspec-devel \
 "
RDEPENDS:rust-gix-pathspec-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-attributes+default-devel \
 rust-gix-config-value+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-thiserror+default-devel \
 "
