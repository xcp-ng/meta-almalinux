# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtquickcontrols"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtquickcontrols \
 qt5-qtquickcontrols-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtquickcontrols-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "681310dc22aeab0fa8bfcb219f7db090057d1f0e516f67c6f249bc33dfac8050"

URI_x86_64_v2_qt5-qtquickcontrols = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols.sha256sum] = "d15a286e4dc968ba1d323537e335dca5973113867b9e04cf167879bb2aecab21"

URI_x86_64_v2_qt5-qtquickcontrols-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols-examples}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols-examples.sha256sum] = "92426f71c30552c4348f24c89467a388b4992f733ba03c4100f7d5219e7a2af8"

URI_aarch64_qt5-qtquickcontrols = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtquickcontrols;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols}"
SRC_URI[aarch64_qt5-qtquickcontrols.sha256sum] = "52f25e0dadbf78d861a9dc99c824aa2aa417e45129fccfe4c6743407b402a97a"

URI_aarch64_qt5-qtquickcontrols-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtquickcontrols-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols-examples}"
SRC_URI[aarch64_qt5-qtquickcontrols-examples.sha256sum] = "b52f9947fa3e8674baa3f6f1ad5b2302fb97866d45b559de09ae0b93437122b0"

RDEPENDS:qt5-qtquickcontrols = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtquickcontrols-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtquickcontrols \
 "
