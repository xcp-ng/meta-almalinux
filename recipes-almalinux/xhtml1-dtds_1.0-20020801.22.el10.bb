# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xhtml1-dtds"
PV = "1.0"
PR = "20020801.22.el10"
PACKAGES = " \
 xhtml1-dtds \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xhtml1-dtds-1.0-20020801.22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d18cc81c1ca6b91a0c7d2c1ef328e49fe2a9683c1cb72782cec6b521efe8cc94"

URI_x86_64_v2_xhtml1-dtds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xhtml1-dtds-1.0-20020801.22.el10.noarch.rpm;name=x86_64_v2_xhtml1-dtds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xhtml1-dtds}"
SRC_URI[x86_64_v2_xhtml1-dtds.sha256sum] = "dff53a5351125b1693672839d0f8e16878a80e80998e057fbb449a44b4ddf614"

URI_aarch64_xhtml1-dtds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xhtml1-dtds-1.0-20020801.22.el10.noarch.rpm;name=aarch64_xhtml1-dtds;unpack=0"
SRC_URI:append = " ${URI_aarch64_xhtml1-dtds}"
SRC_URI[aarch64_xhtml1-dtds.sha256sum] = "dff53a5351125b1693672839d0f8e16878a80e80998e057fbb449a44b4ddf614"

RDEPENDS:xhtml1-dtds = " \
 bash \
 libxml2 \
 sgml-common \
 xml-common \
 "
