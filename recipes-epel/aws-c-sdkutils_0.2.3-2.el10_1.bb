# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-sdkutils"
PV = "0.2.3"
PR = "2.el10_1"
PACKAGES = " \
 aws-c-sdkutils \
 aws-c-sdkutils-devel \
 aws-c-sdkutils-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-sdkutils-0.2.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b586a1b5cecc003d45a0b78608446fe17eb637f597407d8f946ceee89d89f400"

URI_x86_64_v2_aws-c-sdkutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-sdkutils-0.2.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-sdkutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-sdkutils}"
SRC_URI[x86_64_v2_aws-c-sdkutils.sha256sum] = "e1a65c75c3729f2b728e1acfd3a555f28dc842ffb6dea11439eb13566dcfc2cf"

URI_x86_64_v2_aws-c-sdkutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-sdkutils-devel-0.2.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-sdkutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-sdkutils-devel}"
SRC_URI[x86_64_v2_aws-c-sdkutils-devel.sha256sum] = "600d9898db7e88ff1da742bc5369da5611d3160df1fa16a49eb5caef1dc9f3b1"

URI_x86_64_v2_aws-c-sdkutils-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-sdkutils-libs-0.2.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-sdkutils-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-sdkutils-libs}"
SRC_URI[x86_64_v2_aws-c-sdkutils-libs.sha256sum] = "335b98bcf51b66465d11b8e6ed70788b627782ccd88d2d41509cbf6ca9e4e0b6"

URI_aarch64_aws-c-sdkutils = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-sdkutils-0.2.3-2.el10_1.aarch64.rpm;name=aarch64_aws-c-sdkutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-sdkutils}"
SRC_URI[aarch64_aws-c-sdkutils.sha256sum] = "307da32bb917310c0e422cb0b0a6cbab1c2965c2024b7e94159d7f11e80c5b6e"

URI_aarch64_aws-c-sdkutils-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-sdkutils-devel-0.2.3-2.el10_1.aarch64.rpm;name=aarch64_aws-c-sdkutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-sdkutils-devel}"
SRC_URI[aarch64_aws-c-sdkutils-devel.sha256sum] = "231e8700eb687922592f2d982c1e79a4908d42ee0bde3850dc3fa17cdd08f48c"

URI_aarch64_aws-c-sdkutils-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-sdkutils-libs-0.2.3-2.el10_1.aarch64.rpm;name=aarch64_aws-c-sdkutils-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-sdkutils-libs}"
SRC_URI[aarch64_aws-c-sdkutils-libs.sha256sum] = "9c057866097f3586c0fbb0749542b385eb117c4abf04721f38a5850ffdaffc2f"

RDEPENDS:aws-c-sdkutils = " \
 aws-c-common-libs \
 "
RDEPENDS:aws-c-sdkutils-devel = " \
 aws-c-common-devel \
 aws-c-sdkutils-libs \
 cmake-filesystem \
 "
RDEPENDS:aws-c-sdkutils-libs = " \
 aws-c-common-libs \
 aws-c-sdkutils \
 glibc \
 "
