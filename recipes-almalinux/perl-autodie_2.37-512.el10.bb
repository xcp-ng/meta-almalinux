# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-autodie"
PV = "2.37"
PR = "512.el10"
PACKAGES = " \
 perl-autodie \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-autodie-2.37-512.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ec3cbb5b9bce8b1392e1c0240134da2a36cafd0fe5c6d60cf7ef16ef651e899f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-autodie-2.37-512.el10.noarch.rpm;name=x86_64_v2_perl-autodie;unpack=0"
SRC_URI[x86_64_v2_perl-autodie.sha256sum] = "eaef9a8864dab0bb3e507f4dad0bc90c3bd75037ce8262fd32a8642b578210e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-autodie-2.37-512.el10.noarch.rpm;name=aarch64_perl-autodie;unpack=0"
SRC_URI[aarch64_perl-autodie.sha256sum] = "eaef9a8864dab0bb3e507f4dad0bc90c3bd75037ce8262fd32a8642b578210e1"

RDEPENDS:perl-autodie = " \
 perl-B \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-IPC-System-Simple \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-Tie-RefHash \
 perl-autodie \
 perl-constant \
 perl-libs \
 perl-overload \
 perl-parent \
 "
