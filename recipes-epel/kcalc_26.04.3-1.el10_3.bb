# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcalc"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kcalc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcalc-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c316ec6a6ac5cf084b36332eb7cbf162e783410eb86888a532681d9bc4fccda0"

URI_x86_64_v2_kcalc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalc-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcalc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcalc}"
SRC_URI[x86_64_v2_kcalc.sha256sum] = "ad282c4d44807be6edc95e647a97689ceaf7094eacd2771ac343cba944caa155"

URI_aarch64_kcalc = "${EPEL_MIRROR}/aarch64/Packages/k/kcalc-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kcalc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcalc}"
SRC_URI[aarch64_kcalc.sha256sum] = "744b67ff81e7e0bfbb63747342b9005a238fe53deaef867bfab7fa7c28ebe9d8"

RDEPENDS:kcalc = " \
 glibc \
 gmp \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libmpc \
 libstdc++ \
 mpfr \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
