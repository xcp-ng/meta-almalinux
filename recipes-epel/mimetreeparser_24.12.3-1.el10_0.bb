# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mimetreeparser"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 mimetreeparser \
 mimetreeparser-devel \
 mimetreeparser-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mimetreeparser-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8501ddeaad511b62724844ec96b6c37fdf8834a5121efcd4153cb02dd595732"

URI_x86_64_v2_mimetreeparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimetreeparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimetreeparser}"
SRC_URI[x86_64_v2_mimetreeparser.sha256sum] = "d2ddbcc0f27fca64bfd04c26748491251a0cdd9cfdf466ef34144597f0415ab2"

URI_x86_64_v2_mimetreeparser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimetreeparser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimetreeparser-devel}"
SRC_URI[x86_64_v2_mimetreeparser-devel.sha256sum] = "014ea80cac84e011ed05343afe52571dc997b93d7dc1a4092201bb5b0c41be77"

URI_x86_64_v2_mimetreeparser-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mimetreeparser-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimetreeparser-doc}"
SRC_URI[x86_64_v2_mimetreeparser-doc.sha256sum] = "90fee77555f470c4d1f1b35c3b76bd99210ad1410f59d536a9e56612ad52ee69"

URI_aarch64_mimetreeparser = "${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_mimetreeparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimetreeparser}"
SRC_URI[aarch64_mimetreeparser.sha256sum] = "bf9c40f96e565841b68129460d2507c0f8c54c5f3c6f40a20d54c7137a0a5163"

URI_aarch64_mimetreeparser-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_mimetreeparser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimetreeparser-devel}"
SRC_URI[aarch64_mimetreeparser-devel.sha256sum] = "fc4e69e75c8be5cee90732b9181eccd03c6eeeda5a26cf4ce5283614d212a457"

URI_aarch64_mimetreeparser-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_mimetreeparser-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimetreeparser-doc}"
SRC_URI[aarch64_mimetreeparser-doc.sha256sum] = "2f0c4b668ed67416769bad96c9b118b98123e4a5c1754a6ba95bf1f3254e7d3a"

RDEPENDS:mimetreeparser = " \
 glibc \
 gpgmepp \
 kf6-kcalendarcore \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kmbox \
 kmime \
 libkleo \
 libstdc++ \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:mimetreeparser-devel = " \
 cmake-filesystem \
 mimetreeparser \
 "
RDEPENDS:mimetreeparser-doc = " \
 "
