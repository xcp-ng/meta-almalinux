# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indicatif"
PV = "0.18.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-indicatif+default-devel \
 rust-indicatif+futures-devel \
 rust-indicatif+improved_unicode-devel \
 rust-indicatif+in_memory-devel \
 rust-indicatif+rayon-devel \
 rust-indicatif+tokio-devel \
 rust-indicatif+unicode-segmentation-devel \
 rust-indicatif+unicode-width-devel \
 rust-indicatif+vt100-devel \
 rust-indicatif-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indicatif-0.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "401e8ec7a6be527983d33d665d932875bdb08c99a21ec0ad7cc6123f683acbc4"

URI_x86_64_v2_rust-indicatif+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+default-devel-0.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+default-devel}"
SRC_URI[x86_64_v2_rust-indicatif+default-devel.sha256sum] = "9f5678ce361c1bba33d005b5d448403674a679e33b55d52b943b05313492a980"

URI_x86_64_v2_rust-indicatif+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+futures-devel-0.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+futures-devel}"
SRC_URI[x86_64_v2_rust-indicatif+futures-devel.sha256sum] = "e1524215ac389361d80ab02f9f5e1f47c54571d9e8736584f9a17c1c55478e84"

URI_x86_64_v2_rust-indicatif+improved_unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+improved_unicode-devel-0.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+improved_unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+improved_unicode-devel}"
SRC_URI[x86_64_v2_rust-indicatif+improved_unicode-devel.sha256sum] = "23a4743fdca75e5cd254421f5ea629550483070fdea440ec495938147d2ffd32"

URI_x86_64_v2_rust-indicatif+in_memory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+in_memory-devel-0.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+in_memory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+in_memory-devel}"
SRC_URI[x86_64_v2_rust-indicatif+in_memory-devel.sha256sum] = "403a2b58e82311fe933355f82b676222de388eabdc16b884f2525adc94d5aa29"

URI_x86_64_v2_rust-indicatif+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+rayon-devel-0.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+rayon-devel}"
SRC_URI[x86_64_v2_rust-indicatif+rayon-devel.sha256sum] = "099c2ea8bd009da34711a90d237521742b68e1a1f8464596c2865f3a4357006d"

URI_x86_64_v2_rust-indicatif+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+tokio-devel-0.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+tokio-devel}"
SRC_URI[x86_64_v2_rust-indicatif+tokio-devel.sha256sum] = "99e2d20a852694a06076ad65bb89b3ca16ac413d0eebe9e887c74472bd18860b"

URI_x86_64_v2_rust-indicatif+unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+unicode-segmentation-devel-0.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-indicatif+unicode-segmentation-devel.sha256sum] = "c8277edecee3c3d48883cd5a2fa674581ccc6e7436a9da424dd0441dbb40447c"

URI_x86_64_v2_rust-indicatif+unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+unicode-width-devel-0.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+unicode-width-devel}"
SRC_URI[x86_64_v2_rust-indicatif+unicode-width-devel.sha256sum] = "8ca1cd623e6c11cb96ba088b2eef7126cd66955f831dd4b98007122ec5f9643a"

URI_x86_64_v2_rust-indicatif+vt100-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+vt100-devel-0.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+vt100-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+vt100-devel}"
SRC_URI[x86_64_v2_rust-indicatif+vt100-devel.sha256sum] = "2c2cc55e46d785d08db1794fb85785ddb6594aa2f2bbe0cb4cbe0c2db38dee1d"

URI_x86_64_v2_rust-indicatif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif-devel-0.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif-devel}"
SRC_URI[x86_64_v2_rust-indicatif-devel.sha256sum] = "c738b7bb4fad77a67c0122b29a04c462bc3a692193e407ae07e459a682296839"

URI_aarch64_rust-indicatif+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+default-devel-0.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-indicatif+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+default-devel}"
SRC_URI[aarch64_rust-indicatif+default-devel.sha256sum] = "5de6498cb81840524b6616c141b911374b6662c98b95c19be3c346e9835bc5f8"

URI_aarch64_rust-indicatif+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+futures-devel-0.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-indicatif+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+futures-devel}"
SRC_URI[aarch64_rust-indicatif+futures-devel.sha256sum] = "dafdf7dd66f2709ab4509e792d25d94ce9cad8046b37649c2643f2d04e52ed38"

URI_aarch64_rust-indicatif+improved_unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+improved_unicode-devel-0.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-indicatif+improved_unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+improved_unicode-devel}"
SRC_URI[aarch64_rust-indicatif+improved_unicode-devel.sha256sum] = "85833bd6e9088ff5cc8a15ee8d1dd4b33d358a9296b0652fb9accbabefb9bdd5"

URI_aarch64_rust-indicatif+in_memory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+in_memory-devel-0.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-indicatif+in_memory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+in_memory-devel}"
SRC_URI[aarch64_rust-indicatif+in_memory-devel.sha256sum] = "c0304df2db37c492068f48b7a011197fe24f6f91f053d174d0502ced313a5546"

URI_aarch64_rust-indicatif+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+rayon-devel-0.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-indicatif+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+rayon-devel}"
SRC_URI[aarch64_rust-indicatif+rayon-devel.sha256sum] = "310098781daecfdc974b6fd3f422629678d95462f786a601f76954343f5dbede"

URI_aarch64_rust-indicatif+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+tokio-devel-0.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-indicatif+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+tokio-devel}"
SRC_URI[aarch64_rust-indicatif+tokio-devel.sha256sum] = "b6b565a31031b6047eab0d84892793339ece519e5b564a6b35be554092662001"

URI_aarch64_rust-indicatif+unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+unicode-segmentation-devel-0.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-indicatif+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+unicode-segmentation-devel}"
SRC_URI[aarch64_rust-indicatif+unicode-segmentation-devel.sha256sum] = "e3e3fb976b6addcd3b4b882c3382c9ad1d61bdb9c7bcaa57908736a9567a078c"

URI_aarch64_rust-indicatif+unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+unicode-width-devel-0.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-indicatif+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+unicode-width-devel}"
SRC_URI[aarch64_rust-indicatif+unicode-width-devel.sha256sum] = "aebf734af6e399ba097f27d9eee9cee9a48251293549e8b087c92ceb77bca39d"

URI_aarch64_rust-indicatif+vt100-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+vt100-devel-0.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-indicatif+vt100-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+vt100-devel}"
SRC_URI[aarch64_rust-indicatif+vt100-devel.sha256sum] = "bf5fea869d72451c30c99f289a61bf4ec40dd203f5756d4c9dc184ef4d036dac"

URI_aarch64_rust-indicatif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif-devel-0.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-indicatif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif-devel}"
SRC_URI[aarch64_rust-indicatif-devel.sha256sum] = "eb1a8f1445343dcdfb992cc9693f117e48cfb9861a1475e8a39f436acf4e36f9"

RDEPENDS:rust-indicatif+default-devel = " \
 cargo \
 rust-console+unicode-width-devel \
 rust-indicatif+unicode-width-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+futures-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+improved_unicode-devel = " \
 cargo \
 rust-console+unicode-width-devel \
 rust-indicatif+unicode-segmentation-devel \
 rust-indicatif+unicode-width-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+in_memory-devel = " \
 cargo \
 rust-indicatif+vt100-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+rayon-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-indicatif+tokio-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-indicatif+unicode-segmentation-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-unicode-segmentation+default-devel \
 "
RDEPENDS:rust-indicatif+unicode-width-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-indicatif+vt100-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-vt100+default-devel \
 "
RDEPENDS:rust-indicatif-devel = " \
 cargo \
 rust \
 rust-console+ansi-parsing-devel \
 rust-console+std-devel \
 rust-console-devel \
 rust-portable-atomic+default-devel \
 rust-unit-prefix+default-devel \
 "
