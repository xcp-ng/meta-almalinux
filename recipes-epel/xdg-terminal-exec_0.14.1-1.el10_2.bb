# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-terminal-exec"
PV = "0.14.1"
PR = "1.el10_2"
PACKAGES = " \
 xdg-terminal-exec \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xdg-terminal-exec-0.14.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf606ab1f1d329002e7eee386712333c7ce5a46b46d88772f56a2086428775db"

URI_x86_64_v2_xdg-terminal-exec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xdg-terminal-exec-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_xdg-terminal-exec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-terminal-exec}"
SRC_URI[x86_64_v2_xdg-terminal-exec.sha256sum] = "50eb24d2c2526df1daf1ffa0f13255fcbe38de9212610ae4135a1344a384a3ad"

URI_aarch64_xdg-terminal-exec = "${EPEL_MIRROR}/aarch64/Packages/x/xdg-terminal-exec-0.14.1-1.el10_2.noarch.rpm;name=aarch64_xdg-terminal-exec;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-terminal-exec}"
SRC_URI[aarch64_xdg-terminal-exec.sha256sum] = "0b2e89cda704829abc85ec2ac33b3b7ae76460fb9aa0e44820d66159ab54369c"

RDEPENDS:xdg-terminal-exec = " \
 bash \
 "
