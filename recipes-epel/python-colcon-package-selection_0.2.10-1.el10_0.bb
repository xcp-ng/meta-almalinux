# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-package-selection"
PV = "0.2.10"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-package-selection \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-package-selection-0.2.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2138cbd0a6b3a86edef8fec26d02313d2d0d655821adc01246eed9457753d5be"

URI_x86_64_v2_python3-colcon-package-selection = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-package-selection-0.2.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-package-selection;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-package-selection}"
SRC_URI[x86_64_v2_python3-colcon-package-selection.sha256sum] = "c90d5c41ac18cb7452c618a355127df7920e9c640993fb71432225104d664ffd"

URI_aarch64_python3-colcon-package-selection = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-package-selection-0.2.10-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-package-selection;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-package-selection}"
SRC_URI[aarch64_python3-colcon-package-selection.sha256sum] = "463bb9ccdfc6595a542ba92ca5b806fd06009cab41590000d12b15b76618ec1a"

RDEPENDS:python3-colcon-package-selection = " \
 python3 \
 python3-colcon-core \
 "
