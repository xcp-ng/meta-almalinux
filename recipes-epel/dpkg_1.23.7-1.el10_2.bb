# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dpkg"
PV = "1.23.7"
PR = "1.el10_2"
PACKAGES = " \
 dpkg \
 dpkg-dev \
 dpkg-devel \
 dpkg-perl \
 dselect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dpkg-1.23.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ff8e8be87a2239a4c21730d969c6e696eae70599000538655010258daa64cc1"

URI_x86_64_v2_dpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-1.23.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg}"
SRC_URI[x86_64_v2_dpkg.sha256sum] = "5850a03d9e6ef75e90bb8817aed8909b96b4c493f718ddb4f22f0804e173c3b1"

URI_x86_64_v2_dpkg-dev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-dev-1.23.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dpkg-dev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg-dev}"
SRC_URI[x86_64_v2_dpkg-dev.sha256sum] = "25c9fb55754c396a96c73f05c984e2285fa1e188d56c8e197ea96bb4c1c55d36"

URI_x86_64_v2_dpkg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-devel-1.23.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dpkg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg-devel}"
SRC_URI[x86_64_v2_dpkg-devel.sha256sum] = "2a9ddfacc21dac2dc9aa4428eb75af2ba3ee9129724f4789095d711d41a2038a"

URI_x86_64_v2_dpkg-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-perl-1.23.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dpkg-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg-perl}"
SRC_URI[x86_64_v2_dpkg-perl.sha256sum] = "86f0a5897d373356d0b5d6613833c948520b12e7a9614891d34c7884218ecbd0"

URI_x86_64_v2_dselect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dselect-1.23.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dselect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dselect}"
SRC_URI[x86_64_v2_dselect.sha256sum] = "1d9779f4bb18097c33c770ea91f02ee9d40346021f10cfab893b87e52f585c69"

URI_aarch64_dpkg = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-1.23.7-1.el10_2.aarch64.rpm;name=aarch64_dpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg}"
SRC_URI[aarch64_dpkg.sha256sum] = "9a37ba0e046f5f4390457cb7e08eace28020232f89d8d12f3b4eb793db10825b"

URI_aarch64_dpkg-dev = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-dev-1.23.7-1.el10_2.noarch.rpm;name=aarch64_dpkg-dev;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg-dev}"
SRC_URI[aarch64_dpkg-dev.sha256sum] = "dd8627376655265bab54c3d75af15d278c87a50bcba758a18f5c18488c44b460"

URI_aarch64_dpkg-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-devel-1.23.7-1.el10_2.aarch64.rpm;name=aarch64_dpkg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg-devel}"
SRC_URI[aarch64_dpkg-devel.sha256sum] = "f937c5cf283f6addc6a860ff136d2d38288d9735ba869145a5b944c527cdccb3"

URI_aarch64_dpkg-perl = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-perl-1.23.7-1.el10_2.noarch.rpm;name=aarch64_dpkg-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg-perl}"
SRC_URI[aarch64_dpkg-perl.sha256sum] = "9b3bc5d760f76e18cb87111924c739bd970b3b7b2244cbd166faa32d83a7012e"

URI_aarch64_dselect = "${EPEL_MIRROR}/aarch64/Packages/d/dselect-1.23.7-1.el10_2.aarch64.rpm;name=aarch64_dselect;unpack=0"
SRC_URI:append = " ${URI_aarch64_dselect}"
SRC_URI[aarch64_dselect.sha256sum] = "5b128c229e2ccd132bd679f9076640fd8f949fd50afd30e8b7968e612b999336"

RDEPENDS:dpkg = " \
 bash \
 bzip2-libs \
 glibc \
 libmd \
 libselinux \
 libzstd \
 tar \
 xz-libs \
 zlib-ng \
 "
RDEPENDS:dpkg-dev = " \
 binutils \
 bzip2 \
 dpkg-perl \
 gcc \
 make \
 patch \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-interpreter \
 perl-libs \
 xz \
 xz-lzma-compat \
 zstd \
 "
RDEPENDS:dpkg-devel = " \
 pkgconf-pkg-config \
 "
RDEPENDS:dpkg-perl = " \
 dpkg \
 dpkg-perl \
 perl-Carp \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Digest-SHA1 \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-IO \
 perl-MIME-Base64 \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Tie \
 perl-Time-HiRes \
 perl-Time-Piece \
 perl-TimeDate \
 perl-constant \
 perl-libs \
 perl-overload \
 perl-parent \
 "
RDEPENDS:dselect = " \
 bash \
 dpkg \
 dpkg-perl \
 dselect \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Path \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-parent \
 "
