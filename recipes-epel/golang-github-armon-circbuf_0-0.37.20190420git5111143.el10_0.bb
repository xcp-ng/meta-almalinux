# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-armon-circbuf"
PV = "0"
PR = "0.37.20190420git5111143.el10_0"
PACKAGES = " \
 golang-github-armon-circbuf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-armon-circbuf-0-0.37.20190420git5111143.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7f2284e0eaaaef906c145fd2a8e504cc32381dfc789a256902684aca373d33a"

URI_aarch64_golang-github-armon-circbuf-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-armon-circbuf-devel-0-0.37.20190420git5111143.el10_0.noarch.rpm;name=aarch64_golang-github-armon-circbuf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-armon-circbuf-devel}"
SRC_URI[aarch64_golang-github-armon-circbuf-devel.sha256sum] = "74849b4d6cbb3a4c9ddca066c4efe9e364c21cc2b588f754287ac0c7dd863df0"

RDEPENDS:golang-github-armon-circbuf-devel = " \
 go-filesystem \
 "
