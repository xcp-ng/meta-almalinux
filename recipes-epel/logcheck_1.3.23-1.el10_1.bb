# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "logcheck"
PV = "1.3.23"
PR = "1.el10_1"
PACKAGES = " \
 logcheck \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/logcheck-1.3.23-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b355ea00aa9fe045e7218069a50c47521e11ab863db4146c114f59820c1564da"

URI_x86_64_v2_logcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/logcheck-1.3.23-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_logcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_logcheck}"
SRC_URI[x86_64_v2_logcheck.sha256sum] = "bef38efd1ac51ee93172f00f78eb24c29310d24a098d97db05d16285c877698e"

URI_aarch64_logcheck = "${EPEL_MIRROR}/aarch64/Packages/l/logcheck-1.3.23-1.el10_1.noarch.rpm;name=aarch64_logcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_logcheck}"
SRC_URI[aarch64_logcheck.sha256sum] = "566c9e10f06a87653895de15f3f27c31dda4b37d1ec54d7569de9ea1c9e42a43"

RDEPENDS:logcheck = " \
 bash \
 crontabs \
 lockfile-progs \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-interpreter \
 perl-libs \
 perl-mime-construct \
 shadow-utils \
 "
