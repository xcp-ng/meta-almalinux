# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-ocaml"
PV = "0.24.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-ocaml+default-devel \
 rust-tree-sitter-ocaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-ocaml-0.24.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "438e6e88aa91a9c23a5042d457ce1b052e324e48a174931e300a0b5175fac72e"

URI_x86_64_v2_rust-tree-sitter-ocaml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-ocaml+default-devel-0.24.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-ocaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-ocaml+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-ocaml+default-devel.sha256sum] = "58c3eaa697f7517f5c437cd44d4f34b19ca5ef4f4ca9ecfefa6527279d076c0a"

URI_x86_64_v2_rust-tree-sitter-ocaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-ocaml-devel-0.24.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-ocaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-ocaml-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-ocaml-devel.sha256sum] = "8ba79d60c0a4acd62a7ed66f69e3166ba8bdc09ed0b970785a2afc01a2592ecc"

URI_aarch64_rust-tree-sitter-ocaml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-ocaml+default-devel-0.24.2-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-ocaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-ocaml+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-ocaml+default-devel.sha256sum] = "0645b2f3e1e23de187482d27d167339f2f7b0ef892a0ee7b20e8c24a67e7fed1"

URI_aarch64_rust-tree-sitter-ocaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-ocaml-devel-0.24.2-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-ocaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-ocaml-devel}"
SRC_URI[aarch64_rust-tree-sitter-ocaml-devel.sha256sum] = "822248d29c219126e828235d28738760e3da49adf6434ecdc85fa412e060f450"

RDEPENDS:rust-tree-sitter-ocaml+default-devel = " \
 cargo \
 rust-tree-sitter-ocaml-devel \
 "
RDEPENDS:rust-tree-sitter-ocaml-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
