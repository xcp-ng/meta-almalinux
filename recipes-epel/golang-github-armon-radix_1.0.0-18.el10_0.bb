# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-armon-radix"
PV = "1.0.0"
PR = "18.el10_0"
PACKAGES = " \
 golang-github-armon-radix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-armon-radix-1.0.0-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68157d777e9901657af42ab8b8bccf2f64b12db925d70e42d3e344a0a57f52af"

URI_x86_64_v2_golang-github-armon-radix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-armon-radix-devel-1.0.0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-armon-radix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-armon-radix-devel}"
SRC_URI[x86_64_v2_golang-github-armon-radix-devel.sha256sum] = "52dea233f20f070a534b9cf5ebed54cfa28f8b90385ef6f4b180cbdcaae6d048"

URI_aarch64_golang-github-armon-radix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-armon-radix-devel-1.0.0-18.el10_0.noarch.rpm;name=aarch64_golang-github-armon-radix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-armon-radix-devel}"
SRC_URI[aarch64_golang-github-armon-radix-devel.sha256sum] = "2e2478f18cdd385e4295fa295ed5d743b836337fec90d8f2ab8ffa0a506ef080"

RDEPENDS:golang-github-armon-radix-devel = " \
 go-filesystem \
 "
