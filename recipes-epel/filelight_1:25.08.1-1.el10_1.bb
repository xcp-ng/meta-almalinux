# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "filelight"
PE = "1"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 filelight \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/filelight-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7989140237f7138eee0d6e23b26f90edc6e6565a8fbef85d26704e20ce00fb9"

URI_x86_64_v2_filelight = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/filelight-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_filelight;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_filelight}"
SRC_URI[x86_64_v2_filelight.sha256sum] = "0acd75731fe64ef0241bda1a19f027b29f24dfbd49ec18765dae4104a3d49f1e"

URI_aarch64_filelight = "${EPEL_MIRROR}/aarch64/Packages/f/filelight-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_filelight;unpack=0"
SRC_URI:append = " ${URI_aarch64_filelight}"
SRC_URI[aarch64_filelight.sha256sum] = "4e02b467d76993ccc59b30ea2056a198c45bef3e191d6f361adf766f66cae23b"

RDEPENDS:filelight = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kquickcharts \
 kf6-kwidgetsaddons \
 kf6-qqc2-desktop-style \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
