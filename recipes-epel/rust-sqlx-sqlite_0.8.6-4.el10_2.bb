# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sqlx-sqlite"
PV = "0.8.6"
PR = "4.el10_2"
PACKAGES = " \
 rust-sqlx-sqlite+any-devel \
 rust-sqlx-sqlite+chrono-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+json-devel \
 rust-sqlx-sqlite+migrate-devel \
 rust-sqlx-sqlite+offline-devel \
 rust-sqlx-sqlite+preupdate-hook-devel \
 rust-sqlx-sqlite+regexp-devel \
 rust-sqlx-sqlite+serde-devel \
 rust-sqlx-sqlite+time-devel \
 rust-sqlx-sqlite+unbundled-devel \
 rust-sqlx-sqlite+uuid-devel \
 rust-sqlx-sqlite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sqlx-sqlite-0.8.6-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40475324a5b395c76c2cc1ebdd4575a68c67f0c1a436fc31c4882a570b2f3d80"

URI_x86_64_v2_rust-sqlx-sqlite+any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+any-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+any-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+any-devel.sha256sum] = "c8dd121f81aaef6dc7d02c8a523e8a7603d8732949e0d797b0afc7123ecd1f45"

URI_x86_64_v2_rust-sqlx-sqlite+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+chrono-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+chrono-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+chrono-devel.sha256sum] = "324092e44ca7a3ccccdf8a3ee765f9219e10b01a1acbf5a1828eebe392b2c07e"

URI_x86_64_v2_rust-sqlx-sqlite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+default-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+default-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+default-devel.sha256sum] = "0d1ab3f8d6caa6dedce2ee0421c8d9cbcdbceda755731ea4a6ef61098dba5bc1"

URI_x86_64_v2_rust-sqlx-sqlite+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+json-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+json-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+json-devel.sha256sum] = "f1961a6c2b51cd9741571afb49ac0241e0b3d9c6361350520f34453395843907"

URI_x86_64_v2_rust-sqlx-sqlite+migrate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+migrate-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+migrate-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+migrate-devel.sha256sum] = "7e54ac4f5729a99d0c23556f593ae27328aecc75c1f2abea7f1b5476e1c70419"

URI_x86_64_v2_rust-sqlx-sqlite+offline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+offline-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+offline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+offline-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+offline-devel.sha256sum] = "ce713006c55ed7805a51f2fda18f88720a58f87753ecfea048fa077e4cb1cf6a"

URI_x86_64_v2_rust-sqlx-sqlite+preupdate-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+preupdate-hook-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+preupdate-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+preupdate-hook-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+preupdate-hook-devel.sha256sum] = "b4c7049c8f768942c2fbb30c25a170fbaf8ba07c51f2b31fa14ae2af05f4f69c"

URI_x86_64_v2_rust-sqlx-sqlite+regexp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+regexp-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+regexp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+regexp-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+regexp-devel.sha256sum] = "78763e645729d2003fca6b25425ea8e4873b9299f0f71dea54f3dbf91d09b37b"

URI_x86_64_v2_rust-sqlx-sqlite+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+serde-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+serde-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+serde-devel.sha256sum] = "c474468c94056a01cc84dda5d19a6caf156d48b14156ae6455711dd6eb52b025"

URI_x86_64_v2_rust-sqlx-sqlite+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+time-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+time-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+time-devel.sha256sum] = "60e987bf5e7ec17b453820efad6789afe9d373d3cad3edf1ea58fe681b4e11b1"

URI_x86_64_v2_rust-sqlx-sqlite+unbundled-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+unbundled-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+unbundled-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+unbundled-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+unbundled-devel.sha256sum] = "c96d6072516d7b7dfcc890ec45acd1c84f76ce510056f92b886ba9ad0b86c9f5"

URI_x86_64_v2_rust-sqlx-sqlite+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+uuid-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+uuid-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+uuid-devel.sha256sum] = "c01f37cbfde11974f90f26a6b79f0baf1938b801834c5cb306f3d9f3bc42ad03"

URI_x86_64_v2_rust-sqlx-sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite-devel.sha256sum] = "993f8bc0dac3b01f93de07400be0dd622d5ddd518ed6ea1b3db159a8b0ac0205"

URI_aarch64_rust-sqlx-sqlite+any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+any-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-sqlite+any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+any-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+any-devel.sha256sum] = "e5834fc980006e5556beed29fbda8a6c713fa2c1649182d2f7974c7a5dd151ae"

URI_aarch64_rust-sqlx-sqlite+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+chrono-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-sqlite+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+chrono-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+chrono-devel.sha256sum] = "51f3076809c529c0798c5329d21ae92da0f36306fb5e9678a6ace10c1ac9dcee"

URI_aarch64_rust-sqlx-sqlite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+default-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-sqlite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+default-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+default-devel.sha256sum] = "1c1c84e288cf3cb2939c9b036b55e11f82df57cc8bb733a168df4df10e2f9c5b"

URI_aarch64_rust-sqlx-sqlite+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+json-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-sqlite+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+json-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+json-devel.sha256sum] = "fa430000e1883382cc3eb9f4a61a3753be933404cd80dec4835c3a24ae87da38"

URI_aarch64_rust-sqlx-sqlite+migrate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+migrate-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-sqlite+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+migrate-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+migrate-devel.sha256sum] = "d2a791daeecc4b8c3ce876cea1e8a5853e7a729ff64d7718f7d7de74e4913eaf"

URI_aarch64_rust-sqlx-sqlite+offline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+offline-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-sqlite+offline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+offline-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+offline-devel.sha256sum] = "702b18ce5d3bf0182228f4562d8aca51c1dd75ad78327fdb968e759f27b562be"

URI_aarch64_rust-sqlx-sqlite+preupdate-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+preupdate-hook-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-sqlite+preupdate-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+preupdate-hook-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+preupdate-hook-devel.sha256sum] = "f1a5151e5bffad70396ae087a4780452d03e5a23160c319ab46c3cd842c2bfb5"

URI_aarch64_rust-sqlx-sqlite+regexp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+regexp-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-sqlite+regexp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+regexp-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+regexp-devel.sha256sum] = "a26c9e3f3afb5c7b29c1f6c5e695cf5910b10183afede16a891e712cc5714326"

URI_aarch64_rust-sqlx-sqlite+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+serde-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-sqlite+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+serde-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+serde-devel.sha256sum] = "22261e3f7df104c512330fcb96413778ffeee3eacbba08a3856040df42916a5c"

URI_aarch64_rust-sqlx-sqlite+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+time-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-sqlite+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+time-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+time-devel.sha256sum] = "b34ab6cb0ea75cdaf941937816acf5b8fe2e74784273607f23b89991405dfe5d"

URI_aarch64_rust-sqlx-sqlite+unbundled-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+unbundled-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-sqlite+unbundled-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+unbundled-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+unbundled-devel.sha256sum] = "61a7e449ac7a04d47bdf8da669a9e8e9184e2ed51f656570770a154dc31cd59c"

URI_aarch64_rust-sqlx-sqlite+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+uuid-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-sqlite+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+uuid-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+uuid-devel.sha256sum] = "c8059d21238bf237ef940e86c315a6a9e60ec6f501b3845ddb7cfda38db6ad32"

URI_aarch64_rust-sqlx-sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite-devel.sha256sum] = "5da4444137f29b8f48cc8eb6d955a9d721a2c70aa033d2b6b822f7461d677879"

RDEPENDS:rust-sqlx-sqlite+any-devel = " \
 cargo \
 rust-sqlx-core+any-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-sqlx-core+chrono-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+default-devel = " \
 cargo \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+json-devel = " \
 cargo \
 rust-sqlx-core+json-devel \
 rust-sqlx-sqlite+serde-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+migrate-devel = " \
 cargo \
 rust-sqlx-core+migrate-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+offline-devel = " \
 cargo \
 rust-sqlx-core+offline-devel \
 rust-sqlx-sqlite+serde-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+preupdate-hook-devel = " \
 cargo \
 rust-libsqlite3-sys0.28+preupdate_hook-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+regexp-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+time-devel = " \
 cargo \
 rust-sqlx-core+time-devel \
 rust-sqlx-sqlite-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-sqlx-sqlite+unbundled-devel = " \
 cargo \
 rust-libsqlite3-sys0.28+buildtime_bindgen-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+uuid-devel = " \
 cargo \
 rust-sqlx-core+uuid-devel \
 rust-sqlx-sqlite-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-sqlx-sqlite-devel = " \
 cargo \
 rust-atoi+default-devel \
 rust-flume+async-devel \
 rust-flume-devel \
 rust-futures-channel+alloc-devel \
 rust-futures-channel+sink-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-core-devel \
 rust-futures-executor+default-devel \
 rust-futures-intrusive+default-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 rust-libsqlite3-sys0.28+unlock_notify-devel \
 rust-libsqlite3-sys0.28-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-serde_urlencoded+default-devel \
 rust-sqlx-core+default-devel \
 rust-thiserror+default-devel \
 rust-tracing+default-devel \
 rust-tracing+log-devel \
 rust-url+default-devel \
 "
