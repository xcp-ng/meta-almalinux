# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_xoshiro0.7"
PV = "0.7.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_xoshiro0.7+default-devel \
 rust-rand_xoshiro0.7+serde-devel \
 rust-rand_xoshiro0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_xoshiro0.7-0.7.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a9ec14577a979ede7717d0c07e4199e8b1fd8d8a0132803c096cd80eaa00c11"

URI_x86_64_v2_rust-rand_xoshiro0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro0.7+default-devel-0.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xoshiro0.7+default-devel}"
SRC_URI[x86_64_v2_rust-rand_xoshiro0.7+default-devel.sha256sum] = "0d6f7e5703f5bafb2aefaad4886a80e866376fc692a9da82e9cc0f78d71bca35"

URI_x86_64_v2_rust-rand_xoshiro0.7+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro0.7+serde-devel-0.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro0.7+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xoshiro0.7+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_xoshiro0.7+serde-devel.sha256sum] = "f2e708f7df0ace98b77431f64822f672518cc1433d123de0d8bce9354bde398e"

URI_x86_64_v2_rust-rand_xoshiro0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro0.7-devel-0.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xoshiro0.7-devel}"
SRC_URI[x86_64_v2_rust-rand_xoshiro0.7-devel.sha256sum] = "2ebb58f5be49d1e3cc7d70fb265d9c1ed73ae215ef8c4ddfccb533e3d254d2c1"

URI_aarch64_rust-rand_xoshiro0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro0.7+default-devel-0.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xoshiro0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xoshiro0.7+default-devel}"
SRC_URI[aarch64_rust-rand_xoshiro0.7+default-devel.sha256sum] = "ea4a66dbed373f6edf90319413d6e28165cf4e772ce359627b019dc7c870e804"

URI_aarch64_rust-rand_xoshiro0.7+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro0.7+serde-devel-0.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xoshiro0.7+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xoshiro0.7+serde-devel}"
SRC_URI[aarch64_rust-rand_xoshiro0.7+serde-devel.sha256sum] = "7d436da52912fee9463117b7e7b6ef21cc6fc10301d377bc9321443848f2fa70"

URI_aarch64_rust-rand_xoshiro0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro0.7-devel-0.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xoshiro0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xoshiro0.7-devel}"
SRC_URI[aarch64_rust-rand_xoshiro0.7-devel.sha256sum] = "483683f319558a19e383904dc1daa8755d84955ef6e489558ec5e4a14ad0fce7"

RDEPENDS:rust-rand_xoshiro0.7+default-devel = " \
 cargo \
 rust-rand_xoshiro0.7-devel \
 "
RDEPENDS:rust-rand_xoshiro0.7+serde-devel = " \
 cargo \
 rust-rand_xoshiro0.7-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_xoshiro0.7-devel = " \
 cargo \
 rust \
 rust-rand_core0.9+default-devel \
 "
