# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ipnet"
PV = "2.12.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-ipnet+default-devel \
 rust-ipnet+heapless-devel \
 rust-ipnet+schemars08-devel \
 rust-ipnet+schemars1-devel \
 rust-ipnet+ser_as_str-devel \
 rust-ipnet+serde-devel \
 rust-ipnet+std-devel \
 rust-ipnet-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ipnet-2.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5366871167c160abfbe4e13de4cd9443730ee6f5a894e241688fa28e030aa192"

URI_x86_64_v2_rust-ipnet+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+default-devel-2.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+default-devel}"
SRC_URI[x86_64_v2_rust-ipnet+default-devel.sha256sum] = "12e5f54ce74f653d9f73a85d9faf71ad0799faf8dbbdcd60df7c372f65c4471d"

URI_x86_64_v2_rust-ipnet+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+heapless-devel-2.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+heapless-devel}"
SRC_URI[x86_64_v2_rust-ipnet+heapless-devel.sha256sum] = "d5c6bd137cd49ea106c1b6d6680c70b6d57f2bde6b15984ec5bb598465cd5ff6"

URI_x86_64_v2_rust-ipnet+schemars08-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+schemars08-devel-2.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+schemars08-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+schemars08-devel}"
SRC_URI[x86_64_v2_rust-ipnet+schemars08-devel.sha256sum] = "9c25d3429ab2a1ab672b12de7c282a97bf81c3df6700633694ff43dacbf557b1"

URI_x86_64_v2_rust-ipnet+schemars1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+schemars1-devel-2.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+schemars1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+schemars1-devel}"
SRC_URI[x86_64_v2_rust-ipnet+schemars1-devel.sha256sum] = "b867deef3d2039c1800bdd0ee3a90d27f8daef524fb6918d4d77f90d57ee618a"

URI_x86_64_v2_rust-ipnet+ser_as_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+ser_as_str-devel-2.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+ser_as_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+ser_as_str-devel}"
SRC_URI[x86_64_v2_rust-ipnet+ser_as_str-devel.sha256sum] = "185658547f1eadc52e52246bad6d0c988e2a2247c8027666d1ff3238bf0e96d7"

URI_x86_64_v2_rust-ipnet+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+serde-devel-2.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+serde-devel}"
SRC_URI[x86_64_v2_rust-ipnet+serde-devel.sha256sum] = "a99ac271da1d8659cd237c965d6d4ee43f25da122ddecdbeb249d6a8f2b9b393"

URI_x86_64_v2_rust-ipnet+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+std-devel-2.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+std-devel}"
SRC_URI[x86_64_v2_rust-ipnet+std-devel.sha256sum] = "635d3d4786dfffe8f08fcbf3ef0cf777566c3abeb2f719ceddcb83c139562d62"

URI_x86_64_v2_rust-ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet-devel-2.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet-devel}"
SRC_URI[x86_64_v2_rust-ipnet-devel.sha256sum] = "8d1152ea27797a2cb83b52719d4e450051061566178999197217428dad477dfe"

URI_aarch64_rust-ipnet+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+default-devel-2.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-ipnet+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+default-devel}"
SRC_URI[aarch64_rust-ipnet+default-devel.sha256sum] = "dbddf48c1e7044c828594a7f4a817cba1946518a88e4b915f0f2101856b88c9e"

URI_aarch64_rust-ipnet+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+heapless-devel-2.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-ipnet+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+heapless-devel}"
SRC_URI[aarch64_rust-ipnet+heapless-devel.sha256sum] = "f550e5c66d35f0273da1e3e9259d3ea14ed26e32fd8a7ac049d2fff661fc57d8"

URI_aarch64_rust-ipnet+schemars08-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+schemars08-devel-2.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-ipnet+schemars08-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+schemars08-devel}"
SRC_URI[aarch64_rust-ipnet+schemars08-devel.sha256sum] = "d92f2c08a4ad3f3aaf54ba03daedfea378f9e38517a02ec709a433497523e6eb"

URI_aarch64_rust-ipnet+schemars1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+schemars1-devel-2.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-ipnet+schemars1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+schemars1-devel}"
SRC_URI[aarch64_rust-ipnet+schemars1-devel.sha256sum] = "80790de9d8be33b5aae634d3016fd5db125d0c1b37ebd7ad714826922ee79f22"

URI_aarch64_rust-ipnet+ser_as_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+ser_as_str-devel-2.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-ipnet+ser_as_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+ser_as_str-devel}"
SRC_URI[aarch64_rust-ipnet+ser_as_str-devel.sha256sum] = "6ab1f418a7b13b1db07471ab2af753a7c9fb52136521d5ee56f0554269f3c414"

URI_aarch64_rust-ipnet+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+serde-devel-2.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-ipnet+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+serde-devel}"
SRC_URI[aarch64_rust-ipnet+serde-devel.sha256sum] = "505f48d433019e5edd3b689cdbcdd746956a4a1abea9724450cd1721613e3457"

URI_aarch64_rust-ipnet+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+std-devel-2.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-ipnet+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+std-devel}"
SRC_URI[aarch64_rust-ipnet+std-devel.sha256sum] = "c1c60ddbf73fec46f643d12064b5f977e94d2a28cac21eccff10eec2c7969b7f"

URI_aarch64_rust-ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet-devel-2.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet-devel}"
SRC_URI[aarch64_rust-ipnet-devel.sha256sum] = "eb7c6441e67f0bf772aa497b97d741f0ab6d32061733695cf89d8fd03deabbb5"

RDEPENDS:rust-ipnet+default-devel = " \
 cargo \
 rust-ipnet+std-devel \
 rust-ipnet-devel \
 "
RDEPENDS:rust-ipnet+heapless-devel = " \
 cargo \
 rust-ipnet+serde-devel \
 rust-ipnet-devel \
 virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~ \
 "
RDEPENDS:rust-ipnet+schemars08-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-ipnet+schemars1-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-ipnet+ser_as_str-devel = " \
 cargo \
 rust-ipnet-devel \
 virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~ \
 "
RDEPENDS:rust-ipnet+serde-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ipnet+std-devel = " \
 cargo \
 rust-ipnet-devel \
 "
RDEPENDS:rust-ipnet-devel = " \
 cargo \
 "
