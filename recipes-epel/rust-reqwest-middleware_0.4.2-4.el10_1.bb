# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest-middleware"
PV = "0.4.2"
PR = "4.el10_1"
PACKAGES = " \
 rust-reqwest-middleware+charset-devel \
 rust-reqwest-middleware+default-devel \
 rust-reqwest-middleware+http2-devel \
 rust-reqwest-middleware+json-devel \
 rust-reqwest-middleware+multipart-devel \
 rust-reqwest-middleware+rustls-tls-devel \
 rust-reqwest-middleware-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-middleware-0.4.2-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d50b94b9a019e9a5514a1d04bdb7cc13968ee60501b919596ff1e8d51907858c"

URI_x86_64_v2_rust-reqwest-middleware+charset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+charset-devel-0.4.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+charset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+charset-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+charset-devel.sha256sum] = "470b927a6ee8aa9f4a542656f3cc26eecc51685d7c4a0b876d2efede69357c1b"

URI_x86_64_v2_rust-reqwest-middleware+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+default-devel-0.4.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+default-devel.sha256sum] = "151a5c5d1884fb9984666b4bd1022496cb8a2336ff50b3e80947f77ac37abe80"

URI_x86_64_v2_rust-reqwest-middleware+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+http2-devel-0.4.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+http2-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+http2-devel.sha256sum] = "15d561b03f4e204d9ad4bbd2ae8acd0c414dc911ba3fb53c75d79ee57cfa11af"

URI_x86_64_v2_rust-reqwest-middleware+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+json-devel-0.4.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+json-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+json-devel.sha256sum] = "dc0cafbd234c596401bdc26d38f5836b397bae9f1d7f613cab1c8b15a65bd395"

URI_x86_64_v2_rust-reqwest-middleware+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+multipart-devel-0.4.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+multipart-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+multipart-devel.sha256sum] = "6dc0c9a0cb00f8b4594deebe4b8a5fec0850443c61bc22ebe157a3acb937cab6"

URI_x86_64_v2_rust-reqwest-middleware+rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+rustls-tls-devel-0.4.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+rustls-tls-devel.sha256sum] = "a7181f58b814116825489ebe0b5434400ef0b1e11b710a5013bbae003f29edf1"

URI_x86_64_v2_rust-reqwest-middleware-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware-devel-0.4.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware-devel.sha256sum] = "82465752ddc7dea539a999131abb479e2ff5be6df3224cc47e83a0aea432e710"

URI_aarch64_rust-reqwest-middleware+charset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+charset-devel-0.4.2-4.el10_1.noarch.rpm;name=aarch64_rust-reqwest-middleware+charset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+charset-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+charset-devel.sha256sum] = "24c2b7ebd108a551ec041e0e272438356fe26315b694a1e826ecc5ac1f209b6d"

URI_aarch64_rust-reqwest-middleware+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+default-devel-0.4.2-4.el10_1.noarch.rpm;name=aarch64_rust-reqwest-middleware+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+default-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+default-devel.sha256sum] = "a247e1c24624bda0ebdcda3c68de131f36f04b240b25259a408dba03a58d5c96"

URI_aarch64_rust-reqwest-middleware+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+http2-devel-0.4.2-4.el10_1.noarch.rpm;name=aarch64_rust-reqwest-middleware+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+http2-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+http2-devel.sha256sum] = "669e9a103f25df9bed24addfd4357f9d69bb308915935f5f2abe7b6841422b35"

URI_aarch64_rust-reqwest-middleware+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+json-devel-0.4.2-4.el10_1.noarch.rpm;name=aarch64_rust-reqwest-middleware+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+json-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+json-devel.sha256sum] = "5334022bbb2d79c47630e6275fab657a15c043a6da2ca623641aaf1805f641b8"

URI_aarch64_rust-reqwest-middleware+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+multipart-devel-0.4.2-4.el10_1.noarch.rpm;name=aarch64_rust-reqwest-middleware+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+multipart-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+multipart-devel.sha256sum] = "1469aadb125471ef703f00aa2ac1110c75f7c144da3991fddcaaa97243609b14"

URI_aarch64_rust-reqwest-middleware+rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+rustls-tls-devel-0.4.2-4.el10_1.noarch.rpm;name=aarch64_rust-reqwest-middleware+rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+rustls-tls-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+rustls-tls-devel.sha256sum] = "1df4743cf225230cf7d1445889adcc6a33cee1bb6ba7ad2817ce09e131b52c7f"

URI_aarch64_rust-reqwest-middleware-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware-devel-0.4.2-4.el10_1.noarch.rpm;name=aarch64_rust-reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware-devel}"
SRC_URI[aarch64_rust-reqwest-middleware-devel.sha256sum] = "2ef038283fe63cdc0d2a821ca872cda150b1c3334b460a46872018812da167f3"

RDEPENDS:rust-reqwest-middleware+charset-devel = " \
 cargo \
 rust-reqwest+charset-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+default-devel = " \
 cargo \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+http2-devel = " \
 cargo \
 rust-reqwest+http2-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+json-devel = " \
 cargo \
 rust-reqwest+json-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+multipart-devel = " \
 cargo \
 rust-reqwest+multipart-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+rustls-tls-devel = " \
 cargo \
 rust-reqwest+rustls-tls-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-http+default-devel \
 rust-reqwest-devel \
 rust-serde+default-devel \
 rust-thiserror1+default-devel \
 rust-tower-service+default-devel \
 "
