# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-imgref"
PV = "1.12.3"
PR = "2.el10_3"
PACKAGES = " \
 rust-imgref+default-devel \
 rust-imgref+deprecated-devel \
 rust-imgref-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-imgref-1.12.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f8ca2d062b5106202f286b056564618b6e0112af38308422a21dabbbfcc19804"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref+default-devel-1.12.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-imgref+default-devel.sha256sum] = "12e1afa276142eccaf9b892c28a69d795217da01d17c1e27fc6060ae8f010585"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref+deprecated-devel-1.12.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref+deprecated-devel;unpack=0"
SRC_URI[x86_64_v2_rust-imgref+deprecated-devel.sha256sum] = "cc5d3ece84b5ffcad3893284f8c178c2e50f59fdefb4db49c7ecee03727ab470"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref-devel-1.12.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref-devel;unpack=0"
SRC_URI[x86_64_v2_rust-imgref-devel.sha256sum] = "1783a4596e8a91be2613aadc86587375ae4950f4d198d5bdfbad82f1381073e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref+default-devel-1.12.3-2.el10_3.noarch.rpm;name=aarch64_rust-imgref+default-devel;unpack=0"
SRC_URI[aarch64_rust-imgref+default-devel.sha256sum] = "633df206dce2b6289128134ddbe78ef5712dd0c40bedb29f2b2a0a5747a9507b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref+deprecated-devel-1.12.3-2.el10_3.noarch.rpm;name=aarch64_rust-imgref+deprecated-devel;unpack=0"
SRC_URI[aarch64_rust-imgref+deprecated-devel.sha256sum] = "67a46cab618911cae76cd32494d51cc4110ea237c78965e2d7fdb87253a0f210"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref-devel-1.12.3-2.el10_3.noarch.rpm;name=aarch64_rust-imgref-devel;unpack=0"
SRC_URI[aarch64_rust-imgref-devel.sha256sum] = "c98a4542bd23b7e26b460c439819acf0831e3bd1ae6990c95ac775ea60e51492"

RDEPENDS:rust-imgref+default-devel = " \
 cargo \
 rust-imgref+deprecated-devel \
 rust-imgref-devel \
 "
RDEPENDS:rust-imgref+deprecated-devel = " \
 cargo \
 rust-imgref-devel \
 "
RDEPENDS:rust-imgref-devel = " \
 cargo \
 rust \
 "
