# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libfilezilla"
PV = "0.51.1"
PR = "1.el10_1"
PACKAGES = " \
 libfilezilla \
 libfilezilla-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libfilezilla-0.51.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60d938297e4bd5aed4ecb2ebabd7ed889c45c7dd52598170b4953a44435b86a1"

URI_x86_64_v2_libfilezilla = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfilezilla-0.51.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfilezilla;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfilezilla}"
SRC_URI[x86_64_v2_libfilezilla.sha256sum] = "f60f1627cb9d125d15bf345da2321ee5db0a2dc68973a77d7fb70e19b202cdc2"

URI_x86_64_v2_libfilezilla-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfilezilla-devel-0.51.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfilezilla-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfilezilla-devel}"
SRC_URI[x86_64_v2_libfilezilla-devel.sha256sum] = "b9c5f4dd03154674dc71d524cdf3efa3e30834447849bb24f87da027ea3cd9d3"

URI_aarch64_libfilezilla = "${EPEL_MIRROR}/aarch64/Packages/l/libfilezilla-0.51.1-1.el10_1.aarch64.rpm;name=aarch64_libfilezilla;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfilezilla}"
SRC_URI[aarch64_libfilezilla.sha256sum] = "00e6a865e46aaf746374dfa6d562fd46e052755cb8207a8a95e34c2bee78249e"

URI_aarch64_libfilezilla-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libfilezilla-devel-0.51.1-1.el10_1.aarch64.rpm;name=aarch64_libfilezilla-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfilezilla-devel}"
SRC_URI[aarch64_libfilezilla-devel.sha256sum] = "87cc177efc8f3544051fbb8c8a405f94f70124a3ca092c42230490030fe7c61e"

RDEPENDS:libfilezilla = " \
 glibc \
 gmp \
 gnutls \
 libgcc \
 libstdc++ \
 libxcrypt \
 nettle \
 "
RDEPENDS:libfilezilla-devel = " \
 gnutls-devel \
 libfilezilla \
 nettle-devel \
 pkgconf-pkg-config \
 "
