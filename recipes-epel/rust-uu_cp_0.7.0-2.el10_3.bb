# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_cp"
PV = "0.7.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-uu_cp+default-devel \
 rust-uu_cp+exacl-devel \
 rust-uu_cp+feat_acl-devel \
 rust-uu_cp+feat_selinux-devel \
 rust-uu_cp+selinux-devel \
 rust-uu_cp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_cp-0.7.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25cbd554332e21c4376cb6da3ec047eb3dd19dc7b9f4ac25b15641e53bbd6571"

URI_x86_64_v2_rust-uu_cp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_cp+default-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_cp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_cp+default-devel}"
SRC_URI[x86_64_v2_rust-uu_cp+default-devel.sha256sum] = "5a4905394360e353d5e9f1d9e20c0220b8293c6dcc93e16ab151cf1a6d29e154"

URI_x86_64_v2_rust-uu_cp+exacl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_cp+exacl-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_cp+exacl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_cp+exacl-devel}"
SRC_URI[x86_64_v2_rust-uu_cp+exacl-devel.sha256sum] = "1e686b9eb4a22a92020199594dafe0ee6b6f24ed029dc90966996ec263b6c751"

URI_x86_64_v2_rust-uu_cp+feat_acl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_cp+feat_acl-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_cp+feat_acl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_cp+feat_acl-devel}"
SRC_URI[x86_64_v2_rust-uu_cp+feat_acl-devel.sha256sum] = "4cb862c2e4b6bedac47d17b68b8b1001afcc0f2d8cc5f98441610c1bc4af4c34"

URI_x86_64_v2_rust-uu_cp+feat_selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_cp+feat_selinux-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_cp+feat_selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_cp+feat_selinux-devel}"
SRC_URI[x86_64_v2_rust-uu_cp+feat_selinux-devel.sha256sum] = "b7eb339a8d5496cd6484277c9bd3aa802224467df6a92c40ac205813ca02972a"

URI_x86_64_v2_rust-uu_cp+selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_cp+selinux-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_cp+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_cp+selinux-devel}"
SRC_URI[x86_64_v2_rust-uu_cp+selinux-devel.sha256sum] = "daa9ebfcd2b2255606626ab7540860b15525e327d1736af3727ca783018ef3db"

URI_x86_64_v2_rust-uu_cp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_cp-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_cp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_cp-devel}"
SRC_URI[x86_64_v2_rust-uu_cp-devel.sha256sum] = "7c5d7e2d4e8f3c52e009b4835bb23c8815b27b93092a6da2b3b9bd02bde3ef81"

URI_aarch64_rust-uu_cp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_cp+default-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_cp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_cp+default-devel}"
SRC_URI[aarch64_rust-uu_cp+default-devel.sha256sum] = "2620c203b339ad41cca095f4237431dddb197abf3742c4917f0a0666e1d9a1db"

URI_aarch64_rust-uu_cp+exacl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_cp+exacl-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_cp+exacl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_cp+exacl-devel}"
SRC_URI[aarch64_rust-uu_cp+exacl-devel.sha256sum] = "0b033c2c7893e54a2aae051233e6ad9bcd5faf7a36db0e8057d081b8a4c9f930"

URI_aarch64_rust-uu_cp+feat_acl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_cp+feat_acl-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_cp+feat_acl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_cp+feat_acl-devel}"
SRC_URI[aarch64_rust-uu_cp+feat_acl-devel.sha256sum] = "eb29427e0ea6bf21a1a8b55dc07430cecec45211bc9f7dae3b6c29e520fc7532"

URI_aarch64_rust-uu_cp+feat_selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_cp+feat_selinux-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_cp+feat_selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_cp+feat_selinux-devel}"
SRC_URI[aarch64_rust-uu_cp+feat_selinux-devel.sha256sum] = "bde00243089a352910969956bf15624d14827fc7e00a6a89860f4e4712687623"

URI_aarch64_rust-uu_cp+selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_cp+selinux-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_cp+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_cp+selinux-devel}"
SRC_URI[aarch64_rust-uu_cp+selinux-devel.sha256sum] = "c92d7c6ff9c93afe40c40e0c5fc8c1336ebe9ada771306b33b94c84c846ba3ac"

URI_aarch64_rust-uu_cp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_cp-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_cp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_cp-devel}"
SRC_URI[aarch64_rust-uu_cp-devel.sha256sum] = "225d9d8355ef7dd33bbfbd765cc59cf971c02d53a6a721acfa476f873d86c2a7"

RDEPENDS:rust-uu_cp+default-devel = " \
 cargo \
 rust-uu_cp-devel \
 "
RDEPENDS:rust-uu_cp+exacl-devel = " \
 cargo \
 rust-exacl+default-devel \
 rust-uu_cp-devel \
 "
RDEPENDS:rust-uu_cp+feat_acl-devel = " \
 cargo \
 rust-uu_cp+exacl-devel \
 rust-uu_cp-devel \
 "
RDEPENDS:rust-uu_cp+feat_selinux-devel = " \
 cargo \
 rust-uu_cp+selinux-devel \
 rust-uu_cp-devel \
 rust-uucore+selinux-devel \
 "
RDEPENDS:rust-uu_cp+selinux-devel = " \
 cargo \
 rust-selinux+default-devel \
 rust-uu_cp-devel \
 "
RDEPENDS:rust-uu_cp-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-filetime+default-devel \
 rust-fluent+default-devel \
 rust-indicatif+default-devel \
 rust-libc+default-devel \
 rust-nix0.30+fs-devel \
 rust-nix0.30-devel \
 rust-thiserror+default-devel \
 rust-uucore+backup-control-devel \
 rust-uucore+buf-copy-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+fs-devel \
 rust-uucore+fsxattr-devel \
 rust-uucore+mode-devel \
 rust-uucore+parser-devel \
 rust-uucore+perms-devel \
 rust-uucore+update-control-devel \
 rust-walkdir+default-devel \
 "
