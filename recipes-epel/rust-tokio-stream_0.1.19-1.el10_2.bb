# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-stream"
PV = "0.1.19"
PR = "1.el10_2"
PACKAGES = " \
 rust-tokio-stream+default-devel \
 rust-tokio-stream+fs-devel \
 rust-tokio-stream+full-devel \
 rust-tokio-stream+io-util-devel \
 rust-tokio-stream+net-devel \
 rust-tokio-stream+rt-devel \
 rust-tokio-stream+signal-devel \
 rust-tokio-stream+sync-devel \
 rust-tokio-stream+time-devel \
 rust-tokio-stream+tokio-util-devel \
 rust-tokio-stream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-stream-0.1.19-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c777169de7f30cb5a4a81820647f62a3c65f1aac4706cbfb3b8277c4f8a062c"

URI_x86_64_v2_rust-tokio-stream+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+default-devel-0.1.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+default-devel.sha256sum] = "ef5be18408931f274ebda35a875e7bf981e6541a2ba7cb06b2b5061647a69806"

URI_x86_64_v2_rust-tokio-stream+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+fs-devel-0.1.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+fs-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+fs-devel.sha256sum] = "bf99e8c7939994fd12e640240d3f59145d565163a21825068ddb473c177c620e"

URI_x86_64_v2_rust-tokio-stream+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+full-devel-0.1.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+full-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+full-devel.sha256sum] = "0d1a4e4f8cdb0c1849104bd33d3899f2c7155512fcc4edada359cbbe5c5c9c66"

URI_x86_64_v2_rust-tokio-stream+io-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+io-util-devel-0.1.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+io-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+io-util-devel.sha256sum] = "1eece75834b19907b2777dcd3d9529a3d4417e1d6c94904c78421fc24615144c"

URI_x86_64_v2_rust-tokio-stream+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+net-devel-0.1.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+net-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+net-devel.sha256sum] = "c61e76565296ae034b2d119f14a65ce15cf2733e5f1875a69376b0cd99d0b20a"

URI_x86_64_v2_rust-tokio-stream+rt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+rt-devel-0.1.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+rt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+rt-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+rt-devel.sha256sum] = "5187f83a3277b2b2752f528b0ae2f494b62c5f1ff2d4bd9e49fcf0f82c4c68cc"

URI_x86_64_v2_rust-tokio-stream+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+signal-devel-0.1.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+signal-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+signal-devel.sha256sum] = "391e06d2abd4eee4d4ad6124c9d5013218ea786976c5de825b4c88d74ab3ad78"

URI_x86_64_v2_rust-tokio-stream+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+sync-devel-0.1.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+sync-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+sync-devel.sha256sum] = "e8d71b0574ead262b852e36b11b93f531b74e424ac816fa0df38455c296dd5a2"

URI_x86_64_v2_rust-tokio-stream+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+time-devel-0.1.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+time-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+time-devel.sha256sum] = "126bdb81f258c43796f91306b5e31026aabd5eca6822f8a0e98134f75a53f7a7"

URI_x86_64_v2_rust-tokio-stream+tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+tokio-util-devel-0.1.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+tokio-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+tokio-util-devel.sha256sum] = "f2946deac90ab3374c9c9d5d017e55cfe64042284eed698555e1ae404a80a4e6"

URI_x86_64_v2_rust-tokio-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream-devel-0.1.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream-devel.sha256sum] = "f1eacee4457327f9b88ed55a293bee0a644a08d88f88c31f53d0d508a0231a26"

URI_aarch64_rust-tokio-stream+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+default-devel-0.1.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+default-devel}"
SRC_URI[aarch64_rust-tokio-stream+default-devel.sha256sum] = "ac79bdce338fcf64cf098503bc50ea4801dcab4c143ee59da8cb847bcaeec62f"

URI_aarch64_rust-tokio-stream+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+fs-devel-0.1.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-stream+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+fs-devel}"
SRC_URI[aarch64_rust-tokio-stream+fs-devel.sha256sum] = "a1ee9a9275ab0d622cb0506b669cb66fda7b5aa629c905142c087c2886efd516"

URI_aarch64_rust-tokio-stream+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+full-devel-0.1.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-stream+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+full-devel}"
SRC_URI[aarch64_rust-tokio-stream+full-devel.sha256sum] = "a5804f24614379692f0e9255063acb279ab235f52ff46c5e15c2e7fc2890f343"

URI_aarch64_rust-tokio-stream+io-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+io-util-devel-0.1.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-stream+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+io-util-devel}"
SRC_URI[aarch64_rust-tokio-stream+io-util-devel.sha256sum] = "a3f461106bc20a63db2d287df55706b19faab2148fb49a5d8c886faa950eaaa7"

URI_aarch64_rust-tokio-stream+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+net-devel-0.1.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-stream+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+net-devel}"
SRC_URI[aarch64_rust-tokio-stream+net-devel.sha256sum] = "e5a139b99d1ae5faa24b7822510bc0eb86dad13d9bd6ea712b5b2a8e6f4cf74f"

URI_aarch64_rust-tokio-stream+rt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+rt-devel-0.1.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-stream+rt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+rt-devel}"
SRC_URI[aarch64_rust-tokio-stream+rt-devel.sha256sum] = "91fb8c6413a9333d2f9a9e2c31798edd3326c090f2f2fceffefa4e9d93786137"

URI_aarch64_rust-tokio-stream+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+signal-devel-0.1.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-stream+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+signal-devel}"
SRC_URI[aarch64_rust-tokio-stream+signal-devel.sha256sum] = "73e069b3926c2a12a424b8e43e6ca7b823d8f9870e896e6578f80bde07557991"

URI_aarch64_rust-tokio-stream+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+sync-devel-0.1.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-stream+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+sync-devel}"
SRC_URI[aarch64_rust-tokio-stream+sync-devel.sha256sum] = "51b18d3c034067edc5593678e755a446391453f0c72266a0f4f174b6b070bdd8"

URI_aarch64_rust-tokio-stream+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+time-devel-0.1.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-stream+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+time-devel}"
SRC_URI[aarch64_rust-tokio-stream+time-devel.sha256sum] = "3d3b5640d9fdb7f7216e4a099ab20544c1d0978e84d16c8642490aa03d676d6b"

URI_aarch64_rust-tokio-stream+tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+tokio-util-devel-0.1.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-stream+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+tokio-util-devel}"
SRC_URI[aarch64_rust-tokio-stream+tokio-util-devel.sha256sum] = "e2ba98dff9bee5ad829cbfa01fa4e908d6c8852867982fc7cee779b652e6ba25"

URI_aarch64_rust-tokio-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream-devel-0.1.19-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream-devel}"
SRC_URI[aarch64_rust-tokio-stream-devel.sha256sum] = "c0e2f70c6012a7c7cce58121e2474208a3d032a884a006bfd1da2b780922d841"

RDEPENDS:rust-tokio-stream+default-devel = " \
 cargo \
 rust-tokio-stream+time-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+fs-devel = " \
 cargo \
 rust-tokio+fs-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+full-devel = " \
 cargo \
 rust-tokio-stream+fs-devel \
 rust-tokio-stream+io-util-devel \
 rust-tokio-stream+net-devel \
 rust-tokio-stream+rt-devel \
 rust-tokio-stream+signal-devel \
 rust-tokio-stream+sync-devel \
 rust-tokio-stream+time-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+io-util-devel = " \
 cargo \
 rust-tokio+io-util-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+net-devel = " \
 cargo \
 rust-tokio+net-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+rt-devel = " \
 cargo \
 rust-tokio+rt-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+signal-devel = " \
 cargo \
 rust-tokio+signal-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+sync-devel = " \
 cargo \
 rust-tokio+sync-devel \
 rust-tokio-stream+tokio-util-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+time-devel = " \
 cargo \
 rust-tokio+time-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+tokio-util-devel = " \
 cargo \
 rust-tokio-stream-devel \
 rust-tokio-util+default-devel \
 "
RDEPENDS:rust-tokio-stream-devel = " \
 cargo \
 rust \
 rust-futures-core+default-devel \
 rust-pin-project-lite+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
