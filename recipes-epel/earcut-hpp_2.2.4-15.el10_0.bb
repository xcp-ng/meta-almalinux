# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "earcut-hpp"
PV = "2.2.4"
PR = "15.el10_0"
PACKAGES = " \
 earcut-hpp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/earcut-hpp-2.2.4-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "459837510ce633582b8dc11bcc0a897eed676be1e3c2ef4ebc979eef74a2d9ea"

URI_x86_64_v2_earcut-hpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/earcut-hpp-devel-2.2.4-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_earcut-hpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_earcut-hpp-devel}"
SRC_URI[x86_64_v2_earcut-hpp-devel.sha256sum] = "ef7a3a4b42a27a51052359cff9fd4c3aa797517c887bc3327f3fd9236a90f703"

URI_aarch64_earcut-hpp-devel = "${EPEL_MIRROR}/aarch64/Packages/e/earcut-hpp-devel-2.2.4-15.el10_0.noarch.rpm;name=aarch64_earcut-hpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_earcut-hpp-devel}"
SRC_URI[aarch64_earcut-hpp-devel.sha256sum] = "34b3df7a09885301ca1e704b7aad7b116d80adccfaba70c028ca0ed98e66f0b0"

RDEPENDS:earcut-hpp-devel = " \
 "
