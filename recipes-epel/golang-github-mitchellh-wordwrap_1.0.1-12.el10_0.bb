# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mitchellh-wordwrap"
PV = "1.0.1"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-mitchellh-wordwrap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mitchellh-wordwrap-1.0.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfbbde68ff68f4efc5b08cbe9c29ceb6dfd4aeff4057c510c06176be11b51fcd"

URI_x86_64_v2_golang-github-mitchellh-wordwrap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-mitchellh-wordwrap-devel-1.0.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-mitchellh-wordwrap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-mitchellh-wordwrap-devel}"
SRC_URI[x86_64_v2_golang-github-mitchellh-wordwrap-devel.sha256sum] = "d9419a7b5f5b3e2c6b71bd1d3a42629df09f02ca27bee93c0b4344445c2a5cbd"

URI_aarch64_golang-github-mitchellh-wordwrap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mitchellh-wordwrap-devel-1.0.1-12.el10_0.noarch.rpm;name=aarch64_golang-github-mitchellh-wordwrap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mitchellh-wordwrap-devel}"
SRC_URI[aarch64_golang-github-mitchellh-wordwrap-devel.sha256sum] = "b75a47a6f97e3f14b18721b22b4883dd920f67d1da9aeecc33b2a83c1e40f478"

RDEPENDS:golang-github-mitchellh-wordwrap-devel = " \
 go-filesystem \
 "
