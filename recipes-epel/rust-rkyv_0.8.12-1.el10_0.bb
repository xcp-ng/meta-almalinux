# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rkyv"
PV = "0.8.12"
PR = "1.el10_0"
PACKAGES = " \
 rust-rkyv+aligned-devel \
 rust-rkyv+alloc-devel \
 rust-rkyv+big_endian-devel \
 rust-rkyv+bytecheck-devel \
 rust-rkyv+default-devel \
 rust-rkyv+little_endian-devel \
 rust-rkyv+pointer_width_16-devel \
 rust-rkyv+pointer_width_32-devel \
 rust-rkyv+pointer_width_64-devel \
 rust-rkyv+smallvec-1-devel \
 rust-rkyv+std-devel \
 rust-rkyv+unaligned-devel \
 rust-rkyv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rkyv-0.8.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39d9aa44eb62dd1c0a1cb2036f1b7cd2bc1b61181f65c88ec7a1914ec62a5a8c"

URI_x86_64_v2_rust-rkyv+aligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+aligned-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+aligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+aligned-devel}"
SRC_URI[x86_64_v2_rust-rkyv+aligned-devel.sha256sum] = "0aef5f5bb37e2fc86c6a11ffb501427a655aaeb4fa0ee287405f909da5c934bc"

URI_x86_64_v2_rust-rkyv+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+alloc-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+alloc-devel}"
SRC_URI[x86_64_v2_rust-rkyv+alloc-devel.sha256sum] = "607b9dc3abcf7dd56683b0adefef27860df2816497bac21d57f5abb849c3c2f5"

URI_x86_64_v2_rust-rkyv+big_endian-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+big_endian-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+big_endian-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+big_endian-devel}"
SRC_URI[x86_64_v2_rust-rkyv+big_endian-devel.sha256sum] = "0b305f0c697d86bad0db799e8cd490a0c6cd07591016012d5405f10f1ea20a53"

URI_x86_64_v2_rust-rkyv+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+bytecheck-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rkyv+bytecheck-devel.sha256sum] = "4154e12125f9ba9b2745e2a58a01171e7c1deaaacdff7df97e91de3b27b66621"

URI_x86_64_v2_rust-rkyv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+default-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+default-devel}"
SRC_URI[x86_64_v2_rust-rkyv+default-devel.sha256sum] = "4067470a366db32102a8482c7e638159f66228d5afeda654c36cbdb1cf9ac9ce"

URI_x86_64_v2_rust-rkyv+little_endian-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+little_endian-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+little_endian-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+little_endian-devel}"
SRC_URI[x86_64_v2_rust-rkyv+little_endian-devel.sha256sum] = "2b52d1c05cf886c0fe3c0ca419f2238808355c8d051310f4d2e04dec1d974966"

URI_x86_64_v2_rust-rkyv+pointer_width_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+pointer_width_16-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+pointer_width_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+pointer_width_16-devel}"
SRC_URI[x86_64_v2_rust-rkyv+pointer_width_16-devel.sha256sum] = "d2ae36470355ad2a47b04efd652c0f4c48bd0239052856efeee808427985cf02"

URI_x86_64_v2_rust-rkyv+pointer_width_32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+pointer_width_32-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+pointer_width_32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+pointer_width_32-devel}"
SRC_URI[x86_64_v2_rust-rkyv+pointer_width_32-devel.sha256sum] = "fafbdd58be69369d6bada89c8f9a76d6167efbfa1669e88bc5ef74007cab8c15"

URI_x86_64_v2_rust-rkyv+pointer_width_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+pointer_width_64-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+pointer_width_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+pointer_width_64-devel}"
SRC_URI[x86_64_v2_rust-rkyv+pointer_width_64-devel.sha256sum] = "916b386e138d1c2aa0a5b01755043b3e1a4fe34ee2de861d86307f85ae699fc7"

URI_x86_64_v2_rust-rkyv+smallvec-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+smallvec-1-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+smallvec-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+smallvec-1-devel}"
SRC_URI[x86_64_v2_rust-rkyv+smallvec-1-devel.sha256sum] = "b752785bb06bb65bda9db35cf9e091380ee185b8d61c39b145e2f3a6f059f452"

URI_x86_64_v2_rust-rkyv+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+std-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+std-devel}"
SRC_URI[x86_64_v2_rust-rkyv+std-devel.sha256sum] = "2821e218cb6b08198022844e55114426431720e6d7eed5463fd60f2f54e4f222"

URI_x86_64_v2_rust-rkyv+unaligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+unaligned-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+unaligned-devel}"
SRC_URI[x86_64_v2_rust-rkyv+unaligned-devel.sha256sum] = "f440834d88e986ea8720e58e5908aae9d31346e8e6b0f4a395e3491b765126df"

URI_x86_64_v2_rust-rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv-devel}"
SRC_URI[x86_64_v2_rust-rkyv-devel.sha256sum] = "6c59f5f33482d294dbb7b3ec4fb682ee03178fc46fa4b32e0008516e84a4f88b"

URI_aarch64_rust-rkyv+aligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+aligned-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv+aligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+aligned-devel}"
SRC_URI[aarch64_rust-rkyv+aligned-devel.sha256sum] = "3d7db4a8911fb9a6991fa01eb28cb211dcf57f4441851af2a23ba8af2f9220d9"

URI_aarch64_rust-rkyv+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+alloc-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+alloc-devel}"
SRC_URI[aarch64_rust-rkyv+alloc-devel.sha256sum] = "21e6f2d9558e602ea46da5f316d747bad8d0b59a65506969f91042acaac35a4b"

URI_aarch64_rust-rkyv+big_endian-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+big_endian-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv+big_endian-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+big_endian-devel}"
SRC_URI[aarch64_rust-rkyv+big_endian-devel.sha256sum] = "f3a9be233571ec2708f1da7cec105b38e95cf3d6e03b8d025928e2c3216f77a7"

URI_aarch64_rust-rkyv+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+bytecheck-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+bytecheck-devel}"
SRC_URI[aarch64_rust-rkyv+bytecheck-devel.sha256sum] = "99ca4293d1a21da5fb19b074823fdbc0ecdf9af552af72b8e3fc1c69758a655a"

URI_aarch64_rust-rkyv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+default-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+default-devel}"
SRC_URI[aarch64_rust-rkyv+default-devel.sha256sum] = "fd4fb2085d2a7fd425cb0538bafb497126a0bd3562947fc5c47788aaab44e466"

URI_aarch64_rust-rkyv+little_endian-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+little_endian-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv+little_endian-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+little_endian-devel}"
SRC_URI[aarch64_rust-rkyv+little_endian-devel.sha256sum] = "9dfcfb3e76861e2d4293f397ddb7f4920d7719fd495d51999500008f875a5b9f"

URI_aarch64_rust-rkyv+pointer_width_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+pointer_width_16-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv+pointer_width_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+pointer_width_16-devel}"
SRC_URI[aarch64_rust-rkyv+pointer_width_16-devel.sha256sum] = "5236e1f7d45e80fb961388eb3ab5e6a55e4baa4b1ba059cc2a7d3fa55d9f1266"

URI_aarch64_rust-rkyv+pointer_width_32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+pointer_width_32-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv+pointer_width_32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+pointer_width_32-devel}"
SRC_URI[aarch64_rust-rkyv+pointer_width_32-devel.sha256sum] = "28e86e4b2d7b9ffeb061dcd7a49a47341e6f7246779aff4f2c412df3413f87d4"

URI_aarch64_rust-rkyv+pointer_width_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+pointer_width_64-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv+pointer_width_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+pointer_width_64-devel}"
SRC_URI[aarch64_rust-rkyv+pointer_width_64-devel.sha256sum] = "0b1f9bb5b2c268c9d841bd63cceaf44a07d5e3bd175e64f257ea48bf9b78af04"

URI_aarch64_rust-rkyv+smallvec-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+smallvec-1-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv+smallvec-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+smallvec-1-devel}"
SRC_URI[aarch64_rust-rkyv+smallvec-1-devel.sha256sum] = "17db3024e322e661ecb28ea85f58ddf6322a025d12301c9bd2e81f6e5b039d16"

URI_aarch64_rust-rkyv+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+std-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+std-devel}"
SRC_URI[aarch64_rust-rkyv+std-devel.sha256sum] = "e2b657d9902db3faf2cc7fef5e7842e7c28ec4c8bea4e237b6a7d4609f72f3c0"

URI_aarch64_rust-rkyv+unaligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+unaligned-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+unaligned-devel}"
SRC_URI[aarch64_rust-rkyv+unaligned-devel.sha256sum] = "ec53d6745fcb8ad0f16bd7dd333e6551ead7d690d27d4bd169b46353a5699d8e"

URI_aarch64_rust-rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv-devel}"
SRC_URI[aarch64_rust-rkyv-devel.sha256sum] = "c9aad38052a27892c34116c52f46bd4cced55b754dcece55ffc3117f1b5a4d12"

RDEPENDS:rust-rkyv+aligned-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+alloc-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-rancor+alloc-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+big_endian-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+bytecheck-devel = " \
 cargo \
 rust-bytecheck+simdutf8-devel \
 rust-bytecheck-devel \
 rust-rend+bytecheck-devel \
 rust-rkyv-devel \
 rust-rkyv_derive+bytecheck-devel \
 "
RDEPENDS:rust-rkyv+default-devel = " \
 cargo \
 rust-rkyv+bytecheck-devel \
 rust-rkyv+std-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+little_endian-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+pointer_width_16-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+pointer_width_32-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+pointer_width_64-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+smallvec-1-devel = " \
 cargo \
 rust-rkyv-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-rkyv+std-devel = " \
 cargo \
 rust-ptr_meta+std-devel \
 rust-rkyv+alloc-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+unaligned-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv-devel = " \
 cargo \
 rust \
 rust-munge-devel \
 rust-ptr_meta-devel \
 rust-rancor-devel \
 rust-rend-devel \
 rust-rkyv_derive-devel \
 "
