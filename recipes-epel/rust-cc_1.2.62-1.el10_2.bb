# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cc"
PV = "1.2.62"
PR = "1.el10_2"
PACKAGES = " \
 rust-cc+default-devel \
 rust-cc+jobserver-devel \
 rust-cc+parallel-devel \
 rust-cc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cc-1.2.62-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0179759ce0935a90ffbb2b887c7c6078637bb199e9a78b3658e3a52ad0546a7a"

URI_x86_64_v2_rust-cc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc+default-devel-1.2.62-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc+default-devel}"
SRC_URI[x86_64_v2_rust-cc+default-devel.sha256sum] = "62fdb20388fb44d77197d1d92373654b5fb6f461aeac5b5be146f609cbe46903"

URI_x86_64_v2_rust-cc+jobserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc+jobserver-devel-1.2.62-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc+jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc+jobserver-devel}"
SRC_URI[x86_64_v2_rust-cc+jobserver-devel.sha256sum] = "38d0fb4de0c1a0638dab8e43bb15ce44d1d6a612281bf8697b7fc3025b3729cb"

URI_x86_64_v2_rust-cc+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc+parallel-devel-1.2.62-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc+parallel-devel}"
SRC_URI[x86_64_v2_rust-cc+parallel-devel.sha256sum] = "85deef788610f2d64acb669d3d528de6ddd002a0f2fff0b9ec7edc5d52614212"

URI_x86_64_v2_rust-cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc-devel-1.2.62-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc-devel}"
SRC_URI[x86_64_v2_rust-cc-devel.sha256sum] = "abc29789c633c542f42b22ed430f4190decadc96adda437ce3ca2f982429d3ac"

URI_aarch64_rust-cc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc+default-devel-1.2.62-1.el10_2.noarch.rpm;name=aarch64_rust-cc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc+default-devel}"
SRC_URI[aarch64_rust-cc+default-devel.sha256sum] = "32043d86b4a93cca6d259c2862d2d4c4e3faf73f783d7dbd27f8a6ed32e2cad4"

URI_aarch64_rust-cc+jobserver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc+jobserver-devel-1.2.62-1.el10_2.noarch.rpm;name=aarch64_rust-cc+jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc+jobserver-devel}"
SRC_URI[aarch64_rust-cc+jobserver-devel.sha256sum] = "421c6d2d5a55b56a1098e75d8e846e23a08db6057c7f6598525c36846f1a8057"

URI_aarch64_rust-cc+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc+parallel-devel-1.2.62-1.el10_2.noarch.rpm;name=aarch64_rust-cc+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc+parallel-devel}"
SRC_URI[aarch64_rust-cc+parallel-devel.sha256sum] = "e906d88364022cf2816cf496cf0d5ecd3a88ab19cade962c27ff477338de0f5f"

URI_aarch64_rust-cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc-devel-1.2.62-1.el10_2.noarch.rpm;name=aarch64_rust-cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc-devel}"
SRC_URI[aarch64_rust-cc-devel.sha256sum] = "9b10dfbd9643e698d0d1266b014439a7ec0f80ea3ff7ff94b6bb3f1a6fec3ec1"

RDEPENDS:rust-cc+default-devel = " \
 cargo \
 rust-cc-devel \
 "
RDEPENDS:rust-cc+jobserver-devel = " \
 cargo \
 rust-cc-devel \
 "
RDEPENDS:rust-cc+parallel-devel = " \
 cargo \
 rust-cc-devel \
 rust-jobserver-devel \
 rust-libc-devel \
 "
RDEPENDS:rust-cc-devel = " \
 cargo \
 gcc \
 gcc-c++ \
 rust \
 rust-find-msvc-tools+default-devel \
 rust-shlex+default-devel \
 "
