# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "catatonit"
PE = "5"
PV = "0.2.1"
PR = "1.el10"
PACKAGES = " \
 catatonit \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/catatonit-0.2.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09e7a8da8440d12ed104f701006761469158254d29e18065b015cfe3e02b402a"

URI_x86_64_v2_catatonit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/catatonit-0.2.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_catatonit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_catatonit}"
SRC_URI[x86_64_v2_catatonit.sha256sum] = "19ab0ad8da3e231b7bb36f553c42eb4e529832b3a45fec6b00ca5aa989925399"

URI_aarch64_catatonit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/catatonit-0.2.1-1.el10.aarch64.rpm;name=aarch64_catatonit;unpack=0"
SRC_URI:append = " ${URI_aarch64_catatonit}"
SRC_URI[aarch64_catatonit.sha256sum] = "c1bb47ecba3b313e8787e2090ecd823f18ce7c29065e85c5fd05204914d46765"

RDEPENDS:catatonit = " \
 "
