# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-config"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-below-config+default-devel \
 rust-below-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-config-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81d081ee17aad8410d348a21c21c86a65aa5ed26019653cf83102fd4c39b5662"

URI_x86_64_v2_rust-below-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-config+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-config+default-devel}"
SRC_URI[x86_64_v2_rust-below-config+default-devel.sha256sum] = "aed446b75f71b052bb9cf0de21775eb1980b99e110748864a7ceaff8b9f8af56"

URI_x86_64_v2_rust-below-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-config-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-config-devel}"
SRC_URI[x86_64_v2_rust-below-config-devel.sha256sum] = "c0a2889b4c6e19fc8a43dc7b4e23c48932be98e6e2047774435a62cc4b202a15"

URI_aarch64_rust-below-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-config+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-config+default-devel}"
SRC_URI[aarch64_rust-below-config+default-devel.sha256sum] = "3f9a5927e9f477338b02b7517ef1b3b8e03603987d028a32fdd615754d537afa"

URI_aarch64_rust-below-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-config-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-config-devel}"
SRC_URI[aarch64_rust-below-config-devel.sha256sum] = "ed1e4cec26f11553b90b0f41fac4b6ae45173271f5f978bdca950ff654ccd6fd"

RDEPENDS:rust-below-config+default-devel = " \
 cargo \
 rust-below-config-devel \
 "
RDEPENDS:rust-below-config-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-below-btrfs+default-devel \
 rust-cgroupfs+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-toml+default-devel \
 "
