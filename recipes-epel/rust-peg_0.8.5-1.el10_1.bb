# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-peg"
PV = "0.8.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-peg+default-devel \
 rust-peg+std-devel \
 rust-peg+trace-devel \
 rust-peg+unstable-devel \
 rust-peg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-peg-0.8.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2650ececd7889f3b5aac39c54c68dffc3f6664eb720f8716c80f6a0bcfd985b4"

URI_x86_64_v2_rust-peg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg+default-devel-0.8.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg+default-devel}"
SRC_URI[x86_64_v2_rust-peg+default-devel.sha256sum] = "752f588dfb8895b7ea700873344944de6e9115f208d2322623e3be8191504a62"

URI_x86_64_v2_rust-peg+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg+std-devel-0.8.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg+std-devel}"
SRC_URI[x86_64_v2_rust-peg+std-devel.sha256sum] = "5731019d054f1e8c54099599abd6bfe958fdc8ee5853d11fec7bdce6dcdf7406"

URI_x86_64_v2_rust-peg+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg+trace-devel-0.8.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg+trace-devel}"
SRC_URI[x86_64_v2_rust-peg+trace-devel.sha256sum] = "92bd17c9ff35266ec58c5e142e1ab08e8d9104a109deac2cb87a527b15a14c7d"

URI_x86_64_v2_rust-peg+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg+unstable-devel-0.8.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg+unstable-devel}"
SRC_URI[x86_64_v2_rust-peg+unstable-devel.sha256sum] = "af24d0007b610f9261bbb9e1bb292a3f86c64e32e3f611dc7af1d6f472db1c25"

URI_x86_64_v2_rust-peg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-devel-0.8.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-devel}"
SRC_URI[x86_64_v2_rust-peg-devel.sha256sum] = "f10b9b663c7e6dbec536350823eccf793dec5d73c1ce4317b497f1ede5829c28"

URI_aarch64_rust-peg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg+default-devel-0.8.5-1.el10_1.noarch.rpm;name=aarch64_rust-peg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg+default-devel}"
SRC_URI[aarch64_rust-peg+default-devel.sha256sum] = "0cf7d57d5c49dfe10a97680aaf9e7fb2b37b6d8bf3324682470bde6091279b66"

URI_aarch64_rust-peg+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg+std-devel-0.8.5-1.el10_1.noarch.rpm;name=aarch64_rust-peg+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg+std-devel}"
SRC_URI[aarch64_rust-peg+std-devel.sha256sum] = "6e34c390827189c69b7a7edd94479fd64bfa269988a2890a1f90c6d55f12b2ee"

URI_aarch64_rust-peg+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg+trace-devel-0.8.5-1.el10_1.noarch.rpm;name=aarch64_rust-peg+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg+trace-devel}"
SRC_URI[aarch64_rust-peg+trace-devel.sha256sum] = "9930965a0bd14dd1e5ce0949d5b63059c283f3fe223eb0130c7fbae35462894f"

URI_aarch64_rust-peg+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg+unstable-devel-0.8.5-1.el10_1.noarch.rpm;name=aarch64_rust-peg+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg+unstable-devel}"
SRC_URI[aarch64_rust-peg+unstable-devel.sha256sum] = "3f9fb8d5ff5ecb136fe5b4282536fd1d654304c686722fbe5faf1d750bb25c13"

URI_aarch64_rust-peg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-devel-0.8.5-1.el10_1.noarch.rpm;name=aarch64_rust-peg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-devel}"
SRC_URI[aarch64_rust-peg-devel.sha256sum] = "279f1e30fea89b8469164dc1ce419299e06e0d9cb020d41666c8de34582bdca2"

RDEPENDS:rust-peg+default-devel = " \
 cargo \
 rust-peg+std-devel \
 rust-peg-devel \
 "
RDEPENDS:rust-peg+std-devel = " \
 cargo \
 rust-peg-devel \
 rust-peg-runtime+std-devel \
 "
RDEPENDS:rust-peg+trace-devel = " \
 cargo \
 rust-peg-devel \
 rust-peg-macros+trace-devel \
 "
RDEPENDS:rust-peg+unstable-devel = " \
 cargo \
 rust-peg-devel \
 rust-peg-runtime+unstable-devel \
 "
RDEPENDS:rust-peg-devel = " \
 bash \
 cargo \
 rust \
 rust-peg-macros+default-devel \
 rust-peg-runtime+default-devel \
 "
