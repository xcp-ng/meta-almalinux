# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam_yubico"
PV = "2.27"
PR = "7.el10_0"
PACKAGES = " \
 pam_yubico \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam_yubico-2.27-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6381321e08ac5a236f27575638db2cc40ce641445b4dcedb36db10daf6f7c627"

URI_x86_64_v2_pam_yubico = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_yubico-2.27-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_yubico;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_yubico}"
SRC_URI[x86_64_v2_pam_yubico.sha256sum] = "0af24d36f8bf934232856dc6824a6e4186f7732bbed3118788e398b98656190a"

URI_aarch64_pam_yubico = "${EPEL_MIRROR}/aarch64/Packages/p/pam_yubico-2.27-7.el10_0.aarch64.rpm;name=aarch64_pam_yubico;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_yubico}"
SRC_URI[aarch64_pam_yubico.sha256sum] = "7e2fc553c3f009901780a87d0f1683476ba30b91d018997e272316500daa1fb4"

RDEPENDS:pam_yubico = " \
 glibc \
 libyubikey \
 openldap \
 pam \
 pam-libs \
 ykclient \
 ykpers \
 "
