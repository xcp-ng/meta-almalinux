# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Linux-Inotify2"
PV = "2.3"
PR = "11.el10_0"
PACKAGES = " \
 perl-Linux-Inotify2 \
 perl-Linux-Inotify2-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Linux-Inotify2-2.3-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a9fc3be8b4464ee1fa1905747ad7e75ab0a1cd7adc4833a04cbbec06c09221d"

URI_x86_64_v2_perl-Linux-Inotify2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Linux-Inotify2-2.3-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Linux-Inotify2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Linux-Inotify2}"
SRC_URI[x86_64_v2_perl-Linux-Inotify2.sha256sum] = "eac0e52bc742bc5adfd5d812116804862e31ceab5c8f40a6becca633752e962d"

URI_x86_64_v2_perl-Linux-Inotify2-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Linux-Inotify2-tests-2.3-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Linux-Inotify2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Linux-Inotify2-tests}"
SRC_URI[x86_64_v2_perl-Linux-Inotify2-tests.sha256sum] = "49c6fe9d6e0e6864a9fbfff603f8cf71504ecb5f08a72e8b72438b15a8d93826"

URI_aarch64_perl-Linux-Inotify2 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Linux-Inotify2-2.3-11.el10_0.aarch64.rpm;name=aarch64_perl-Linux-Inotify2;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Linux-Inotify2}"
SRC_URI[aarch64_perl-Linux-Inotify2.sha256sum] = "22b4a4c622f482e3bc11043b3dfee68287ebd5fba3d02a726ea88d9447f783be"

URI_aarch64_perl-Linux-Inotify2-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Linux-Inotify2-tests-2.3-11.el10_0.aarch64.rpm;name=aarch64_perl-Linux-Inotify2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Linux-Inotify2-tests}"
SRC_URI[aarch64_perl-Linux-Inotify2-tests.sha256sum] = "b7071dec0ed4f592eaebbe9bd0121b9e1a9f99743cd448f77ac064b46419bfbe"

RDEPENDS:perl-Linux-Inotify2 = " \
 glibc \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-common-sense \
 perl-libs \
 "
RDEPENDS:perl-Linux-Inotify2-tests = " \
 bash \
 perl-File-Temp \
 perl-Linux-Inotify2 \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 "
