# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcerf"
PV = "2.4"
PR = "2.el10_0"
PACKAGES = " \
 libcerf \
 libcerf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcerf-2.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7272f0bd8149c72e874c7b15fcb2e9126693d8dc6c17f8762c4286a9d9f3174b"

URI_x86_64_v2_libcerf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcerf-2.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcerf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcerf}"
SRC_URI[x86_64_v2_libcerf.sha256sum] = "3952ffba32259fd8759b459e81ca4e2469a8dca97a9c802231a6d1e9e5d9dfcc"

URI_x86_64_v2_libcerf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcerf-devel-2.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcerf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcerf-devel}"
SRC_URI[x86_64_v2_libcerf-devel.sha256sum] = "5337027c88bd400e1e96056a2ee2b617dc24a6509284d7861aacc4579dadcc26"

URI_aarch64_libcerf = "${EPEL_MIRROR}/aarch64/Packages/l/libcerf-2.4-2.el10_0.aarch64.rpm;name=aarch64_libcerf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcerf}"
SRC_URI[aarch64_libcerf.sha256sum] = "aa9986c05d49268cf6954fb6787c1b46d02a56f873de4dcb862efef7f025eb66"

URI_aarch64_libcerf-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcerf-devel-2.4-2.el10_0.aarch64.rpm;name=aarch64_libcerf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcerf-devel}"
SRC_URI[aarch64_libcerf-devel.sha256sum] = "fa59144291fd962916fb593a6978390f11006f7dbfe37225678970cf3629faad"

RDEPENDS:libcerf = " \
 glibc \
 "
RDEPENDS:libcerf-devel = " \
 cmake-filesystem \
 libcerf \
 pkgconf-pkg-config \
 "
