# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bstr"
PV = "1.13.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-bstr+alloc-devel \
 rust-bstr+default-devel \
 rust-bstr+serde-devel \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bstr-1.13.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7740be334f2c07b7d3151b981f8fbe1811b45e8a3d8ad12158d92f18f9a490c5"

URI_x86_64_v2_rust-bstr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+alloc-devel-1.13.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+alloc-devel}"
SRC_URI[x86_64_v2_rust-bstr+alloc-devel.sha256sum] = "a4f8ed4b48d4ff847698d0b1980cc9da42e6cf35dc2bf27da29768cb7190f0e4"

URI_x86_64_v2_rust-bstr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+default-devel-1.13.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+default-devel}"
SRC_URI[x86_64_v2_rust-bstr+default-devel.sha256sum] = "ebe07d6d98d869d46b2f42eec6edce37fad549264b908e747daceca12ec7362f"

URI_x86_64_v2_rust-bstr+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+serde-devel-1.13.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+serde-devel}"
SRC_URI[x86_64_v2_rust-bstr+serde-devel.sha256sum] = "3f87eb4339a9e03d6c4bcc81b3ac1dc7d64802c55777ac597e6f4109f7746dbf"

URI_x86_64_v2_rust-bstr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+std-devel-1.13.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+std-devel}"
SRC_URI[x86_64_v2_rust-bstr+std-devel.sha256sum] = "d8a1abf365345e7883b4e58f3996d04c8a10cdc70cc947b357283d0e6ace622f"

URI_x86_64_v2_rust-bstr+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+unicode-devel-1.13.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+unicode-devel}"
SRC_URI[x86_64_v2_rust-bstr+unicode-devel.sha256sum] = "d1392c7e1ce09eb22f174c6cd1dc042b94989b53032b1e4cfbaed543522dbade"

URI_x86_64_v2_rust-bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr-devel-1.13.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr-devel}"
SRC_URI[x86_64_v2_rust-bstr-devel.sha256sum] = "7ae21b7a733715d6f00fb21f40133eb3b05df8d7dea3c1cdc687a970cb268b7e"

URI_aarch64_rust-bstr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+alloc-devel-1.13.0-1.el10_2.noarch.rpm;name=aarch64_rust-bstr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+alloc-devel}"
SRC_URI[aarch64_rust-bstr+alloc-devel.sha256sum] = "e52cb8290de0614a2c320f2a8d76b906a2ce2b1ce9ffdaf9e3cb403681a4ab74"

URI_aarch64_rust-bstr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+default-devel-1.13.0-1.el10_2.noarch.rpm;name=aarch64_rust-bstr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+default-devel}"
SRC_URI[aarch64_rust-bstr+default-devel.sha256sum] = "395fe8b5bfda93861d6f2a9132cea01c14a17ceba3ebc910a94ae647d493da32"

URI_aarch64_rust-bstr+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+serde-devel-1.13.0-1.el10_2.noarch.rpm;name=aarch64_rust-bstr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+serde-devel}"
SRC_URI[aarch64_rust-bstr+serde-devel.sha256sum] = "aeb94f7588a5f76085f1d580ddd50d59a7e50501ac6c6a3c32d530555c166dc0"

URI_aarch64_rust-bstr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+std-devel-1.13.0-1.el10_2.noarch.rpm;name=aarch64_rust-bstr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+std-devel}"
SRC_URI[aarch64_rust-bstr+std-devel.sha256sum] = "db34d7b8271819d37c4fa8785a5f1d13f76fb7b4d17bb614cfe62aa3fdb03ffa"

URI_aarch64_rust-bstr+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+unicode-devel-1.13.0-1.el10_2.noarch.rpm;name=aarch64_rust-bstr+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+unicode-devel}"
SRC_URI[aarch64_rust-bstr+unicode-devel.sha256sum] = "e964f06beddc7a20c9c3a8dfa90a3e3734b40f4ac7f600818a47da4a30765c1d"

URI_aarch64_rust-bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr-devel-1.13.0-1.el10_2.noarch.rpm;name=aarch64_rust-bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr-devel}"
SRC_URI[aarch64_rust-bstr-devel.sha256sum] = "7d3a340d09c7501a769fe293139ec93eb53182091826fc51de260def75d8f011"

RDEPENDS:rust-bstr+alloc-devel = " \
 cargo \
 rust-bstr-devel \
 rust-memchr+alloc-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bstr+default-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 "
RDEPENDS:rust-bstr+serde-devel = " \
 cargo \
 rust-bstr-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bstr+std-devel = " \
 cargo \
 rust-bstr+alloc-devel \
 rust-bstr-devel \
 rust-memchr+std-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bstr+unicode-devel = " \
 cargo \
 rust-bstr-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-bstr-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "
