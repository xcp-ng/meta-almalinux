# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-groupcache"
PV = "0"
PR = "0.35.20210729git41bb18b.el10_0"
PACKAGES = " \
 golang-github-groupcache-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-groupcache-0-0.35.20210729git41bb18b.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf518dca7dc4998be2a4bb3bbf9fb58b29f2a8f0e0b84aeda2d3a987ac7e4b00"

URI_aarch64_golang-github-groupcache-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-groupcache-devel-0-0.35.20210729git41bb18b.el10_0.noarch.rpm;name=aarch64_golang-github-groupcache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-groupcache-devel}"
SRC_URI[aarch64_golang-github-groupcache-devel.sha256sum] = "0a978970898bc6244cdf2faed397690082732149b81aa6ec1eb75f7e64edbd92"

RDEPENDS:golang-github-groupcache-devel = " \
 go-filesystem \
 golang-github-protobuf-devel \
 "
