# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ropey"
PV = "1.6.1"
PR = "5.el10_1"
PACKAGES = " \
 rust-ropey+cr_lines-devel \
 rust-ropey+default-devel \
 rust-ropey+simd-devel \
 rust-ropey+small_chunks-devel \
 rust-ropey+unicode_lines-devel \
 rust-ropey-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ropey-1.6.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6e8ec80e2d03b500bde2f282bc709d83c7745aeb3349b3631fe7dd0f67a053f"

URI_x86_64_v2_rust-ropey+cr_lines-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ropey+cr_lines-devel-1.6.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ropey+cr_lines-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ropey+cr_lines-devel}"
SRC_URI[x86_64_v2_rust-ropey+cr_lines-devel.sha256sum] = "b5fa15211160c084d462678cb84e0ded11fc1e9d65d4286cc06a0a16763c267c"

URI_x86_64_v2_rust-ropey+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ropey+default-devel-1.6.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ropey+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ropey+default-devel}"
SRC_URI[x86_64_v2_rust-ropey+default-devel.sha256sum] = "5ee721a10f383ef2c03928a3df19fb128cd861e36feec07a9f73620e57c766f2"

URI_x86_64_v2_rust-ropey+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ropey+simd-devel-1.6.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ropey+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ropey+simd-devel}"
SRC_URI[x86_64_v2_rust-ropey+simd-devel.sha256sum] = "ac7238f3a6ffad13b5e210feca64b01bc3771e737cdd62f92225f5755ab5ce8a"

URI_x86_64_v2_rust-ropey+small_chunks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ropey+small_chunks-devel-1.6.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ropey+small_chunks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ropey+small_chunks-devel}"
SRC_URI[x86_64_v2_rust-ropey+small_chunks-devel.sha256sum] = "533dc364bddcdc6d6343fcf820d9d6aab0e67e413ef7905521d43065409252ff"

URI_x86_64_v2_rust-ropey+unicode_lines-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ropey+unicode_lines-devel-1.6.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ropey+unicode_lines-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ropey+unicode_lines-devel}"
SRC_URI[x86_64_v2_rust-ropey+unicode_lines-devel.sha256sum] = "b07ffb9770753d54bf07ce0fe67369d27535a0983d4874be0d6ef7887a3d7b07"

URI_x86_64_v2_rust-ropey-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ropey-devel-1.6.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ropey-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ropey-devel}"
SRC_URI[x86_64_v2_rust-ropey-devel.sha256sum] = "986846f948ba1cad40d795499b66efe755aad2d12e41ea0a06e72063410b4508"

URI_aarch64_rust-ropey+cr_lines-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ropey+cr_lines-devel-1.6.1-5.el10_1.noarch.rpm;name=aarch64_rust-ropey+cr_lines-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ropey+cr_lines-devel}"
SRC_URI[aarch64_rust-ropey+cr_lines-devel.sha256sum] = "f9a9132288746baa809c8ef325a41e17e781079039516ed5a10fca1b5428a29b"

URI_aarch64_rust-ropey+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ropey+default-devel-1.6.1-5.el10_1.noarch.rpm;name=aarch64_rust-ropey+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ropey+default-devel}"
SRC_URI[aarch64_rust-ropey+default-devel.sha256sum] = "0b4e6c568d4d6dc28b00b7c1df0767029f762c3be7b81fadcf720f0bea8f774e"

URI_aarch64_rust-ropey+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ropey+simd-devel-1.6.1-5.el10_1.noarch.rpm;name=aarch64_rust-ropey+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ropey+simd-devel}"
SRC_URI[aarch64_rust-ropey+simd-devel.sha256sum] = "e59e96cff4971bc088915915af6569c2b009b33bd1cca3413562003f14b2ffb1"

URI_aarch64_rust-ropey+small_chunks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ropey+small_chunks-devel-1.6.1-5.el10_1.noarch.rpm;name=aarch64_rust-ropey+small_chunks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ropey+small_chunks-devel}"
SRC_URI[aarch64_rust-ropey+small_chunks-devel.sha256sum] = "f0f17d414fa1e3b3ac8751d4a37d0cbae0054eba7e03b775363a913c3b9cc6f9"

URI_aarch64_rust-ropey+unicode_lines-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ropey+unicode_lines-devel-1.6.1-5.el10_1.noarch.rpm;name=aarch64_rust-ropey+unicode_lines-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ropey+unicode_lines-devel}"
SRC_URI[aarch64_rust-ropey+unicode_lines-devel.sha256sum] = "86ad34d363340d9436e1c2e65a352599f1591cfd2ca0597477399523bc94047f"

URI_aarch64_rust-ropey-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ropey-devel-1.6.1-5.el10_1.noarch.rpm;name=aarch64_rust-ropey-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ropey-devel}"
SRC_URI[aarch64_rust-ropey-devel.sha256sum] = "47afd7fbab578d4f1e34e4854fe0fed74a98505b1ef76fe07058aa971d349d88"

RDEPENDS:rust-ropey+cr_lines-devel = " \
 cargo \
 rust-ropey-devel \
 "
RDEPENDS:rust-ropey+default-devel = " \
 cargo \
 rust-ropey+simd-devel \
 rust-ropey+unicode_lines-devel \
 rust-ropey-devel \
 "
RDEPENDS:rust-ropey+simd-devel = " \
 cargo \
 rust-ropey-devel \
 rust-str_indices+simd-devel \
 "
RDEPENDS:rust-ropey+small_chunks-devel = " \
 cargo \
 rust-ropey-devel \
 "
RDEPENDS:rust-ropey+unicode_lines-devel = " \
 cargo \
 rust-ropey+cr_lines-devel \
 rust-ropey-devel \
 "
RDEPENDS:rust-ropey-devel = " \
 cargo \
 rust-smallvec+default-devel \
 rust-str_indices-devel \
 "
