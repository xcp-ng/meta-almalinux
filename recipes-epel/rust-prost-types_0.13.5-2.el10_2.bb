# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prost-types"
PV = "0.13.5"
PR = "2.el10_2"
PACKAGES = " \
 rust-prost-types+arbitrary-devel \
 rust-prost-types+default-devel \
 rust-prost-types+std-devel \
 rust-prost-types-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-prost-types-0.13.5-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d351530c63d51a7cf016df4d1797e6825b43de2613c0c213f897e949b53865a"

URI_x86_64_v2_rust-prost-types+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-types+arbitrary-devel-0.13.5-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-types+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-types+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-prost-types+arbitrary-devel.sha256sum] = "8aa7180df129d32f37971fd0fa40444e155a263e015b31471a4bca489720b56b"

URI_x86_64_v2_rust-prost-types+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-types+default-devel-0.13.5-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-types+default-devel}"
SRC_URI[x86_64_v2_rust-prost-types+default-devel.sha256sum] = "8cca708ffe55ef4fc58055dbb8e4e182900bc25f5616755c133cf6c235654400"

URI_x86_64_v2_rust-prost-types+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-types+std-devel-0.13.5-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-types+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-types+std-devel}"
SRC_URI[x86_64_v2_rust-prost-types+std-devel.sha256sum] = "98a9f2627c8f51b1beabf9268776ffcfb21738912a73053f515ee30e4e7c1b80"

URI_x86_64_v2_rust-prost-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-types-devel-0.13.5-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-types-devel}"
SRC_URI[x86_64_v2_rust-prost-types-devel.sha256sum] = "533bde90db2c875fc63bfea353fc5de9611b19bfc9b73b0fdda4984def3b08a9"

URI_aarch64_rust-prost-types+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-types+arbitrary-devel-0.13.5-2.el10_2.noarch.rpm;name=aarch64_rust-prost-types+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-types+arbitrary-devel}"
SRC_URI[aarch64_rust-prost-types+arbitrary-devel.sha256sum] = "fe2ce7ba77c5c79657fe808b567820041459474de8696fc9fca3220322950293"

URI_aarch64_rust-prost-types+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-types+default-devel-0.13.5-2.el10_2.noarch.rpm;name=aarch64_rust-prost-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-types+default-devel}"
SRC_URI[aarch64_rust-prost-types+default-devel.sha256sum] = "1daca0f83454684a14acca26928221e3a2a5a0750895d2fb918ce4f067a58826"

URI_aarch64_rust-prost-types+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-types+std-devel-0.13.5-2.el10_2.noarch.rpm;name=aarch64_rust-prost-types+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-types+std-devel}"
SRC_URI[aarch64_rust-prost-types+std-devel.sha256sum] = "3acacf3e51b65f03d001fc29454fcb44e6ac68a5b6d448b59138553ac526a9e7"

URI_aarch64_rust-prost-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-types-devel-0.13.5-2.el10_2.noarch.rpm;name=aarch64_rust-prost-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-types-devel}"
SRC_URI[aarch64_rust-prost-types-devel.sha256sum] = "6e64918307991105cd5e3080fafdba72cd5eed653ede9459a5b90d8b94787799"

RDEPENDS:rust-prost-types+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-prost-types-devel \
 "
RDEPENDS:rust-prost-types+default-devel = " \
 cargo \
 rust-prost-types+std-devel \
 rust-prost-types-devel \
 "
RDEPENDS:rust-prost-types+std-devel = " \
 cargo \
 rust-prost+std-devel \
 rust-prost-types-devel \
 "
RDEPENDS:rust-prost-types-devel = " \
 cargo \
 rust \
 rust-prost+prost-derive-devel \
 rust-prost-devel \
 "
