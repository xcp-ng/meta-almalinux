# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "erofs-utils"
PV = "1.8.10"
PR = "1.el10"
PACKAGES = " \
 erofs-fuse \
 erofs-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/erofs-utils-1.8.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "701e19d151e1dd9077ac6b10ca29351700c868ffa022291db5f3de79026d5406"

URI_x86_64_v2_erofs-fuse = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/erofs-fuse-1.8.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_erofs-fuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_erofs-fuse}"
SRC_URI[x86_64_v2_erofs-fuse.sha256sum] = "90f9484d8260325289512802d4c1ef0d09782edd7d66cc9af8c28f6de8f71de5"

URI_x86_64_v2_erofs-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/erofs-utils-1.8.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_erofs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_erofs-utils}"
SRC_URI[x86_64_v2_erofs-utils.sha256sum] = "b587d4ccf624da509212a2886ef7e5a1bf869a11c13eb77fdbd02aa340f44b3d"

URI_aarch64_erofs-fuse = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/erofs-fuse-1.8.10-1.el10.aarch64.rpm;name=aarch64_erofs-fuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_erofs-fuse}"
SRC_URI[aarch64_erofs-fuse.sha256sum] = "cddd6077ccbd5d96131247ee806bde21e3423b03d693caadeb3b2a3e24e69a12"

URI_aarch64_erofs-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/erofs-utils-1.8.10-1.el10.aarch64.rpm;name=aarch64_erofs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_erofs-utils}"
SRC_URI[aarch64_erofs-utils.sha256sum] = "726d479eddeefe2c529bb553905d0075e332acecf98e46896c16d1c44e01e57a"

RDEPENDS:erofs-fuse = " \
 fuse3 \
 fuse3-libs \
 glibc \
 libselinux \
 libzstd \
 lz4-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:erofs-utils = " \
 glibc \
 libselinux \
 libuuid \
 libzstd \
 lz4-libs \
 xz-libs \
 zlib-ng-compat \
 "
