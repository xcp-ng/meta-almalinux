# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-munge"
PV = "0.4.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-munge+default-devel \
 rust-munge-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-munge-0.4.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2a1d7c69c9c39c412483de73e971d9dad564b1321f4879f42c085e4f3493ae7"

URI_x86_64_v2_rust-munge+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-munge+default-devel-0.4.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-munge+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-munge+default-devel}"
SRC_URI[x86_64_v2_rust-munge+default-devel.sha256sum] = "ce1760fd290e22d86a0225d571b8e342201d2855118e116c2e7bf3c8295f9eaf"

URI_x86_64_v2_rust-munge-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-munge-devel-0.4.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-munge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-munge-devel}"
SRC_URI[x86_64_v2_rust-munge-devel.sha256sum] = "759a710246b2c37e5c5dc9eeabf2589c003a405bcbac0bf77b2e49aa080b2c95"

URI_aarch64_rust-munge+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-munge+default-devel-0.4.7-1.el10_1.noarch.rpm;name=aarch64_rust-munge+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-munge+default-devel}"
SRC_URI[aarch64_rust-munge+default-devel.sha256sum] = "c447030fcbcc483b18de03e1dddd2e645239d2b2324e96d16cca16791f557f2d"

URI_aarch64_rust-munge-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-munge-devel-0.4.7-1.el10_1.noarch.rpm;name=aarch64_rust-munge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-munge-devel}"
SRC_URI[aarch64_rust-munge-devel.sha256sum] = "e9ae0471738bdd5a20a62f310b8f7fb675f5c7cd23d018aa2bb453ac63adaad9"

RDEPENDS:rust-munge+default-devel = " \
 cargo \
 rust-munge-devel \
 "
RDEPENDS:rust-munge-devel = " \
 cargo \
 rust \
 rust-munge_macro-devel \
 "
