# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_pwd"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_pwd+default-devel \
 rust-uu_pwd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_pwd-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "245def3f43bda50e150f823a0da5e205870d95cefaedb121e917774e2cf850fe"

URI_x86_64_v2_rust-uu_pwd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_pwd+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_pwd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_pwd+default-devel}"
SRC_URI[x86_64_v2_rust-uu_pwd+default-devel.sha256sum] = "31f543091cea0b6068bde8aa6db906108fecf3e96e8ba6d39e51bea8c523e5bf"

URI_x86_64_v2_rust-uu_pwd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_pwd-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_pwd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_pwd-devel}"
SRC_URI[x86_64_v2_rust-uu_pwd-devel.sha256sum] = "51c6e507d4914aa9dff2c417a83ba880f3f5e18b0d7192789f1e10ec6797f360"

URI_aarch64_rust-uu_pwd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_pwd+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_pwd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_pwd+default-devel}"
SRC_URI[aarch64_rust-uu_pwd+default-devel.sha256sum] = "64274bbb17d1eb0a626bf088092d031ee1a0f18bd3922b7ac79f9653cf956bb1"

URI_aarch64_rust-uu_pwd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_pwd-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_pwd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_pwd-devel}"
SRC_URI[aarch64_rust-uu_pwd-devel.sha256sum] = "24e3d04cdb9892c0f3f03045be10beac5ec3cefaa63d32cc3eb66b673cbe3fa9"

RDEPENDS:rust-uu_pwd+default-devel = " \
 cargo \
 rust-uu_pwd-devel \
 "
RDEPENDS:rust-uu_pwd-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 "
