# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pin-project-internal"
PV = "1.1.11"
PR = "1.el10_3"
PACKAGES = " \
 rust-pin-project-internal+default-devel \
 rust-pin-project-internal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pin-project-internal-1.1.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d707dcc2730210be0d46cff2bacf0bd8f4fc79929ec3ca58891794284d0aa177"

URI_x86_64_v2_rust-pin-project-internal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-internal+default-devel-1.1.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-internal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-internal+default-devel}"
SRC_URI[x86_64_v2_rust-pin-project-internal+default-devel.sha256sum] = "8fc858c31c329698a305ba2c59ef08a08ab99ad33a1e78244310bb120111ea4f"

URI_x86_64_v2_rust-pin-project-internal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-internal-devel-1.1.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-internal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-internal-devel}"
SRC_URI[x86_64_v2_rust-pin-project-internal-devel.sha256sum] = "df6634ac5704b6755866f12f3e35af244a7224e12c200fcd355ef57152e734ea"

URI_aarch64_rust-pin-project-internal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-internal+default-devel-1.1.11-1.el10_3.noarch.rpm;name=aarch64_rust-pin-project-internal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-internal+default-devel}"
SRC_URI[aarch64_rust-pin-project-internal+default-devel.sha256sum] = "a75822f95115e5adf7eba1ea6ea068ba2000d3c91f48e2f27dcb1f6c49b28788"

URI_aarch64_rust-pin-project-internal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-internal-devel-1.1.11-1.el10_3.noarch.rpm;name=aarch64_rust-pin-project-internal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-internal-devel}"
SRC_URI[aarch64_rust-pin-project-internal-devel.sha256sum] = "fe689c1a2aa875bd0d89694671b7fc86f7bcae8fb6ddad8f74fcbe056185d844"

RDEPENDS:rust-pin-project-internal+default-devel = " \
 cargo \
 rust-pin-project-internal-devel \
 "
RDEPENDS:rust-pin-project-internal-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+clone-impls-devel \
 rust-syn2+full-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2+proc-macro-devel \
 rust-syn2+visit-mut-devel \
 rust-syn2-devel \
 "
