# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-polyval0.6"
PV = "0.6.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-polyval0.6+default-devel \
 rust-polyval0.6+std-devel \
 rust-polyval0.6+zeroize-devel \
 rust-polyval0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-polyval0.6-0.6.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3153ba8d0397de962da0dda5093526c28a92d926e004917db3184f0b71e87b37"

URI_x86_64_v2_rust-polyval0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polyval0.6+default-devel-0.6.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polyval0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polyval0.6+default-devel}"
SRC_URI[x86_64_v2_rust-polyval0.6+default-devel.sha256sum] = "00901e720d298f4f83df36cd3d8d997a0d1556491aeb048fd9a72b4a3d39898f"

URI_x86_64_v2_rust-polyval0.6+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polyval0.6+std-devel-0.6.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polyval0.6+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polyval0.6+std-devel}"
SRC_URI[x86_64_v2_rust-polyval0.6+std-devel.sha256sum] = "503b9fdb64b1e28025908479c58b53d8f208d5dfae560bbdb706863447ca7a9f"

URI_x86_64_v2_rust-polyval0.6+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polyval0.6+zeroize-devel-0.6.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polyval0.6+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polyval0.6+zeroize-devel}"
SRC_URI[x86_64_v2_rust-polyval0.6+zeroize-devel.sha256sum] = "502866d79ea693060106e1b499c490daa98e1e036603cf5f21963fb14cfaba74"

URI_x86_64_v2_rust-polyval0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polyval0.6-devel-0.6.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polyval0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polyval0.6-devel}"
SRC_URI[x86_64_v2_rust-polyval0.6-devel.sha256sum] = "47dc62ebd2c1634dc94f8135ba62e689ce3b69942076690ce77af1209105e8a6"

URI_aarch64_rust-polyval0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polyval0.6+default-devel-0.6.2-1.el10_3.noarch.rpm;name=aarch64_rust-polyval0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polyval0.6+default-devel}"
SRC_URI[aarch64_rust-polyval0.6+default-devel.sha256sum] = "2e9a5da21788506214fb5ad273020a0232564ae1091c5c27ac5c3e6d72fc219a"

URI_aarch64_rust-polyval0.6+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polyval0.6+std-devel-0.6.2-1.el10_3.noarch.rpm;name=aarch64_rust-polyval0.6+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polyval0.6+std-devel}"
SRC_URI[aarch64_rust-polyval0.6+std-devel.sha256sum] = "3b2f119bd5984ca3e716b7640b14fb4755ed2764fc2c2964b54bc04fe1cbda69"

URI_aarch64_rust-polyval0.6+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polyval0.6+zeroize-devel-0.6.2-1.el10_3.noarch.rpm;name=aarch64_rust-polyval0.6+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polyval0.6+zeroize-devel}"
SRC_URI[aarch64_rust-polyval0.6+zeroize-devel.sha256sum] = "d0699f831e80fdb91514d2eba1f4e3167e3645a4d176c9bdce5164c3fe7aa59d"

URI_aarch64_rust-polyval0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polyval0.6-devel-0.6.2-1.el10_3.noarch.rpm;name=aarch64_rust-polyval0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polyval0.6-devel}"
SRC_URI[aarch64_rust-polyval0.6-devel.sha256sum] = "99ae0304be270cd43d014c155bfc2c51a82c7bd9fef0d98f8371cf2794ffc5fc"

RDEPENDS:rust-polyval0.6+default-devel = " \
 cargo \
 rust-polyval0.6-devel \
 "
RDEPENDS:rust-polyval0.6+std-devel = " \
 cargo \
 rust-polyval0.6-devel \
 rust-universal-hash0.5+std-devel \
 "
RDEPENDS:rust-polyval0.6+zeroize-devel = " \
 cargo \
 rust-polyval0.6-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-polyval0.6-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-cpufeatures0.2+default-devel \
 rust-opaque-debug+default-devel \
 rust-universal-hash0.5-devel \
 "
