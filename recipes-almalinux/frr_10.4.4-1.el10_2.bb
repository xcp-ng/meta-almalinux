# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "frr"
PV = "10.4.4"
PR = "1.el10_2"
PACKAGES = " \
 frr \
 frr-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/frr-10.4.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "871dae5187f1cf37e3658ab076c77284bee5c39b1902b80540c54866a3c734d7"

URI_x86_64_v2_frr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/frr-10.4.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_frr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_frr}"
SRC_URI[x86_64_v2_frr.sha256sum] = "99818b38a23fb5870031a9ee3634dac0c8cd4d7f77569a57ddce43f327acb2e9"

URI_x86_64_v2_frr-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/frr-selinux-10.4.4-1.el10_2.noarch.rpm;name=x86_64_v2_frr-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_frr-selinux}"
SRC_URI[x86_64_v2_frr-selinux.sha256sum] = "e52027fd1714316b10d57ad6d1986270e9103048cce6f181fddac53f9ff01c8c"

URI_aarch64_frr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/frr-10.4.4-1.el10_2.aarch64.rpm;name=aarch64_frr;unpack=0"
SRC_URI:append = " ${URI_aarch64_frr}"
SRC_URI[aarch64_frr.sha256sum] = "d8dea90b674adf3240c12570a505c5dc2e341d172f06e2cec2970c6bddb126d2"

URI_aarch64_frr-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/frr-selinux-10.4.4-1.el10_2.noarch.rpm;name=aarch64_frr-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_frr-selinux}"
SRC_URI[aarch64_frr-selinux.sha256sum] = "e52027fd1714316b10d57ad6d1986270e9103048cce6f181fddac53f9ff01c8c"

RDEPENDS:frr:x86_64_v2 = " \
 bash \
 c-ares \
 frr-selinux \
 glibc \
 hostname \
 json-c \
 libcap \
 libgcc \
 libxcrypt \
 libyang \
 ncurses \
 net-snmp \
 net-snmp-agent-libs \
 net-snmp-libs \
 openssl-libs \
 protobuf-c \
 python3 \
 readline \
 shadow-utils \
 systemd \
"
RDEPENDS:frr:aarch64 = " \
 bash \
 c-ares \
 frr-selinux \
 glibc \
 hostname \
 json-c \
 libatomic \
 libcap \
 libgcc \
 libxcrypt \
 libyang \
 ncurses \
 net-snmp \
 net-snmp-agent-libs \
 net-snmp-libs \
 openssl-libs \
 protobuf-c \
 python3 \
 readline \
 shadow-utils \
 systemd \
"
RDEPENDS:frr-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
