# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-calendrical_calculations"
PV = "0.2.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-calendrical_calculations+default-devel \
 rust-calendrical_calculations+logging-devel \
 rust-calendrical_calculations-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-calendrical_calculations-0.2.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48c74849cf44a568018b9a5663877331bdaef37cb23a248ecf6cd6558addc7a7"

URI_x86_64_v2_rust-calendrical_calculations+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-calendrical_calculations+default-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-calendrical_calculations+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-calendrical_calculations+default-devel}"
SRC_URI[x86_64_v2_rust-calendrical_calculations+default-devel.sha256sum] = "ebc546ea3ca01ff96decf54aa7da6aa7fba0b3c9600944af55e24e72604f75cc"

URI_x86_64_v2_rust-calendrical_calculations+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-calendrical_calculations+logging-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-calendrical_calculations+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-calendrical_calculations+logging-devel}"
SRC_URI[x86_64_v2_rust-calendrical_calculations+logging-devel.sha256sum] = "f072a0ab7d0f89e6a6c2fbd365870664cb1c8234c5e6413a7cffb42e7381255b"

URI_x86_64_v2_rust-calendrical_calculations-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-calendrical_calculations-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-calendrical_calculations-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-calendrical_calculations-devel}"
SRC_URI[x86_64_v2_rust-calendrical_calculations-devel.sha256sum] = "d95ec1c6bd2483d1bea25e96b8a1fd8d85281171d340295c8e921f94980941e4"

URI_aarch64_rust-calendrical_calculations+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-calendrical_calculations+default-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-calendrical_calculations+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-calendrical_calculations+default-devel}"
SRC_URI[aarch64_rust-calendrical_calculations+default-devel.sha256sum] = "ef2d6021b16add0f8e3afefc12839d5a05deea97b411b6689e5c5fdbb9421b48"

URI_aarch64_rust-calendrical_calculations+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-calendrical_calculations+logging-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-calendrical_calculations+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-calendrical_calculations+logging-devel}"
SRC_URI[aarch64_rust-calendrical_calculations+logging-devel.sha256sum] = "f452148f70a918d23d77149ff94a348e565396a85ff44807e1f6f927994ffd26"

URI_aarch64_rust-calendrical_calculations-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-calendrical_calculations-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-calendrical_calculations-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-calendrical_calculations-devel}"
SRC_URI[aarch64_rust-calendrical_calculations-devel.sha256sum] = "2cffd392445ac740a2ae6d34d0386e4503306dff69bfc215700a5d1b23109a15"

RDEPENDS:rust-calendrical_calculations+default-devel = " \
 cargo \
 rust-calendrical_calculations-devel \
 "
RDEPENDS:rust-calendrical_calculations+logging-devel = " \
 cargo \
 rust-calendrical_calculations-devel \
 rust-log-devel \
 "
RDEPENDS:rust-calendrical_calculations-devel = " \
 cargo \
 rust \
 rust-core_maths-devel \
 rust-displaydoc-devel \
 "
