# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crash"
PV = "9.0.1"
PR = "1.el10.alma.1"
PACKAGES = " \
 crash \
 crash-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/crash-9.0.1-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4eefaacf7eddc16bf82cac33b6a63208bd55a64839a611c56ff3c8d479b4d2e8"

URI_x86_64_v2_crash = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crash-9.0.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_crash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crash}"
SRC_URI[x86_64_v2_crash.sha256sum] = "f0ae6a4c822575c217a9eed77ca9836195539b704c42a973738131a07b0d3982"

URI_x86_64_v2_crash-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/crash-devel-9.0.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_crash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crash-devel}"
SRC_URI[x86_64_v2_crash-devel.sha256sum] = "97560dec353d75582ae4e7d86ef93a97454f1a49b74b6a243e2d73620194d5d9"

URI_aarch64_crash = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crash-9.0.1-1.el10.alma.1.aarch64.rpm;name=aarch64_crash;unpack=0"
SRC_URI:append = " ${URI_aarch64_crash}"
SRC_URI[aarch64_crash.sha256sum] = "fab9077791a04e0267d9dfaa2318a25f6ee1b425d5c9e5d643a0a9ecab24b8fe"

URI_aarch64_crash-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/crash-devel-9.0.1-1.el10.alma.1.aarch64.rpm;name=aarch64_crash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_crash-devel}"
SRC_URI[aarch64_crash-devel.sha256sum] = "d132cae9bfbc2d84516b9ec27ba7bf5f8c196af6bc17c21efee31a6082ac4e55"

RDEPENDS:crash = " \
 binutils \
 glibc \
 gmp \
 libgcc \
 libstdc++ \
 libzstd \
 lzo \
 mpfr \
 ncurses-libs \
 snappy \
 "
RDEPENDS:crash-devel = " \
 crash \
 zlib-ng-compat-devel \
 "
