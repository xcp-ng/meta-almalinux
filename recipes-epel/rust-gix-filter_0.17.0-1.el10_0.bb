# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-filter"
PV = "0.17.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-filter+default-devel \
 rust-gix-filter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-filter-0.17.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1554d42fff50e40c0e020712cb8381219ac58106c145186577a3b85c72713f16"

URI_x86_64_v2_rust-gix-filter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-filter+default-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-filter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-filter+default-devel}"
SRC_URI[x86_64_v2_rust-gix-filter+default-devel.sha256sum] = "934ad4af2546a4cb235b95003fa0aedf95e1d72c0d49d37535201c5b774ae672"

URI_x86_64_v2_rust-gix-filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-filter-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-filter-devel}"
SRC_URI[x86_64_v2_rust-gix-filter-devel.sha256sum] = "7d754d44ebdc999c0a555a732c853bbdca6a6879c36613203717ba5954f922a8"

URI_aarch64_rust-gix-filter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-filter+default-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-filter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-filter+default-devel}"
SRC_URI[aarch64_rust-gix-filter+default-devel.sha256sum] = "f2f45f01fdf58f08a688349a6fc3db78c54e8b81ff8e4781ee9c0902617d83ec"

URI_aarch64_rust-gix-filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-filter-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-filter-devel}"
SRC_URI[aarch64_rust-gix-filter-devel.sha256sum] = "164c0a071b3143a0194c4ec11926f30b73ef9854ec75a23b8b8e5d69d5a2510b"

RDEPENDS:rust-gix-filter+default-devel = " \
 cargo \
 rust-gix-filter-devel \
 "
RDEPENDS:rust-gix-filter-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-encoding_rs+default-devel \
 rust-gix-attributes+default-devel \
 rust-gix-command+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-packetline-blocking+default-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-utils+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
