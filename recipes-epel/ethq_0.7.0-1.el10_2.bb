# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ethq"
PV = "0.7.0"
PR = "1.el10_2"
PACKAGES = " \
 ethq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/ethq-0.7.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ed37bab50cf9c5528e544494abf18c863feb7b49a8a8f49e8c9851adf9b5ec5"

URI_x86_64_v2_ethq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ethq-0.7.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ethq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ethq}"
SRC_URI[x86_64_v2_ethq.sha256sum] = "271d5a461ba8d671f20b593ba2173b4f0a8ad3434ad7358d34af5160466ad3fb"

URI_aarch64_ethq = "${EPEL_MIRROR}/aarch64/Packages/e/ethq-0.7.0-1.el10_2.aarch64.rpm;name=aarch64_ethq;unpack=0"
SRC_URI:append = " ${URI_aarch64_ethq}"
SRC_URI[aarch64_ethq.sha256sum] = "d39761b243cd0e5d541f1f5ce6a292635f00736caa1c1c7d6667725253dc1455"

RDEPENDS:ethq = " \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 "
