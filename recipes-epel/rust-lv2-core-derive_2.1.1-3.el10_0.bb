# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lv2-core-derive"
PV = "2.1.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-lv2-core-derive+default-devel \
 rust-lv2-core-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lv2-core-derive-2.1.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a29193f8ee43c469eafaab2b132e9cb71d5fa5434f8a18918210b44efdc022cd"

URI_x86_64_v2_rust-lv2-core-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-core-derive+default-devel-2.1.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-core-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-core-derive+default-devel}"
SRC_URI[x86_64_v2_rust-lv2-core-derive+default-devel.sha256sum] = "f37978bcfd000ba2d787b18b5b677644471a6b7ff6e9844562bdd657c413d7ee"

URI_x86_64_v2_rust-lv2-core-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-core-derive-devel-2.1.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-core-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-core-derive-devel}"
SRC_URI[x86_64_v2_rust-lv2-core-derive-devel.sha256sum] = "76cea12e67301e48e3f705a10dace65665d9b3a76d58ea3082d98da6bb06634e"

URI_aarch64_rust-lv2-core-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-core-derive+default-devel-2.1.1-3.el10_0.noarch.rpm;name=aarch64_rust-lv2-core-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-core-derive+default-devel}"
SRC_URI[aarch64_rust-lv2-core-derive+default-devel.sha256sum] = "751b7d17e80e37bf7e5ff1d846b4b64612f7c6ffbcb259fc9f3f376eeb0745c7"

URI_aarch64_rust-lv2-core-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-core-derive-devel-2.1.1-3.el10_0.noarch.rpm;name=aarch64_rust-lv2-core-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-core-derive-devel}"
SRC_URI[aarch64_rust-lv2-core-derive-devel.sha256sum] = "3b604d7338fd8178df5da5bdf341e2ccaf33fda0c06959a89b6002384eed085c"

RDEPENDS:rust-lv2-core-derive+default-devel = " \
 cargo \
 rust-lv2-core-derive-devel \
 "
RDEPENDS:rust-lv2-core-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 "
