# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkexiv2"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 libkexiv2-qt6 \
 libkexiv2-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkexiv2-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bad8fe88d5ca6d27d404bb8e6e023ec3ac1838200553d83bdfd37610826caea5"

URI_x86_64_v2_libkexiv2-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkexiv2-qt6-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkexiv2-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkexiv2-qt6}"
SRC_URI[x86_64_v2_libkexiv2-qt6.sha256sum] = "4435dd970b31292122da898ee55add99807fe7eb9ede7e5fa9f701f635f24c9b"

URI_x86_64_v2_libkexiv2-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkexiv2-qt6-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkexiv2-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkexiv2-qt6-devel}"
SRC_URI[x86_64_v2_libkexiv2-qt6-devel.sha256sum] = "0f33b781c8eb1413feed00fc705a63dcfe9759e23981194fbea83555cc35ae91"

URI_aarch64_libkexiv2-qt6 = "${EPEL_MIRROR}/aarch64/Packages/l/libkexiv2-qt6-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkexiv2-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkexiv2-qt6}"
SRC_URI[aarch64_libkexiv2-qt6.sha256sum] = "a64458f873ad2827fd55ac0effb3cf77be10c72efd39ade1c576af16d4f091cb"

URI_aarch64_libkexiv2-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkexiv2-qt6-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkexiv2-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkexiv2-qt6-devel}"
SRC_URI[aarch64_libkexiv2-qt6-devel.sha256sum] = "2db0291249eca37c21da07014cf4d1f000ed47cad26d3cadbf387fea1fbb62e9"

RDEPENDS:libkexiv2-qt6 = " \
 exiv2-libs \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkexiv2-qt6-devel = " \
 cmake-filesystem \
 libkexiv2-qt6 \
 qt6-qtbase-devel \
 "
