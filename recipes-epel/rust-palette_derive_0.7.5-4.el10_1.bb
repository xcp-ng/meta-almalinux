# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-palette_derive"
PV = "0.7.5"
PR = "4.el10_1"
PACKAGES = " \
 rust-palette_derive+default-devel \
 rust-palette_derive+find-crate-devel \
 rust-palette_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-palette_derive-0.7.5-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2974f3e299e7dce2ea6638b109d5ebe8c6a7a0c02e0cb128be5e0993c9d75795"

URI_x86_64_v2_rust-palette_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette_derive+default-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette_derive+default-devel}"
SRC_URI[x86_64_v2_rust-palette_derive+default-devel.sha256sum] = "5361928b1d775b7ca13dce12cc7a100c37d20badf4415d9b3d40eb6b92bbcfb1"

URI_x86_64_v2_rust-palette_derive+find-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette_derive+find-crate-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette_derive+find-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette_derive+find-crate-devel}"
SRC_URI[x86_64_v2_rust-palette_derive+find-crate-devel.sha256sum] = "14d20250c05b2f1bcaede1e42729dbbc48726a12fbd59ca6b2d4acaab908af08"

URI_x86_64_v2_rust-palette_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette_derive-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette_derive-devel}"
SRC_URI[x86_64_v2_rust-palette_derive-devel.sha256sum] = "d862f4416fdb019877f76297b5893a88b5030dbaa09056fc664c13b38921d531"

URI_aarch64_rust-palette_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette_derive+default-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette_derive+default-devel}"
SRC_URI[aarch64_rust-palette_derive+default-devel.sha256sum] = "fc19773ac03dfceb0279459658fecb670a9947ff04d40ec2acded24541ff4d2e"

URI_aarch64_rust-palette_derive+find-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette_derive+find-crate-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette_derive+find-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette_derive+find-crate-devel}"
SRC_URI[aarch64_rust-palette_derive+find-crate-devel.sha256sum] = "2873f6eb2dbacc632e0bfe28649675f0832be82c4730b8be900deeae2c910d48"

URI_aarch64_rust-palette_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette_derive-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette_derive-devel}"
SRC_URI[aarch64_rust-palette_derive-devel.sha256sum] = "5428ddc8be9905654c2178a0f5a61db380bf5e607b2a44c76e2e9942d156fd31"

RDEPENDS:rust-palette_derive+default-devel = " \
 cargo \
 rust-palette_derive-devel \
 "
RDEPENDS:rust-palette_derive+find-crate-devel = " \
 cargo \
 rust-find-crate+default-devel \
 rust-palette_derive-devel \
 "
RDEPENDS:rust-palette_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+clone-impls-devel \
 rust-syn2+derive-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2+proc-macro-devel \
 rust-syn2-devel \
 "
