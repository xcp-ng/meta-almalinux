# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cronie"
PV = "1.7.0"
PR = "15.el10"
PACKAGES = " \
 cronie \
 cronie-anacron \
 cronie-noanacron \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cronie-1.7.0-15.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b12d720b4519fe7e1a27d3b960ac7af31bef4036918f50f1cfb8d3f0299ff7ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cronie-1.7.0-15.el10.x86_64_v2.rpm;name=x86_64_v2_cronie;unpack=0"
SRC_URI[x86_64_v2_cronie.sha256sum] = "bf8d73ab3d4afa3ef78977b8670841e735b65034d9b75f6cb0a7d4b9339e500c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cronie-anacron-1.7.0-15.el10.x86_64_v2.rpm;name=x86_64_v2_cronie-anacron;unpack=0"
SRC_URI[x86_64_v2_cronie-anacron.sha256sum] = "8e2cbb5f5b01b99436eea6b88dffdfce61f5495a3f4a7fb8c31696992b90ea20"
RPROVIDES:cronie-anacron:append:x86_64_v2 = " virtual/dailyjobs"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cronie-noanacron-1.7.0-15.el10.x86_64_v2.rpm;name=x86_64_v2_cronie-noanacron;unpack=0"
SRC_URI[x86_64_v2_cronie-noanacron.sha256sum] = "042fbd6febc5eea9d9e5f4e5db38e5c321a165db430b6a8edc50ec6545f63ccf"
RPROVIDES:cronie-noanacron:append:x86_64_v2 = " virtual/dailyjobs"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cronie-1.7.0-15.el10.aarch64.rpm;name=aarch64_cronie;unpack=0"
SRC_URI[aarch64_cronie.sha256sum] = "43e758389228e4ecee95468b4a46549f61810f571c83ac72b296e55e7fcf9c4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cronie-anacron-1.7.0-15.el10.aarch64.rpm;name=aarch64_cronie-anacron;unpack=0"
SRC_URI[aarch64_cronie-anacron.sha256sum] = "44400326fd949e0af73e31dcdedc80669d946f25f3b6ef071c04c14dfbd234eb"
RPROVIDES:cronie-anacron:append:aarch64 = " virtual/dailyjobs"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cronie-noanacron-1.7.0-15.el10.aarch64.rpm;name=aarch64_cronie-noanacron;unpack=0"
SRC_URI[aarch64_cronie-noanacron.sha256sum] = "0e25f72b4e763c19e64cd58b9f5788ae5f20b02066d151fee5a751ce22b87b7a"
RPROVIDES:cronie-noanacron:append:aarch64 = " virtual/dailyjobs"

RDEPENDS:cronie = " \
 audit-libs \
 bash \
 glibc \
 libselinux \
 pam \
 pam-libs \
 sed \
 virtual/coreutils \
 virtual/dailyjobs \
 "
RDEPENDS:cronie-anacron = " \
 bash \
 cronie \
 crontabs \
 glibc \
 virtual/coreutils \
 "
RDEPENDS:cronie-noanacron = " \
 cronie \
 crontabs \
 "
