# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kldap"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kldap \
 kldap-devel \
 kldap-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kldap-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fca8ec27df685d8091c052ef6639bfd2075113223ffdf452083e51e1360f2c40"

URI_x86_64_v2_kldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kldap}"
SRC_URI[x86_64_v2_kldap.sha256sum] = "e5bf5dd92a506c101fb658ec127ba97ced19356ba21355a79418ce3bc60aa8fe"

URI_x86_64_v2_kldap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kldap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kldap-devel}"
SRC_URI[x86_64_v2_kldap-devel.sha256sum] = "3d32167e4bb1619d5bfbab35f04ea8d56e2b8ac49ab88ee77ac43b2d83f6917f"

URI_x86_64_v2_kldap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kldap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kldap-doc}"
SRC_URI[x86_64_v2_kldap-doc.sha256sum] = "6761f370291a6228f819ecc5f851278aecb62be1e94fe10205c0f484846ebc63"

URI_aarch64_kldap = "${EPEL_MIRROR}/aarch64/Packages/k/kldap-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_kldap}"
SRC_URI[aarch64_kldap.sha256sum] = "0a7d4ff43b1498f0a785b7dd02b10a227d404f76c1d88ad9d05ed40f23ba48ef"

URI_aarch64_kldap-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kldap-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kldap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kldap-devel}"
SRC_URI[aarch64_kldap-devel.sha256sum] = "7e98e4cbd75170a27de6cc397e242266212e812a84fb8c690a9fe9610ff73881"

URI_aarch64_kldap-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kldap-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kldap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kldap-doc}"
SRC_URI[aarch64_kldap-doc.sha256sum] = "d6b41c7ccb1a19ef1f72a041a53efb8c6b0907a4f9f6dae8f664b02e7ff8faad"

RDEPENDS:kldap = " \
 cyrus-sasl-lib \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 libstdc++ \
 openldap \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:kldap-devel = " \
 cmake-filesystem \
 cyrus-sasl-devel \
 kldap \
 openldap-devel \
 "
RDEPENDS:kldap-doc = " \
 "
