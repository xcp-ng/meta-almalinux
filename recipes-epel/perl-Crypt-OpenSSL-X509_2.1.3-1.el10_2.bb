# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-OpenSSL-X509"
PV = "2.1.3"
PR = "1.el10_2"
PACKAGES = " \
 perl-Crypt-OpenSSL-X509 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-OpenSSL-X509-2.1.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49cda2fa1bbc0d8d6b6efc495f47aeb8b811e86b9be39e3d180ecd799c0c3553"

URI_x86_64_v2_perl-Crypt-OpenSSL-X509 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-X509-2.1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-X509;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-X509}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-X509.sha256sum] = "e5cb856954389d296d2a850e1f334c734fe66772e6f241f7472a2829b9790f77"

URI_aarch64_perl-Crypt-OpenSSL-X509 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-X509-2.1.3-1.el10_2.aarch64.rpm;name=aarch64_perl-Crypt-OpenSSL-X509;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-X509}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-X509.sha256sum] = "93c7ccee98158fdd55b93fe57c49ad7f3873a5813a1386c1d2c29f9edf92ea41"

RDEPENDS:perl-Crypt-OpenSSL-X509 = " \
 glibc \
 openssl-libs \
 perl-Convert-ASN1 \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-version \
 "
