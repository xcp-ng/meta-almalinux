# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bootc"
PV = "1.8.0"
PR = "4.el10_1"
PACKAGES = " \
 bootc \
 system-reinstall-bootc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bootc-1.8.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3028f5267e22c1e759df326bf0ef250dbba4e0dde93ad5bc786cb7f7f6b157b3"

URI_x86_64_v2_bootc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bootc-1.8.0-4.el10_1.x86_64_v2.rpm;name=x86_64_v2_bootc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bootc}"
SRC_URI[x86_64_v2_bootc.sha256sum] = "9beb664b5cb3ab50b288c97a781197c9f09b21f72d55f689fef4d368677e22e7"

URI_x86_64_v2_system-reinstall-bootc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/system-reinstall-bootc-1.8.0-4.el10_1.x86_64_v2.rpm;name=x86_64_v2_system-reinstall-bootc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_system-reinstall-bootc}"
SRC_URI[x86_64_v2_system-reinstall-bootc.sha256sum] = "69095b05ad349c5204ccb9403a512c54c609d22b4c001c0eb0b816e84c57a335"

URI_aarch64_bootc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bootc-1.8.0-4.el10_1.aarch64.rpm;name=aarch64_bootc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bootc}"
SRC_URI[aarch64_bootc.sha256sum] = "c843e5ecaf17fccb8465f05773242a5ddc938d09b99bb1c02c3341ed57a85106"

URI_aarch64_system-reinstall-bootc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/system-reinstall-bootc-1.8.0-4.el10_1.aarch64.rpm;name=aarch64_system-reinstall-bootc;unpack=0"
SRC_URI:append = " ${URI_aarch64_system-reinstall-bootc}"
SRC_URI[aarch64_system-reinstall-bootc.sha256sum] = "e5f097a2ff615fbcc0c420d1763cc98559c624b330177ba9ca3c124af11d9595"

RDEPENDS:bootc = " \
 bash \
 composefs \
 glib2 \
 glibc \
 libgcc \
 libzstd \
 openssl-libs \
 ostree \
 ostree-libs \
 podman \
 skopeo \
 zlib-ng-compat \
 "
RDEPENDS:system-reinstall-bootc = " \
 bash \
 glibc \
 libgcc \
 "
