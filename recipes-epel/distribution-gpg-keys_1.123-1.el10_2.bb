# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "distribution-gpg-keys"
PV = "1.123"
PR = "1.el10_2"
PACKAGES = " \
 distribution-gpg-keys \
 distribution-gpg-keys-copr \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/distribution-gpg-keys-1.123-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7f2d8c3e7e1327bc24708bdfe029e23d9b957ddb47489922830a7d01204fab63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distribution-gpg-keys-1.123-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_distribution-gpg-keys;unpack=0"
SRC_URI[x86_64_v2_distribution-gpg-keys.sha256sum] = "cd6b6f5d4d934cfc00cc3d448e6a80a34d12b3a6260107c4cf59b97b4029007e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distribution-gpg-keys-copr-1.123-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_distribution-gpg-keys-copr;unpack=0"
SRC_URI[x86_64_v2_distribution-gpg-keys-copr.sha256sum] = "64db71c34230b6b4249bb5c191ff166364c362f24f3f11da983e99a94afad933"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/distribution-gpg-keys-1.123-1.el10_2.noarch.rpm;name=aarch64_distribution-gpg-keys;unpack=0"
SRC_URI[aarch64_distribution-gpg-keys.sha256sum] = "9a3efb12975e62174536a65caa5c70edcab45097d0237353a07c18a63f111e55"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/distribution-gpg-keys-copr-1.123-1.el10_2.noarch.rpm;name=aarch64_distribution-gpg-keys-copr;unpack=0"
SRC_URI[aarch64_distribution-gpg-keys-copr.sha256sum] = "ad1242c47610373cb6aa9b48c471722763fff1a28aa47deaa2123e1ca1e2155e"

RDEPENDS:distribution-gpg-keys = " \
 "
RDEPENDS:distribution-gpg-keys-copr = " \
 "
