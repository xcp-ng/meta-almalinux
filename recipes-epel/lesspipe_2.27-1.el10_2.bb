# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lesspipe"
PV = "2.27"
PR = "1.el10_2"
PACKAGES = " \
 lesspipe \
 lesspipe-profile \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/lesspipe-2.27-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "db4fd05eb216c438730be40bebfe226c5669402c5a22411f57e1df3b693add6a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lesspipe-2.27-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lesspipe;unpack=0"
SRC_URI[x86_64_v2_lesspipe.sha256sum] = "93252b0df13f5586be2995b05e241e15fe58f6cac7069de42775e7485f5b92c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lesspipe-profile-2.27-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lesspipe-profile;unpack=0"
SRC_URI[x86_64_v2_lesspipe-profile.sha256sum] = "13cbfc18ba51eccdf4e3aff3f6ec382b0eff5e09d21d7dc3a548724cf1724f2f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lesspipe-2.27-1.el10_2.noarch.rpm;name=aarch64_lesspipe;unpack=0"
SRC_URI[aarch64_lesspipe.sha256sum] = "7e9d658cfc14ac34e8773ce583e5be43998fbf1e44435952123dc9889af4f718"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lesspipe-profile-2.27-1.el10_2.noarch.rpm;name=aarch64_lesspipe-profile;unpack=0"
SRC_URI[aarch64_lesspipe-profile.sha256sum] = "fdada5b5c41854d7274ceb892623a4d89f236ab582e52e6f4937912f2615e71a"

RDEPENDS:lesspipe = " \
 bash \
 file \
 glibc-common \
 procps-ng \
 virtual//usr/bin/head \
 "
RDEPENDS:lesspipe-profile = " \
 lesspipe \
 setup \
 "
