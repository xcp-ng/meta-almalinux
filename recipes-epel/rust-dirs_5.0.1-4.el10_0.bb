# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dirs"
PV = "5.0.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-dirs+default-devel \
 rust-dirs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dirs-5.0.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8af91415e5e031868bbe13726bc273ee061c8fd2741ff1c86234dd010a7f9981"

URI_x86_64_v2_rust-dirs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dirs+default-devel-5.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dirs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dirs+default-devel}"
SRC_URI[x86_64_v2_rust-dirs+default-devel.sha256sum] = "230accd9311dcce8347fb97a90fea40344440e2f218035619a1f868280d89c96"

URI_x86_64_v2_rust-dirs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dirs-devel-5.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dirs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dirs-devel}"
SRC_URI[x86_64_v2_rust-dirs-devel.sha256sum] = "9b4b121d11f604c9aa20756d56b6a7c3b4c134aa8ded27353074e977db7b6669"

URI_aarch64_rust-dirs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dirs+default-devel-5.0.1-4.el10_0.noarch.rpm;name=aarch64_rust-dirs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dirs+default-devel}"
SRC_URI[aarch64_rust-dirs+default-devel.sha256sum] = "2f8b0292f136acaf6837b155d7596e159cf5045f070ce2381bd1f99543f05c1e"

URI_aarch64_rust-dirs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dirs-devel-5.0.1-4.el10_0.noarch.rpm;name=aarch64_rust-dirs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dirs-devel}"
SRC_URI[aarch64_rust-dirs-devel.sha256sum] = "8efd9fdab3e7dc4530ea6e1e2679b0e6f3f7a8bdcbff9bc88a1a0ad6ced2b0a5"

RDEPENDS:rust-dirs+default-devel = " \
 cargo \
 rust-dirs-devel \
 "
RDEPENDS:rust-dirs-devel = " \
 cargo \
 rust-dirs-sys+default-devel \
 "
