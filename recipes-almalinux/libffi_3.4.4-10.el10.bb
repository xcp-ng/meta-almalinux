# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libffi"
PV = "3.4.4"
PR = "10.el10"
PACKAGES = " \
 libffi \
 libffi-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libffi-3.4.4-10.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e7d6802d7503238c0c54d63e6ca3e4918eb91b271c42a3b10cc05f438bb0d16b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libffi-3.4.4-10.el10.x86_64_v2.rpm;name=x86_64_v2_libffi;unpack=0"
SRC_URI[x86_64_v2_libffi.sha256sum] = "46d88d35880f872d1b1552239d964c56349dd95ea2d5c7392b70b8a564379590"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libffi-devel-3.4.4-10.el10.x86_64_v2.rpm;name=x86_64_v2_libffi-devel;unpack=0"
SRC_URI[x86_64_v2_libffi-devel.sha256sum] = "f2a92c555edbff23355e862d173927661c4cba577df788d6b054567f012cf765"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libffi-3.4.4-10.el10.aarch64.rpm;name=aarch64_libffi;unpack=0"
SRC_URI[aarch64_libffi.sha256sum] = "4815f0f203481185dfebb34117a2a69ad4be5b4c5e1ec77a8643b91fa4fd8ee4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libffi-devel-3.4.4-10.el10.aarch64.rpm;name=aarch64_libffi-devel;unpack=0"
SRC_URI[aarch64_libffi-devel.sha256sum] = "4bd291b794a8a8d2ae7a5e8fbdbef5969f8fff0029ba550f3aae18183ba24ee4"

RDEPENDS:libffi = " \
 glibc \
 "
RDEPENDS:libffi-devel = " \
 libffi \
 pkgconf-pkg-config \
 "
