# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pycodestyle"
PV = "2.12.1"
PR = "8.el10_1"
PACKAGES = " \
 python3-pycodestyle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pycodestyle-2.12.1-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d543053d13d1d84c3a0bb66d695f04246215e0b3f0c2f794dee2801d9a7c4808"

URI_x86_64_v2_python3-pycodestyle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pycodestyle-2.12.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pycodestyle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pycodestyle}"
SRC_URI[x86_64_v2_python3-pycodestyle.sha256sum] = "0115a4ad0a3155c01175fd257695c7302671be556e2fcb4c3a0c4554fc242bd1"

URI_aarch64_python3-pycodestyle = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pycodestyle-2.12.1-8.el10_1.noarch.rpm;name=aarch64_python3-pycodestyle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pycodestyle}"
SRC_URI[aarch64_python3-pycodestyle.sha256sum] = "db2966afa362e1a24c487765c098f12ba7dcc181b748c4054e19a4c581df7046"

RDEPENDS:python3-pycodestyle = " \
 python3 \
 "
