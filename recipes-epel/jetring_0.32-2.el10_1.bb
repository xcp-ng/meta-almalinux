# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jetring"
PV = "0.32"
PR = "2.el10_1"
PACKAGES = " \
 jetring \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jetring-0.32-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd5eea357064e433d72ff9c490be1c65c2abbad780be75d6a35a8f26d8ec61ae"

URI_x86_64_v2_jetring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jetring-0.32-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_jetring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jetring}"
SRC_URI[x86_64_v2_jetring.sha256sum] = "d0461cbf090ed94763fed223254019f90860215c6fa6ba0005f1ede19aa5862c"

URI_aarch64_jetring = "${EPEL_MIRROR}/aarch64/Packages/j/jetring-0.32-2.el10_1.noarch.rpm;name=aarch64_jetring;unpack=0"
SRC_URI:append = " ${URI_aarch64_jetring}"
SRC_URI[aarch64_jetring.sha256sum] = "8f56ef100ee9f2f840bd0af5ff9461ed25c800487c4707cfd3bdd932d90478b5"

RDEPENDS:jetring = " \
 bash \
 gnupg2 \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 "
