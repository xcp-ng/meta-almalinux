# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-crc32c"
PV = "1.1.2"
PR = "11.el10_0"
PACKAGES = " \
 google-crc32c \
 google-crc32c-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/google-crc32c-1.1.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf9852db5861d6ba8fe71c53be3a30096771165c96f09fe3bd46940b636494b9"

URI_x86_64_v2_google-crc32c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-crc32c-1.1.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_google-crc32c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-crc32c}"
SRC_URI[x86_64_v2_google-crc32c.sha256sum] = "d0d4dd874ef8290e72cf9000ef1d27d5553aad21add09cd5a1c5e8172014d144"

URI_x86_64_v2_google-crc32c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-crc32c-devel-1.1.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_google-crc32c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-crc32c-devel}"
SRC_URI[x86_64_v2_google-crc32c-devel.sha256sum] = "66cfad3f5564674047d65fe5ca2915e8fc0a79c45b583d9eacd4894e9331c2b8"

URI_aarch64_google-crc32c = "${EPEL_MIRROR}/aarch64/Packages/g/google-crc32c-1.1.2-11.el10_0.aarch64.rpm;name=aarch64_google-crc32c;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-crc32c}"
SRC_URI[aarch64_google-crc32c.sha256sum] = "a717dcc919b46db5f5d77f16f3416845bb883479593321953b51636d1941831d"

URI_aarch64_google-crc32c-devel = "${EPEL_MIRROR}/aarch64/Packages/g/google-crc32c-devel-1.1.2-11.el10_0.aarch64.rpm;name=aarch64_google-crc32c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-crc32c-devel}"
SRC_URI[aarch64_google-crc32c-devel.sha256sum] = "e8f404cd6675171f6fa87164f2e060eaa2aaca345442195adc09efac956a5e43"

RDEPENDS:google-crc32c = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:google-crc32c-devel = " \
 cmake-filesystem \
 google-crc32c \
 "
