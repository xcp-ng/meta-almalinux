# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qalculate-gtk"
PV = "5.3.0"
PR = "1.el10_3"
PACKAGES = " \
 qalculate-gtk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qalculate-gtk-5.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d94fbf333b8a3e5f463505c87af851445e59796aac536df4b7f74b7681fd12ba"

URI_x86_64_v2_qalculate-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qalculate-gtk-5.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qalculate-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qalculate-gtk}"
SRC_URI[x86_64_v2_qalculate-gtk.sha256sum] = "17987efaa57b8e8b646d3aa3523867f3fa1fefdfb6a94b23cfa42593e86de908"

URI_aarch64_qalculate-gtk = "${EPEL_MIRROR}/aarch64/Packages/q/qalculate-gtk-5.3.0-1.el10_3.aarch64.rpm;name=aarch64_qalculate-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_qalculate-gtk}"
SRC_URI[aarch64_qalculate-gtk.sha256sum] = "cf2f2e640634c7168fc9409aee7a05001a07d17f2d76824ae69d90054a8b8c97"

RDEPENDS:qalculate-gtk = " \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libgcc \
 libqalculate \
 libstdc++ \
 pango \
 virtual/gnuplot \
 "
