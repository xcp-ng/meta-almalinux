# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyatspi"
PV = "2.46.1"
PR = "5.el10"
PACKAGES = " \
 python3-pyatspi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pyatspi-2.46.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd55cadf022b49996e985c89d0392170c12d5fca37adde1aef4ce36a62360fa6"

URI_x86_64_v2_python3-pyatspi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyatspi-2.46.1-5.el10.noarch.rpm;name=x86_64_v2_python3-pyatspi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyatspi}"
SRC_URI[x86_64_v2_python3-pyatspi.sha256sum] = "add4bfe3cd3f200b17bfb8b1567af3849d7471c34a155ae3cbebfbd465f74705"

URI_aarch64_python3-pyatspi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyatspi-2.46.1-5.el10.noarch.rpm;name=aarch64_python3-pyatspi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyatspi}"
SRC_URI[aarch64_python3-pyatspi.sha256sum] = "add4bfe3cd3f200b17bfb8b1567af3849d7471c34a155ae3cbebfbd465f74705"

RDEPENDS:python3-pyatspi = " \
 at-spi2-core \
 python3 \
 python3-gobject \
 "
