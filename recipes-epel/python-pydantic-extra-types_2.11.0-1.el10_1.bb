# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pydantic-extra-types"
PV = "2.11.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-pydantic-extra-types \
 python3-pydantic-extra-types+cron \
 python3-pydantic-extra-types+python_ulid \
 python3-pydantic-extra-types+semver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pydantic-extra-types-2.11.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7aa784916f695e2e39b290d8b4a5da7b88832abd955564d056fd0389b610daba"

URI_x86_64_v2_python3-pydantic-extra-types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-extra-types-2.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic-extra-types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic-extra-types}"
SRC_URI[x86_64_v2_python3-pydantic-extra-types.sha256sum] = "0c50676ca32d1abee0e1df431d9b4a5185c3212ef5d9d921a5158809a7b2fb90"

URI_x86_64_v2_python3-pydantic-extra-types+cron = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-extra-types+cron-2.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic-extra-types+cron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic-extra-types+cron}"
SRC_URI[x86_64_v2_python3-pydantic-extra-types+cron.sha256sum] = "f7a2bdcb3be5b0ec11d39a765d41556e67a26b0fb4a0bfd34411c916694a8d76"

URI_x86_64_v2_python3-pydantic-extra-types+python_ulid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-extra-types+python_ulid-2.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic-extra-types+python_ulid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic-extra-types+python_ulid}"
SRC_URI[x86_64_v2_python3-pydantic-extra-types+python_ulid.sha256sum] = "709e3fd10417a0dd104df7e6f7c85766006c9d8a488ed44b255877d2584a3afc"

URI_x86_64_v2_python3-pydantic-extra-types+semver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-extra-types+semver-2.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic-extra-types+semver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic-extra-types+semver}"
SRC_URI[x86_64_v2_python3-pydantic-extra-types+semver.sha256sum] = "2a68645521a0174bcae2adefbbccab9ea101f56ea4633a35f91fbf2f949c965c"

URI_aarch64_python3-pydantic-extra-types = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-extra-types-2.11.0-1.el10_1.noarch.rpm;name=aarch64_python3-pydantic-extra-types;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic-extra-types}"
SRC_URI[aarch64_python3-pydantic-extra-types.sha256sum] = "4d7c6b860dd8cc3e7b59d1a42beb7c2a9795f1a2ae5beb45984334742a7dee0b"

URI_aarch64_python3-pydantic-extra-types+cron = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-extra-types+cron-2.11.0-1.el10_1.noarch.rpm;name=aarch64_python3-pydantic-extra-types+cron;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic-extra-types+cron}"
SRC_URI[aarch64_python3-pydantic-extra-types+cron.sha256sum] = "a696aa1c8dbac29b9af24b2938c5dda0315625534b17ebd5debc99bbd87a0946"

URI_aarch64_python3-pydantic-extra-types+python_ulid = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-extra-types+python_ulid-2.11.0-1.el10_1.noarch.rpm;name=aarch64_python3-pydantic-extra-types+python_ulid;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic-extra-types+python_ulid}"
SRC_URI[aarch64_python3-pydantic-extra-types+python_ulid.sha256sum] = "877bc700ec3acc04ba5a0ad872c0f76527cd35c42aa07585a6e81d4a14929b8a"

URI_aarch64_python3-pydantic-extra-types+semver = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-extra-types+semver-2.11.0-1.el10_1.noarch.rpm;name=aarch64_python3-pydantic-extra-types+semver;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic-extra-types+semver}"
SRC_URI[aarch64_python3-pydantic-extra-types+semver.sha256sum] = "1c9cd9b3d196830da617e922285d7ebcdf9ba32b4af1014a5e7a5c04050b8f2d"

RDEPENDS:python3-pydantic-extra-types = " \
 python3 \
 python3-pydantic \
 python3-typing-extensions \
 "
RDEPENDS:python3-pydantic-extra-types+cron = " \
 python3 \
 python3-cron-converter \
 python3-pydantic-extra-types \
 "
RDEPENDS:python3-pydantic-extra-types+python_ulid = " \
 python3 \
 python3-pydantic-extra-types \
 python3-python-ulid \
 "
RDEPENDS:python3-pydantic-extra-types+semver = " \
 python3 \
 python3-pydantic-extra-types \
 python3-semver \
 "
