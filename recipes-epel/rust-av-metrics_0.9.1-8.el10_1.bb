# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-av-metrics"
PV = "0.9.1"
PR = "8.el10_1"
PACKAGES = " \
 rust-av-metrics+default-devel \
 rust-av-metrics+serde-devel \
 rust-av-metrics-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-av-metrics-0.9.1-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "076fa32e05e8887474420b3e5a1ea744dc119efb79d80bab4eccfdd129548b92"

URI_x86_64_v2_rust-av-metrics+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-metrics+default-devel-0.9.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-metrics+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-metrics+default-devel}"
SRC_URI[x86_64_v2_rust-av-metrics+default-devel.sha256sum] = "8768d4939e779f99db61aa60179d996871c300d774b4a873c86d4c4e7b86a8a8"

URI_x86_64_v2_rust-av-metrics+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-metrics+serde-devel-0.9.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-metrics+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-metrics+serde-devel}"
SRC_URI[x86_64_v2_rust-av-metrics+serde-devel.sha256sum] = "196d37b7a0608240096a9d2a2be03b69982c8c33746fa80e172fdcae7c28c7dc"

URI_x86_64_v2_rust-av-metrics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-metrics-devel-0.9.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-metrics-devel}"
SRC_URI[x86_64_v2_rust-av-metrics-devel.sha256sum] = "904846060959ba07c78251219b818fcc6a5a0942492c41e914663e60a55c8e95"

URI_aarch64_rust-av-metrics+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-metrics+default-devel-0.9.1-8.el10_1.noarch.rpm;name=aarch64_rust-av-metrics+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-metrics+default-devel}"
SRC_URI[aarch64_rust-av-metrics+default-devel.sha256sum] = "50a52c816cfb799736726455d66220a609df95c49a50c2219af492f6e84ffcd9"

URI_aarch64_rust-av-metrics+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-metrics+serde-devel-0.9.1-8.el10_1.noarch.rpm;name=aarch64_rust-av-metrics+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-metrics+serde-devel}"
SRC_URI[aarch64_rust-av-metrics+serde-devel.sha256sum] = "3afee9de3108560d4e30eaa2aa76b5b3eaa97d093731b06e79211e6c692644af"

URI_aarch64_rust-av-metrics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-metrics-devel-0.9.1-8.el10_1.noarch.rpm;name=aarch64_rust-av-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-metrics-devel}"
SRC_URI[aarch64_rust-av-metrics-devel.sha256sum] = "955864db07927fbac78a604ef3b65463a3b575a01fe1a5e7d803312b5ad08d3f"

RDEPENDS:rust-av-metrics+default-devel = " \
 cargo \
 rust-av-metrics-devel \
 "
RDEPENDS:rust-av-metrics+serde-devel = " \
 cargo \
 rust-av-metrics-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-av-metrics-devel = " \
 cargo \
 rust-crossbeam+default-devel \
 rust-itertools+default-devel \
 rust-lab+default-devel \
 rust-num-traits+default-devel \
 rust-rayon+default-devel \
 rust-thiserror+default-devel \
 rust-v_frame+default-devel \
 "
