# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-rake-compiler"
PV = "1.3.0"
PR = "2.el10_1"
PACKAGES = " \
 rubygem-rake-compiler \
 rubygem-rake-compiler-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-rake-compiler-1.3.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d7b2e77a299792042fd779b8e68f1913459dbb8beed4cc93f989a312937e88d"

URI_x86_64_v2_rubygem-rake-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-rake-compiler-1.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-rake-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rake-compiler}"
SRC_URI[x86_64_v2_rubygem-rake-compiler.sha256sum] = "20390d832d0947bad091c2ab0b3306e8ce269102c4147e285c8466ab95d0b3c2"

URI_x86_64_v2_rubygem-rake-compiler-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-rake-compiler-doc-1.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-rake-compiler-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rake-compiler-doc}"
SRC_URI[x86_64_v2_rubygem-rake-compiler-doc.sha256sum] = "08570cc5e49399407f161002dc0c002f0397342e0036ee08a9d155347740c7b0"

URI_aarch64_rubygem-rake-compiler = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-rake-compiler-1.3.0-2.el10_1.noarch.rpm;name=aarch64_rubygem-rake-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rake-compiler}"
SRC_URI[aarch64_rubygem-rake-compiler.sha256sum] = "960389bdcdde8bfac4f3dc6d25392a1f59181288fa4885526c94d51ef01d8eb1"

URI_aarch64_rubygem-rake-compiler-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-rake-compiler-doc-1.3.0-2.el10_1.noarch.rpm;name=aarch64_rubygem-rake-compiler-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rake-compiler-doc}"
SRC_URI[aarch64_rubygem-rake-compiler-doc.sha256sum] = "a34973bb4a8c8e8160a0cdc24ee2f70418a577df72afc15422d55f3072e83899"

RDEPENDS:rubygem-rake-compiler = " \
 ruby \
 ruby-libs \
 rubygem-rake \
 rubygems \
 "
RDEPENDS:rubygem-rake-compiler-doc = " \
 rubygem-rake-compiler \
 "
