# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-utils"
PV = "3.5.1"
PR = "8.el10"
PACKAGES = " \
 plexus-utils \
 plexus-utils-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/plexus-utils-3.5.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "059027fd76e75a340b23291c0e9d2625cdf861a4d14f2e068f3df34d5bcfac39"

URI_x86_64_v2_plexus-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plexus-utils-3.5.1-8.el10.noarch.rpm;name=x86_64_v2_plexus-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-utils}"
SRC_URI[x86_64_v2_plexus-utils.sha256sum] = "c75047b690cd8f68ffb3a56515e19589648901a68b55637539926349d50200da"

URI_x86_64_v2_plexus-utils-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-utils-javadoc-3.5.1-8.el10.noarch.rpm;name=x86_64_v2_plexus-utils-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-utils-javadoc}"
SRC_URI[x86_64_v2_plexus-utils-javadoc.sha256sum] = "f50fbe943396bba8b2ab01e6aa4339bbc40c9497c044a761b6a3e8358d0ea2e4"

URI_aarch64_plexus-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plexus-utils-3.5.1-8.el10.noarch.rpm;name=aarch64_plexus-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-utils}"
SRC_URI[aarch64_plexus-utils.sha256sum] = "c75047b690cd8f68ffb3a56515e19589648901a68b55637539926349d50200da"

URI_aarch64_plexus-utils-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-utils-javadoc-3.5.1-8.el10.noarch.rpm;name=aarch64_plexus-utils-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-utils-javadoc}"
SRC_URI[aarch64_plexus-utils-javadoc.sha256sum] = "f50fbe943396bba8b2ab01e6aa4339bbc40c9497c044a761b6a3e8358d0ea2e4"

RDEPENDS:plexus-utils = " \
 javapackages-filesystem \
 "
RDEPENDS:plexus-utils-javadoc = " \
 javapackages-filesystem \
 "
