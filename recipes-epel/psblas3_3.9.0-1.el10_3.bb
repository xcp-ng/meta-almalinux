# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "psblas3"
PV = "3.9.0"
PR = "1.el10_3"
PACKAGES = " \
 psblas3-common \
 psblas3-mpich \
 psblas3-mpich-devel \
 psblas3-mpich-static \
 psblas3-openmpi \
 psblas3-openmpi-devel \
 psblas3-openmpi-static \
 psblas3-serial \
 psblas3-serial-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/psblas3-3.9.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e47f17ca5fb99bef01b4ece58ccdae3888cea91c9e23f43b62bcb84ea8af7e16"

URI_x86_64_v2_psblas3-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/psblas3-common-3.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_psblas3-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_psblas3-common}"
SRC_URI[x86_64_v2_psblas3-common.sha256sum] = "dccb57ed68d09362c9d27e2c9d3d26ea13b04649258d98d8339f5dfb60c1c567"

URI_x86_64_v2_psblas3-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/psblas3-mpich-3.9.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_psblas3-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_psblas3-mpich}"
SRC_URI[x86_64_v2_psblas3-mpich.sha256sum] = "52d048b8a4784c2142f5638973df8cb7c30de43e79de6b0ba02622329252b191"

URI_x86_64_v2_psblas3-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/psblas3-mpich-devel-3.9.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_psblas3-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_psblas3-mpich-devel}"
SRC_URI[x86_64_v2_psblas3-mpich-devel.sha256sum] = "aec9146485c29fbddbf6f239bf979be2247edd9263935a56d02f179588107f91"

URI_x86_64_v2_psblas3-mpich-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/psblas3-mpich-static-3.9.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_psblas3-mpich-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_psblas3-mpich-static}"
SRC_URI[x86_64_v2_psblas3-mpich-static.sha256sum] = "a29606ab6edf21ca1247c219a024f02f7d71bdbdc64157fcd3db49afc2071b72"

URI_x86_64_v2_psblas3-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/psblas3-openmpi-3.9.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_psblas3-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_psblas3-openmpi}"
SRC_URI[x86_64_v2_psblas3-openmpi.sha256sum] = "278ab680a7190c69b31583a6d4e10ef6e4e5056fba9b839e9efe4287e9e8ef73"

URI_x86_64_v2_psblas3-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/psblas3-openmpi-devel-3.9.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_psblas3-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_psblas3-openmpi-devel}"
SRC_URI[x86_64_v2_psblas3-openmpi-devel.sha256sum] = "3e1f66c433a9f87ad979d0be88c115e22a88adbb14c53e5c249f35cdb2c58e51"

URI_x86_64_v2_psblas3-openmpi-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/psblas3-openmpi-static-3.9.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_psblas3-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_psblas3-openmpi-static}"
SRC_URI[x86_64_v2_psblas3-openmpi-static.sha256sum] = "cc3a51fe549b6af72b3daad2b6487bce3e0796c3e52a7b2ac523ad3be7ef0d4a"

URI_x86_64_v2_psblas3-serial = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/psblas3-serial-3.9.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_psblas3-serial;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_psblas3-serial}"
SRC_URI[x86_64_v2_psblas3-serial.sha256sum] = "2f362d6825e22d6cf25c656628b6e763b32fe4a912f84497057b85df6ef6299b"

URI_x86_64_v2_psblas3-serial-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/psblas3-serial-devel-3.9.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_psblas3-serial-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_psblas3-serial-devel}"
SRC_URI[x86_64_v2_psblas3-serial-devel.sha256sum] = "94e9f38e1b90b44df2d2a699d19fa7791e152cef49be0b99240c13629e16b01d"

URI_aarch64_psblas3-common = "${EPEL_MIRROR}/aarch64/Packages/p/psblas3-common-3.9.0-1.el10_3.noarch.rpm;name=aarch64_psblas3-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_psblas3-common}"
SRC_URI[aarch64_psblas3-common.sha256sum] = "10e8e09ff9d4e285e3dc3c46f076529a44701e2892a3b91d5120598eff6b6843"

URI_aarch64_psblas3-mpich = "${EPEL_MIRROR}/aarch64/Packages/p/psblas3-mpich-3.9.0-1.el10_3.aarch64.rpm;name=aarch64_psblas3-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_psblas3-mpich}"
SRC_URI[aarch64_psblas3-mpich.sha256sum] = "5663029c379eebe8e62f664010400787dc7d349d472eb557ad58b5bf7f26145c"

URI_aarch64_psblas3-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/p/psblas3-mpich-devel-3.9.0-1.el10_3.aarch64.rpm;name=aarch64_psblas3-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_psblas3-mpich-devel}"
SRC_URI[aarch64_psblas3-mpich-devel.sha256sum] = "87e3f37049297cb0dbdb70a198b2f1460a081c48775ca62081c1a82dc43f4d86"

URI_aarch64_psblas3-mpich-static = "${EPEL_MIRROR}/aarch64/Packages/p/psblas3-mpich-static-3.9.0-1.el10_3.aarch64.rpm;name=aarch64_psblas3-mpich-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_psblas3-mpich-static}"
SRC_URI[aarch64_psblas3-mpich-static.sha256sum] = "df6e78412eaf9d5e91281f4479869a339b3100bd153971e7e780332fcc049712"

URI_aarch64_psblas3-openmpi = "${EPEL_MIRROR}/aarch64/Packages/p/psblas3-openmpi-3.9.0-1.el10_3.aarch64.rpm;name=aarch64_psblas3-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_psblas3-openmpi}"
SRC_URI[aarch64_psblas3-openmpi.sha256sum] = "43a36602aee872dd852336ca96aa85accc717a0e148ac4732c0ddb9bf66f8337"

URI_aarch64_psblas3-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/p/psblas3-openmpi-devel-3.9.0-1.el10_3.aarch64.rpm;name=aarch64_psblas3-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_psblas3-openmpi-devel}"
SRC_URI[aarch64_psblas3-openmpi-devel.sha256sum] = "74f58fb78eb122b1e3f951a526b8c1377f3b30bc5b24a833033d181955653fc5"

URI_aarch64_psblas3-openmpi-static = "${EPEL_MIRROR}/aarch64/Packages/p/psblas3-openmpi-static-3.9.0-1.el10_3.aarch64.rpm;name=aarch64_psblas3-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_psblas3-openmpi-static}"
SRC_URI[aarch64_psblas3-openmpi-static.sha256sum] = "626ba04a4e445b96fdd2ebaba106865707e57f57bd8e91791fe7475c8e794424"

URI_aarch64_psblas3-serial = "${EPEL_MIRROR}/aarch64/Packages/p/psblas3-serial-3.9.0-1.el10_3.aarch64.rpm;name=aarch64_psblas3-serial;unpack=0"
SRC_URI:append = " ${URI_aarch64_psblas3-serial}"
SRC_URI[aarch64_psblas3-serial.sha256sum] = "0d36fee373d75daa6c102411d1501c18356e13dfb1030c44b70a20130fd5f13a"

URI_aarch64_psblas3-serial-devel = "${EPEL_MIRROR}/aarch64/Packages/p/psblas3-serial-devel-3.9.0-1.el10_3.aarch64.rpm;name=aarch64_psblas3-serial-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_psblas3-serial-devel}"
SRC_URI[aarch64_psblas3-serial-devel.sha256sum] = "5e7659d65c8a79cbab3d616cc64a931cce0aba37be6d6bcc3e27557b7e7cf542"

RDEPENDS:psblas3-common = " \
 "
RDEPENDS:psblas3-mpich = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 metis \
 mpich \
 psblas3-common \
 suitesparse \
 "
RDEPENDS:psblas3-mpich-devel = " \
 psblas3-mpich \
 "
RDEPENDS:psblas3-mpich-static = " \
 mpich \
 "
RDEPENDS:psblas3-openmpi = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 metis \
 openmpi \
 psblas3-common \
 suitesparse \
 "
RDEPENDS:psblas3-openmpi-devel = " \
 psblas3-openmpi \
 "
RDEPENDS:psblas3-openmpi-static = " \
 openmpi \
 "
RDEPENDS:psblas3-serial = " \
 flexiblas-netlib \
 gcc-gfortran \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 metis \
 psblas3-common \
 suitesparse \
 "
RDEPENDS:psblas3-serial-devel = " \
 psblas3-serial \
 "
