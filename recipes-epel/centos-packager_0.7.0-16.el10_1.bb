# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "centos-packager"
PV = "0.7.0"
PR = "16.el10_1"
PACKAGES = " \
 centos-packager \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/centos-packager-0.7.0-16.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c03103d5fd9f3baf289def8fc582be2017eb31b967ac1a602a83406dd41ace89"

URI_x86_64_v2_centos-packager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/centos-packager-0.7.0-16.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_centos-packager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_centos-packager}"
SRC_URI[x86_64_v2_centos-packager.sha256sum] = "633579ac606496aaf1d6a2c9ac2e6b13dc48999e37dc0783217995bde0ee090c"

URI_aarch64_centos-packager = "${EPEL_MIRROR}/aarch64/Packages/c/centos-packager-0.7.0-16.el10_1.noarch.rpm;name=aarch64_centos-packager;unpack=0"
SRC_URI:append = " ${URI_aarch64_centos-packager}"
SRC_URI[aarch64_centos-packager.sha256sum] = "e1bcfd11f14feebb6ccf18c788f3fd40971a10c9a3934d7f8278512d91ce503f"

RDEPENDS:centos-packager = " \
 bash \
 bc \
 curl \
 fasjson-client \
 koji \
 krb5-workstation \
 mock \
 openssh-clients \
 openssl \
 python3-fasjson-client \
 redhat-rpm-config \
 rpm-build \
 rpmdevtools \
 rpmlint \
 "
