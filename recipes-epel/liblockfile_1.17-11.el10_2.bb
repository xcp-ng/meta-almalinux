# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liblockfile"
PV = "1.17"
PR = "11.el10_2"
PACKAGES = " \
 liblockfile \
 liblockfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/liblockfile-1.17-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2008c0828b17493a329744d54f36dd0e64f7c521691931708fd82d28105fc8a"

URI_x86_64_v2_liblockfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblockfile-1.17-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblockfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblockfile}"
SRC_URI[x86_64_v2_liblockfile.sha256sum] = "73584a92a7d2da6f552663336efa307cd89009a1aeedac2e59c5e503c1eb2a6f"

URI_x86_64_v2_liblockfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblockfile-devel-1.17-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblockfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblockfile-devel}"
SRC_URI[x86_64_v2_liblockfile-devel.sha256sum] = "b76f62533cce5c1a1184eeebbd8dc40a575de9c2fa88a029740cd6cef663bf95"

URI_aarch64_liblockfile = "${EPEL_MIRROR}/aarch64/Packages/l/liblockfile-1.17-11.el10_2.aarch64.rpm;name=aarch64_liblockfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblockfile}"
SRC_URI[aarch64_liblockfile.sha256sum] = "caf87b074b6e340de853e663bd3f96d4ff792ddb8282ed64b51c69f5cb9a43e5"

URI_aarch64_liblockfile-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liblockfile-devel-1.17-11.el10_2.aarch64.rpm;name=aarch64_liblockfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblockfile-devel}"
SRC_URI[aarch64_liblockfile-devel.sha256sum] = "92ae76544360ee7dc16701b6452150b5d7716c52f72d51b0501f99b731d8def5"

RDEPENDS:liblockfile = " \
 glibc \
 "
RDEPENDS:liblockfile-devel = " \
 liblockfile \
 "
