# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-interpolation"
PV = "1.27"
PR = "4.el10"
PACKAGES = " \
 plexus-interpolation \
 plexus-interpolation-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/plexus-interpolation-1.27-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c2aa70355140cbdeb47735d841012beaf42f80cbaa90e8ff967a808cf2f377c"

URI_x86_64_v2_plexus-interpolation = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plexus-interpolation-1.27-4.el10.noarch.rpm;name=x86_64_v2_plexus-interpolation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-interpolation}"
SRC_URI[x86_64_v2_plexus-interpolation.sha256sum] = "9a5a016771f128ec995723ebb79f555518b2aae0cece859a55e722b217afd3e2"

URI_x86_64_v2_plexus-interpolation-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-interpolation-javadoc-1.27-4.el10.noarch.rpm;name=x86_64_v2_plexus-interpolation-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-interpolation-javadoc}"
SRC_URI[x86_64_v2_plexus-interpolation-javadoc.sha256sum] = "e5bbd9af2ed44626b8fbcbe1a8b67e8a4ec405a4b604d9c18f797d3fd8f23a35"

URI_aarch64_plexus-interpolation = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plexus-interpolation-1.27-4.el10.noarch.rpm;name=aarch64_plexus-interpolation;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-interpolation}"
SRC_URI[aarch64_plexus-interpolation.sha256sum] = "9a5a016771f128ec995723ebb79f555518b2aae0cece859a55e722b217afd3e2"

URI_aarch64_plexus-interpolation-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-interpolation-javadoc-1.27-4.el10.noarch.rpm;name=aarch64_plexus-interpolation-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-interpolation-javadoc}"
SRC_URI[aarch64_plexus-interpolation-javadoc.sha256sum] = "e5bbd9af2ed44626b8fbcbe1a8b67e8a4ec405a4b604d9c18f797d3fd8f23a35"

RDEPENDS:plexus-interpolation = " \
 javapackages-filesystem \
 "
RDEPENDS:plexus-interpolation-javadoc = " \
 javapackages-filesystem \
 "
