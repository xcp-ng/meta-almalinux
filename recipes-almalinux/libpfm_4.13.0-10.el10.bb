# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpfm"
PV = "4.13.0"
PR = "10.el10"
PACKAGES = " \
 libpfm \
 libpfm-devel \
 python3-libpfm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libpfm-4.13.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2eb240321a167fcc3435d09d9a99326e03406df36ccca19e4e9d1550dcca1fcb"

URI_x86_64_v2_libpfm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpfm-4.13.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_libpfm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpfm}"
SRC_URI[x86_64_v2_libpfm.sha256sum] = "adbc4e1d3d76aca2b8017e6b11e5912ba4de5ba0f45964f50c672e88aa5a1470"

URI_x86_64_v2_libpfm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpfm-devel-4.13.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_libpfm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpfm-devel}"
SRC_URI[x86_64_v2_libpfm-devel.sha256sum] = "b6963990c165dce3ff98598c460aac184d115cbe5a775d742a0409bb73daff9c"

URI_x86_64_v2_python3-libpfm = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-libpfm-4.13.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libpfm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libpfm}"
SRC_URI[x86_64_v2_python3-libpfm.sha256sum] = "9cee6a1fdf3aaf68f0993f21de7e67e536ac287d066d731dc674bf7531635c79"

URI_aarch64_libpfm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpfm-4.13.0-10.el10.aarch64.rpm;name=aarch64_libpfm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpfm}"
SRC_URI[aarch64_libpfm.sha256sum] = "4cde1b07b743c4ae38b122d72c30795c3bcded87484474ad6b16b9d4adf157c5"

URI_aarch64_libpfm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpfm-devel-4.13.0-10.el10.aarch64.rpm;name=aarch64_libpfm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpfm-devel}"
SRC_URI[aarch64_libpfm-devel.sha256sum] = "baf3d27f111f58693f9567e897cbc21e0d8374a453577b7c0a71583726216011"

URI_aarch64_python3-libpfm = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-libpfm-4.13.0-10.el10.aarch64.rpm;name=aarch64_python3-libpfm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libpfm}"
SRC_URI[aarch64_python3-libpfm.sha256sum] = "347e9d9ed0693b9f27d2643a07b0ac0ede7be7cc437cabfeb0bfb3b3097be5fc"

RDEPENDS:libpfm = " \
 glibc \
 "
RDEPENDS:libpfm-devel = " \
 libpfm \
 "
RDEPENDS:python3-libpfm = " \
 glibc \
 libpfm \
 python3 \
 "
