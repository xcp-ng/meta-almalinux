# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "checkpolicy"
PV = "3.11"
PR = "1.el10"
PACKAGES = " \
 checkpolicy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/checkpolicy-3.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4d53c7aab4456f46060a82e923aeb1a78c8dd081c960f327715676c8f57ae1d"

URI_x86_64_v2_checkpolicy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/checkpolicy-3.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_checkpolicy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_checkpolicy}"
SRC_URI[x86_64_v2_checkpolicy.sha256sum] = "6673049f1a7e13bd6c49ce65846e429cef2c4002cd6d21d800619b2dbb75d141"

URI_aarch64_checkpolicy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/checkpolicy-3.11-1.el10.aarch64.rpm;name=aarch64_checkpolicy;unpack=0"
SRC_URI:append = " ${URI_aarch64_checkpolicy}"
SRC_URI[aarch64_checkpolicy.sha256sum] = "f7c38ac6414092d40042778eb74d75d29c1b10d2ddfac6ec0bbe5e7c71851014"

RDEPENDS:checkpolicy = " \
 glibc \
 "
