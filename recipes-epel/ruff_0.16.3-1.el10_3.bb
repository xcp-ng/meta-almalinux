# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruff"
PV = "0.16.3"
PR = "1.el10_3"
PACKAGES = " \
 python3-ruff \
 ruff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/ruff-0.16.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0cc9473a00af6cbcefa7be80ad7e7d7add90fc8e16cba2038f88b46b6599b70"

URI_aarch64_python3-ruff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ruff-0.16.3-1.el10_3.noarch.rpm;name=aarch64_python3-ruff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ruff}"
SRC_URI[aarch64_python3-ruff.sha256sum] = "31b2e7ba6bb28805a8da1da7cc0442cd2cae8f391bf8f44d047c38cddf1d3d5f"

URI_aarch64_ruff = "${EPEL_MIRROR}/aarch64/Packages/r/ruff-0.16.3-1.el10_3.aarch64.rpm;name=aarch64_ruff;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruff}"
SRC_URI[aarch64_ruff.sha256sum] = "9c15a0f2baedc469416523aae18db2926bf237e60b790f41348ef707312b7fba"

RDEPENDS:python3-ruff = " \
 python3 \
 ruff \
 "
RDEPENDS:ruff = " \
 glibc \
 jemalloc \
 libgcc \
 "
