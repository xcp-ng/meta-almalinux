# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "polkit-kde"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 polkit-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/polkit-kde-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5aacf24dc0d335a873c215587e98f742d60abce29ce731d259ee28c9667f3ad"

URI_x86_64_v2_polkit-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-kde-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-kde}"
SRC_URI[x86_64_v2_polkit-kde.sha256sum] = "2620546758765c99fcaa028d59d05ee06aa198150c14b25119ffe08bc18894b3"

URI_aarch64_polkit-kde = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-kde-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_polkit-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-kde}"
SRC_URI[aarch64_polkit-kde.sha256sum] = "b6e193e4099964455265237cf517779d308df81117747bdda15b305198f0b36f"

RDEPENDS:polkit-kde = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwindowsystem \
 libstdc++ \
 polkit \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
