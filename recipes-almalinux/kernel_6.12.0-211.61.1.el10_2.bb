# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kernel"
PV = "6.12.0"
PR = "211.61.1.el10_2"
PACKAGES:x86_64_v2 = " \
 kernel \
 kernel-abi-stablelists \
 kernel-core \
 kernel-cross-headers \
 kernel-debug \
 kernel-debug-core \
 kernel-debug-devel \
 kernel-debug-devel-matched \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 kernel-debug-uki-virt \
 kernel-devel \
 kernel-devel-matched \
 kernel-doc \
 kernel-headers \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 kernel-modules-extra-matched \
 kernel-tools \
 kernel-tools-libs \
 kernel-tools-libs-devel \
 kernel-uki-virt \
 kernel-uki-virt-addons \
 libperf \
 perf \
 python3-perf \
 rtla \
 rv \
"
PACKAGES:aarch64 = " \
 kernel \
 kernel-64k \
 kernel-64k-core \
 kernel-64k-debug \
 kernel-64k-debug-core \
 kernel-64k-debug-devel \
 kernel-64k-debug-devel-matched \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 kernel-64k-debug-modules-extra \
 kernel-64k-devel \
 kernel-64k-devel-matched \
 kernel-64k-modules \
 kernel-64k-modules-core \
 kernel-64k-modules-extra \
 kernel-abi-stablelists \
 kernel-core \
 kernel-cross-headers \
 kernel-debug \
 kernel-debug-core \
 kernel-debug-devel \
 kernel-debug-devel-matched \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 kernel-devel \
 kernel-devel-matched \
 kernel-doc \
 kernel-headers \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 kernel-modules-extra-matched \
 kernel-tools \
 kernel-tools-libs \
 kernel-tools-libs-devel \
 kernel-uki-virt \
 kernel-uki-virt-addons \
 libperf \
 perf \
 python3-perf \
 rtla \
 rv \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kernel-6.12.0-211.61.1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "43c2090167270cfed7530d98182a693a3c40f929c3182fbfc5164c41e640ca32"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel;unpack=0"
SRC_URI[x86_64_v2_kernel.sha256sum] = "7aee34393292a791ea496321973d2ae5cb2975045f178970bca11833862aa6f3"
RPROVIDES:kernel:append:x86_64_v2 = " virtual/kernel"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-abi-stablelists-6.12.0-211.61.1.el10_2.noarch.rpm;name=x86_64_v2_kernel-abi-stablelists;unpack=0"
SRC_URI[x86_64_v2_kernel-abi-stablelists.sha256sum] = "7473c6fc31239b380b4d38753d69377747a820418018f74a7f1029950089aa33"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-core-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-core;unpack=0"
SRC_URI[x86_64_v2_kernel-core.sha256sum] = "79d070ac2a5559bf065098288cb1b011488faad9c7117f2939e3bd0d8ad346ff"
RPROVIDES:kernel-core:append:x86_64_v2 = " virtual/kernel virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.x86_64_v2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kernel-cross-headers-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-cross-headers;unpack=0"
SRC_URI[x86_64_v2_kernel-cross-headers.sha256sum] = "3054b608f014a55de2e4ab3fa887fa6428db9c033d745c0160c9ba77d2a63ed5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug;unpack=0"
SRC_URI[x86_64_v2_kernel-debug.sha256sum] = "8ddcccbf29182d55b77b9181cb1c213bf9b184bedc3dd9be54c7a457f5a4d741"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-core-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-core;unpack=0"
SRC_URI[x86_64_v2_kernel-debug-core.sha256sum] = "7f8c7db85baa3bf13b7e6cf7e9310a3746f34c5a0172db564e78a99389f45bab"
RPROVIDES:kernel-debug-core:append:x86_64_v2 = " virtual/kernel virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.x86_64_v2+debug"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-debug-devel-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-devel;unpack=0"
SRC_URI[x86_64_v2_kernel-debug-devel.sha256sum] = "a894930a68f663a095963816ab3566b7a2f3711b68e11cb0e8056b00257e197e"
RPROVIDES:kernel-debug-devel:append:x86_64_v2 = " virtual/kernel-devel-uname-r"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-debug-devel-matched-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-devel-matched;unpack=0"
SRC_URI[x86_64_v2_kernel-debug-devel-matched.sha256sum] = "c26f7be1e7406d11395f20182bcddde7b9b4c73bde0fdd6849586f3dc0e404fc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules;unpack=0"
SRC_URI[x86_64_v2_kernel-debug-modules.sha256sum] = "ef8dbfa0a3e86ed5123c62afb5ef6ec19465d0ee71c2354fea2ce5edb2040b9f"
RPROVIDES:kernel-debug-modules:append:x86_64_v2 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-core-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules-core;unpack=0"
SRC_URI[x86_64_v2_kernel-debug-modules-core.sha256sum] = "3920ba3c5097f8ba1dffccbe1c84151c51d7c290eae1071e7b8e76778252cb47"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-extra-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules-extra;unpack=0"
SRC_URI[x86_64_v2_kernel-debug-modules-extra.sha256sum] = "cb48aa61b825ecc07403d6a2b05c80f5efafae2805fb1e898a4a0587b8135fe8"
RPROVIDES:kernel-debug-modules-extra:append:x86_64_v2 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-uki-virt-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-uki-virt;unpack=0"
SRC_URI[x86_64_v2_kernel-debug-uki-virt.sha256sum] = "1ba363de3d33b5cb790f0dee3dee69a667f45e1236b1fe0b152f0b0011355620"
RPROVIDES:kernel-debug-uki-virt:append:x86_64_v2 = " virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.x86_64_v2+debug"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-devel-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-devel;unpack=0"
SRC_URI[x86_64_v2_kernel-devel.sha256sum] = "8fd38044ac924f531068d2467715a618d1fa2f965f6fd31fa84ef540b2bf4af2"
RPROVIDES:kernel-devel:append:x86_64_v2 = " virtual/kernel-devel-uname-r"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-devel-matched-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-devel-matched;unpack=0"
SRC_URI[x86_64_v2_kernel-devel-matched.sha256sum] = "89c251b015c1cda6c18b5469618a8ec3c881be659801edf842a9d885d2aa887d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-doc-6.12.0-211.61.1.el10_2.noarch.rpm;name=x86_64_v2_kernel-doc;unpack=0"
SRC_URI[x86_64_v2_kernel-doc.sha256sum] = "6d745d7d315fc5f6d99298e2a1473d86795b33684aeb63850538eb9f248208c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-headers-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-headers;unpack=0"
SRC_URI[x86_64_v2_kernel-headers.sha256sum] = "33691a40532a006c8d1024fcdc8ebb5c7caa79a87a38857d9c0022490d795591"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-modules;unpack=0"
SRC_URI[x86_64_v2_kernel-modules.sha256sum] = "672cb47267e0d3d955e106c4e198c9fb68e2c1f11c1fa33024a6e672ab33f0ab"
RPROVIDES:kernel-modules:append:x86_64_v2 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-core-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-core;unpack=0"
SRC_URI[x86_64_v2_kernel-modules-core.sha256sum] = "20c2e96256b3d782f6bf1b947a0498ae91fc2c2a7f86ee114e000038da30a10d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-extra-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-extra;unpack=0"
SRC_URI[x86_64_v2_kernel-modules-extra.sha256sum] = "9485ff50ba254255404194d04502b45c5f749cdacff6cd1217fcafc6fd97f86f"
RPROVIDES:kernel-modules-extra:append:x86_64_v2 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-extra-matched-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-extra-matched;unpack=0"
SRC_URI[x86_64_v2_kernel-modules-extra-matched.sha256sum] = "74caea32dc492f88085abd4f155626a6f7476afea4b540e41f4ecf33303c4993"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-tools-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-tools;unpack=0"
SRC_URI[x86_64_v2_kernel-tools.sha256sum] = "d884bdfd5cd02a401e45a8d0c45f61ace5a910262b250d0e12e8048bb89f8f2f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-tools-libs-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-tools-libs;unpack=0"
SRC_URI[x86_64_v2_kernel-tools-libs.sha256sum] = "dd76284f63b7a629d3ae987c0554a902e80388961829db32a15b0a10664c84bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kernel-tools-libs-devel-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-tools-libs-devel;unpack=0"
SRC_URI[x86_64_v2_kernel-tools-libs-devel.sha256sum] = "fcccf44c9d58e05aeb66e1764d31e8c622e63d7418b70c6ad70ccc4fd9c6349d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-uki-virt-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-uki-virt;unpack=0"
SRC_URI[x86_64_v2_kernel-uki-virt.sha256sum] = "240c0d0df9601511ed89e0774c93a220ea2bba8dc0044bb42bc464a84f600436"
RPROVIDES:kernel-uki-virt:append:x86_64_v2 = " virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.x86_64_v2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-uki-virt-addons-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-uki-virt-addons;unpack=0"
SRC_URI[x86_64_v2_kernel-uki-virt-addons.sha256sum] = "1216d35e5030eaed6133906b29cbb21ebf6f0f5441705f341ae7386eae24e3e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libperf-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libperf;unpack=0"
SRC_URI[x86_64_v2_libperf.sha256sum] = "01118b1ed0e6c02d3ea10034e0008a2854fa1bc21fc8d67da22703f58cca3c69"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perf-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_perf;unpack=0"
SRC_URI[x86_64_v2_perf.sha256sum] = "9ba9d5e2e0cf3b7c5ab79941942ad235571d1b043c48d77b833a62aaa66d09dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-perf-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-perf;unpack=0"
SRC_URI[x86_64_v2_python3-perf.sha256sum] = "0171dc007a5554796ba56e0cf4a20c8359001e2135856657dd76934bdc17208e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rtla-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_rtla;unpack=0"
SRC_URI[x86_64_v2_rtla.sha256sum] = "a3c203d71e69b283d56ab1704dceffa400af1e794d13272b7dd71948bb46c761"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rv-6.12.0-211.61.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_rv;unpack=0"
SRC_URI[x86_64_v2_rv.sha256sum] = "ed0cccaa7eba8d2ae7b0837a81bcba725f1746f9a9eee7eb9eb526e7eaa4e9b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel;unpack=0"
SRC_URI[aarch64_kernel.sha256sum] = "7fc674445485d7b110688945476838094a101f6ee6aad9171c10c8a800556a7a"
RPROVIDES:kernel:append:aarch64 = " virtual/kernel"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k;unpack=0"
SRC_URI[aarch64_kernel-64k.sha256sum] = "becb21840940786b02cc1d77dc2c22c32a6b7ffdc075fb87dee29e76513fb68a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-core-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-core;unpack=0"
SRC_URI[aarch64_kernel-64k-core.sha256sum] = "abc41c27c25e198a4eec9ab06e0fa4c045d8b144d9763877ec8ee24000f35d74"
RPROVIDES:kernel-64k-core:append:aarch64 = " virtual/kernel"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-debug;unpack=0"
SRC_URI[aarch64_kernel-64k-debug.sha256sum] = "782759da33e3bc26776a11ca338b064636f63cf0a632fb80bc76c057bfdfb061"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-core-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-debug-core;unpack=0"
SRC_URI[aarch64_kernel-64k-debug-core.sha256sum] = "6f4240d6f626ea004ff6a5e6df28a607ce5091e326c708b481a2114ecc75a48d"
RPROVIDES:kernel-64k-debug-core:append:aarch64 = " virtual/kernel"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-debug-devel-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-debug-devel;unpack=0"
SRC_URI[aarch64_kernel-64k-debug-devel.sha256sum] = "b1aa7bb7de32a129cbfba82490c40db755eba2222a7b28b233c9ebe09a9b043a"
RPROVIDES:kernel-64k-debug-devel:append:aarch64 = " virtual/kernel-devel-uname-r"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-debug-devel-matched-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-debug-devel-matched;unpack=0"
SRC_URI[aarch64_kernel-64k-debug-devel-matched.sha256sum] = "17c81aaf3d1f86cdf10713174e310d01e4762943b140b1e28d616174d0d05946"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-debug-modules;unpack=0"
SRC_URI[aarch64_kernel-64k-debug-modules.sha256sum] = "e1fa12857ba95c917beba796fc2dcc65309d8cd73acfa8e80c83bce8313e375c"
RPROVIDES:kernel-64k-debug-modules:append:aarch64 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-core-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-debug-modules-core;unpack=0"
SRC_URI[aarch64_kernel-64k-debug-modules-core.sha256sum] = "a200d3b7d9469ca7f9792e35881904667513ad9c0e8f31745404bfd3a00b7ee7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-extra-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-debug-modules-extra;unpack=0"
SRC_URI[aarch64_kernel-64k-debug-modules-extra.sha256sum] = "54d7f0239c39a92abe6c4edc3b0dbeac6b3d3bcabbce776c85aa642877354828"
RPROVIDES:kernel-64k-debug-modules-extra:append:aarch64 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-devel-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-devel;unpack=0"
SRC_URI[aarch64_kernel-64k-devel.sha256sum] = "4e18bee804c1679cc892152acb11b8bb78bac910e398eb33d1135e010ac4475b"
RPROVIDES:kernel-64k-devel:append:aarch64 = " virtual/kernel-devel-uname-r"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-devel-matched-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-devel-matched;unpack=0"
SRC_URI[aarch64_kernel-64k-devel-matched.sha256sum] = "fd9799ddb1f7e6fada5ab95718a299b8c537b8e22497861a9f0df7d98830a369"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-modules;unpack=0"
SRC_URI[aarch64_kernel-64k-modules.sha256sum] = "59d665c929a0f9330d88b509816c1e4ef3dd76bfdc796fab8a77e69fb932d770"
RPROVIDES:kernel-64k-modules:append:aarch64 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-core-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-modules-core;unpack=0"
SRC_URI[aarch64_kernel-64k-modules-core.sha256sum] = "7d5318e9f3e9cc353ede6f66808cc72475391921a6705c4f274961d3caf8a806"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-extra-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-modules-extra;unpack=0"
SRC_URI[aarch64_kernel-64k-modules-extra.sha256sum] = "171512b29d03c71226daa5b85b6ca72ff880e63e0ca3505c1a01fb038cb4ab91"
RPROVIDES:kernel-64k-modules-extra:append:aarch64 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-abi-stablelists-6.12.0-211.61.1.el10_2.noarch.rpm;name=aarch64_kernel-abi-stablelists;unpack=0"
SRC_URI[aarch64_kernel-abi-stablelists.sha256sum] = "7473c6fc31239b380b4d38753d69377747a820418018f74a7f1029950089aa33"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-core-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-core;unpack=0"
SRC_URI[aarch64_kernel-core.sha256sum] = "e94c804bb28e950a524eafdcd8f60d1c32867d90b964a15bbadac122ac71a3d6"
RPROVIDES:kernel-core:append:aarch64 = " virtual/kernel virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.aarch64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kernel-cross-headers-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-cross-headers;unpack=0"
SRC_URI[aarch64_kernel-cross-headers.sha256sum] = "95f344733cae4c35f7b42f93ae34e55dd8c4376e179139eb7bd39a19ad706f64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-debug;unpack=0"
SRC_URI[aarch64_kernel-debug.sha256sum] = "a9fda176ec7fa56b8bacaf5a71d7cb24388a28f31e57db365786b7e92f96a8fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-core-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-debug-core;unpack=0"
SRC_URI[aarch64_kernel-debug-core.sha256sum] = "299ed367624b55857cb64833f2e7a40318119f9b8ae6b818e833a7b6a60f7d61"
RPROVIDES:kernel-debug-core:append:aarch64 = " virtual/kernel"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-debug-devel-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-debug-devel;unpack=0"
SRC_URI[aarch64_kernel-debug-devel.sha256sum] = "82d6bf67ccb5ca6adbca3946bf21c3727eb79987fa0c963a4aa4ae98e42dd056"
RPROVIDES:kernel-debug-devel:append:aarch64 = " virtual/kernel-devel-uname-r"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-debug-devel-matched-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-debug-devel-matched;unpack=0"
SRC_URI[aarch64_kernel-debug-devel-matched.sha256sum] = "8e0b103440f2a8fe3f17a84419701ef0220ee0e289eab79614134aba6988bcfd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-debug-modules;unpack=0"
SRC_URI[aarch64_kernel-debug-modules.sha256sum] = "baccac2a868a8d378f286b33e77d1a9d11b763d113220a8880cbed658e276815"
RPROVIDES:kernel-debug-modules:append:aarch64 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-core-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-debug-modules-core;unpack=0"
SRC_URI[aarch64_kernel-debug-modules-core.sha256sum] = "7b0704d756e681a18bde3c04bf5e732a7db3d53f252548ef29725f8172376bb8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-extra-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-debug-modules-extra;unpack=0"
SRC_URI[aarch64_kernel-debug-modules-extra.sha256sum] = "56e187f7a3dafbfa3812526f9f29d3d118ad4340bf5d76905dc346a608f9ba18"
RPROVIDES:kernel-debug-modules-extra:append:aarch64 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-devel-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-devel;unpack=0"
SRC_URI[aarch64_kernel-devel.sha256sum] = "95078330ed8f43051c202a472d54aff9e3bad13910f6cd7ce097c5e885419aaa"
RPROVIDES:kernel-devel:append:aarch64 = " virtual/kernel-devel-uname-r"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-devel-matched-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-devel-matched;unpack=0"
SRC_URI[aarch64_kernel-devel-matched.sha256sum] = "13f3df00819c2a88ec08de4cb47e435721d7b0454b35e353ec38d33fa6ec1289"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-doc-6.12.0-211.61.1.el10_2.noarch.rpm;name=aarch64_kernel-doc;unpack=0"
SRC_URI[aarch64_kernel-doc.sha256sum] = "6d745d7d315fc5f6d99298e2a1473d86795b33684aeb63850538eb9f248208c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-headers-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-headers;unpack=0"
SRC_URI[aarch64_kernel-headers.sha256sum] = "3b8bca81939c7e87a93204bab5e6e7d5c9e0a77177b8fd399b2f0e5a45293382"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-modules;unpack=0"
SRC_URI[aarch64_kernel-modules.sha256sum] = "4bae5a57caa226f7f64ba2d9aff9d7c06f36fba5402d2a328d0b0db5f254e1c4"
RPROVIDES:kernel-modules:append:aarch64 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-core-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-modules-core;unpack=0"
SRC_URI[aarch64_kernel-modules-core.sha256sum] = "7f982af028889ee2403f7041d21a523fa1f84d7cd49cc846fcc390e8baf4d6e3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-extra-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-modules-extra;unpack=0"
SRC_URI[aarch64_kernel-modules-extra.sha256sum] = "71616f03485b260b3994e2e9bf160eda0b41ed440d16af818f1a42922ed025bf"
RPROVIDES:kernel-modules-extra:append:aarch64 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-extra-matched-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-modules-extra-matched;unpack=0"
SRC_URI[aarch64_kernel-modules-extra-matched.sha256sum] = "f2b290c0233116a512f601569175a830bb6a96fac0f6acc228489ed8ed463086"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-tools-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-tools;unpack=0"
SRC_URI[aarch64_kernel-tools.sha256sum] = "792750afd8041ac4607a82ac881445cb3c1853567be82755e7db4fe8da6facce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-tools-libs-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-tools-libs;unpack=0"
SRC_URI[aarch64_kernel-tools-libs.sha256sum] = "76b1f44500767cbdda2e6989f13ab684b946f5c31ead3a921a5558e3cf2c4ac3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kernel-tools-libs-devel-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-tools-libs-devel;unpack=0"
SRC_URI[aarch64_kernel-tools-libs-devel.sha256sum] = "4a794d566e9fe26e299225818701543344ab0fa278e514eadcaa4e25146a1c08"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-uki-virt-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-uki-virt;unpack=0"
SRC_URI[aarch64_kernel-uki-virt.sha256sum] = "2483764ea9eb77f14bcaea665b66c0af6e202a0bf650685a5bd4e738150756ce"
RPROVIDES:kernel-uki-virt:append:aarch64 = " virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.aarch64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-uki-virt-addons-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_kernel-uki-virt-addons;unpack=0"
SRC_URI[aarch64_kernel-uki-virt-addons.sha256sum] = "93553233090feb5eb84b331d6638ce90453351741364610f10e56a34451e5542"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libperf-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_libperf;unpack=0"
SRC_URI[aarch64_libperf.sha256sum] = "31b92bc777c058d18b729e46897f15926c3ab1b5ccaacd5a0bf8740d03ab51bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perf-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_perf;unpack=0"
SRC_URI[aarch64_perf.sha256sum] = "ae781cf01d38057f52a46786a300b7fff17cd7ee6b2fa4a267483107ca433d9d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-perf-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_python3-perf;unpack=0"
SRC_URI[aarch64_python3-perf.sha256sum] = "ca5c161d99ec791857ec67bf9741ecf77b90dbc081e8500660962bc0e7fffac4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rtla-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_rtla;unpack=0"
SRC_URI[aarch64_rtla.sha256sum] = "b0f8032f53bf12221f82c020da4283ee2e89494c86f232574932089be530e2aa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rv-6.12.0-211.61.1.el10_2.aarch64.rpm;name=aarch64_rv;unpack=0"
SRC_URI[aarch64_rv.sha256sum] = "69b93c7c4388c9fa9f11eb68053f6656df8e0e1beed63a1f53d08536a6949d57"

RDEPENDS:kernel = " \
 kernel-core \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 "
RDEPENDS:kernel-abi-stablelists = " \
 "
RDEPENDS:kernel-core = " \
 bash \
 dracut \
 kernel-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-cross-headers = " \
 "
RDEPENDS:kernel-debug = " \
 kernel-debug-core \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 "
RDEPENDS:kernel-debug-core = " \
 bash \
 dracut \
 kernel-debug-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-debug-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-debug-devel-matched = " \
 kernel-debug-core \
 kernel-debug-devel \
 "
RDEPENDS:kernel-debug-modules:x86_64_v2 = " \
 bash \
 kernel-debug-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules:aarch64 = " \
 bash \
 kernel-debug-core \
 kernel-debug-modules-core \
"
RDEPENDS:kernel-debug-modules-core:x86_64_v2 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules-core:aarch64 = " \
 bash \
 kernel-debug-core \
"
RDEPENDS:kernel-debug-modules-extra:x86_64_v2 = " \
 bash \
 kernel-debug-modules \
 kernel-debug-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules-extra:aarch64 = " \
 bash \
 kernel-debug-core \
 kernel-debug-modules \
 kernel-debug-modules-core \
"
RDEPENDS:kernel-debug-uki-virt = " \
 bash \
 kernel-debug-modules-core \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-devel-matched = " \
 kernel-core \
 kernel-devel \
 "
RDEPENDS:kernel-doc = " \
 "
RDEPENDS:kernel-headers = " \
 "
RDEPENDS:kernel-modules:x86_64_v2 = " \
 bash \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.x86_64_v2 \
"
RDEPENDS:kernel-modules:aarch64 = " \
 bash \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.aarch64 \
"
RDEPENDS:kernel-modules-core:x86_64_v2 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.x86_64_v2 \
"
RDEPENDS:kernel-modules-core:aarch64 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.aarch64 \
"
RDEPENDS:kernel-modules-extra:x86_64_v2 = " \
 bash \
 kernel-modules \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.x86_64_v2 \
"
RDEPENDS:kernel-modules-extra:aarch64 = " \
 bash \
 kernel-modules \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-211.61.1.el10_2.aarch64 \
"
RDEPENDS:kernel-modules-extra-matched = " \
 "
RDEPENDS:kernel-tools:x86_64_v2 = " \
 glibc \
 kernel-tools-libs \
 libcap \
 libnl3 \
 ncurses-libs \
 pciutils-libs \
 python3 \
 python3-jsonschema \
 python3-pyyaml \
"
RDEPENDS:kernel-tools:aarch64 = " \
 glibc \
 kernel-tools-libs \
 ncurses-libs \
 python3 \
 python3-jsonschema \
 python3-pyyaml \
"
RDEPENDS:kernel-tools-libs = " \
 bash \
 glibc \
 "
RDEPENDS:kernel-tools-libs-devel = " \
 glibc \
 kernel-tools \
 kernel-tools-libs \
 python3 \
 "
RDEPENDS:kernel-uki-virt = " \
 bash \
 kernel-modules-core \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-uki-virt-addons = " \
 kernel-uki-virt \
 systemd \
 "
RDEPENDS:libperf = " \
 glibc \
 "
RDEPENDS:perf:x86_64_v2 = " \
 bash \
 bzip2 \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 perf \
 perl-Exporter \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:perf:aarch64 = " \
 bash \
 bzip2 \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 opencsd \
 perf \
 perl-Exporter \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:python3-perf:x86_64_v2 = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 perl-libs \
 python3 \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:python3-perf:aarch64 = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 opencsd \
 perl-libs \
 python3 \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:rtla = " \
 glibc \
 kernel-tools-libs \
 libbpf \
 libtraceevent \
 libtracefs \
 "
RDEPENDS:rv = " \
 glibc \
 libtraceevent \
 libtracefs \
 "
RDEPENDS:kernel-64k = " \
 kernel-64k-core \
 kernel-64k-modules \
 kernel-64k-modules-core \
 kernel-64k-modules-extra \
 "
RDEPENDS:kernel-64k-core = " \
 bash \
 dracut \
 kernel-64k-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-64k-debug = " \
 kernel-64k-debug-core \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 kernel-64k-debug-modules-extra \
 "
RDEPENDS:kernel-64k-debug-core = " \
 bash \
 dracut \
 kernel-64k-debug-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-64k-debug-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-64k-debug-devel-matched = " \
 kernel-64k-debug-core \
 kernel-64k-debug-devel \
 "
RDEPENDS:kernel-64k-debug-modules = " \
 bash \
 kernel-64k-debug-core \
 kernel-64k-debug-modules-core \
 "
RDEPENDS:kernel-64k-debug-modules-core = " \
 bash \
 kernel-64k-debug-core \
 "
RDEPENDS:kernel-64k-debug-modules-extra = " \
 bash \
 kernel-64k-debug-core \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 "
RDEPENDS:kernel-64k-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-64k-devel-matched = " \
 kernel-64k-core \
 kernel-64k-devel \
 "
RDEPENDS:kernel-64k-modules = " \
 bash \
 kernel-64k-core \
 kernel-64k-modules-core \
 "
RDEPENDS:kernel-64k-modules-core = " \
 bash \
 kernel-64k-core \
 "
RDEPENDS:kernel-64k-modules-extra = " \
 bash \
 kernel-64k-core \
 kernel-64k-modules \
 kernel-64k-modules-core \
 "
