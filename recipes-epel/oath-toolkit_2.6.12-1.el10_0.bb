# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oath-toolkit"
PV = "2.6.12"
PR = "1.el10_0"
PACKAGES = " \
 liboath \
 liboath-devel \
 liboath-doc \
 libpskc \
 libpskc-devel \
 libpskc-doc \
 oathtool \
 pam_oath \
 pskctool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/oath-toolkit-2.6.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "031b316021cc0551def6c50a9481daa630b580d98afef24897b9e0ca320ed2fa"

URI_x86_64_v2_liboath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liboath-2.6.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liboath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liboath}"
SRC_URI[x86_64_v2_liboath.sha256sum] = "dc3097b0cab1e5020984f244a1c26c4074ec9c6476349956a928658b5cb12534"

URI_x86_64_v2_liboath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liboath-devel-2.6.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liboath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liboath-devel}"
SRC_URI[x86_64_v2_liboath-devel.sha256sum] = "19dbdd09a6554d493e1b5bfc169ce210104f47998319d5acbdb0e1e6ed4b60b6"

URI_x86_64_v2_liboath-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liboath-doc-2.6.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_liboath-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liboath-doc}"
SRC_URI[x86_64_v2_liboath-doc.sha256sum] = "74d89ee11a2ce96e425f490c0f415c6dec0200162561c84d61130c0db8dd99a6"

URI_x86_64_v2_libpskc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpskc-2.6.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpskc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpskc}"
SRC_URI[x86_64_v2_libpskc.sha256sum] = "b2dfe9dd4f454e561d19f48c4883d26ae78f6e76a6c5d0ae0a97aaea3eb2ce2f"

URI_x86_64_v2_libpskc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpskc-devel-2.6.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpskc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpskc-devel}"
SRC_URI[x86_64_v2_libpskc-devel.sha256sum] = "d683ed2fd24146ff19b99e9dd4b56a2988d35bac2823a2c8891ef1c06d776559"

URI_x86_64_v2_libpskc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpskc-doc-2.6.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libpskc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpskc-doc}"
SRC_URI[x86_64_v2_libpskc-doc.sha256sum] = "0e1afb1aa6ecbde65bea62d8897729a4f2f40ac9a203cb8a19198ac28ba5427a"

URI_x86_64_v2_oathtool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oathtool-2.6.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oathtool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oathtool}"
SRC_URI[x86_64_v2_oathtool.sha256sum] = "25b13880fa9490d8b1d80c278a7567329795c239c697ac33323b7f3e4e76abcb"

URI_x86_64_v2_pam_oath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_oath-2.6.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_oath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_oath}"
SRC_URI[x86_64_v2_pam_oath.sha256sum] = "188fc0e5276959cd56a94903bbff118d5657141f4af4d020d80fda7b4d9df253"

URI_x86_64_v2_pskctool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pskctool-2.6.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pskctool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pskctool}"
SRC_URI[x86_64_v2_pskctool.sha256sum] = "195937bbd543d2bb15eeccc2fd551a86079900b8d420f79a2741678bee648419"

URI_aarch64_liboath = "${EPEL_MIRROR}/aarch64/Packages/l/liboath-2.6.12-1.el10_0.aarch64.rpm;name=aarch64_liboath;unpack=0"
SRC_URI:append = " ${URI_aarch64_liboath}"
SRC_URI[aarch64_liboath.sha256sum] = "ac17351554b3d648e3472d26edf133ddc08292e36151f4f6c200f52f93dd534c"

URI_aarch64_liboath-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liboath-devel-2.6.12-1.el10_0.aarch64.rpm;name=aarch64_liboath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liboath-devel}"
SRC_URI[aarch64_liboath-devel.sha256sum] = "888a742d46dd425c4200164dbc8ffc88a78c3d3f72489d9f63d6721649665694"

URI_aarch64_liboath-doc = "${EPEL_MIRROR}/aarch64/Packages/l/liboath-doc-2.6.12-1.el10_0.noarch.rpm;name=aarch64_liboath-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_liboath-doc}"
SRC_URI[aarch64_liboath-doc.sha256sum] = "091c28307b540d31e631670bd87ba52c14e4521e554c9486f19de5644887287d"

URI_aarch64_libpskc = "${EPEL_MIRROR}/aarch64/Packages/l/libpskc-2.6.12-1.el10_0.aarch64.rpm;name=aarch64_libpskc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpskc}"
SRC_URI[aarch64_libpskc.sha256sum] = "8e0867f56706c8abb6f0f02617a2034cdb51ca9b7ad9c8dceeae2196dcfb1adb"

URI_aarch64_libpskc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libpskc-devel-2.6.12-1.el10_0.aarch64.rpm;name=aarch64_libpskc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpskc-devel}"
SRC_URI[aarch64_libpskc-devel.sha256sum] = "564eda41d2147fe778683698d6bfde53f5c5ff4af67949a9932155dc2ab9a909"

URI_aarch64_libpskc-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libpskc-doc-2.6.12-1.el10_0.noarch.rpm;name=aarch64_libpskc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpskc-doc}"
SRC_URI[aarch64_libpskc-doc.sha256sum] = "96df09ceab9ead9f7406397871aedc26f5c9b90870b247720fa2c975748c9b9c"

URI_aarch64_oathtool = "${EPEL_MIRROR}/aarch64/Packages/o/oathtool-2.6.12-1.el10_0.aarch64.rpm;name=aarch64_oathtool;unpack=0"
SRC_URI:append = " ${URI_aarch64_oathtool}"
SRC_URI[aarch64_oathtool.sha256sum] = "634c40965058e5ed691a0a3c7b1f15995d396b60c47a178b946018bb9d00355c"

URI_aarch64_pam_oath = "${EPEL_MIRROR}/aarch64/Packages/p/pam_oath-2.6.12-1.el10_0.aarch64.rpm;name=aarch64_pam_oath;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_oath}"
SRC_URI[aarch64_pam_oath.sha256sum] = "65a4870307bf7d0409154ea4f699e563bc1e6a5e19822d97e3f28b56b07d0a24"

URI_aarch64_pskctool = "${EPEL_MIRROR}/aarch64/Packages/p/pskctool-2.6.12-1.el10_0.aarch64.rpm;name=aarch64_pskctool;unpack=0"
SRC_URI:append = " ${URI_aarch64_pskctool}"
SRC_URI[aarch64_pskctool.sha256sum] = "5e167424481193e140e87d66b77ca572545902bf9b777843c8c1de43203c19a6"

RDEPENDS:liboath = " \
 glibc \
 "
RDEPENDS:liboath-devel = " \
 liboath \
 pkgconf-pkg-config \
 "
RDEPENDS:liboath-doc = " \
 gtk-doc \
 liboath \
 "
RDEPENDS:libpskc = " \
 glibc \
 libxml2 \
 xml-common \
 xmlsec1 \
 "
RDEPENDS:libpskc-devel = " \
 libpskc \
 pkgconf-pkg-config \
 "
RDEPENDS:libpskc-doc = " \
 gtk-doc \
 libpskc \
 "
RDEPENDS:oathtool = " \
 glibc \
 liboath \
 "
RDEPENDS:pam_oath = " \
 glibc \
 liboath \
 pam \
 pam-libs \
 "
RDEPENDS:pskctool = " \
 glibc \
 libpskc \
 xmlsec1-openssl \
 "
