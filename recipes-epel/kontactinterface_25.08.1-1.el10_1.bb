# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kontactinterface"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kontactinterface \
 kontactinterface-devel \
 kontactinterface-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kontactinterface-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58afda40b5e0162ad5a26513bb43e7b3f016f7d958f904b74eb0ef50a77fe9a5"

URI_x86_64_v2_kontactinterface = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontactinterface;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontactinterface}"
SRC_URI[x86_64_v2_kontactinterface.sha256sum] = "6b10e089a3e7ded14fedaec10ecb28476c54a4f91715da36ce1ef8be3899dd9e"

URI_x86_64_v2_kontactinterface-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontactinterface-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontactinterface-devel}"
SRC_URI[x86_64_v2_kontactinterface-devel.sha256sum] = "3bb3b28c20f54588054d03a45ecd45586926da140d6adcd14b23a07cf1a235f8"

URI_x86_64_v2_kontactinterface-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kontactinterface-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontactinterface-doc}"
SRC_URI[x86_64_v2_kontactinterface-doc.sha256sum] = "c54d786634d0ea48bf2100d36ba02e51297d3298801cc445dbce51369f1a4b39"

URI_aarch64_kontactinterface = "${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kontactinterface;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontactinterface}"
SRC_URI[aarch64_kontactinterface.sha256sum] = "073f8991d07b051b5c8dcfef2ab6c5ceb0fce47d19c27eed5b6814a0c2b44f37"

URI_aarch64_kontactinterface-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kontactinterface-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontactinterface-devel}"
SRC_URI[aarch64_kontactinterface-devel.sha256sum] = "a37097f92da5b865dec02d97c79bbffab69c677fd7ab7c195d1576cbec53007b"

URI_aarch64_kontactinterface-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kontactinterface-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontactinterface-doc}"
SRC_URI[aarch64_kontactinterface-doc.sha256sum] = "27bc82ea77597254b338fb3dedf0098190777eef6c4dfdfa66610265b4ce9f41"

RDEPENDS:kontactinterface = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kontactinterface-devel = " \
 cmake-filesystem \
 kf6-kparts-devel \
 kontactinterface \
 "
RDEPENDS:kontactinterface-doc = " \
 "
