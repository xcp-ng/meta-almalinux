# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libusb-compat-0.1"
PV = "0.1.9"
PR = "1.el10_2"
PACKAGES = " \
 libusb-compat-0.1 \
 libusb-compat-0.1-devel \
 libusb-compat-0.1-tests-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libusb-compat-0.1-0.1.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfd0dd3d0a54bb2135910c5c162e4a52e4930c8328be11f9cbc8d4ac989b440c"

URI_x86_64_v2_libusb-compat-0.1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusb-compat-0.1-0.1.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusb-compat-0.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb-compat-0.1}"
SRC_URI[x86_64_v2_libusb-compat-0.1.sha256sum] = "3a6cc9d2bc154d8581747c78d65a34d0abfdefd9ef1c9d3c34344ad6f196d3a5"

URI_x86_64_v2_libusb-compat-0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusb-compat-0.1-devel-0.1.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusb-compat-0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb-compat-0.1-devel}"
SRC_URI[x86_64_v2_libusb-compat-0.1-devel.sha256sum] = "dce86a74d9ba87cb80c2db263eba0ce4a29dd320290c2431bb617bd2fa765869"

URI_x86_64_v2_libusb-compat-0.1-tests-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusb-compat-0.1-tests-examples-0.1.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusb-compat-0.1-tests-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb-compat-0.1-tests-examples}"
SRC_URI[x86_64_v2_libusb-compat-0.1-tests-examples.sha256sum] = "62982e72d3bd1c02e9ef19f7bbe9400d5940fc2ffcc8b3e39bbf636d3a2d6c64"

URI_aarch64_libusb-compat-0.1 = "${EPEL_MIRROR}/aarch64/Packages/l/libusb-compat-0.1-0.1.9-1.el10_2.aarch64.rpm;name=aarch64_libusb-compat-0.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb-compat-0.1}"
SRC_URI[aarch64_libusb-compat-0.1.sha256sum] = "0ee80363f9828bdf317f0e5199b6b2b08de022a668266e6166fabbcc8f1c8232"

URI_aarch64_libusb-compat-0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libusb-compat-0.1-devel-0.1.9-1.el10_2.aarch64.rpm;name=aarch64_libusb-compat-0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb-compat-0.1-devel}"
SRC_URI[aarch64_libusb-compat-0.1-devel.sha256sum] = "491c64c11bc73dba32b075ff8d7a20180d7edce184225dc154b8680211d70293"

URI_aarch64_libusb-compat-0.1-tests-examples = "${EPEL_MIRROR}/aarch64/Packages/l/libusb-compat-0.1-tests-examples-0.1.9-1.el10_2.aarch64.rpm;name=aarch64_libusb-compat-0.1-tests-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb-compat-0.1-tests-examples}"
SRC_URI[aarch64_libusb-compat-0.1-tests-examples.sha256sum] = "1c7bdbeb114de263150da287d142a68fe1886b12868cbc340bc539246835df0c"

RDEPENDS:libusb-compat-0.1 = " \
 glibc \
 libusb1 \
 "
RDEPENDS:libusb-compat-0.1-devel = " \
 bash \
 libusb-compat-0.1 \
 libusb1-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libusb-compat-0.1-tests-examples = " \
 glibc \
 libusb-compat-0.1 \
 "
