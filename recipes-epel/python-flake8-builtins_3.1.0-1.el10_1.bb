# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flake8-builtins"
PV = "3.1.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-flake8-builtins \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-flake8-builtins-3.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "035706b69fc532af6e66e1ef0b52587a562c0af75f33b3800d4269e9368679c9"

URI_x86_64_v2_python3-flake8-builtins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flake8-builtins-3.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flake8-builtins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flake8-builtins}"
SRC_URI[x86_64_v2_python3-flake8-builtins.sha256sum] = "3743add018ef3896d616ce429d26f78830b63046d0a170279ca139de4be8147d"

URI_aarch64_python3-flake8-builtins = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flake8-builtins-3.1.0-1.el10_1.noarch.rpm;name=aarch64_python3-flake8-builtins;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flake8-builtins}"
SRC_URI[aarch64_python3-flake8-builtins.sha256sum] = "e4e932bf4e71bc26b3b6eb1816099b984c32633562de50aed98364fc93cab74c"

RDEPENDS:python3-flake8-builtins = " \
 python3 \
 python3-flake8 \
 "
