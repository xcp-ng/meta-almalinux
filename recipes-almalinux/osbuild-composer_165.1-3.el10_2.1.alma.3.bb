# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osbuild-composer"
PV = "165.1"
PR = "3.el10_2.1.alma.3"
PACKAGES = " \
 osbuild-composer \
 osbuild-composer-core \
 osbuild-composer-worker \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/osbuild-composer-165.1-3.el10_2.1.alma.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "227878e4f65f7fada953123add078c88955b9853a7b8540453be0116666a2e43"

URI_x86_64_v2_osbuild-composer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-composer-165.1-3.el10_2.1.alma.3.x86_64_v2.rpm;name=x86_64_v2_osbuild-composer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-composer}"
SRC_URI[x86_64_v2_osbuild-composer.sha256sum] = "5ed5ad0f0d5dc36c80efa92d1fe48135a864c9e0880e09f680733c8ef096cebd"

URI_x86_64_v2_osbuild-composer-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-composer-core-165.1-3.el10_2.1.alma.3.x86_64_v2.rpm;name=x86_64_v2_osbuild-composer-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-composer-core}"
SRC_URI[x86_64_v2_osbuild-composer-core.sha256sum] = "290cd3932ad7a5738892690cc85374e2dcf75068cffe30bdd96f43d7ff01c7bb"

URI_x86_64_v2_osbuild-composer-worker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-composer-worker-165.1-3.el10_2.1.alma.3.x86_64_v2.rpm;name=x86_64_v2_osbuild-composer-worker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-composer-worker}"
SRC_URI[x86_64_v2_osbuild-composer-worker.sha256sum] = "ea9b002913de51b6a465c48b1996f0eab0262f3b1b77a2d28a25e8423db94621"

URI_aarch64_osbuild-composer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-composer-165.1-3.el10_2.1.alma.3.aarch64.rpm;name=aarch64_osbuild-composer;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-composer}"
SRC_URI[aarch64_osbuild-composer.sha256sum] = "954f666de69e01435f4ddc563bc02109abe9da1f496fad627ec2bc03a12a3447"

URI_aarch64_osbuild-composer-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-composer-core-165.1-3.el10_2.1.alma.3.aarch64.rpm;name=aarch64_osbuild-composer-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-composer-core}"
SRC_URI[aarch64_osbuild-composer-core.sha256sum] = "d03914881df18ac885947ef174a74f3d95edb20d3993a67c8b7cfb3ce95ec0dd"

URI_aarch64_osbuild-composer-worker = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-composer-worker-165.1-3.el10_2.1.alma.3.aarch64.rpm;name=aarch64_osbuild-composer-worker;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-composer-worker}"
SRC_URI[aarch64_osbuild-composer-worker.sha256sum] = "cbb7a995b66054ab226ae742fb86c13985d51c0b26b95cd1333caba0d94821db"

RDEPENDS:osbuild-composer = " \
 bash \
 osbuild-composer-core \
 osbuild-composer-worker \
 systemd \
 "
RDEPENDS:osbuild-composer-core = " \
 glibc \
 gpgme \
 libxcrypt \
 osbuild-depsolve-dnf \
 "
RDEPENDS:osbuild-composer-worker = " \
 bash \
 glibc \
 gpgme \
 krb5-libs \
 libcom_err \
 libxcrypt \
 osbuild \
 osbuild-depsolve-dnf \
 osbuild-luks2 \
 osbuild-lvm2 \
 osbuild-ostree \
 qemu-img \
 systemd \
 "
