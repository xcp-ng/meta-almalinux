# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnupg2"
PV = "2.4.5"
PR = "4.el10_1"
PACKAGES = " \
 gnupg2 \
 gnupg2-smime \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gnupg2-2.4.5-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bc8e634fdc58ec638b8efc33519a5d3e3145c58a048b0c79913fbfbc81147c6a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gnupg2-2.4.5-4.el10_1.x86_64_v2.rpm;name=x86_64_v2_gnupg2;unpack=0"
SRC_URI[x86_64_v2_gnupg2.sha256sum] = "95ea656845e0d0a36483e89dfcec17e036968ee1d6c7216ee41240336f09c18b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnupg2-smime-2.4.5-4.el10_1.x86_64_v2.rpm;name=x86_64_v2_gnupg2-smime;unpack=0"
SRC_URI[x86_64_v2_gnupg2-smime.sha256sum] = "8e60fedc6dffa644842696826204b6354a4264c656e22853032de7821dbe7c0a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gnupg2-2.4.5-4.el10_1.aarch64.rpm;name=aarch64_gnupg2;unpack=0"
SRC_URI[aarch64_gnupg2.sha256sum] = "99de55f8627eb06a495c4e8e37815596cf1219c525c9d43c611bf5a8e08a849c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnupg2-smime-2.4.5-4.el10_1.aarch64.rpm;name=aarch64_gnupg2-smime;unpack=0"
SRC_URI[aarch64_gnupg2-smime.sha256sum] = "6a32f56e2f4f5c58e6a8e0501c7d69336c01fd91ea651b0f6fc03058418e3199"

RDEPENDS:gnupg2 = " \
 bash \
 bzip2-libs \
 glibc \
 gnutls \
 libassuan \
 libgcrypt \
 libgpg-error \
 libksba \
 npth \
 openldap \
 readline \
 sqlite-libs \
 tpm2-tss \
 zlib-ng-compat \
 "
RDEPENDS:gnupg2-smime = " \
 glibc \
 gnupg2 \
 libassuan \
 libgcrypt \
 libgpg-error \
 libksba \
 npth \
 readline \
 "
