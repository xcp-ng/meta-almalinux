# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-der_derive"
PV = "0.7.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-der_derive+default-devel \
 rust-der_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-der_derive-0.7.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "badfbad880547076264e5623b531143c14d4279d5fc90830944e6a306e024c4f"

URI_x86_64_v2_rust-der_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der_derive+default-devel-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der_derive+default-devel}"
SRC_URI[x86_64_v2_rust-der_derive+default-devel.sha256sum] = "8219ce20337ddd079348765d430ac27914951fdbe0da576c410a2e325874f2b8"

URI_x86_64_v2_rust-der_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der_derive-devel-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der_derive-devel}"
SRC_URI[x86_64_v2_rust-der_derive-devel.sha256sum] = "de13577b0a2a82c6c170a0442306ada4e90480347be6487b7aaf4469a954b165"

URI_aarch64_rust-der_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der_derive+default-devel-0.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-der_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der_derive+default-devel}"
SRC_URI[aarch64_rust-der_derive+default-devel.sha256sum] = "b2c9f691085f1df053be6c49bc69f9a80b8f586dd48c9873daf83d6ccacc7119"

URI_aarch64_rust-der_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der_derive-devel-0.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-der_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der_derive-devel}"
SRC_URI[aarch64_rust-der_derive-devel.sha256sum] = "43a996ccef8c8a8e01a1e187de1215c6325c3ba4c8941b073748418d14ecb9f0"

RDEPENDS:rust-der_derive+default-devel = " \
 cargo \
 rust-der_derive-devel \
 "
RDEPENDS:rust-der_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 "
