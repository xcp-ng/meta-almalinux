# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-mailmap"
PV = "0.25.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-mailmap+default-devel \
 rust-gix-mailmap+document-features-devel \
 rust-gix-mailmap+serde-devel \
 rust-gix-mailmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-mailmap-0.25.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b0e27ee18d869b568b6b6f980ff6f0ec523d001dddaef1417fcb39a2d8e9e7f"

URI_x86_64_v2_rust-gix-mailmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap+default-devel-0.25.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap+default-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap+default-devel.sha256sum] = "d612fcb2e2017fbab9459c1a9e7c6f2ec4b67b21cb8f30c07bd34298c2a0ddc7"

URI_x86_64_v2_rust-gix-mailmap+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap+document-features-devel-0.25.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap+document-features-devel.sha256sum] = "86b19cc03789540cbbb2be6a48c9c008fb2e78a890acd013f0b844e3e87f242e"

URI_x86_64_v2_rust-gix-mailmap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap+serde-devel-0.25.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap+serde-devel.sha256sum] = "ad76d7746fdbf8371842e1b98b817ed491ca65fae8efe8d50c883265b6815d50"

URI_x86_64_v2_rust-gix-mailmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap-devel-0.25.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap-devel.sha256sum] = "ac54a027a5e75f3150ae833112d930fa46b3f14a3382b0a219852419c4b4f909"

URI_aarch64_rust-gix-mailmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap+default-devel-0.25.2-1.el10_0.noarch.rpm;name=aarch64_rust-gix-mailmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap+default-devel}"
SRC_URI[aarch64_rust-gix-mailmap+default-devel.sha256sum] = "03533d729b273a23e3115f97365c73e7de3f4df67ceb3e9e4d274743e6b1f4fa"

URI_aarch64_rust-gix-mailmap+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap+document-features-devel-0.25.2-1.el10_0.noarch.rpm;name=aarch64_rust-gix-mailmap+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap+document-features-devel}"
SRC_URI[aarch64_rust-gix-mailmap+document-features-devel.sha256sum] = "6aca4e36b6ae304c9c14aeaf73db6576dd6f65159522bec14604cdc3b9ba4346"

URI_aarch64_rust-gix-mailmap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap+serde-devel-0.25.2-1.el10_0.noarch.rpm;name=aarch64_rust-gix-mailmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap+serde-devel}"
SRC_URI[aarch64_rust-gix-mailmap+serde-devel.sha256sum] = "e5baca50f6a5c69256034a3f53251e84abc2bf3cd4bdfbaea36a5b49952b851d"

URI_aarch64_rust-gix-mailmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap-devel-0.25.2-1.el10_0.noarch.rpm;name=aarch64_rust-gix-mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap-devel}"
SRC_URI[aarch64_rust-gix-mailmap-devel.sha256sum] = "e18672b50b792be35681252b2bf075b56fca10bb28f8b4a7d0d568e1dcde9bd8"

RDEPENDS:rust-gix-mailmap+default-devel = " \
 cargo \
 rust-gix-mailmap-devel \
 "
RDEPENDS:rust-gix-mailmap+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-mailmap-devel \
 "
RDEPENDS:rust-gix-mailmap+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-actor+serde-devel \
 rust-gix-mailmap-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-mailmap-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-actor+default-devel \
 rust-gix-date+default-devel \
 rust-thiserror+default-devel \
 "
