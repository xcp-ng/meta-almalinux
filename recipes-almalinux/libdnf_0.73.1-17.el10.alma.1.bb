# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdnf"
PV = "0.73.1"
PR = "17.el10.alma.1"
PACKAGES = " \
 libdnf \
 libdnf-devel \
 python3-hawkey \
 python3-libdnf \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libdnf-0.73.1-17.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "df1d676df8f13ea1809681bb0b0529ef8e4f248ee12501c5677144c14bdac4b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libdnf-0.73.1-17.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libdnf;unpack=0"
SRC_URI[x86_64_v2_libdnf.sha256sum] = "4ffd2764a1fe3a610139edd9fe1c047d53eb39364a9121a0873d9ede7aeed9ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdnf-devel-0.73.1-17.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libdnf-devel;unpack=0"
SRC_URI[x86_64_v2_libdnf-devel.sha256sum] = "5ece410183ceaedbad765db56e7b0e4d756f53573083b183b5f68768e1a35a8f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-hawkey-0.73.1-17.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-hawkey;unpack=0"
SRC_URI[x86_64_v2_python3-hawkey.sha256sum] = "d945d15cf4235b5ede9813b1b7dc76f55ad2b985a5848d6cd421da33578f694a"
RPROVIDES:python3-hawkey:append:x86_64_v2 = " virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libdnf-0.73.1-17.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-libdnf;unpack=0"
SRC_URI[x86_64_v2_python3-libdnf.sha256sum] = "ebc3436f13ea7d23098d09511db6f080bd17f3977a126997756b15df7426e441"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libdnf-0.73.1-17.el10.alma.1.aarch64.rpm;name=aarch64_libdnf;unpack=0"
SRC_URI[aarch64_libdnf.sha256sum] = "643fd7f489379f97378a75914f02a342eec87e700cf74d576ba5c569582ede3c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdnf-devel-0.73.1-17.el10.alma.1.aarch64.rpm;name=aarch64_libdnf-devel;unpack=0"
SRC_URI[aarch64_libdnf-devel.sha256sum] = "288217cb480e5cd523b0eec98ec803875ae089109d3d6aaf35c1d3528f4fe524"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-hawkey-0.73.1-17.el10.alma.1.aarch64.rpm;name=aarch64_python3-hawkey;unpack=0"
SRC_URI[aarch64_python3-hawkey.sha256sum] = "6d68ce6aa720629e5a307291cbdd66aaa2a3d2773282a9ebc9efb4ea0b4bf06a"
RPROVIDES:python3-hawkey:append:aarch64 = " virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libdnf-0.73.1-17.el10.alma.1.aarch64.rpm;name=aarch64_python3-libdnf;unpack=0"
SRC_URI[aarch64_python3-libdnf.sha256sum] = "ea744ac25c41bec8c2a6f43b2c9e30832ae5cc2657d7127680163469d3a5aefe"

RDEPENDS:libdnf = " \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libmodulemd \
 librepo \
 libsmartcols \
 libsolv \
 libstdc++ \
 rpm-libs \
 sqlite-libs \
 "
RDEPENDS:libdnf-devel = " \
 glib2-devel \
 libdnf \
 librepo-devel \
 libsolv-devel \
 pkgconf-pkg-config \
 rpm-devel \
 sqlite-devel \
 "
RDEPENDS:python3-hawkey = " \
 glib2 \
 glibc \
 libdnf \
 libgcc \
 libsolv \
 libstdc++ \
 python3 \
 python3-libdnf \
 python3-libs \
 "
RDEPENDS:python3-libdnf = " \
 glibc \
 libdnf \
 libgcc \
 libsmartcols \
 libstdc++ \
 python3 \
 python3-libs \
 "
