# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clamav-unofficial-sigs"
PV = "7.2.5"
PR = "12.el10_0"
PACKAGES = " \
 clamav-unofficial-sigs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/clamav-unofficial-sigs-7.2.5-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "019ebad79c30513163b97fb1df7f18645cb5f714ae139b94b3bdc9182c8e7f87"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-unofficial-sigs-7.2.5-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-unofficial-sigs;unpack=0"
SRC_URI[x86_64_v2_clamav-unofficial-sigs.sha256sum] = "ee764681f64080c911c0f7960324633318317157c68fc60f009b92958b154835"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-unofficial-sigs-7.2.5-12.el10_0.noarch.rpm;name=aarch64_clamav-unofficial-sigs;unpack=0"
SRC_URI[aarch64_clamav-unofficial-sigs.sha256sum] = "c6709f41fa58afb1aa2f5aaf4e8a331e54367515ccf3ac1a2d3d73aaa0881ff8"

RDEPENDS:clamav-unofficial-sigs = " \
 bash \
 bind-utils \
 clamav \
 clamav-freshclam \
 curl \
 diffutils \
 gnupg2 \
 rsync \
 systemd \
 "
