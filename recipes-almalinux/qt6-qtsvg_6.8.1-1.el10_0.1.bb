# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtsvg"
PV = "6.8.1"
PR = "1.el10_0.1"
PACKAGES = " \
 qt6-qtsvg \
 qt6-qtsvg-devel \
 qt6-qtsvg-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtsvg-6.8.1-1.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b4098d9f873b07cdd24ea87bb28b665e612db720dffb47a843ca4bd27aaea34"

URI_x86_64_v2_qt6-qtsvg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtsvg-6.8.1-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsvg}"
SRC_URI[x86_64_v2_qt6-qtsvg.sha256sum] = "156ba71f7852f7705910fa56e2bff7cb0090422a5c64ea2cce0a42dcaeb8fdf5"

URI_x86_64_v2_qt6-qtsvg-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtsvg-devel-6.8.1-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsvg-devel}"
SRC_URI[x86_64_v2_qt6-qtsvg-devel.sha256sum] = "296fb4e6290e0b6202e011c041a7f94fc5b884bfbeeec94b77d29428634daef8"

URI_x86_64_v2_qt6-qtsvg-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtsvg-examples-6.8.1-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsvg-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsvg-examples}"
SRC_URI[x86_64_v2_qt6-qtsvg-examples.sha256sum] = "18c9dd6cd2ff47cf2b5b8e9de44f4d54ecadb00446e30daccf78c5652311b22e"

URI_aarch64_qt6-qtsvg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtsvg-6.8.1-1.el10_0.1.aarch64.rpm;name=aarch64_qt6-qtsvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsvg}"
SRC_URI[aarch64_qt6-qtsvg.sha256sum] = "1335354cf51d5cfdbdf541ec080cd36e554418b7f67ba5e99315dc7629e34f44"

URI_aarch64_qt6-qtsvg-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtsvg-devel-6.8.1-1.el10_0.1.aarch64.rpm;name=aarch64_qt6-qtsvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsvg-devel}"
SRC_URI[aarch64_qt6-qtsvg-devel.sha256sum] = "b86623b24ffcac4ec504a8a0f2b79cce0910e93f0708331801d9e7010ffe0e11"

URI_aarch64_qt6-qtsvg-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtsvg-examples-6.8.1-1.el10_0.1.aarch64.rpm;name=aarch64_qt6-qtsvg-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsvg-examples}"
SRC_URI[aarch64_qt6-qtsvg-examples.sha256sum] = "29c07cbd65f84e71eb63745e298136dbb212d9882b46b56e84bece16d829f2fd"

RDEPENDS:qt6-qtsvg = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:qt6-qtsvg-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtsvg \
 qt6-qtsvg-devel \
 "
RDEPENDS:qt6-qtsvg-examples = " \
 qt6-qtsvg \
 "
