# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iptstate"
PV = "2.2.7"
PR = "9.el10_1"
PACKAGES = " \
 iptstate \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/i/iptstate-2.2.7-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5cf37dd41646a12d18f021bcb7988db0b8c1de208c1cd08107bf4371108bade1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iptstate-2.2.7-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_iptstate;unpack=0"
SRC_URI[x86_64_v2_iptstate.sha256sum] = "ccdcb54016732dca256df53672f9eca9aecfc0512197201fc457df6cc6094a9a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/iptstate-2.2.7-9.el10_1.aarch64.rpm;name=aarch64_iptstate;unpack=0"
SRC_URI[aarch64_iptstate.sha256sum] = "2aa8b51db5ccbfda0ceed1c44f6555f17fba94e2feb8e465489c3449c0d912be"

RDEPENDS:iptstate = " \
 glibc \
 iptables-nft \
 libgcc \
 libnetfilter_conntrack \
 libstdc++ \
 ncurses-libs \
 "
