# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uvw"
PV = "2.12.1"
PR = "9.el10_1"
PACKAGES = " \
 uvw-devel \
 uvw-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/u/uvw-2.12.1-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4bab563195fec65f3c4eb5b97445f4539080885d0c44035623c3592bcb7d60a6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uvw-devel-2.12.1-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uvw-devel;unpack=0"
SRC_URI[x86_64_v2_uvw-devel.sha256sum] = "94f8bc7f1fa04fb85059dd1ca152a623471ea736845fe04b706ce52d5616f46e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uvw-doc-2.12.1-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_uvw-doc;unpack=0"
SRC_URI[x86_64_v2_uvw-doc.sha256sum] = "22c549cb2e6f859893bf3c9b8219e35c88702b564e48804a62f781cf0f39f54b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/uvw-devel-2.12.1-9.el10_1.aarch64.rpm;name=aarch64_uvw-devel;unpack=0"
SRC_URI[aarch64_uvw-devel.sha256sum] = "503c14ebb2d6d702f5667988273e1d9e52bb07b83164330e9fd05d007b3d4d79"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/uvw-doc-2.12.1-9.el10_1.noarch.rpm;name=aarch64_uvw-doc;unpack=0"
SRC_URI[aarch64_uvw-doc.sha256sum] = "3edbe1d1696fe6e8de1b2d0ac2a8d41b11e120c1b309d8031273aadc9575df04"

RDEPENDS:uvw-devel = " \
 cmake-filesystem \
 libuv-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:uvw-doc = " \
 "
