# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-ffi0.26"
PV = "0.26.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-pyo3-ffi0.26+abi3-devel \
 rust-pyo3-ffi0.26+abi3-py310-devel \
 rust-pyo3-ffi0.26+abi3-py311-devel \
 rust-pyo3-ffi0.26+abi3-py312-devel \
 rust-pyo3-ffi0.26+abi3-py313-devel \
 rust-pyo3-ffi0.26+abi3-py314-devel \
 rust-pyo3-ffi0.26+abi3-py37-devel \
 rust-pyo3-ffi0.26+abi3-py38-devel \
 rust-pyo3-ffi0.26+abi3-py39-devel \
 rust-pyo3-ffi0.26+default-devel \
 rust-pyo3-ffi0.26+extension-module-devel \
 rust-pyo3-ffi0.26-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-ffi0.26-0.26.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9b9793be76efa14356f838504277ba1bee351a5874b09dfe6e19e9c9911f5b1"

URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.26+abi3-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.26+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.26+abi3-devel.sha256sum] = "1c3fe73a1db3634c2c9b25f7e14cf4a221df8d9d071a90cb2766a26dafa5d7eb"

URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.26+abi3-py310-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.26+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.26+abi3-py310-devel.sha256sum] = "eac647f7d395e12673509e891b5e5852fe8fb635e07cc680df4ca12956d775e1"

URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.26+abi3-py311-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.26+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.26+abi3-py311-devel.sha256sum] = "22f9aa8baee517998ed06ac1e3ee28dfdcea6026577224f3a9c3c7cded36286f"

URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.26+abi3-py312-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.26+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.26+abi3-py312-devel.sha256sum] = "ebb5660523ceb04c4fbf6dd023d0c686c636044347c1b7695e532d0dc69bf2b7"

URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.26+abi3-py313-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.26+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.26+abi3-py313-devel.sha256sum] = "ff014b9b05b888d03cbe9729ceb4b98e81c1bd98f311f101db1a947c8d7c5a0e"

URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.26+abi3-py314-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.26+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.26+abi3-py314-devel.sha256sum] = "b83844d852eb3df94cdfcf6562897d430e1a8a07fffddac97844927313759c85"

URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.26+abi3-py37-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.26+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.26+abi3-py37-devel.sha256sum] = "02036c3e5806abd74a5bd0f1969f2b2ff3003da2e9933dbfe59cdab77aba8e90"

URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.26+abi3-py38-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.26+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.26+abi3-py38-devel.sha256sum] = "b3b55e2e196b0a95ca4df82e9fb00a4c6d4914adc8a5d9dc2f0f6054f67e611c"

URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.26+abi3-py39-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.26+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.26+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.26+abi3-py39-devel.sha256sum] = "788068c93acbe7a9151161be5a0a19fb7c75b0fcde03defc252d13d01a8ed610"

URI_x86_64_v2_rust-pyo3-ffi0.26+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.26+default-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.26+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.26+default-devel.sha256sum] = "bbfe9b30bf3189676897970e81b99e007fb81a45203fc0bf80aaf16d107561c9"

URI_x86_64_v2_rust-pyo3-ffi0.26+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.26+extension-module-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.26+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.26+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.26+extension-module-devel.sha256sum] = "002c5d1c346ee1857928d6ba88e5fa3323a87421b5c286e8064a546c65be7b8b"

URI_x86_64_v2_rust-pyo3-ffi0.26-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.26-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.26-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.26-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.26-devel.sha256sum] = "8728d25fefc1e451745bb27a8be2c9d2239c5031d8f3a5995a64dcf3788c8979"

URI_aarch64_rust-pyo3-ffi0.26+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.26+abi3-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.26+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.26+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.26+abi3-devel.sha256sum] = "638b97b33ba14a8f7f334a10296fc2baae2d0145a0f3efec0a4cd1fae3246637"

URI_aarch64_rust-pyo3-ffi0.26+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.26+abi3-py310-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.26+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.26+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.26+abi3-py310-devel.sha256sum] = "706f3c7c9021bbf11f6f7018f26ed1ea97eae4cae1deb68d88e3014e97e4e813"

URI_aarch64_rust-pyo3-ffi0.26+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.26+abi3-py311-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.26+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.26+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.26+abi3-py311-devel.sha256sum] = "02bc7335471fb611510ec7e52260e0935d1ca786c8290e502223ca2e1d78ee36"

URI_aarch64_rust-pyo3-ffi0.26+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.26+abi3-py312-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.26+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.26+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.26+abi3-py312-devel.sha256sum] = "6367d10106d90c5bbabe48b38a40322562007730b9d8f7e4db8416e329f26575"

URI_aarch64_rust-pyo3-ffi0.26+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.26+abi3-py313-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.26+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.26+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.26+abi3-py313-devel.sha256sum] = "1dcd46c32cabe346cac958dac48d3f5e84195385455ed209d5c8a49725c635fd"

URI_aarch64_rust-pyo3-ffi0.26+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.26+abi3-py314-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.26+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.26+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.26+abi3-py314-devel.sha256sum] = "c905f8b538d05661f7f45616c5c23dca58608bf8092a6f44aef346abd5f39167"

URI_aarch64_rust-pyo3-ffi0.26+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.26+abi3-py37-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.26+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.26+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.26+abi3-py37-devel.sha256sum] = "761b878d8112d165d1b3f73a3f878793cd9876e4e05d8cc49cc34783f352b4ec"

URI_aarch64_rust-pyo3-ffi0.26+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.26+abi3-py38-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.26+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.26+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.26+abi3-py38-devel.sha256sum] = "0ead5b896c2af1faec9ae27649570bea43982a7edbbbb6e2be59feef963d1cd6"

URI_aarch64_rust-pyo3-ffi0.26+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.26+abi3-py39-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.26+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.26+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.26+abi3-py39-devel.sha256sum] = "ee7dbcf0ef270c686708aaf89150b375eed8fe6bd20263c0b1f7cb0ccff04490"

URI_aarch64_rust-pyo3-ffi0.26+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.26+default-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.26+default-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.26+default-devel.sha256sum] = "6ea586a94527b628f7005831202fe6ebd5ecda1b5b180e7023c3ae75905a602a"

URI_aarch64_rust-pyo3-ffi0.26+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.26+extension-module-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.26+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.26+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.26+extension-module-devel.sha256sum] = "d31baee93cbca3880362b5862b838feda3b0c75eccb91c943382b672a4a88e4a"

URI_aarch64_rust-pyo3-ffi0.26-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.26-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.26-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.26-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.26-devel.sha256sum] = "ebd483c44f38f812efbc6a9ef2a46bb5b1bb1017f51a5312506b4e718b21382c"

RDEPENDS:rust-pyo3-ffi0.26+abi3-devel = " \
 cargo \
 rust-pyo3-ffi0.26-devel \
 "
RDEPENDS:rust-pyo3-ffi0.26+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py311-devel \
 rust-pyo3-ffi0.26-devel \
 "
RDEPENDS:rust-pyo3-ffi0.26+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py312-devel \
 rust-pyo3-ffi0.26-devel \
 "
RDEPENDS:rust-pyo3-ffi0.26+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py313-devel \
 rust-pyo3-ffi0.26-devel \
 "
RDEPENDS:rust-pyo3-ffi0.26+abi3-py313-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py314-devel \
 rust-pyo3-ffi0.26-devel \
 "
RDEPENDS:rust-pyo3-ffi0.26+abi3-py314-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-devel \
 rust-pyo3-ffi0.26-devel \
 "
RDEPENDS:rust-pyo3-ffi0.26+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py38-devel \
 rust-pyo3-ffi0.26-devel \
 "
RDEPENDS:rust-pyo3-ffi0.26+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py39-devel \
 rust-pyo3-ffi0.26-devel \
 "
RDEPENDS:rust-pyo3-ffi0.26+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py310-devel \
 rust-pyo3-ffi0.26-devel \
 "
RDEPENDS:rust-pyo3-ffi0.26+default-devel = " \
 cargo \
 rust-pyo3-ffi0.26-devel \
 "
RDEPENDS:rust-pyo3-ffi0.26+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi0.26-devel \
 "
RDEPENDS:rust-pyo3-ffi0.26-devel = " \
 cargo \
 python3-devel \
 rust \
 rust-libc+default-devel \
 rust-pyo3-build-config0.26+default-devel \
 rust-pyo3-build-config0.26+resolve-config-devel \
 "
