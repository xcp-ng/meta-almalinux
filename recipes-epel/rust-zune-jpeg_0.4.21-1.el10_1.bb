# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zune-jpeg"
PV = "0.4.21"
PR = "1.el10_1"
PACKAGES = " \
 rust-zune-jpeg+default-devel \
 rust-zune-jpeg+log-devel \
 rust-zune-jpeg+neon-devel \
 rust-zune-jpeg+std-devel \
 rust-zune-jpeg+x86-devel \
 rust-zune-jpeg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zune-jpeg-0.4.21-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f22918b1bea8ad9fc0f4c95b9bbdc7b486ca852fbe31d8ea278710183ff6620"

URI_x86_64_v2_rust-zune-jpeg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+default-devel-0.4.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+default-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+default-devel.sha256sum] = "0a0500da2bcf66bda32a1b79a41cb5426fc4bed20a295835e274541ce9931f46"

URI_x86_64_v2_rust-zune-jpeg+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+log-devel-0.4.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+log-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+log-devel.sha256sum] = "fe3038fa51fc497138b836c7f07e09bf5fe146472eabc148f472f0b55aed807d"

URI_x86_64_v2_rust-zune-jpeg+neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+neon-devel-0.4.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+neon-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+neon-devel.sha256sum] = "14ad76f68abd3500e54831cec8d652c7823cb4c5d5e0be04ed842c0a8ccb0f04"

URI_x86_64_v2_rust-zune-jpeg+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+std-devel-0.4.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+std-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+std-devel.sha256sum] = "ebe27f41135dad21743ad87b53dea7166436dbd601b50ede3fa87b5db272d856"

URI_x86_64_v2_rust-zune-jpeg+x86-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+x86-devel-0.4.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+x86-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+x86-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+x86-devel.sha256sum] = "6508c67ff2cacb2a52b27a5341aa126dd2395128eef5f7c09702e2a9bbe661d3"

URI_x86_64_v2_rust-zune-jpeg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg-devel-0.4.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg-devel.sha256sum] = "b6d15bdc7d26618ab89de635a1784c47caf3699fd1510174cca5ce3f1270ad83"

URI_aarch64_rust-zune-jpeg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+default-devel-0.4.21-1.el10_1.noarch.rpm;name=aarch64_rust-zune-jpeg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+default-devel}"
SRC_URI[aarch64_rust-zune-jpeg+default-devel.sha256sum] = "e29f253a1fd01138ee3d0ca24bd4a20bdaebfc4f8f4a06335e74552aeaf31b70"

URI_aarch64_rust-zune-jpeg+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+log-devel-0.4.21-1.el10_1.noarch.rpm;name=aarch64_rust-zune-jpeg+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+log-devel}"
SRC_URI[aarch64_rust-zune-jpeg+log-devel.sha256sum] = "16c0e6ffe48cfc8c80f1f9093aa4541bc36f05962bcfe689be38f8b2d3f05fe4"

URI_aarch64_rust-zune-jpeg+neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+neon-devel-0.4.21-1.el10_1.noarch.rpm;name=aarch64_rust-zune-jpeg+neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+neon-devel}"
SRC_URI[aarch64_rust-zune-jpeg+neon-devel.sha256sum] = "7054ad8391688ade945cab9baaf5e43745b0b4444cb714af7a4c73efbdfbf1b3"

URI_aarch64_rust-zune-jpeg+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+std-devel-0.4.21-1.el10_1.noarch.rpm;name=aarch64_rust-zune-jpeg+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+std-devel}"
SRC_URI[aarch64_rust-zune-jpeg+std-devel.sha256sum] = "db398e2c12f1a46b43ae6f1039aaf577f3eae77f174701d804a734bcb3d1788e"

URI_aarch64_rust-zune-jpeg+x86-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+x86-devel-0.4.21-1.el10_1.noarch.rpm;name=aarch64_rust-zune-jpeg+x86-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+x86-devel}"
SRC_URI[aarch64_rust-zune-jpeg+x86-devel.sha256sum] = "43e4505c8a10c182ec40aced31147e8142dfb909ae51898b0b6ecb1d41e6e7ba"

URI_aarch64_rust-zune-jpeg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg-devel-0.4.21-1.el10_1.noarch.rpm;name=aarch64_rust-zune-jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg-devel}"
SRC_URI[aarch64_rust-zune-jpeg-devel.sha256sum] = "1c56803f298082c47a58582ae413637c2bedbe16cf70ce57f075dd9add3d8379"

RDEPENDS:rust-zune-jpeg+default-devel = " \
 cargo \
 rust-zune-jpeg+neon-devel \
 rust-zune-jpeg+std-devel \
 rust-zune-jpeg+x86-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+log-devel = " \
 cargo \
 rust-zune-core+log-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+neon-devel = " \
 cargo \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+std-devel = " \
 cargo \
 rust-zune-core+std-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+x86-devel = " \
 cargo \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg-devel = " \
 cargo \
 rust-zune-core+default-devel \
 "
