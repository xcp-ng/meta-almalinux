# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tqdm"
PV = "4.67.1"
PR = "2.el10_0"
PACKAGES = " \
 python3-tqdm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tqdm-4.67.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f228fe33523c9e0631230f70a0d9661cb995ba3776c7542519800adba6de27cf"

URI_x86_64_v2_python3-tqdm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tqdm-4.67.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tqdm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tqdm}"
SRC_URI[x86_64_v2_python3-tqdm.sha256sum] = "be7a1a6b199bc27cd418e3ad39c0f6cb5f9100b2f3acaaec2bac346c1a3c2338"

URI_aarch64_python3-tqdm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tqdm-4.67.1-2.el10_0.noarch.rpm;name=aarch64_python3-tqdm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tqdm}"
SRC_URI[aarch64_python3-tqdm.sha256sum] = "57c5d0812bd9d8dcf921641fe73fce46b7e034e555bad23ce77c78a5f6d5e1bb"

RDEPENDS:python3-tqdm = " \
 python3 \
 "
