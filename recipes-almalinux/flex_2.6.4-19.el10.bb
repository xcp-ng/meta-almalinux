# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flex"
PV = "2.6.4"
PR = "19.el10"
PACKAGES = " \
 flex \
 libfl-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/flex-2.6.4-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6934df491088498ba132fb3e9447a6efd88975a40eb4e72781b98acc92c2002c"

URI_x86_64_v2_flex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flex-2.6.4-19.el10.x86_64_v2.rpm;name=x86_64_v2_flex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flex}"
SRC_URI[x86_64_v2_flex.sha256sum] = "ced8a8995cfcfa0ccac6da12565cd133c253ce54b8c735b74c1ec637de70a00c"

URI_x86_64_v2_libfl-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libfl-static-2.6.4-19.el10.x86_64_v2.rpm;name=x86_64_v2_libfl-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfl-static}"
SRC_URI[x86_64_v2_libfl-static.sha256sum] = "8f6d68386f07054077b54db38eeeba32b4a28641af768236ddc01ef235b8b12a"

URI_aarch64_flex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flex-2.6.4-19.el10.aarch64.rpm;name=aarch64_flex;unpack=0"
SRC_URI:append = " ${URI_aarch64_flex}"
SRC_URI[aarch64_flex.sha256sum] = "dd953c85148380cf67fc33eb90568415fab617c687c8b62d6ab88a96368274db"

URI_aarch64_libfl-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfl-static-2.6.4-19.el10.aarch64.rpm;name=aarch64_libfl-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfl-static}"
SRC_URI[aarch64_libfl-static.sha256sum] = "40cc62b13cebab859e4f19a1939d8de0c949455c78b81f027707217d33b377fb"

RDEPENDS:flex = " \
 glibc \
 m4 \
 "
RDEPENDS:libfl-static = " \
 "
