# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "butane"
PV = "0.23.0"
PR = "1.el10"
PACKAGES = " \
 butane \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/butane-0.23.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5752c1f0d4d113de11708de993b08b5b3518ad3d40fb01500b0b37459c08e4f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/butane-0.23.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_butane;unpack=0"
SRC_URI[x86_64_v2_butane.sha256sum] = "542dd15da703aaeaebb5c94ae1561ebfc2c38628f622a04b0aecdce46c84533e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/butane-0.23.0-1.el10.aarch64.rpm;name=aarch64_butane;unpack=0"
SRC_URI[aarch64_butane.sha256sum] = "72b6c84ef5a4fe6cb9e17401d808b8108816bcced0c3bf39cf0f1c86aacaadf3"

RDEPENDS:butane = " \
 glibc \
 "
