# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scipy"
PV = "1.11.3"
PR = "17.el10"
PACKAGES = " \
 python3-scipy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/scipy-1.11.3-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d79151f9fdd950b0d77863520d0da248729a42da51f56ea6c50b738cc10b6930"

URI_x86_64_v2_python3-scipy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-scipy-1.11.3-17.el10.x86_64_v2.rpm;name=x86_64_v2_python3-scipy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-scipy}"
SRC_URI[x86_64_v2_python3-scipy.sha256sum] = "de6fc09bbe3456dc0805e09d4a215e954809d12ca086a5a5bc9b639911160bad"

URI_aarch64_python3-scipy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-scipy-1.11.3-17.el10.aarch64.rpm;name=aarch64_python3-scipy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-scipy}"
SRC_URI[aarch64_python3-scipy.sha256sum] = "29d433febc31d1f3083e4b14ac0e23c95f847182c88ef135c3ffface95e76485"

RDEPENDS:python3-scipy = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 libstdc++ \
 python3 \
 python3-numpy \
 python3-numpy-f2py \
 "
