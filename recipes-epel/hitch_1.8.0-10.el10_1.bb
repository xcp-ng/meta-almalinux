# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hitch"
PV = "1.8.0"
PR = "10.el10_1"
PACKAGES = " \
 hitch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hitch-1.8.0-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9307e42032dce2dc418f653a8af20195d7686a080d0396b0b12a504a5a5609a7"

URI_x86_64_v2_hitch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hitch-1.8.0-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hitch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hitch}"
SRC_URI[x86_64_v2_hitch.sha256sum] = "7e4ef76c60cd124bdba16f67035f8cc4cc7267574bcb769f8414da4969e8d67b"

URI_aarch64_hitch = "${EPEL_MIRROR}/aarch64/Packages/h/hitch-1.8.0-10.el10_1.aarch64.rpm;name=aarch64_hitch;unpack=0"
SRC_URI:append = " ${URI_aarch64_hitch}"
SRC_URI[aarch64_hitch.sha256sum] = "ccc60f6fd70f8889dccec4c3ef238f8f7826433421211b5f308772be37d7f8d2"

RDEPENDS:hitch = " \
 bash \
 glibc \
 libev \
 openssl \
 openssl-libs \
 shadow-utils \
 systemd \
 "
