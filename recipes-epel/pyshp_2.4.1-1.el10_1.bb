# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyshp"
PV = "2.4.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-pyshp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pyshp-2.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de7e18adc64b9d911831e6e29a40cc183ed79173079c15959e3a3f7f7e9624cf"

URI_x86_64_v2_python3-pyshp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyshp-2.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyshp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyshp}"
SRC_URI[x86_64_v2_python3-pyshp.sha256sum] = "d9f25089b857b5702dd133847e1178c5455ff3f7e66e68a185ac3fe77fd2bcad"

URI_aarch64_python3-pyshp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyshp-2.4.1-1.el10_1.noarch.rpm;name=aarch64_python3-pyshp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyshp}"
SRC_URI[aarch64_python3-pyshp.sha256sum] = "cc5956dafbde969bf6071eb1c74527ab05e1c7afeb02a6861a26d79795936833"

RDEPENDS:python3-pyshp = " \
 python3 \
 "
