# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-prompt-toolkit"
PV = "3.0.41"
PR = "5.el10"
PACKAGES = " \
 python3-prompt-toolkit \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-prompt-toolkit-3.0.41-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf3a9ba777903d2eb93b1e90320618721d4a21650c66eb07a47d5dfc58659383"

URI_x86_64_v2_python3-prompt-toolkit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-prompt-toolkit-3.0.41-5.el10.noarch.rpm;name=x86_64_v2_python3-prompt-toolkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-prompt-toolkit}"
SRC_URI[x86_64_v2_python3-prompt-toolkit.sha256sum] = "61ba7076eda97140ee9e33118b2f796ea09f50097d7c22c30ee3cd505efbfda7"

URI_aarch64_python3-prompt-toolkit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-prompt-toolkit-3.0.41-5.el10.noarch.rpm;name=aarch64_python3-prompt-toolkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-prompt-toolkit}"
SRC_URI[aarch64_python3-prompt-toolkit.sha256sum] = "61ba7076eda97140ee9e33118b2f796ea09f50097d7c22c30ee3cd505efbfda7"

RDEPENDS:python3-prompt-toolkit = " \
 python3 \
 python3-wcwidth \
 "
