# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pnet_datalink"
PV = "0.35.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-pnet_datalink+default-devel \
 rust-pnet_datalink+netmap-devel \
 rust-pnet_datalink+netmap_sys-devel \
 rust-pnet_datalink+pcap-devel \
 rust-pnet_datalink+serde-devel \
 rust-pnet_datalink+std-devel \
 rust-pnet_datalink-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pnet_datalink-0.35.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3563fec1a4b8b64cb9e10003a80d2951043bdd927ed50cd8cd12ef590210d36e"

URI_x86_64_v2_rust-pnet_datalink+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pnet_datalink+default-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pnet_datalink+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pnet_datalink+default-devel}"
SRC_URI[x86_64_v2_rust-pnet_datalink+default-devel.sha256sum] = "8c5297ee4cb0ef86fe212ba72f3c4faaa73097ba7876bb7bc05d86416dd08e7b"

URI_x86_64_v2_rust-pnet_datalink+netmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pnet_datalink+netmap-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pnet_datalink+netmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pnet_datalink+netmap-devel}"
SRC_URI[x86_64_v2_rust-pnet_datalink+netmap-devel.sha256sum] = "cb165967fff4837e77f2c64b8ea9bc7ad0fb9b4598e6c514225524d2308c63f2"

URI_x86_64_v2_rust-pnet_datalink+netmap_sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pnet_datalink+netmap_sys-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pnet_datalink+netmap_sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pnet_datalink+netmap_sys-devel}"
SRC_URI[x86_64_v2_rust-pnet_datalink+netmap_sys-devel.sha256sum] = "f56a1929584762519107c239a6b80e2d42c854cfb3f4038eeea18542e7b391e1"

URI_x86_64_v2_rust-pnet_datalink+pcap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pnet_datalink+pcap-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pnet_datalink+pcap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pnet_datalink+pcap-devel}"
SRC_URI[x86_64_v2_rust-pnet_datalink+pcap-devel.sha256sum] = "d9ce93dba9eda58dbf1bce3191e35368bacb94b71c5f4d850f24f1b9cf4a874d"

URI_x86_64_v2_rust-pnet_datalink+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pnet_datalink+serde-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pnet_datalink+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pnet_datalink+serde-devel}"
SRC_URI[x86_64_v2_rust-pnet_datalink+serde-devel.sha256sum] = "5119c06b63b3ce6d7c9d8610b841f0082eb11c82cd5d53b066d1b8da06c547e4"

URI_x86_64_v2_rust-pnet_datalink+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pnet_datalink+std-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pnet_datalink+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pnet_datalink+std-devel}"
SRC_URI[x86_64_v2_rust-pnet_datalink+std-devel.sha256sum] = "6b4621de743999581379a8df19b15e795c89d2e78a223889b87c380fcc53a7ea"

URI_x86_64_v2_rust-pnet_datalink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pnet_datalink-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pnet_datalink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pnet_datalink-devel}"
SRC_URI[x86_64_v2_rust-pnet_datalink-devel.sha256sum] = "65eb96339ffe8e87a1bb74746c7e0c18ece9fd1e0ea9121db1b26f3c203cae77"

URI_aarch64_rust-pnet_datalink+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pnet_datalink+default-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-pnet_datalink+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pnet_datalink+default-devel}"
SRC_URI[aarch64_rust-pnet_datalink+default-devel.sha256sum] = "34692490b910744426b68ecee2cabea240caeb7251acc457736baf92c4363e91"

URI_aarch64_rust-pnet_datalink+netmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pnet_datalink+netmap-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-pnet_datalink+netmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pnet_datalink+netmap-devel}"
SRC_URI[aarch64_rust-pnet_datalink+netmap-devel.sha256sum] = "23006bb735dfbf874327d8fbc4a61a29dfcce48bcfaee34f9d3b180d5c3086c6"

URI_aarch64_rust-pnet_datalink+netmap_sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pnet_datalink+netmap_sys-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-pnet_datalink+netmap_sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pnet_datalink+netmap_sys-devel}"
SRC_URI[aarch64_rust-pnet_datalink+netmap_sys-devel.sha256sum] = "88adc342080427f03d5461b9b3347af36a7d9d58f15744a71739a6bed47a5b95"

URI_aarch64_rust-pnet_datalink+pcap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pnet_datalink+pcap-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-pnet_datalink+pcap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pnet_datalink+pcap-devel}"
SRC_URI[aarch64_rust-pnet_datalink+pcap-devel.sha256sum] = "08cae76b437d6c595110e1b65c6e521a4c972c24e8fcb742f017be86018e90ed"

URI_aarch64_rust-pnet_datalink+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pnet_datalink+serde-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-pnet_datalink+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pnet_datalink+serde-devel}"
SRC_URI[aarch64_rust-pnet_datalink+serde-devel.sha256sum] = "93c4184a0b4a1970c056980059b05dae1c4efd5e7fd9ac1787a24c5adcf01dcf"

URI_aarch64_rust-pnet_datalink+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pnet_datalink+std-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-pnet_datalink+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pnet_datalink+std-devel}"
SRC_URI[aarch64_rust-pnet_datalink+std-devel.sha256sum] = "04fab0ae8404243ac4e64d6d5dda37932708252598ae77b016b75f66f91e7952"

URI_aarch64_rust-pnet_datalink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pnet_datalink-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-pnet_datalink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pnet_datalink-devel}"
SRC_URI[aarch64_rust-pnet_datalink-devel.sha256sum] = "e0ce88346a21ab567093723aa55b35be2c3b66c9c48e6b085b480a5d9ef0cd69"

RDEPENDS:rust-pnet_datalink+default-devel = " \
 cargo \
 rust-pnet_datalink+std-devel \
 rust-pnet_datalink-devel \
 "
RDEPENDS:rust-pnet_datalink+netmap-devel = " \
 cargo \
 rust-pnet_datalink-devel \
 "
RDEPENDS:rust-pnet_datalink+netmap_sys-devel = " \
 cargo \
 rust-netmap_sys+default-devel \
 rust-netmap_sys+netmap_with_libs-devel \
 rust-pnet_datalink-devel \
 "
RDEPENDS:rust-pnet_datalink+pcap-devel = " \
 cargo \
 rust-pcap+default-devel \
 rust-pnet_datalink-devel \
 "
RDEPENDS:rust-pnet_datalink+serde-devel = " \
 cargo \
 rust-pnet_datalink-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-pnet_datalink+std-devel = " \
 cargo \
 rust-pnet_base+std-devel \
 rust-pnet_datalink-devel \
 "
RDEPENDS:rust-pnet_datalink-devel = " \
 cargo \
 rust-ipnetwork+default-devel \
 rust-libc+default-devel \
 rust-pnet_base-devel \
 rust-pnet_sys+default-devel \
 "
