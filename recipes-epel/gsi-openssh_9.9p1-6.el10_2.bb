# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gsi-openssh"
PV = "9.9p1"
PR = "6.el10_2"
PACKAGES = " \
 gsi-openssh \
 gsi-openssh-clients \
 gsi-openssh-keysign \
 gsi-openssh-server \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gsi-openssh-9.9p1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c724609d031ba77edb6ca1ec6b488e41b1489129a650f703a2ead9352bfb60bf"

URI_x86_64_v2_gsi-openssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-9.9p1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh}"
SRC_URI[x86_64_v2_gsi-openssh.sha256sum] = "4e531d5d388432edaaf5ec18b932474a33514f3a9370061b4c1991a6793d14ba"

URI_x86_64_v2_gsi-openssh-clients = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-clients-9.9p1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh-clients}"
SRC_URI[x86_64_v2_gsi-openssh-clients.sha256sum] = "f9a0ecf74d4f4750e556d364adbca891b6180fcb07f7b098fb6a7f95055e4e0d"

URI_x86_64_v2_gsi-openssh-keysign = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-keysign-9.9p1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh-keysign}"
SRC_URI[x86_64_v2_gsi-openssh-keysign.sha256sum] = "29826f402d44df4475cfac45309dc5198fceb3aff98ee24ba41122d23c9179ca"

URI_x86_64_v2_gsi-openssh-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-server-9.9p1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh-server}"
SRC_URI[x86_64_v2_gsi-openssh-server.sha256sum] = "267bdce64517fd2b9d8e6be77e15a97a07991deb5fd997015b92b0ab5adc4b95"

URI_aarch64_gsi-openssh = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-9.9p1-6.el10_2.aarch64.rpm;name=aarch64_gsi-openssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh}"
SRC_URI[aarch64_gsi-openssh.sha256sum] = "501db0d1b085d2b6d2dda465b434acdfeddceb3e43ba954bcd50835aa3f62ab5"

URI_aarch64_gsi-openssh-clients = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-clients-9.9p1-6.el10_2.aarch64.rpm;name=aarch64_gsi-openssh-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh-clients}"
SRC_URI[aarch64_gsi-openssh-clients.sha256sum] = "8e9de4397f57e315ca9cc301d64ba1f7f54b9845c15477988a7687679e05e06f"

URI_aarch64_gsi-openssh-keysign = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-keysign-9.9p1-6.el10_2.aarch64.rpm;name=aarch64_gsi-openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh-keysign}"
SRC_URI[aarch64_gsi-openssh-keysign.sha256sum] = "6e2c7709f5a176d3e339c1fa64e268441220cdd24523b6f9a36536b000e1dc77"

URI_aarch64_gsi-openssh-server = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-server-9.9p1-6.el10_2.aarch64.rpm;name=aarch64_gsi-openssh-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh-server}"
SRC_URI[aarch64_gsi-openssh-server.sha256sum] = "f7987602a83a2dedd217a123110d2da8dca5bdb1f138f489560079d39f3c5cc7"

RDEPENDS:gsi-openssh = " \
 audit-libs \
 glibc \
 libgcc \
 libselinux \
 openssl-libs \
 util-linux \
 "
RDEPENDS:gsi-openssh-clients = " \
 crypto-policies \
 glibc \
 globus-gssapi-gsi \
 gsi-openssh \
 libedit \
 libfido2 \
 libgcc \
 libselinux \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:gsi-openssh-keysign = " \
 glibc \
 gsi-openssh \
 libgcc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:gsi-openssh-server = " \
 audit-libs \
 bash \
 crypto-policies \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 gsi-openssh \
 libgcc \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam \
 pam-libs \
 policycoreutils-python-utils \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
