# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-PPI"
PV = "1.281"
PR = "1.el10_0"
PACKAGES = " \
 perl-PPI \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-PPI-1.281-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbc10baeee4b5569d374fa5a3bfb52d6daec2c3aec89056989432b5b6c4bf945"

URI_x86_64_v2_perl-PPI = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-PPI-1.281-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-PPI;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PPI}"
SRC_URI[x86_64_v2_perl-PPI.sha256sum] = "75749d7ca514ce3ccee0690298e5b34fb38d122f70700b1d672ba53354283751"

URI_aarch64_perl-PPI = "${EPEL_MIRROR}/aarch64/Packages/p/perl-PPI-1.281-1.el10_0.noarch.rpm;name=aarch64_perl-PPI;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PPI}"
SRC_URI[aarch64_perl-PPI.sha256sum] = "1b04447cc0e440c0ab7573269f9675a602e794420fa36872b644471051b03f91"

RDEPENDS:perl-PPI = " \
 perl-Carp \
 perl-Clone \
 perl-Digest-MD5 \
 perl-Exporter \
 perl-File-Path \
 perl-PPI \
 perl-Params-Util \
 perl-PathTools \
 perl-Safe-Isa \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Task-Weaken \
 perl-YAML-PP \
 perl-constant \
 perl-if \
 perl-libs \
 perl-overload \
 perl-version \
 "
