# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "minizip-ng"
PV = "4.0.7"
PR = "2.el10_0"
PACKAGES = " \
 minizip-ng \
 minizip-ng-compat \
 minizip-ng-compat-devel \
 minizip-ng-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/minizip-ng-4.0.7-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a671abc500813124db81fd1557c61c1ca0e7efc952aea3ca8b44ec404383376"

URI_x86_64_v2_minizip-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minizip-ng-4.0.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minizip-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minizip-ng}"
SRC_URI[x86_64_v2_minizip-ng.sha256sum] = "6fdd91501fbace28b1ef7c64929024f7054f2d003c1193032624bae1070cdc89"

URI_x86_64_v2_minizip-ng-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minizip-ng-compat-4.0.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minizip-ng-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minizip-ng-compat}"
SRC_URI[x86_64_v2_minizip-ng-compat.sha256sum] = "6e7dcb3f8da3cbed9b014cbdf31eb01eebb80de8a67d560cdf16bd8433092b84"

URI_x86_64_v2_minizip-ng-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minizip-ng-compat-devel-4.0.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minizip-ng-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minizip-ng-compat-devel}"
SRC_URI[x86_64_v2_minizip-ng-compat-devel.sha256sum] = "1ac5321181a6dc9c0c0e9832d16280bac7085dfbb2270058f3a4fd6bcb5c07b1"

URI_x86_64_v2_minizip-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minizip-ng-devel-4.0.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minizip-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minizip-ng-devel}"
SRC_URI[x86_64_v2_minizip-ng-devel.sha256sum] = "f77ff8dae1f7733ef5c3a6ebda739a452e14646a886d4f0f50fbb029ae7ef34c"

URI_aarch64_minizip-ng = "${EPEL_MIRROR}/aarch64/Packages/m/minizip-ng-4.0.7-2.el10_0.aarch64.rpm;name=aarch64_minizip-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_minizip-ng}"
SRC_URI[aarch64_minizip-ng.sha256sum] = "9715a05da3e6500ecfd5c569714b80f06a9fca474de343dc85f85ee721c33714"

URI_aarch64_minizip-ng-compat = "${EPEL_MIRROR}/aarch64/Packages/m/minizip-ng-compat-4.0.7-2.el10_0.aarch64.rpm;name=aarch64_minizip-ng-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_minizip-ng-compat}"
SRC_URI[aarch64_minizip-ng-compat.sha256sum] = "e04acb260e3cf763905b90e09921facfaf6087729899a2c0cde58f089d2b1b18"

URI_aarch64_minizip-ng-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/m/minizip-ng-compat-devel-4.0.7-2.el10_0.aarch64.rpm;name=aarch64_minizip-ng-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_minizip-ng-compat-devel}"
SRC_URI[aarch64_minizip-ng-compat-devel.sha256sum] = "355825c8944787a3524972eaf376a8d171b59a5f8edb71dd2883bad47620ab2b"

URI_aarch64_minizip-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/m/minizip-ng-devel-4.0.7-2.el10_0.aarch64.rpm;name=aarch64_minizip-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_minizip-ng-devel}"
SRC_URI[aarch64_minizip-ng-devel.sha256sum] = "cc4e688a89b30aee7e80c49dc33399b52199001c0b2cef1600fe1df3625ea112"

RDEPENDS:minizip-ng = " \
 bzip2-libs \
 glibc \
 libzstd \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:minizip-ng-compat = " \
 bzip2-libs \
 glibc \
 libzstd \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:minizip-ng-compat-devel = " \
 cmake-filesystem \
 minizip-ng-compat \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:minizip-ng-devel = " \
 cmake-filesystem \
 minizip-ng \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
