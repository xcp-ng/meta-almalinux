# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-tools"
PV = "2022.12"
PR = "1.el10_0"
PACKAGES = " \
 git-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/git-tools-2022.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c75c4facd19f2deb624a9196447614fc31a5c754b80f19b881927c3dcc2666b"

URI_x86_64_v2_git-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-tools-2022.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_git-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-tools}"
SRC_URI[x86_64_v2_git-tools.sha256sum] = "76ec6bd08be3d26f27ec937f5308aa8f9bbe62472b8b883bf4300efdeb475a43"

URI_aarch64_git-tools = "${EPEL_MIRROR}/aarch64/Packages/g/git-tools-2022.12-1.el10_0.noarch.rpm;name=aarch64_git-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-tools}"
SRC_URI[aarch64_git-tools.sha256sum] = "31d0cedc2a5850edd4bc84f7c4c364c2e736b3653b0177bc297efb06abee269a"

RDEPENDS:git-tools = " \
 bash \
 git \
 python3 \
 "
