# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-interpolate_name"
PV = "0.2.4"
PR = "3.el10_0"
PACKAGES = " \
 rust-interpolate_name+default-devel \
 rust-interpolate_name-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-interpolate_name-0.2.4-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42a3ca287e85b283a582f9df14b022c8b87d22708907da9dea4e07b5c76c8b35"

URI_x86_64_v2_rust-interpolate_name+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-interpolate_name+default-devel-0.2.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-interpolate_name+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-interpolate_name+default-devel}"
SRC_URI[x86_64_v2_rust-interpolate_name+default-devel.sha256sum] = "9ce3a66d700eff31c474d767b432382673cad7120787d2e3ada26e98f6c86e0c"

URI_x86_64_v2_rust-interpolate_name-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-interpolate_name-devel-0.2.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-interpolate_name-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-interpolate_name-devel}"
SRC_URI[x86_64_v2_rust-interpolate_name-devel.sha256sum] = "deebc282e5d0ac846fb6524f9c5e03a95003346bc7367cd3b2d8fa7b8af9fbf2"

URI_aarch64_rust-interpolate_name+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-interpolate_name+default-devel-0.2.4-3.el10_0.noarch.rpm;name=aarch64_rust-interpolate_name+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-interpolate_name+default-devel}"
SRC_URI[aarch64_rust-interpolate_name+default-devel.sha256sum] = "2a5e9073a28fb781b1dda3bed78ee7c47f092f63e80ea793f0a823dfdb8b4b15"

URI_aarch64_rust-interpolate_name-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-interpolate_name-devel-0.2.4-3.el10_0.noarch.rpm;name=aarch64_rust-interpolate_name-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-interpolate_name-devel}"
SRC_URI[aarch64_rust-interpolate_name-devel.sha256sum] = "2e58edaaa9abe01792a325b96248658ce4372d0acd78ce104b38a21f7a614a8f"

RDEPENDS:rust-interpolate_name+default-devel = " \
 cargo \
 rust-interpolate_name-devel \
 "
RDEPENDS:rust-interpolate_name-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 "
