# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_security"
PV = "2.9.9"
PR = "1.el10_1"
PACKAGES = " \
 mod_security \
 mod_security-mlogc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mod_security-2.9.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84da700922239d5c5630ccabbc24177dbab8f5d8cc2a1e4d57fa1ac23900a504"

URI_x86_64_v2_mod_security = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mod_security-2.9.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mod_security;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_security}"
SRC_URI[x86_64_v2_mod_security.sha256sum] = "2430f1cbf294e182f2a833c927c0b203ff641fcfd7a4a85a7f5ddd7acb781a47"

URI_x86_64_v2_mod_security-mlogc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mod_security-mlogc-2.9.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mod_security-mlogc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_security-mlogc}"
SRC_URI[x86_64_v2_mod_security-mlogc.sha256sum] = "58605b3d3e21d2d58ad68538b7bc42452bcb1aee7e3787589322a7692b873ba4"

URI_aarch64_mod_security = "${EPEL_MIRROR}/aarch64/Packages/m/mod_security-2.9.9-1.el10_1.aarch64.rpm;name=aarch64_mod_security;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_security}"
SRC_URI[aarch64_mod_security.sha256sum] = "76105de24ea61d9c3112f85827824eb32156907db8235a53c6df5388528a7195"

URI_aarch64_mod_security-mlogc = "${EPEL_MIRROR}/aarch64/Packages/m/mod_security-mlogc-2.9.9-1.el10_1.aarch64.rpm;name=aarch64_mod_security-mlogc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_security-mlogc}"
SRC_URI[aarch64_mod_security-mlogc.sha256sum] = "816c4d1632129d7c43175d18b7cb9df61c02ee859381341491dcfee201d9be24"

RDEPENDS:mod_security = " \
 apr \
 apr-util \
 expat \
 glibc \
 httpd \
 httpd-core \
 httpd-filesystem \
 libxcrypt \
 libxml2 \
 lua-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:mod_security-mlogc = " \
 apr \
 glibc \
 httpd-filesystem \
 mod_security \
 pcre2 \
 perl-Digest-MD5 \
 perl-File-Find \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-interpreter \
 perl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
