# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-annotate-snippets0.6"
PV = "0.6.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-annotate-snippets0.6+ansi_term-devel \
 rust-annotate-snippets0.6+color-devel \
 rust-annotate-snippets0.6+default-devel \
 rust-annotate-snippets0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-annotate-snippets0.6-0.6.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c134efca4b57f4dccaa7e7fb8a70284b440e539f07ce29fb41d118e46db620d"

URI_x86_64_v2_rust-annotate-snippets0.6+ansi_term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.6+ansi_term-devel-0.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.6+ansi_term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.6+ansi_term-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.6+ansi_term-devel.sha256sum] = "2543b13f252e56067e3fccf526761177ede174ea1511436b85578d810d615d1a"

URI_x86_64_v2_rust-annotate-snippets0.6+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.6+color-devel-0.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.6+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.6+color-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.6+color-devel.sha256sum] = "3aab88ece1a6d0132d80d0ca07e71d94101a451a0cb679e25347cbf9e7ea1601"

URI_x86_64_v2_rust-annotate-snippets0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.6+default-devel-0.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.6+default-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.6+default-devel.sha256sum] = "ca50032c75692289adb452400e08e6d2bd5ba0691849b0f6c3418ee888337fc7"

URI_x86_64_v2_rust-annotate-snippets0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.6-devel-0.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.6-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.6-devel.sha256sum] = "fff45126d7c2ad55ae34fcf137a509b04aabdeae1a22465cb6efcc3b69508c43"

URI_aarch64_rust-annotate-snippets0.6+ansi_term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.6+ansi_term-devel-0.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets0.6+ansi_term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.6+ansi_term-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.6+ansi_term-devel.sha256sum] = "17a2217a1710d9390e3792987b5e8292397caebd496f4e10eccc5eb60a50e32d"

URI_aarch64_rust-annotate-snippets0.6+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.6+color-devel-0.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets0.6+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.6+color-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.6+color-devel.sha256sum] = "4391a9e05e89586134f0327b8211d6ad0a23cd8db157017bc58a7fc2eeece945"

URI_aarch64_rust-annotate-snippets0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.6+default-devel-0.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.6+default-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.6+default-devel.sha256sum] = "02f5b3353fe5b7003d4c46c49faa67d6208b589ffd06560725b3277ba0de51b2"

URI_aarch64_rust-annotate-snippets0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.6-devel-0.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.6-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.6-devel.sha256sum] = "f9ab11293b5ad86ef66faa1f5f2a4ce9987a0300bc202a07ab3c10719bb9897a"

RDEPENDS:rust-annotate-snippets0.6+ansi_term-devel = " \
 cargo \
 rust-annotate-snippets0.6-devel \
 rust-ansi_term0.11+default-devel \
 "
RDEPENDS:rust-annotate-snippets0.6+color-devel = " \
 cargo \
 rust-annotate-snippets0.6+ansi_term-devel \
 rust-annotate-snippets0.6-devel \
 "
RDEPENDS:rust-annotate-snippets0.6+default-devel = " \
 cargo \
 rust-annotate-snippets0.6-devel \
 "
RDEPENDS:rust-annotate-snippets0.6-devel = " \
 cargo \
 "
