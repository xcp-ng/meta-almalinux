# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "etckeeper"
PV = "1.18.22"
PR = "3.el10_1"
PACKAGES = " \
 etckeeper \
 etckeeper-dnf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/etckeeper-1.18.22-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df3f9ea22509b69cf22345d4a821dd998153ba002a2bca7cf5704620ec4cc04d"

URI_x86_64_v2_etckeeper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/etckeeper-1.18.22-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_etckeeper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_etckeeper}"
SRC_URI[x86_64_v2_etckeeper.sha256sum] = "f0734befa0e10676ac500e61b2ddde771375ca37f73a3c6d15163f310f3c9ba8"

URI_x86_64_v2_etckeeper-dnf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/etckeeper-dnf-1.18.22-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_etckeeper-dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_etckeeper-dnf}"
SRC_URI[x86_64_v2_etckeeper-dnf.sha256sum] = "f1e33410734608d0c325bc57c57e411c672be5c23c0c9c92a393008806d588a3"

URI_aarch64_etckeeper = "${EPEL_MIRROR}/aarch64/Packages/e/etckeeper-1.18.22-3.el10_1.noarch.rpm;name=aarch64_etckeeper;unpack=0"
SRC_URI:append = " ${URI_aarch64_etckeeper}"
SRC_URI[aarch64_etckeeper.sha256sum] = "c0fd17d665cb5650b70134f84211fa56ce8095fd94227ad63f2201a1615995e3"

URI_aarch64_etckeeper-dnf = "${EPEL_MIRROR}/aarch64/Packages/e/etckeeper-dnf-1.18.22-3.el10_1.noarch.rpm;name=aarch64_etckeeper-dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_etckeeper-dnf}"
SRC_URI[aarch64_etckeeper-dnf.sha256sum] = "10394962f73332b3b906887071e797e414f1d23a868f8cccfe97447492b81904"

RDEPENDS:etckeeper = " \
 bash \
 crontabs \
 etckeeper-dnf \
 findutils \
 git-core \
 hostname \
 perl-interpreter \
 systemd \
 which \
 "
RDEPENDS:etckeeper-dnf = " \
 dnf-plugins-core \
 etckeeper \
 python3 \
 python3-dnf \
 "
