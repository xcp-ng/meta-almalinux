# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-loader"
PV = "0.25.10"
PR = "3.el10_2"
PACKAGES = " \
 rust-tree-sitter-loader+default-devel \
 rust-tree-sitter-loader+tree-sitter-highlight-devel \
 rust-tree-sitter-loader+tree-sitter-tags-devel \
 rust-tree-sitter-loader-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-loader-0.25.10-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80ef19aa3503f055ab7f215ab9a6078d892b9996ea784604b74417d4b28ee842"

URI_x86_64_v2_rust-tree-sitter-loader+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-loader+default-devel-0.25.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-loader+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-loader+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-loader+default-devel.sha256sum] = "956a641f0802eb7f3142b37bcf6e86e2d2e8cb336d1f5b5e763c4675802335ee"

URI_x86_64_v2_rust-tree-sitter-loader+tree-sitter-highlight-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-loader+tree-sitter-highlight-devel-0.25.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-loader+tree-sitter-highlight-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-loader+tree-sitter-highlight-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-loader+tree-sitter-highlight-devel.sha256sum] = "ae89d7319bdc43448a42a2a61748d4b751078255b601b52cb32511ee67d0a19d"

URI_x86_64_v2_rust-tree-sitter-loader+tree-sitter-tags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-loader+tree-sitter-tags-devel-0.25.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-loader+tree-sitter-tags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-loader+tree-sitter-tags-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-loader+tree-sitter-tags-devel.sha256sum] = "5bc17e3b4f806efbd139212264e96207af7114cf72e77292f872831332395480"

URI_x86_64_v2_rust-tree-sitter-loader-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-loader-devel-0.25.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-loader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-loader-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-loader-devel.sha256sum] = "ec313ccf0b832ef217ba93e89a08ac8f58f89e03e27c6b0ab5e122265f3cfb60"

URI_aarch64_rust-tree-sitter-loader+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-loader+default-devel-0.25.10-3.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-loader+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-loader+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-loader+default-devel.sha256sum] = "fd710b9ad5e271b350fbf4104eb33e342d4ce0c29fd16ac6a145d4023263fffd"

URI_aarch64_rust-tree-sitter-loader+tree-sitter-highlight-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-loader+tree-sitter-highlight-devel-0.25.10-3.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-loader+tree-sitter-highlight-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-loader+tree-sitter-highlight-devel}"
SRC_URI[aarch64_rust-tree-sitter-loader+tree-sitter-highlight-devel.sha256sum] = "63e7226ef3f154e9fcac9220230a9291738886fb9bf53c452fe57dea0f08608a"

URI_aarch64_rust-tree-sitter-loader+tree-sitter-tags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-loader+tree-sitter-tags-devel-0.25.10-3.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-loader+tree-sitter-tags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-loader+tree-sitter-tags-devel}"
SRC_URI[aarch64_rust-tree-sitter-loader+tree-sitter-tags-devel.sha256sum] = "b918551d9735d9a664afc1f373e7b9c851f80740bea4104e62d83821cc2049c3"

URI_aarch64_rust-tree-sitter-loader-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-loader-devel-0.25.10-3.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-loader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-loader-devel}"
SRC_URI[aarch64_rust-tree-sitter-loader-devel.sha256sum] = "2660dba0de74c2f622be367c084115a62a6d98a23226b4f63d7bbeba7e582379"

RDEPENDS:rust-tree-sitter-loader+default-devel = " \
 cargo \
 rust-tree-sitter-loader+tree-sitter-highlight-devel \
 rust-tree-sitter-loader+tree-sitter-tags-devel \
 rust-tree-sitter-loader-devel \
 "
RDEPENDS:rust-tree-sitter-loader+tree-sitter-highlight-devel = " \
 cargo \
 rust-tree-sitter-highlight+default-devel \
 rust-tree-sitter-loader-devel \
 "
RDEPENDS:rust-tree-sitter-loader+tree-sitter-tags-devel = " \
 cargo \
 rust-tree-sitter-loader-devel \
 rust-tree-sitter-tags+default-devel \
 "
RDEPENDS:rust-tree-sitter-loader-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-cc+default-devel \
 rust-etcetera+default-devel \
 rust-fs4+default-devel \
 rust-indoc+default-devel \
 rust-libloading0.8+default-devel \
 rust-once_cell+default-devel \
 rust-path-slash+default-devel \
 rust-regex+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+preserve_order-devel \
 rust-tempfile+default-devel \
 rust-tree-sitter0.25+default-devel \
 rust-url+default-devel \
 rust-url+serde-devel \
 "
