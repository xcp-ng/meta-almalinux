# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwin"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kwin \
 kwin-common \
 kwin-devel \
 kwin-doc \
 kwin-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kwin-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7e8be29564f6fa1595f63661036bbee2df8b560f291d9750d3a330d177ce5b06"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin;unpack=0"
SRC_URI[x86_64_v2_kwin.sha256sum] = "de18f17ca4fced025851603213574cc9ffdb3002684ea309110f9eeb5705b135"
RPROVIDES:kwin:append:x86_64_v2 = " virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-common-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin-common;unpack=0"
SRC_URI[x86_64_v2_kwin-common.sha256sum] = "49b6efecc238172a4dbce3b6d234addab745a2046745f5146140ee28e0af7e2c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin-devel;unpack=0"
SRC_URI[x86_64_v2_kwin-devel.sha256sum] = "8de8e30fbe9ee8ac3904d47aead2213ec799b477af0f46e8d13f2e301b98d31b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-doc-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kwin-doc;unpack=0"
SRC_URI[x86_64_v2_kwin-doc.sha256sum] = "d89ba235be2dcd3231360a800c8b59a255a1a136c6252677b9009b636ce18b2a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-libs-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin-libs;unpack=0"
SRC_URI[x86_64_v2_kwin-libs.sha256sum] = "175f87e6d8ed846660768efc33f6d04faedf6cde4fd86ab0324ca3550e2a09eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kwin-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kwin;unpack=0"
SRC_URI[aarch64_kwin.sha256sum] = "c87984adc7e8b8780a246b7b29f52f8586d40bb3b90558ca88e17c6335738dfa"
RPROVIDES:kwin:append:aarch64 = " virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kwin-common-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kwin-common;unpack=0"
SRC_URI[aarch64_kwin-common.sha256sum] = "725e067ce92b7d49f374558f80aa4f853b355b28f738a7e6b4e72f821ff81b40"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kwin-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kwin-devel;unpack=0"
SRC_URI[aarch64_kwin-devel.sha256sum] = "b83883c112da7c7bbea9b700f0b4aaef6ef609b5e38da9e9728f0c8e8d61998f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kwin-doc-6.7.5-1.el10_3.noarch.rpm;name=aarch64_kwin-doc;unpack=0"
SRC_URI[aarch64_kwin-doc.sha256sum] = "32790454ea1c94050261aa8e934a4b804d8c192d99eb5e8e32c05ff959afb23e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kwin-libs-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kwin-libs;unpack=0"
SRC_URI[aarch64_kwin-libs.sha256sum] = "5c761bd0291919ce7ff24873f48ff7814fa048ed7eb26723390bca5e7c9f4cc3"

RDEPENDS:kwin = " \
 aurorae \
 glibc \
 iio-sensor-proxy \
 kdecoration \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kirigami \
 kf6-knotifications \
 kf6-ksvg \
 kf6-kwindowsystem \
 kglobalacceld \
 kscreenlocker \
 kwin-common \
 kwin-libs \
 libcanberra \
 libepoxy \
 libplasma \
 libstdc++ \
 libxcb \
 qaccessibilityclient-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 systemd-libs \
 xorg-x11-server-Xwayland \
 "
RDEPENDS:kwin-common = " \
 glibc \
 kdecoration \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-ksvg \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 knighttime \
 kwayland \
 kwin-libs \
 libeis \
 libepoxy \
 libevdev \
 libgcc \
 libstdc++ \
 pipewire-libs \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools \
 systemd-libs \
 "
RDEPENDS:kwin-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kservice-devel \
 kf6-kwindowsystem-devel \
 kwin-common \
 kwin-libs \
 "
RDEPENDS:kwin-doc = " \
 kwin \
 "
RDEPENDS:kwin-libs = " \
 glibc \
 kdecoration \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kglobalacceld \
 kscreenlocker \
 kwayland \
 lcms2 \
 libdisplay-info \
 libdrm \
 libepoxy \
 libgcc \
 libinput \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 libxcb \
 libxcvt \
 libxkbcommon \
 mesa-libgbm \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 systemd-libs \
 vulkan-loader \
 xcb-util-keysyms \
 xcb-util-wm \
 "
