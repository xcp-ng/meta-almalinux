# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-bigint-dig"
PV = "0.8.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-num-bigint-dig+arbitrary-devel \
 rust-num-bigint-dig+default-devel \
 rust-num-bigint-dig+fuzz-devel \
 rust-num-bigint-dig+i128-devel \
 rust-num-bigint-dig+prime-devel \
 rust-num-bigint-dig+rand-devel \
 rust-num-bigint-dig+serde-devel \
 rust-num-bigint-dig+std-devel \
 rust-num-bigint-dig+u64_digit-devel \
 rust-num-bigint-dig+zeroize-devel \
 rust-num-bigint-dig-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-bigint-dig-0.8.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35c57c4fd1b34cae495fcd3b16e5efad8785155d24e23b8c681f0898fdc1f6f5"

URI_x86_64_v2_rust-num-bigint-dig+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+arbitrary-devel-0.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+arbitrary-devel.sha256sum] = "7796770183f30491681b0c2c3b4c69a49797aca45e53b3647e46de1cc9435a0e"

URI_x86_64_v2_rust-num-bigint-dig+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+default-devel-0.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+default-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+default-devel.sha256sum] = "25bb60eeb8e9a721a4a22c750742d9e4d411a086ee96af9ec0b0cd5b4b395e89"

URI_x86_64_v2_rust-num-bigint-dig+fuzz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+fuzz-devel-0.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+fuzz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+fuzz-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+fuzz-devel.sha256sum] = "2fda499bf41ecc45c65fab2408c90921f385d7c1284a84c9834dcfc1193d85fe"

URI_x86_64_v2_rust-num-bigint-dig+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+i128-devel-0.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+i128-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+i128-devel.sha256sum] = "4337301785e5290149422a06c68ce217d636607ca76f41d776f0053f19149d64"

URI_x86_64_v2_rust-num-bigint-dig+prime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+prime-devel-0.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+prime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+prime-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+prime-devel.sha256sum] = "8a26ad95219fd10ae3791c254b2cd9ca28169026533716746d6139ae339f3d2f"

URI_x86_64_v2_rust-num-bigint-dig+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+rand-devel-0.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+rand-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+rand-devel.sha256sum] = "4cf2b293c9fd9a21d033315be812012dcc8952f093aba2aafc63d7c6bf377b9f"

URI_x86_64_v2_rust-num-bigint-dig+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+serde-devel-0.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+serde-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+serde-devel.sha256sum] = "f9f4ee965bb88eb3971e66fc80fe4d4fc75456090997ff650d815b02356aa3ff"

URI_x86_64_v2_rust-num-bigint-dig+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+std-devel-0.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+std-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+std-devel.sha256sum] = "4322b90830a49e24fc1f5a19ebae993edbd170ea7ed4cb4a654021690b101be2"

URI_x86_64_v2_rust-num-bigint-dig+u64_digit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+u64_digit-devel-0.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+u64_digit-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+u64_digit-devel.sha256sum] = "11ad37a17bc1a89bbec0d792f13ac1e1a5474e04e0187595cbfb4abbe8cf89b5"

URI_x86_64_v2_rust-num-bigint-dig+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+zeroize-devel-0.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+zeroize-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+zeroize-devel.sha256sum] = "6162147e177673aa7db0de3549e0333b615f8c47a8c1a8e3d03bcb495c554fa4"

URI_x86_64_v2_rust-num-bigint-dig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig-devel-0.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig-devel.sha256sum] = "1e516f5df9d8cac7224bcab4face929827bee92dfb26e55345b6a514a6f78b7a"

URI_aarch64_rust-num-bigint-dig+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+arbitrary-devel-0.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint-dig+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+arbitrary-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+arbitrary-devel.sha256sum] = "3f22796d5c86216bdb98e18ace48d64d448436ad5fddbef469620ef37d28dfb1"

URI_aarch64_rust-num-bigint-dig+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+default-devel-0.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint-dig+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+default-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+default-devel.sha256sum] = "9bede656bbfb38b34e30837793a4f1736f0182b617b2a09f10174e166ae9ad72"

URI_aarch64_rust-num-bigint-dig+fuzz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+fuzz-devel-0.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint-dig+fuzz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+fuzz-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+fuzz-devel.sha256sum] = "2087a461032c4a5ba4d73aaf6dc08129094986fb0c5a105d00f5667fd5edf5d7"

URI_aarch64_rust-num-bigint-dig+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+i128-devel-0.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint-dig+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+i128-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+i128-devel.sha256sum] = "768103e9e5e1fe0bd066e92499881505ec23d9fd72bba0d5438969d9990a94c5"

URI_aarch64_rust-num-bigint-dig+prime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+prime-devel-0.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint-dig+prime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+prime-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+prime-devel.sha256sum] = "8e4faf695ad705d5d76a124fb45929b155c2df196a93c2ffc7e0aef0f5377de3"

URI_aarch64_rust-num-bigint-dig+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+rand-devel-0.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint-dig+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+rand-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+rand-devel.sha256sum] = "dd61010d11ee71f6c6c07fcaaf0f30445a78063fdaa2964800b468865556bb7a"

URI_aarch64_rust-num-bigint-dig+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+serde-devel-0.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint-dig+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+serde-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+serde-devel.sha256sum] = "11159556ee90fa15d6773d347211aafda2a62fbbbb1ea13682d0026d72cced7f"

URI_aarch64_rust-num-bigint-dig+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+std-devel-0.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint-dig+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+std-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+std-devel.sha256sum] = "0acf9f5e8dec3d7cf5f38d7f9aaca0433df0d718eac80b82031a1ae626a09c48"

URI_aarch64_rust-num-bigint-dig+u64_digit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+u64_digit-devel-0.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint-dig+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+u64_digit-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+u64_digit-devel.sha256sum] = "dd44f3d9eab4a08e27f6aa921646f033407eb9d418eb1e1464459077798cc960"

URI_aarch64_rust-num-bigint-dig+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+zeroize-devel-0.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint-dig+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+zeroize-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+zeroize-devel.sha256sum] = "b0daef871eecef0ee8c22a79f9dc5ecd31126fec38d224f354762203fb6576ac"

URI_aarch64_rust-num-bigint-dig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig-devel-0.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint-dig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig-devel}"
SRC_URI[aarch64_rust-num-bigint-dig-devel.sha256sum] = "1f966605507bff157bf6e374ba1b5891cf9f967ef71fbc13e9e1fbcf85a633b7"

RDEPENDS:rust-num-bigint-dig+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+default-devel = " \
 cargo \
 rust-num-bigint-dig+std-devel \
 rust-num-bigint-dig+u64_digit-devel \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+fuzz-devel = " \
 cargo \
 rust-num-bigint-dig+arbitrary-devel \
 rust-num-bigint-dig-devel \
 rust-smallvec+arbitrary-devel \
 "
RDEPENDS:rust-num-bigint-dig+i128-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+prime-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-num-bigint-dig+rand-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-num-bigint-dig+serde-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-num-bigint-dig+std-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-num-integer+std-devel \
 rust-num-traits+std-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8-devel \
 rust-serde+alloc-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-smallvec+write-devel \
 "
RDEPENDS:rust-num-bigint-dig+u64_digit-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+zeroize-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-num-bigint-dig-devel = " \
 bash \
 cargo \
 rust \
 rust-lazy_static+spin_no_std-devel \
 rust-lazy_static-devel \
 rust-libm+default-devel \
 rust-num-integer+i128-devel \
 rust-num-integer-devel \
 rust-num-iter-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 rust-smallvec-devel \
 "
