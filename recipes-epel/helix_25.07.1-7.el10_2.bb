# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "helix"
PV = "25.07.1"
PR = "7.el10_2"
PACKAGES = " \
 helix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/helix-25.07.1-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2063d7292556c7ef778a1bf218637b6fff3af3b3b14cc90a02340da783dccd9a"

URI_x86_64_v2_helix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/helix-25.07.1-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_helix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_helix}"
SRC_URI[x86_64_v2_helix.sha256sum] = "31c9995080ff27f5881391a11d8a71f4eba2457b5659b7e2632a564a285bac45"

URI_aarch64_helix = "${EPEL_MIRROR}/aarch64/Packages/h/helix-25.07.1-7.el10_2.aarch64.rpm;name=aarch64_helix;unpack=0"
SRC_URI:append = " ${URI_aarch64_helix}"
SRC_URI[aarch64_helix.sha256sum] = "1a16623d62e64992466357855661c3008cd7ca9cf3a9fe0be819f3efc45865a1"

RDEPENDS:helix = " \
 gcc-c++ \
 git-core \
 glibc \
 libgcc \
 libstdc++ \
 "
