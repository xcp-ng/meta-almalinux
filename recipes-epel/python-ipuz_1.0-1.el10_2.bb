# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ipuz"
PV = "1.0"
PR = "1.el10_2"
PACKAGES = " \
 python-ipuz-doc \
 python3-ipuz \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ipuz-1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdc0dc1c8cbea895ade23ee7f58c0d52fcc42348c13e47ff46c9b26a4b86f076"

URI_x86_64_v2_python-ipuz-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-ipuz-doc-1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-ipuz-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-ipuz-doc}"
SRC_URI[x86_64_v2_python-ipuz-doc.sha256sum] = "f0b411dbfd3fced464af3c5ded4d2d994d24d3476e7741320dbfb0be1f89232b"

URI_x86_64_v2_python3-ipuz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipuz-1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipuz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipuz}"
SRC_URI[x86_64_v2_python3-ipuz.sha256sum] = "db2a01c82ae9fe3d2f3c68695ff6bcb224b610982062eb8aa03258823be93c44"

URI_aarch64_python-ipuz-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-ipuz-doc-1.0-1.el10_2.noarch.rpm;name=aarch64_python-ipuz-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-ipuz-doc}"
SRC_URI[aarch64_python-ipuz-doc.sha256sum] = "aa651dd4691137f897aff4509746eab1cf8d1d529444fade69d371aa1e0895fd"

URI_aarch64_python3-ipuz = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipuz-1.0-1.el10_2.noarch.rpm;name=aarch64_python3-ipuz;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipuz}"
SRC_URI[aarch64_python3-ipuz.sha256sum] = "714c096ccf41095f0033d7b0947c0525cb23d81f05930b6624a8d917c3aadcc7"

RDEPENDS:python-ipuz-doc = " \
 "
RDEPENDS:python3-ipuz = " \
 python3 \
 "
