# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "marisa"
PV = "0.2.6"
PR = "8.el10_3"
PACKAGES = " \
 marisa \
 marisa-devel \
 marisa-perl \
 marisa-ruby \
 marisa-tools \
 python3-marisa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/marisa-0.2.6-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d31a180a98fa95b93f4f6edfc123fbd6d31e649b7927a5dd68c936a1ca32d4d"

URI_x86_64_v2_marisa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marisa-0.2.6-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marisa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marisa}"
SRC_URI[x86_64_v2_marisa.sha256sum] = "b560f7646e4cd6117c9dcbe6cef3f237fc4ae0cf960601c0ab0b1b7a01f73c6f"

URI_x86_64_v2_marisa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marisa-devel-0.2.6-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marisa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marisa-devel}"
SRC_URI[x86_64_v2_marisa-devel.sha256sum] = "0118eeb3386d403d9c84b5ca926807b019b455f211d839628a2e7f98e742fa15"

URI_x86_64_v2_marisa-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marisa-perl-0.2.6-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marisa-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marisa-perl}"
SRC_URI[x86_64_v2_marisa-perl.sha256sum] = "3eede025a66785eb6dd0545824ae59c77d36536b01a1f9384423a18340f4e360"

URI_x86_64_v2_marisa-ruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marisa-ruby-0.2.6-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marisa-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marisa-ruby}"
SRC_URI[x86_64_v2_marisa-ruby.sha256sum] = "4ef0610ebf68a9794fb3cde5a8102084748109a462cd3a155ebc393368ef323e"

URI_x86_64_v2_marisa-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marisa-tools-0.2.6-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marisa-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marisa-tools}"
SRC_URI[x86_64_v2_marisa-tools.sha256sum] = "4fdfb7b81e8241854f99806ba8a3d2928ac7c303f152d3cae4ef31166d15baa7"

URI_x86_64_v2_python3-marisa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-marisa-0.2.6-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-marisa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-marisa}"
SRC_URI[x86_64_v2_python3-marisa.sha256sum] = "63aebc26aab7975d042e4f8ece4729ce2999807c6e6d8530e7b4f6fe4822aad7"

URI_aarch64_marisa = "${EPEL_MIRROR}/aarch64/Packages/m/marisa-0.2.6-8.el10_3.aarch64.rpm;name=aarch64_marisa;unpack=0"
SRC_URI:append = " ${URI_aarch64_marisa}"
SRC_URI[aarch64_marisa.sha256sum] = "70c91138e77b41f62f196cbc2d9a06df5114037fa360fedf4128917a164280dd"

URI_aarch64_marisa-devel = "${EPEL_MIRROR}/aarch64/Packages/m/marisa-devel-0.2.6-8.el10_3.aarch64.rpm;name=aarch64_marisa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_marisa-devel}"
SRC_URI[aarch64_marisa-devel.sha256sum] = "18a1a8afbd9acd0d78aaaf483de00dade471756b5fe4de92e4dde8ba52a4e25e"

URI_aarch64_marisa-perl = "${EPEL_MIRROR}/aarch64/Packages/m/marisa-perl-0.2.6-8.el10_3.aarch64.rpm;name=aarch64_marisa-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_marisa-perl}"
SRC_URI[aarch64_marisa-perl.sha256sum] = "a747373813c792c4cf57141703dc3905b1b58de02207a6d0f285b4b9cbaea01b"

URI_aarch64_marisa-ruby = "${EPEL_MIRROR}/aarch64/Packages/m/marisa-ruby-0.2.6-8.el10_3.aarch64.rpm;name=aarch64_marisa-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_marisa-ruby}"
SRC_URI[aarch64_marisa-ruby.sha256sum] = "c505a75cf1097c4b60ac611d646896225a3a25f2211d53e537f2c8b9321bd37d"

URI_aarch64_marisa-tools = "${EPEL_MIRROR}/aarch64/Packages/m/marisa-tools-0.2.6-8.el10_3.aarch64.rpm;name=aarch64_marisa-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_marisa-tools}"
SRC_URI[aarch64_marisa-tools.sha256sum] = "8d418b8f628eb047e2ad6af34dd45c6889cbdc9b08c28767a4e4401cf68f38ec"

URI_aarch64_python3-marisa = "${EPEL_MIRROR}/aarch64/Packages/p/python3-marisa-0.2.6-8.el10_3.aarch64.rpm;name=aarch64_python3-marisa;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-marisa}"
SRC_URI[aarch64_python3-marisa.sha256sum] = "e60091bd106a0a12a9c24cc763c1e99bc189099b9202a1e6a8710e2c739e51fa"

RDEPENDS:marisa = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:marisa-devel = " \
 marisa \
 pkgconf-pkg-config \
 "
RDEPENDS:marisa-perl = " \
 glibc \
 libgcc \
 marisa \
 perl-DynaLoader \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-vars \
 "
RDEPENDS:marisa-ruby = " \
 glibc \
 libgcc \
 libstdc++ \
 marisa \
 ruby-libs \
 virtual/ruby_release_ \
 "
RDEPENDS:marisa-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 marisa \
 "
RDEPENDS:python3-marisa = " \
 glibc \
 libgcc \
 libstdc++ \
 marisa \
 python3 \
 "
