# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_http2"
PV = "2.0.29"
PR = "4.el10_2.2"
PACKAGES = " \
 mod_http2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_http2-2.0.29-4.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7279b3d3bd1c53a505cd4e14d9cdb67a36970a57fa871e84a541a1198a31753e"

URI_x86_64_v2_mod_http2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_http2-2.0.29-4.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_mod_http2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_http2}"
SRC_URI[x86_64_v2_mod_http2.sha256sum] = "dc344983f24347a2ae39fc97bbafb7f309e40e10f7d0fe68c99a2d661570dc34"

URI_aarch64_mod_http2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_http2-2.0.29-4.el10_2.2.aarch64.rpm;name=aarch64_mod_http2;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_http2}"
SRC_URI[aarch64_mod_http2.sha256sum] = "9b89ef86f1c348c9554f9d80f2d7e521100db343b986c49ca87b4e99740bdb7a"

RDEPENDS:mod_http2 = " \
 glibc \
 httpd-core \
 libnghttp2 \
 openssl-libs \
 "
