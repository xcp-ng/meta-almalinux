# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvpl-tools"
PV = "1.5.0"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 libvpl-tools \
 libvpl-tools-devel \
 libvpl-tools-libs \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/l/libvpl-tools-1.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7b7d7deb6190f5e8870ac4bf4226fd27fcac9172b3e3d76233fdc30f50a7393"

URI_x86_64_v2_libvpl-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-tools-1.5.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-tools}"
SRC_URI[x86_64_v2_libvpl-tools.sha256sum] = "06091accc56f8d8b26fc64c2fd213f519a24e1aee8fcd9a7f12a1af9f17ab8f2"

URI_x86_64_v2_libvpl-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-tools-devel-1.5.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-tools-devel}"
SRC_URI[x86_64_v2_libvpl-tools-devel.sha256sum] = "aed9fce0372f2b44715ca8e15cba7d30763943469a6afeb72eb8af6d2b707b2b"

URI_x86_64_v2_libvpl-tools-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-tools-libs-1.5.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-tools-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-tools-libs}"
SRC_URI[x86_64_v2_libvpl-tools-libs.sha256sum] = "c8a7dbe14b61452581f257c245c45de415c5b0dcfe32b6cfe97803316710f94d"

RDEPENDS:libvpl-tools = " \
 glib2 \
 glibc \
 glibmm2.68 \
 gtk4 \
 gtkmm4.0 \
 libX11 \
 libepoxy \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libva \
 libvpl \
 libvpl-tools-libs \
 "
RDEPENDS:libvpl-tools-devel = " \
 libvpl-tools-libs \
 "
RDEPENDS:libvpl-tools-libs = " \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libvpl-tools \
 libwayland-client \
 "
