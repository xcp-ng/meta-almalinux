# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-bash"
PV = "0.25.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-bash+default-devel \
 rust-tree-sitter-bash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-bash-0.25.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "417e12338a15d2d17ce006c9a156837a84e688ed15a8aaead53dcd4c6d72aff4"

URI_x86_64_v2_rust-tree-sitter-bash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-bash+default-devel-0.25.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-bash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-bash+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-bash+default-devel.sha256sum] = "7676b60ce32854c80cb65116f7e85c5e2540f8ae2f9956f57df693bee4685c82"

URI_x86_64_v2_rust-tree-sitter-bash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-bash-devel-0.25.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-bash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-bash-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-bash-devel.sha256sum] = "d08edae54fb8c4d2ac979e5bc0cdab5e8ef69adefe37587c51a31569565df0b6"

URI_aarch64_rust-tree-sitter-bash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-bash+default-devel-0.25.1-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-bash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-bash+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-bash+default-devel.sha256sum] = "ec521ecaa55e6b1898567f1c96ff48ef8a86aa567f48538f5e0046a8386824a3"

URI_aarch64_rust-tree-sitter-bash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-bash-devel-0.25.1-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-bash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-bash-devel}"
SRC_URI[aarch64_rust-tree-sitter-bash-devel.sha256sum] = "d0ea8cf8b592e5efc78ffd4e6ab967bd30727a190e6bf8966778c55d10c68226"

RDEPENDS:rust-tree-sitter-bash+default-devel = " \
 cargo \
 rust-tree-sitter-bash-devel \
 "
RDEPENDS:rust-tree-sitter-bash-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
