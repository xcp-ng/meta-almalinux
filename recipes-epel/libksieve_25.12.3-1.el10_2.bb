# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksieve"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 libksieve \
 libksieve-devel \
 libksieve-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libksieve-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4499ffb8ecdbf5b383b9e3ae494c5088789ac609f938a51b9b7e14ec9f66b116"

URI_x86_64_v2_libksieve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksieve-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksieve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksieve}"
SRC_URI[x86_64_v2_libksieve.sha256sum] = "43eaf57cfac09ecd15aa58eae5d59f495d7a7a8ef1effd1efec7012b89250422"

URI_x86_64_v2_libksieve-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksieve-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksieve-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksieve-devel}"
SRC_URI[x86_64_v2_libksieve-devel.sha256sum] = "193d9b9b2a1fb7e871470fbe3165cd3d04ea450036212f4c4ddfd4d34dfd56fc"

URI_x86_64_v2_libksieve-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksieve-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libksieve-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksieve-doc}"
SRC_URI[x86_64_v2_libksieve-doc.sha256sum] = "386e0b785d84e4b955f21dfccac99c4803fb845eeea0ba4708252b7591567816"

URI_aarch64_libksieve = "${EPEL_MIRROR}/aarch64/Packages/l/libksieve-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libksieve;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksieve}"
SRC_URI[aarch64_libksieve.sha256sum] = "bcac3a3ba2a93197f4b6775e7e02a50b14efad89f7b053fce33e636adafd1851"

URI_aarch64_libksieve-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libksieve-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libksieve-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksieve-devel}"
SRC_URI[aarch64_libksieve-devel.sha256sum] = "d5a3ca09bb37c4821e0d5f9f6c8fd70eef753a7be55e8129ec02afb2e97d4336"

URI_aarch64_libksieve-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libksieve-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_libksieve-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksieve-doc}"
SRC_URI[aarch64_libksieve-doc.sha256sum] = "362385ed9644f04481511dad401bc16e30888e16bf6c96eed9819357e8a418e3"

RDEPENDS:libksieve = " \
 cyrus-sasl-lib \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kmime \
 ktextaddons-qt6 \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:libksieve-devel = " \
 cmake-filesystem \
 kf6-syntax-highlighting-devel \
 libksieve \
 "
RDEPENDS:libksieve-doc = " \
 "
