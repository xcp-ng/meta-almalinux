# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-partial-io"
PV = "0.5.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-partial-io+default-devel \
 rust-partial-io+futures-devel \
 rust-partial-io+futures03-devel \
 rust-partial-io+pin-project-devel \
 rust-partial-io+proptest-devel \
 rust-partial-io+proptest1-devel \
 rust-partial-io+quickcheck-devel \
 rust-partial-io+quickcheck1-devel \
 rust-partial-io+rand-devel \
 rust-partial-io+tokio-devel \
 rust-partial-io+tokio1-devel \
 rust-partial-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-partial-io-0.5.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7870d8d04fef304800beebb653a8b06350c91eeb8f820f9bd79869a68f8d3a9f"

URI_x86_64_v2_rust-partial-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+default-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+default-devel}"
SRC_URI[x86_64_v2_rust-partial-io+default-devel.sha256sum] = "fae62f3b7477f41e7da512d8f051a9bddb4d14def59c910948563d01b06e9805"

URI_x86_64_v2_rust-partial-io+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+futures-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+futures-devel}"
SRC_URI[x86_64_v2_rust-partial-io+futures-devel.sha256sum] = "3c4faff711b84980f8f22632f73997f68f44e35aefaf227a99142320b5e396d5"

URI_x86_64_v2_rust-partial-io+futures03-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+futures03-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+futures03-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+futures03-devel}"
SRC_URI[x86_64_v2_rust-partial-io+futures03-devel.sha256sum] = "0c02f49a556f516be18b26b87bc2949b7935fa5a2543ad4db594891e9a725d05"

URI_x86_64_v2_rust-partial-io+pin-project-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+pin-project-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+pin-project-devel}"
SRC_URI[x86_64_v2_rust-partial-io+pin-project-devel.sha256sum] = "897b540a1fb0548c3de24a00b27561aea1dfde5558a62959a0db9ba611048e79"

URI_x86_64_v2_rust-partial-io+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+proptest-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+proptest-devel}"
SRC_URI[x86_64_v2_rust-partial-io+proptest-devel.sha256sum] = "bf43f127888dd21249b62bbcec94fad49e7b879ec2fa68ad2fd1c47a308127d5"

URI_x86_64_v2_rust-partial-io+proptest1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+proptest1-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+proptest1-devel}"
SRC_URI[x86_64_v2_rust-partial-io+proptest1-devel.sha256sum] = "56a12e9d6bfe4f74d73a28adbfd95a80beaab7a0967a200811a9cea61f586d3b"

URI_x86_64_v2_rust-partial-io+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+quickcheck-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-partial-io+quickcheck-devel.sha256sum] = "5e4179002c6a9959ba86fe28012e500781c2a45f70a280768358017dc6b2602f"

URI_x86_64_v2_rust-partial-io+quickcheck1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+quickcheck1-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+quickcheck1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+quickcheck1-devel}"
SRC_URI[x86_64_v2_rust-partial-io+quickcheck1-devel.sha256sum] = "39af1866125dbe582ef8e5a1fe30e8c844857dbf4537c5fa288aea833e6b07ca"

URI_x86_64_v2_rust-partial-io+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+rand-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+rand-devel}"
SRC_URI[x86_64_v2_rust-partial-io+rand-devel.sha256sum] = "5d71a64a6c27d60efe80a9316f99b13e8adabcf37b0f75ed31e444c0760c9ffb"

URI_x86_64_v2_rust-partial-io+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+tokio-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+tokio-devel}"
SRC_URI[x86_64_v2_rust-partial-io+tokio-devel.sha256sum] = "a483df778c4112a56ca8e2a8b6950851e9e80ff4253323c9ab8b06f087181803"

URI_x86_64_v2_rust-partial-io+tokio1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+tokio1-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+tokio1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+tokio1-devel}"
SRC_URI[x86_64_v2_rust-partial-io+tokio1-devel.sha256sum] = "13cb0b8898f4a7c4178760227687e9de0f9375709338fe87484d6834f8254896"

URI_x86_64_v2_rust-partial-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io-devel}"
SRC_URI[x86_64_v2_rust-partial-io-devel.sha256sum] = "9bc9638a98037cca726056c1f2471cc1b53aed82941519b48f27a15a0f2ef1b1"

URI_aarch64_rust-partial-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+default-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-partial-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+default-devel}"
SRC_URI[aarch64_rust-partial-io+default-devel.sha256sum] = "a364713bfeb3f2cb3ef9ad0c650088a8b1600fe21057f77820bc057f753e0db5"

URI_aarch64_rust-partial-io+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+futures-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-partial-io+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+futures-devel}"
SRC_URI[aarch64_rust-partial-io+futures-devel.sha256sum] = "82d0ab94e7e603b270ea6bbb28d5cd5bf55711e17ad473851c03e42a835de69d"

URI_aarch64_rust-partial-io+futures03-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+futures03-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-partial-io+futures03-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+futures03-devel}"
SRC_URI[aarch64_rust-partial-io+futures03-devel.sha256sum] = "06c31a494c3e3e333b0c0df3007813d3b8c5ef3e9dce960beea921d5cf2e5e07"

URI_aarch64_rust-partial-io+pin-project-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+pin-project-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-partial-io+pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+pin-project-devel}"
SRC_URI[aarch64_rust-partial-io+pin-project-devel.sha256sum] = "a36f0ace86a18acb71758666bdac4b62b657a49532e3ff038b8c6f3465cdccd9"

URI_aarch64_rust-partial-io+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+proptest-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-partial-io+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+proptest-devel}"
SRC_URI[aarch64_rust-partial-io+proptest-devel.sha256sum] = "27a1400e3bb07318e7a2a74ebbc8752fb2902065abe1da4a61470633a7db56cb"

URI_aarch64_rust-partial-io+proptest1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+proptest1-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-partial-io+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+proptest1-devel}"
SRC_URI[aarch64_rust-partial-io+proptest1-devel.sha256sum] = "bdabe92e724661f8b6373da08b3ecdf9b7794b3e40210b9e9962dc869f40af15"

URI_aarch64_rust-partial-io+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+quickcheck-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-partial-io+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+quickcheck-devel}"
SRC_URI[aarch64_rust-partial-io+quickcheck-devel.sha256sum] = "22767e9924b4551405ca87a82459445793c62f413273db7739d7965d2f64700c"

URI_aarch64_rust-partial-io+quickcheck1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+quickcheck1-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-partial-io+quickcheck1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+quickcheck1-devel}"
SRC_URI[aarch64_rust-partial-io+quickcheck1-devel.sha256sum] = "a1b4dcf603d629bb1758892edbfc674a6c57867ae5c8fded550cc6862dda2fb1"

URI_aarch64_rust-partial-io+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+rand-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-partial-io+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+rand-devel}"
SRC_URI[aarch64_rust-partial-io+rand-devel.sha256sum] = "e7236dab220a610e7b2c02ba16b239df458844ce6b4a17c756e52ed1ac237230"

URI_aarch64_rust-partial-io+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+tokio-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-partial-io+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+tokio-devel}"
SRC_URI[aarch64_rust-partial-io+tokio-devel.sha256sum] = "305da497cb09a0304ad357da0e832ce14c4160c609885447f510f162fd9469f5"

URI_aarch64_rust-partial-io+tokio1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+tokio1-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-partial-io+tokio1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+tokio1-devel}"
SRC_URI[aarch64_rust-partial-io+tokio1-devel.sha256sum] = "0902c0121b78f95a0107fea771bd4a8649effab0a5e330658fbcb67beae016d0"

URI_aarch64_rust-partial-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-partial-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io-devel}"
SRC_URI[aarch64_rust-partial-io-devel.sha256sum] = "5c7b2834f71201bd7d06ea66091242ca18cf47eaae1a4d974650e12a92bd98ff"

RDEPENDS:rust-partial-io+default-devel = " \
 cargo \
 rust-partial-io-devel \
 "
RDEPENDS:rust-partial-io+futures-devel = " \
 cargo \
 rust-futures+default-devel \
 rust-partial-io-devel \
 "
RDEPENDS:rust-partial-io+futures03-devel = " \
 cargo \
 rust-partial-io+futures-devel \
 rust-partial-io+pin-project-devel \
 rust-partial-io-devel \
 "
RDEPENDS:rust-partial-io+pin-project-devel = " \
 cargo \
 rust-partial-io-devel \
 rust-pin-project+default-devel \
 "
RDEPENDS:rust-partial-io+proptest-devel = " \
 cargo \
 rust-partial-io-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-partial-io+proptest1-devel = " \
 cargo \
 rust-partial-io+proptest-devel \
 rust-partial-io-devel \
 "
RDEPENDS:rust-partial-io+quickcheck-devel = " \
 cargo \
 rust-partial-io-devel \
 rust-quickcheck+default-devel \
 "
RDEPENDS:rust-partial-io+quickcheck1-devel = " \
 cargo \
 rust-partial-io+quickcheck-devel \
 rust-partial-io+rand-devel \
 rust-partial-io-devel \
 "
RDEPENDS:rust-partial-io+rand-devel = " \
 cargo \
 rust-partial-io-devel \
 rust-rand0.8+default-devel \
 rust-rand0.8+getrandom-devel \
 rust-rand0.8+small_rng-devel \
 "
RDEPENDS:rust-partial-io+tokio-devel = " \
 cargo \
 rust-partial-io-devel \
 rust-tokio+default-devel \
 "
RDEPENDS:rust-partial-io+tokio1-devel = " \
 cargo \
 rust-partial-io+futures03-devel \
 rust-partial-io+tokio-devel \
 rust-partial-io-devel \
 "
RDEPENDS:rust-partial-io-devel = " \
 bash \
 cargo \
 rust \
 "
