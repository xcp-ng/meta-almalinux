# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "haveged"
PV = "1.9.18"
PR = "1.el10_1"
PACKAGES = " \
 haveged \
 haveged-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/haveged-1.9.18-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43a467fc0f16c259736d8b2bea7630e386bad02d610dda0952fc96a32cb88b0d"

URI_x86_64_v2_haveged = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/haveged-1.9.18-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_haveged;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_haveged}"
SRC_URI[x86_64_v2_haveged.sha256sum] = "ea8f027e54ddc7f695fbfa95b16b003a0b72dcafc7512ef25da7cdce64622f04"

URI_x86_64_v2_haveged-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/haveged-devel-1.9.18-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_haveged-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_haveged-devel}"
SRC_URI[x86_64_v2_haveged-devel.sha256sum] = "2e0308968f196c9c595c2f4c982bb365872905fe3471a48c6c82ab48275085c9"

URI_aarch64_haveged = "${EPEL_MIRROR}/aarch64/Packages/h/haveged-1.9.18-1.el10_1.aarch64.rpm;name=aarch64_haveged;unpack=0"
SRC_URI:append = " ${URI_aarch64_haveged}"
SRC_URI[aarch64_haveged.sha256sum] = "0aee92c59426069503b53db25537b573e2233d73f4ee07d74a283c08faa8ca36"

URI_aarch64_haveged-devel = "${EPEL_MIRROR}/aarch64/Packages/h/haveged-devel-1.9.18-1.el10_1.aarch64.rpm;name=aarch64_haveged-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_haveged-devel}"
SRC_URI[aarch64_haveged-devel.sha256sum] = "40063a5dd9da64747875af45b17541934da9f49f8542ff3dfc0b6fcfbc070d52"

RDEPENDS:haveged = " \
 bash \
 glibc \
 systemd \
 "
RDEPENDS:haveged-devel = " \
 haveged \
 "
