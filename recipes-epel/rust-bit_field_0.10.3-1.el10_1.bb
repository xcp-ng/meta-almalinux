# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bit_field"
PV = "0.10.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-bit_field+default-devel \
 rust-bit_field-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bit_field-0.10.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fa8a25fd0fab55c0bb23497d3d20f36af2442d95749c8588aa611c30260aabf"

URI_x86_64_v2_rust-bit_field+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit_field+default-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit_field+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit_field+default-devel}"
SRC_URI[x86_64_v2_rust-bit_field+default-devel.sha256sum] = "4e205d516bb2eb57087cd5e3b46382b1a19ccac83f5c54c6b7f127a12a91c6bd"

URI_x86_64_v2_rust-bit_field-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit_field-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit_field-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit_field-devel}"
SRC_URI[x86_64_v2_rust-bit_field-devel.sha256sum] = "f471e85454c177c046a47f7eccf787a9cf3b0484c75ff7ddbdff4fb1c8a5660a"

URI_aarch64_rust-bit_field+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit_field+default-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-bit_field+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit_field+default-devel}"
SRC_URI[aarch64_rust-bit_field+default-devel.sha256sum] = "7611cdca776cae9ba30f24d43bd0418e6310b6aa75c10e0b7104488c06b167bd"

URI_aarch64_rust-bit_field-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit_field-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-bit_field-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit_field-devel}"
SRC_URI[aarch64_rust-bit_field-devel.sha256sum] = "b15364d5f18e446452608c30af851a771f4c0af34ee7ddd8a7599280f734b740"

RDEPENDS:rust-bit_field+default-devel = " \
 cargo \
 rust-bit_field-devel \
 "
RDEPENDS:rust-bit_field-devel = " \
 cargo \
 "
