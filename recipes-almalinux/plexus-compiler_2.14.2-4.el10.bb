# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-compiler"
PV = "2.14.2"
PR = "4.el10"
PACKAGES = " \
 plexus-compiler \
 plexus-compiler-extras \
 plexus-compiler-javadoc \
 plexus-compiler-pom \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/plexus-compiler-2.14.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7389f87c39ac1a6e6ccd5d29ccfc36c6ddfb8175543f34b01c7cac709f029e4c"

URI_x86_64_v2_plexus-compiler = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-compiler-2.14.2-4.el10.noarch.rpm;name=x86_64_v2_plexus-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-compiler}"
SRC_URI[x86_64_v2_plexus-compiler.sha256sum] = "b47afc9aa4da6aa577063dcf872dfdc9b85d4594a2de1b4fb6e32d2fc4ea8587"

URI_x86_64_v2_plexus-compiler-extras = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-compiler-extras-2.14.2-4.el10.noarch.rpm;name=x86_64_v2_plexus-compiler-extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-compiler-extras}"
SRC_URI[x86_64_v2_plexus-compiler-extras.sha256sum] = "098d8a32c816a040087643043c55c16d34fb5036599e0bb88ad2697e61f8e997"

URI_x86_64_v2_plexus-compiler-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-compiler-javadoc-2.14.2-4.el10.noarch.rpm;name=x86_64_v2_plexus-compiler-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-compiler-javadoc}"
SRC_URI[x86_64_v2_plexus-compiler-javadoc.sha256sum] = "7515a6f49b81a217c87b75de0704f884e1e5c16dc9c2522a175b38bd0a70910f"

URI_x86_64_v2_plexus-compiler-pom = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-compiler-pom-2.14.2-4.el10.noarch.rpm;name=x86_64_v2_plexus-compiler-pom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-compiler-pom}"
SRC_URI[x86_64_v2_plexus-compiler-pom.sha256sum] = "b0fd4fb2077b72301208ef2ea5c68285ff43cbbea9a9dd394ca3cab9ff9b49a5"

URI_aarch64_plexus-compiler = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-compiler-2.14.2-4.el10.noarch.rpm;name=aarch64_plexus-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-compiler}"
SRC_URI[aarch64_plexus-compiler.sha256sum] = "b47afc9aa4da6aa577063dcf872dfdc9b85d4594a2de1b4fb6e32d2fc4ea8587"

URI_aarch64_plexus-compiler-extras = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-compiler-extras-2.14.2-4.el10.noarch.rpm;name=aarch64_plexus-compiler-extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-compiler-extras}"
SRC_URI[aarch64_plexus-compiler-extras.sha256sum] = "098d8a32c816a040087643043c55c16d34fb5036599e0bb88ad2697e61f8e997"

URI_aarch64_plexus-compiler-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-compiler-javadoc-2.14.2-4.el10.noarch.rpm;name=aarch64_plexus-compiler-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-compiler-javadoc}"
SRC_URI[aarch64_plexus-compiler-javadoc.sha256sum] = "7515a6f49b81a217c87b75de0704f884e1e5c16dc9c2522a175b38bd0a70910f"

URI_aarch64_plexus-compiler-pom = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-compiler-pom-2.14.2-4.el10.noarch.rpm;name=aarch64_plexus-compiler-pom;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-compiler-pom}"
SRC_URI[aarch64_plexus-compiler-pom.sha256sum] = "b0fd4fb2077b72301208ef2ea5c68285ff43cbbea9a9dd394ca3cab9ff9b49a5"

RDEPENDS:plexus-compiler = " \
 atinject \
 javapackages-filesystem \
 plexus-utils \
 slf4j \
 "
RDEPENDS:plexus-compiler-extras = " \
 atinject \
 javapackages-filesystem \
 plexus-compiler \
 plexus-utils \
 "
RDEPENDS:plexus-compiler-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:plexus-compiler-pom = " \
 javapackages-filesystem \
 plexus-compiler \
 plexus-pom \
 sisu-mojos \
 "
