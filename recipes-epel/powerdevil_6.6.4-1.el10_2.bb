# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "powerdevil"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 powerdevil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/powerdevil-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65557795e9888a997ebd61760d7a7512cd0e9c067f193d38842d73ccd165830f"

URI_x86_64_v2_powerdevil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerdevil-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_powerdevil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_powerdevil}"
SRC_URI[x86_64_v2_powerdevil.sha256sum] = "b75c3e9b77079cdb573f571ff2abab10c580f8303095dcebe4c00e4e6067df7f"

URI_aarch64_powerdevil = "${EPEL_MIRROR}/aarch64/Packages/p/powerdevil-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_powerdevil;unpack=0"
SRC_URI:append = " ${URI_aarch64_powerdevil}"
SRC_URI[aarch64_powerdevil.sha256sum] = "e2043dde204f0d08eff955304e93d1c6e527516c493d3d8f2789fb76a075109d"

RDEPENDS:powerdevil = " \
 ddcutil \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kirigami \
 kf6-knotifications \
 kf6-krunner \
 kf6-kservice \
 kf6-kxmlgui \
 kf6-solid \
 libddcutil \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-activities \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 systemd-libs \
 "
