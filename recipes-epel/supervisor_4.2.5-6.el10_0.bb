# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "supervisor"
PV = "4.2.5"
PR = "6.el10_0"
PACKAGES = " \
 supervisor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/supervisor-4.2.5-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c506a61b5ec95192f40411b7429ceec258257986f6ab46f0511d81b157f30629"

URI_x86_64_v2_supervisor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supervisor-4.2.5-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_supervisor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supervisor}"
SRC_URI[x86_64_v2_supervisor.sha256sum] = "7b8a1f4bcc1f0c2a8a71ad31f1e340977bdd73a63558db8ed6f0cb395a99665a"

URI_aarch64_supervisor = "${EPEL_MIRROR}/aarch64/Packages/s/supervisor-4.2.5-6.el10_0.noarch.rpm;name=aarch64_supervisor;unpack=0"
SRC_URI:append = " ${URI_aarch64_supervisor}"
SRC_URI[aarch64_supervisor.sha256sum] = "ebdb59d31effca08a6ddac6ade0623576fe69ef576d413f74514732b3de7680c"

RDEPENDS:supervisor = " \
 bash \
 python3 \
 python3-setuptools \
 "
