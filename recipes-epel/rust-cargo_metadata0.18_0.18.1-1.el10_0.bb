# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_metadata0.18"
PV = "0.18.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-cargo_metadata0.18+builder-devel \
 rust-cargo_metadata0.18+default-devel \
 rust-cargo_metadata0.18+derive_builder-devel \
 rust-cargo_metadata0.18+unstable-devel \
 rust-cargo_metadata0.18-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_metadata0.18-0.18.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a67a3dd463a5a0630786ea273f695c7208a0e8deb5011b72442f22b344dd6b7b"

URI_x86_64_v2_rust-cargo_metadata0.18+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.18+builder-devel-0.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.18+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.18+builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.18+builder-devel.sha256sum] = "209d3f9615f5a38fa89ab893bc7375ffdf0e981925d573637993a81ecdaed349"

URI_x86_64_v2_rust-cargo_metadata0.18+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.18+default-devel-0.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.18+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.18+default-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.18+default-devel.sha256sum] = "e15bbefff643db28c5203c1ea976c0efef5765929e227075ae575f867d67594e"

URI_x86_64_v2_rust-cargo_metadata0.18+derive_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.18+derive_builder-devel-0.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.18+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.18+derive_builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.18+derive_builder-devel.sha256sum] = "974eb65193eac95a8ce0ce63d02a78b13354bc335f51497f1bda8c262ff1a7c0"

URI_x86_64_v2_rust-cargo_metadata0.18+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.18+unstable-devel-0.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.18+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.18+unstable-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.18+unstable-devel.sha256sum] = "80e76dfa9843510661384fdbe73ef5c493cd569f854aabc1dc55a93742cbb0c9"

URI_x86_64_v2_rust-cargo_metadata0.18-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.18-devel-0.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.18-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.18-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.18-devel.sha256sum] = "420eea76bfc31ea75ff1172a3685de1350d9293ebdaec6b64613b0f130b69937"

URI_aarch64_rust-cargo_metadata0.18+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.18+builder-devel-0.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-cargo_metadata0.18+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.18+builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.18+builder-devel.sha256sum] = "3cae85bfda22ce6803448820d9566c4536a9fd9f8da04498f00a143f7c3dbe9b"

URI_aarch64_rust-cargo_metadata0.18+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.18+default-devel-0.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-cargo_metadata0.18+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.18+default-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.18+default-devel.sha256sum] = "580c305a6d3360f50dcf7016fd4c5075697bec222a27428e67664493cd8827ec"

URI_aarch64_rust-cargo_metadata0.18+derive_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.18+derive_builder-devel-0.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-cargo_metadata0.18+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.18+derive_builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.18+derive_builder-devel.sha256sum] = "710e97875420066dd986f3605ddefe6006b8131536cf85cca033b2411dbf7008"

URI_aarch64_rust-cargo_metadata0.18+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.18+unstable-devel-0.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-cargo_metadata0.18+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.18+unstable-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.18+unstable-devel.sha256sum] = "92df239b5aabd184a096eb99f41a578bc866fd0c5abd3637ba4a5a30a8dc44fe"

URI_aarch64_rust-cargo_metadata0.18-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.18-devel-0.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-cargo_metadata0.18-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.18-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.18-devel.sha256sum] = "16bd7d10813741ce4d0c5f0ad1857d2dd32cd864d83d89c1108147619b94e463"

RDEPENDS:rust-cargo_metadata0.18+builder-devel = " \
 cargo \
 rust-cargo_metadata0.18+derive_builder-devel \
 rust-cargo_metadata0.18-devel \
 "
RDEPENDS:rust-cargo_metadata0.18+default-devel = " \
 cargo \
 rust-cargo_metadata0.18-devel \
 "
RDEPENDS:rust-cargo_metadata0.18+derive_builder-devel = " \
 cargo \
 rust-cargo_metadata0.18-devel \
 rust-derive_builder+default-devel \
 "
RDEPENDS:rust-cargo_metadata0.18+unstable-devel = " \
 cargo \
 rust-cargo_metadata0.18-devel \
 "
RDEPENDS:rust-cargo_metadata0.18-devel = " \
 cargo \
 rust \
 rust-camino+default-devel \
 rust-camino+serde1-devel \
 rust-cargo-platform+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-thiserror1+default-devel \
 "
