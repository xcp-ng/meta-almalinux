# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libaec"
PV = "1.1.7"
PR = "1.el10_3"
PACKAGES = " \
 libaec \
 libaec-devel \
 libaec-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libaec-1.1.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d44d4cf607fb3abc56bbc83d8ebb3def010cced7da470c82ab0459cd5271a62"

URI_x86_64_v2_libaec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaec-1.1.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaec}"
SRC_URI[x86_64_v2_libaec.sha256sum] = "57e5f5d3cef11f361ce4fdb8d3dd0673f7bf36f0958476d6cd9db34cf49714e7"

URI_x86_64_v2_libaec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaec-devel-1.1.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaec-devel}"
SRC_URI[x86_64_v2_libaec-devel.sha256sum] = "5339f0bb10896d1ca4ddd7c4b27912d19bcfcb228c0a4a6ca2f306bac647d03f"

URI_x86_64_v2_libaec-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaec-static-1.1.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaec-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaec-static}"
SRC_URI[x86_64_v2_libaec-static.sha256sum] = "8b7c867c4b03a89dffbeefc66defc4e1100bfe08ce026e005f6e077ed003e1bc"

URI_aarch64_libaec = "${EPEL_MIRROR}/aarch64/Packages/l/libaec-1.1.7-1.el10_3.aarch64.rpm;name=aarch64_libaec;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaec}"
SRC_URI[aarch64_libaec.sha256sum] = "de522babc4d1074d7562b44a2566321a5cd3a8826197884924ed27eb230a3100"

URI_aarch64_libaec-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libaec-devel-1.1.7-1.el10_3.aarch64.rpm;name=aarch64_libaec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaec-devel}"
SRC_URI[aarch64_libaec-devel.sha256sum] = "25a94056e9f681fd8f22c03857b61bcaf08fd31b8542829515b3c08030e7174a"

URI_aarch64_libaec-static = "${EPEL_MIRROR}/aarch64/Packages/l/libaec-static-1.1.7-1.el10_3.aarch64.rpm;name=aarch64_libaec-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaec-static}"
SRC_URI[aarch64_libaec-static.sha256sum] = "7946637dc3e08caeda4cdf96c6f7e1c329167933113dec05dd0c1a63538ce975"

RDEPENDS:libaec = " \
 glibc \
 "
RDEPENDS:libaec-devel = " \
 cmake-filesystem \
 libaec \
 "
RDEPENDS:libaec-static = " \
 libaec-devel \
 "
