# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_complete_fig"
PV = "4.5.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-clap_complete_fig+default-devel \
 rust-clap_complete_fig-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_complete_fig-4.5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "667b4c02472d925996a32fc28dd8816f5182a2fdf48b446921615d9fac4776a0"

URI_x86_64_v2_rust-clap_complete_fig+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete_fig+default-devel-4.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete_fig+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete_fig+default-devel}"
SRC_URI[x86_64_v2_rust-clap_complete_fig+default-devel.sha256sum] = "2a2d4f7d5da612460f21956664536015d32da6a66835d42c4329fde68ba84630"

URI_x86_64_v2_rust-clap_complete_fig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete_fig-devel-4.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete_fig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete_fig-devel}"
SRC_URI[x86_64_v2_rust-clap_complete_fig-devel.sha256sum] = "d89ac4b03a16be3e0ec82e04224102aa8fc6396e172290afafb8f52c4fd932b4"

URI_aarch64_rust-clap_complete_fig+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete_fig+default-devel-4.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-clap_complete_fig+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete_fig+default-devel}"
SRC_URI[aarch64_rust-clap_complete_fig+default-devel.sha256sum] = "a58ff919f568c1826e2da3a070fa574499ff2703c510724f9a435455e6f3b6da"

URI_aarch64_rust-clap_complete_fig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete_fig-devel-4.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-clap_complete_fig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete_fig-devel}"
SRC_URI[aarch64_rust-clap_complete_fig-devel.sha256sum] = "fb157e5a3425bcf3b715603e4ec1ff38057181054e8535d517032cfc96300518"

RDEPENDS:rust-clap_complete_fig+default-devel = " \
 cargo \
 rust-clap_complete_fig-devel \
 "
RDEPENDS:rust-clap_complete_fig-devel = " \
 cargo \
 rust \
 rust-clap+std-devel \
 rust-clap-devel \
 rust-clap_complete+default-devel \
 "
