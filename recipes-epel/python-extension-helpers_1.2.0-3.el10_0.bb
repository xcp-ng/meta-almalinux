# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-extension-helpers"
PV = "1.2.0"
PR = "3.el10_0"
PACKAGES = " \
 python3-extension-helpers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-extension-helpers-1.2.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57398a7eea3fdbdaf865fd93995cd881991e8f6556ae8dc9bd72eac2bc6c7d27"

URI_x86_64_v2_python3-extension-helpers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-extension-helpers-1.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-extension-helpers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-extension-helpers}"
SRC_URI[x86_64_v2_python3-extension-helpers.sha256sum] = "365ea21872bab93d8368a3ff67df8951d524eb9380cc61f7f8df84f21eb1cd4d"

URI_aarch64_python3-extension-helpers = "${EPEL_MIRROR}/aarch64/Packages/p/python3-extension-helpers-1.2.0-3.el10_0.noarch.rpm;name=aarch64_python3-extension-helpers;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-extension-helpers}"
SRC_URI[aarch64_python3-extension-helpers.sha256sum] = "ce286b2faafd8c62e44896b6a2bb4988b5ca055b9655f559a9826ac4be8f116f"

RDEPENDS:python3-extension-helpers = " \
 python3 \
 python3-setuptools \
 "
