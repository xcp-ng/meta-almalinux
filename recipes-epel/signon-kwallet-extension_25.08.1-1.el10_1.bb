# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "signon-kwallet-extension"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 signon-kwallet-extension \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/signon-kwallet-extension-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b01bc502a3f19d6f093b45f35a9c4fc24139c42c1ec2b435567d3e6f2d28b61"

URI_x86_64_v2_signon-kwallet-extension = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-kwallet-extension-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signon-kwallet-extension;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signon-kwallet-extension}"
SRC_URI[x86_64_v2_signon-kwallet-extension.sha256sum] = "9832ca217a6725cab904ec571b6a9a084df7edec95fd01ef2a5abfa14722544f"

URI_aarch64_signon-kwallet-extension = "${EPEL_MIRROR}/aarch64/Packages/s/signon-kwallet-extension-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_signon-kwallet-extension;unpack=0"
SRC_URI:append = " ${URI_aarch64_signon-kwallet-extension}"
SRC_URI[aarch64_signon-kwallet-extension.sha256sum] = "9a67fca494d8e46641f32d25b3131c73288060667a4323499f29455ce74ce880"

RDEPENDS:signon-kwallet-extension = " \
 glibc \
 kf6-kwallet-libs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 signon \
 "
