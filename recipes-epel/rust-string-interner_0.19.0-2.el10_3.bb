# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-string-interner"
PV = "0.19.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-string-interner+backends-devel \
 rust-string-interner+default-devel \
 rust-string-interner+inline-more-devel \
 rust-string-interner+serde-devel \
 rust-string-interner+std-devel \
 rust-string-interner+test-allocations-devel \
 rust-string-interner-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-string-interner-0.19.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da0b336f39d0ffd1deeaeaaaf6548afb5ec838553e81e14314578af67fc3c4ba"

URI_x86_64_v2_rust-string-interner+backends-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string-interner+backends-devel-0.19.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string-interner+backends-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string-interner+backends-devel}"
SRC_URI[x86_64_v2_rust-string-interner+backends-devel.sha256sum] = "6ddb889fb6e9eb893872266c8cb1188203065499a134e8f27b24f53b47df48b7"

URI_x86_64_v2_rust-string-interner+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string-interner+default-devel-0.19.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string-interner+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string-interner+default-devel}"
SRC_URI[x86_64_v2_rust-string-interner+default-devel.sha256sum] = "2ce5fc3329a2096e385e5235b49a08de7ccc62bb3d6fff1ae9ee1a4e3d39f8a1"

URI_x86_64_v2_rust-string-interner+inline-more-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string-interner+inline-more-devel-0.19.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string-interner+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string-interner+inline-more-devel}"
SRC_URI[x86_64_v2_rust-string-interner+inline-more-devel.sha256sum] = "6855e622a5615dd4e7dc0304faa0db71d3226034cde919f8c030f0dba9729d3d"

URI_x86_64_v2_rust-string-interner+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string-interner+serde-devel-0.19.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string-interner+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string-interner+serde-devel}"
SRC_URI[x86_64_v2_rust-string-interner+serde-devel.sha256sum] = "bf7edf9b7aff472d8f9ce1821d6f5c951ff3b20bbafa4010ddf63950e69eec4b"

URI_x86_64_v2_rust-string-interner+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string-interner+std-devel-0.19.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string-interner+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string-interner+std-devel}"
SRC_URI[x86_64_v2_rust-string-interner+std-devel.sha256sum] = "1f01d46f6f8736b5408e0b9cb7709c194f6960820a8f78a685b1abf1a8e1f4b2"

URI_x86_64_v2_rust-string-interner+test-allocations-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string-interner+test-allocations-devel-0.19.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string-interner+test-allocations-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string-interner+test-allocations-devel}"
SRC_URI[x86_64_v2_rust-string-interner+test-allocations-devel.sha256sum] = "6b1a1ce54da9347bdb388390822e165171c503129452ece7dc5d44fca17dd79f"

URI_x86_64_v2_rust-string-interner-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string-interner-devel-0.19.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string-interner-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string-interner-devel}"
SRC_URI[x86_64_v2_rust-string-interner-devel.sha256sum] = "034a64fb33f91f834c0c2c3cc4f9e0c621c8997d9dffe750eb85322ae8fa02f2"

URI_aarch64_rust-string-interner+backends-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string-interner+backends-devel-0.19.0-2.el10_3.noarch.rpm;name=aarch64_rust-string-interner+backends-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string-interner+backends-devel}"
SRC_URI[aarch64_rust-string-interner+backends-devel.sha256sum] = "e521abeb6f62883fe4883cfc539d20c07d6d9ec8837b2f3bb2263af87c3b94ae"

URI_aarch64_rust-string-interner+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string-interner+default-devel-0.19.0-2.el10_3.noarch.rpm;name=aarch64_rust-string-interner+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string-interner+default-devel}"
SRC_URI[aarch64_rust-string-interner+default-devel.sha256sum] = "5a7a6261931cf9013eaa2fe80edc630b59105bcade8e9a309598286e779a0f1c"

URI_aarch64_rust-string-interner+inline-more-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string-interner+inline-more-devel-0.19.0-2.el10_3.noarch.rpm;name=aarch64_rust-string-interner+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string-interner+inline-more-devel}"
SRC_URI[aarch64_rust-string-interner+inline-more-devel.sha256sum] = "f16f3f284593b4298cbcfa7ef88e76edac9f7f1c39c6c93b1547e05546b6913f"

URI_aarch64_rust-string-interner+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string-interner+serde-devel-0.19.0-2.el10_3.noarch.rpm;name=aarch64_rust-string-interner+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string-interner+serde-devel}"
SRC_URI[aarch64_rust-string-interner+serde-devel.sha256sum] = "90cbf56827598ca57760af17af86732ad9992b874a10fad8d001806d2390b236"

URI_aarch64_rust-string-interner+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string-interner+std-devel-0.19.0-2.el10_3.noarch.rpm;name=aarch64_rust-string-interner+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string-interner+std-devel}"
SRC_URI[aarch64_rust-string-interner+std-devel.sha256sum] = "b58aa56a4f5c80a3432fbb72648320bddc009851aafe87046b924ed5a9e383c5"

URI_aarch64_rust-string-interner+test-allocations-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string-interner+test-allocations-devel-0.19.0-2.el10_3.noarch.rpm;name=aarch64_rust-string-interner+test-allocations-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string-interner+test-allocations-devel}"
SRC_URI[aarch64_rust-string-interner+test-allocations-devel.sha256sum] = "4816bd9533b450d701daa0bc66eedbad6241b470b489a451065a78144f7ceec8"

URI_aarch64_rust-string-interner-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string-interner-devel-0.19.0-2.el10_3.noarch.rpm;name=aarch64_rust-string-interner-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string-interner-devel}"
SRC_URI[aarch64_rust-string-interner-devel.sha256sum] = "b5169e05bc5b88740060daa8d0f7d3d1c2d4ea35a57832299c64096253ea433b"

RDEPENDS:rust-string-interner+backends-devel = " \
 cargo \
 rust-string-interner-devel \
 "
RDEPENDS:rust-string-interner+default-devel = " \
 cargo \
 rust-string-interner+backends-devel \
 rust-string-interner+inline-more-devel \
 rust-string-interner+serde-devel \
 rust-string-interner+std-devel \
 rust-string-interner-devel \
 "
RDEPENDS:rust-string-interner+inline-more-devel = " \
 cargo \
 rust-hashbrown0.15+inline-more-devel \
 rust-string-interner-devel \
 "
RDEPENDS:rust-string-interner+serde-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-string-interner-devel \
 "
RDEPENDS:rust-string-interner+std-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-string-interner-devel \
 "
RDEPENDS:rust-string-interner+test-allocations-devel = " \
 cargo \
 rust-string-interner-devel \
 "
RDEPENDS:rust-string-interner-devel = " \
 cargo \
 rust-hashbrown0.15+default-hasher-devel \
 rust-hashbrown0.15+raw-entry-devel \
 rust-hashbrown0.15-devel \
 "
