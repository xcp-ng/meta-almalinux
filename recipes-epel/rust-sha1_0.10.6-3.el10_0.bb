# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha1"
PV = "0.10.6"
PR = "3.el10_0"
PACKAGES = " \
 rust-sha1+asm-devel \
 rust-sha1+compress-devel \
 rust-sha1+default-devel \
 rust-sha1+force-soft-devel \
 rust-sha1+loongarch64_asm-devel \
 rust-sha1+oid-devel \
 rust-sha1+sha1-asm-devel \
 rust-sha1+std-devel \
 rust-sha1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sha1-0.10.6-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e20e7747d9a7618e15d54b654d0475421127ebe4f199cc7d3dd67a9d069cbe79"

URI_x86_64_v2_rust-sha1+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1+asm-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1+asm-devel}"
SRC_URI[x86_64_v2_rust-sha1+asm-devel.sha256sum] = "1d2f2b6fb3030923d93456c5c2c63c095ffd2ba0439845ca22843331e2790b3f"

URI_x86_64_v2_rust-sha1+compress-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1+compress-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1+compress-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1+compress-devel}"
SRC_URI[x86_64_v2_rust-sha1+compress-devel.sha256sum] = "d93aee015b190dd654eb4b5b378672028abc1d8c2f1ab4ab3ae677ddb332c171"

URI_x86_64_v2_rust-sha1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1+default-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1+default-devel}"
SRC_URI[x86_64_v2_rust-sha1+default-devel.sha256sum] = "fad75cd76653a798983263c4b73323fe488cc9b2100f9cc6f73e10cf354aa1ab"

URI_x86_64_v2_rust-sha1+force-soft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1+force-soft-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1+force-soft-devel}"
SRC_URI[x86_64_v2_rust-sha1+force-soft-devel.sha256sum] = "15015c2fdab9316281ae6c02bff1501ff779575e7e1c635f0da6680c253edbe6"

URI_x86_64_v2_rust-sha1+loongarch64_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1+loongarch64_asm-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1+loongarch64_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1+loongarch64_asm-devel}"
SRC_URI[x86_64_v2_rust-sha1+loongarch64_asm-devel.sha256sum] = "a0003591b94e193db2440804362f0abb5aebf6601dfe32e94a5833b97c68ed00"

URI_x86_64_v2_rust-sha1+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1+oid-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1+oid-devel}"
SRC_URI[x86_64_v2_rust-sha1+oid-devel.sha256sum] = "09c4f2a65867c78e0d203e5c7b44ba4d83f2eeced6ee17fd1ab7c3711adc928a"

URI_x86_64_v2_rust-sha1+sha1-asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1+sha1-asm-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1+sha1-asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1+sha1-asm-devel}"
SRC_URI[x86_64_v2_rust-sha1+sha1-asm-devel.sha256sum] = "35165691bc2c6cedf57a409a02f8446862c1e0999be0e7061fa1b083f86e6cb0"

URI_x86_64_v2_rust-sha1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1+std-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1+std-devel}"
SRC_URI[x86_64_v2_rust-sha1+std-devel.sha256sum] = "7aa259f38259d25b9cb68ca198c18652c1c3990842dff7a9551a60d48300ba3b"

URI_x86_64_v2_rust-sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1-devel}"
SRC_URI[x86_64_v2_rust-sha1-devel.sha256sum] = "bc13bb42565b5ea1d48882e81bed9d0580d88eb81a310cddee3d92fa94a50c16"

URI_aarch64_rust-sha1+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1+asm-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-sha1+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1+asm-devel}"
SRC_URI[aarch64_rust-sha1+asm-devel.sha256sum] = "0c4e71d9a508639375afd1538cd773af5aba66599db2fa7e24b6ea34a0ccece4"

URI_aarch64_rust-sha1+compress-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1+compress-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-sha1+compress-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1+compress-devel}"
SRC_URI[aarch64_rust-sha1+compress-devel.sha256sum] = "357bf86a48ccbb27092ef39b89f2a8a1ef20504d8da24307295f8efb25a1642d"

URI_aarch64_rust-sha1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1+default-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-sha1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1+default-devel}"
SRC_URI[aarch64_rust-sha1+default-devel.sha256sum] = "61fc2faa1fea3fa533c7b49c35660b66d0ea1a5bafd37b38ef499ea9c8d58f5f"

URI_aarch64_rust-sha1+force-soft-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1+force-soft-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-sha1+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1+force-soft-devel}"
SRC_URI[aarch64_rust-sha1+force-soft-devel.sha256sum] = "83029ac731b1a209e7bc965c983314cca36bc3f06207b20382bb679a6170d6d0"

URI_aarch64_rust-sha1+loongarch64_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1+loongarch64_asm-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-sha1+loongarch64_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1+loongarch64_asm-devel}"
SRC_URI[aarch64_rust-sha1+loongarch64_asm-devel.sha256sum] = "5b4346767f2451231b8b6063097a562dfedd693d03ec922eb21d50f9b8b5a40c"

URI_aarch64_rust-sha1+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1+oid-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-sha1+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1+oid-devel}"
SRC_URI[aarch64_rust-sha1+oid-devel.sha256sum] = "f85b166e167d54bcdc9bd52ef353f2947179a42262839d4c3c70bcb9affb3ad5"

URI_aarch64_rust-sha1+sha1-asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1+sha1-asm-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-sha1+sha1-asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1+sha1-asm-devel}"
SRC_URI[aarch64_rust-sha1+sha1-asm-devel.sha256sum] = "e7f7c2d20feabbbdddf799e72e8ce6c2b72a112d76230e922a3a7869e39fb15a"

URI_aarch64_rust-sha1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1+std-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-sha1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1+std-devel}"
SRC_URI[aarch64_rust-sha1+std-devel.sha256sum] = "e6debd232625e589cb1145ac65e2fd1b04766d1cb8ed0832342fba8c546ff4af"

URI_aarch64_rust-sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1-devel}"
SRC_URI[aarch64_rust-sha1-devel.sha256sum] = "e8628301706ea266b2db8a143f98707da17c6f14977316a1ee98246e6546adbb"

RDEPENDS:rust-sha1+asm-devel = " \
 cargo \
 rust-sha1+sha1-asm-devel \
 rust-sha1-devel \
 "
RDEPENDS:rust-sha1+compress-devel = " \
 cargo \
 rust-sha1-devel \
 "
RDEPENDS:rust-sha1+default-devel = " \
 cargo \
 rust-sha1+std-devel \
 rust-sha1-devel \
 "
RDEPENDS:rust-sha1+force-soft-devel = " \
 cargo \
 rust-sha1-devel \
 "
RDEPENDS:rust-sha1+loongarch64_asm-devel = " \
 cargo \
 rust-sha1-devel \
 "
RDEPENDS:rust-sha1+oid-devel = " \
 cargo \
 rust-digest+oid-devel \
 rust-sha1-devel \
 "
RDEPENDS:rust-sha1+sha1-asm-devel = " \
 cargo \
 rust-sha1-asm+default-devel \
 rust-sha1-devel \
 "
RDEPENDS:rust-sha1+std-devel = " \
 cargo \
 rust-digest+std-devel \
 rust-sha1-devel \
 "
RDEPENDS:rust-sha1-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-cpufeatures+default-devel \
 rust-digest+default-devel \
 "
