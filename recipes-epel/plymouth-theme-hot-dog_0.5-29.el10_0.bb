# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plymouth-theme-hot-dog"
PV = "0.5"
PR = "29.el10_0"
PACKAGES = " \
 plymouth-theme-hot-dog \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plymouth-theme-hot-dog-0.5-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "083e4719d4a81dfc56de5af456ef9d473325479627c8d5ec5f6de442e01f3f3c"

URI_x86_64_v2_plymouth-theme-hot-dog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plymouth-theme-hot-dog-0.5-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_plymouth-theme-hot-dog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-hot-dog}"
SRC_URI[x86_64_v2_plymouth-theme-hot-dog.sha256sum] = "8d20b33cd05a782d37c04a6bf48b4d6b7240f382c14b4fdf6f1b1c58c72e3899"

URI_aarch64_plymouth-theme-hot-dog = "${EPEL_MIRROR}/aarch64/Packages/p/plymouth-theme-hot-dog-0.5-29.el10_0.noarch.rpm;name=aarch64_plymouth-theme-hot-dog;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-hot-dog}"
SRC_URI[aarch64_plymouth-theme-hot-dog.sha256sum] = "a628f00f36ea331fe52d693b506a4b3ddac75c9aa453d01ce987e70d8f293249"

RDEPENDS:plymouth-theme-hot-dog = " \
 bash \
 plymouth-plugin-two-step \
 plymouth-scripts \
 "
