# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grpc"
PV = "1.48.4"
PR = "44.el10_0"
PACKAGES = " \
 grpc \
 grpc-cli \
 grpc-cpp \
 grpc-data \
 grpc-devel \
 grpc-doc \
 grpc-plugins \
 python3-grpcio \
 python3-grpcio+protobuf \
 python3-grpcio-channelz \
 python3-grpcio-health-checking \
 python3-grpcio-reflection \
 python3-grpcio-status \
 python3-grpcio-testing \
 python3-grpcio-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grpc-1.48.4-44.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b46aaa137fc3b22c9782b550b34bec46c6f1ae100f3ae9138d26fae69201f972"

URI_x86_64_v2_grpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grpc-1.48.4-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grpc}"
SRC_URI[x86_64_v2_grpc.sha256sum] = "965b64befdf44b8521652de7788f4059dc02e919b64c845d5d6a7c328e9ced53"

URI_x86_64_v2_grpc-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grpc-cli-1.48.4-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grpc-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grpc-cli}"
SRC_URI[x86_64_v2_grpc-cli.sha256sum] = "3ec595ca831fc68105d180cfc5b643ceccaedee16f329ce2341540717c9de1c6"

URI_x86_64_v2_grpc-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grpc-cpp-1.48.4-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grpc-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grpc-cpp}"
SRC_URI[x86_64_v2_grpc-cpp.sha256sum] = "74bba4354885dd2200fec31b798b1aece8c92df8396da854e86fe814419b0952"

URI_x86_64_v2_grpc-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grpc-data-1.48.4-44.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_grpc-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grpc-data}"
SRC_URI[x86_64_v2_grpc-data.sha256sum] = "89304683712199809f3dc91c513fb10793ac1bcc5617fad75385fc51d1d3175a"

URI_x86_64_v2_grpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grpc-devel-1.48.4-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grpc-devel}"
SRC_URI[x86_64_v2_grpc-devel.sha256sum] = "3bf8251a53488189ccfd51597c80ee063da726af2c43151199f4aeabdbcf5172"

URI_x86_64_v2_grpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grpc-doc-1.48.4-44.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_grpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grpc-doc}"
SRC_URI[x86_64_v2_grpc-doc.sha256sum] = "2b044782ca2357e759f327f606b0af3f744b7c11b171f9c2c410c5e65f1f92a9"

URI_x86_64_v2_grpc-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grpc-plugins-1.48.4-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grpc-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grpc-plugins}"
SRC_URI[x86_64_v2_grpc-plugins.sha256sum] = "27c52356b2fa9b6776fbe0a3f35932097c659d24d145eb689c84caf010268f9a"

URI_x86_64_v2_python3-grpcio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-grpcio-1.48.4-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-grpcio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-grpcio}"
SRC_URI[x86_64_v2_python3-grpcio.sha256sum] = "ca8259b942e3af0b6d27d205b54233f4c44a077507bcd9d7cb4f86f1aa02896f"

URI_x86_64_v2_python3-grpcio+protobuf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-grpcio+protobuf-1.48.4-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-grpcio+protobuf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-grpcio+protobuf}"
SRC_URI[x86_64_v2_python3-grpcio+protobuf.sha256sum] = "b084bd5857fa218e2f1b1c360483960b8e9db83e9dc0d1d1723db7c862a989c1"

URI_x86_64_v2_python3-grpcio-channelz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-grpcio-channelz-1.48.4-44.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-grpcio-channelz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-grpcio-channelz}"
SRC_URI[x86_64_v2_python3-grpcio-channelz.sha256sum] = "969a539f2a5d208890d74b9dedfd1d14a509e27892230818f00f0f72eef248dd"

URI_x86_64_v2_python3-grpcio-health-checking = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-grpcio-health-checking-1.48.4-44.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-grpcio-health-checking;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-grpcio-health-checking}"
SRC_URI[x86_64_v2_python3-grpcio-health-checking.sha256sum] = "ac271577cd637113b3f159a71ee43cbe38c16b675de4fc912399cfc20926b7c4"

URI_x86_64_v2_python3-grpcio-reflection = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-grpcio-reflection-1.48.4-44.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-grpcio-reflection;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-grpcio-reflection}"
SRC_URI[x86_64_v2_python3-grpcio-reflection.sha256sum] = "895c7fbb4c0808c3b2223eeef19a497c7016b0eece3c62660ba7f5f99d69f71d"

URI_x86_64_v2_python3-grpcio-status = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-grpcio-status-1.48.4-44.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-grpcio-status;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-grpcio-status}"
SRC_URI[x86_64_v2_python3-grpcio-status.sha256sum] = "77c5784fb8420b63acc17a4a9f7129747dbb95f3c132ff8530822dddafe7873b"

URI_x86_64_v2_python3-grpcio-testing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-grpcio-testing-1.48.4-44.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-grpcio-testing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-grpcio-testing}"
SRC_URI[x86_64_v2_python3-grpcio-testing.sha256sum] = "fa727f344c55d4b29dc470888aaf24ead8b5b734091d1f4be5e82d85cc81405c"

URI_x86_64_v2_python3-grpcio-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-grpcio-tools-1.48.4-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-grpcio-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-grpcio-tools}"
SRC_URI[x86_64_v2_python3-grpcio-tools.sha256sum] = "b3706df93514022d6d268f196755f8f1414d1435a54b397b62a5a825c77b4c23"

URI_aarch64_grpc = "${EPEL_MIRROR}/aarch64/Packages/g/grpc-1.48.4-44.el10_0.aarch64.rpm;name=aarch64_grpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_grpc}"
SRC_URI[aarch64_grpc.sha256sum] = "96ca88fda6c7c6bcdcd6f6bfb470745edcda1fcf5f71ebc448fdafe4a6229842"

URI_aarch64_grpc-cli = "${EPEL_MIRROR}/aarch64/Packages/g/grpc-cli-1.48.4-44.el10_0.aarch64.rpm;name=aarch64_grpc-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_grpc-cli}"
SRC_URI[aarch64_grpc-cli.sha256sum] = "2acf0feeeb562568795e0b5a0d344351b6aa18fa555d7daea564992b3e2fb48b"

URI_aarch64_grpc-cpp = "${EPEL_MIRROR}/aarch64/Packages/g/grpc-cpp-1.48.4-44.el10_0.aarch64.rpm;name=aarch64_grpc-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_grpc-cpp}"
SRC_URI[aarch64_grpc-cpp.sha256sum] = "0ecf079497d8372dde6d9fd24b515a625e7cc4d52c6493c35bc27efcba82fa6e"

URI_aarch64_grpc-data = "${EPEL_MIRROR}/aarch64/Packages/g/grpc-data-1.48.4-44.el10_0.noarch.rpm;name=aarch64_grpc-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_grpc-data}"
SRC_URI[aarch64_grpc-data.sha256sum] = "36c2741ddabb6b688cf6467c8e2f9c4d8154927aa243b8178bc8e2b787050c82"

URI_aarch64_grpc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/grpc-devel-1.48.4-44.el10_0.aarch64.rpm;name=aarch64_grpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_grpc-devel}"
SRC_URI[aarch64_grpc-devel.sha256sum] = "3f736d64350941c28e04baa361c5934cc8dbbf2fb1e934bd9f79bac8c93591a7"

URI_aarch64_grpc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/grpc-doc-1.48.4-44.el10_0.noarch.rpm;name=aarch64_grpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_grpc-doc}"
SRC_URI[aarch64_grpc-doc.sha256sum] = "316aab78051e722ff5dceb136244a5bf19feeb42623a388b25061da4c219f9c1"

URI_aarch64_grpc-plugins = "${EPEL_MIRROR}/aarch64/Packages/g/grpc-plugins-1.48.4-44.el10_0.aarch64.rpm;name=aarch64_grpc-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_grpc-plugins}"
SRC_URI[aarch64_grpc-plugins.sha256sum] = "c385031a6624f5509a77aaa0e0f92b7738862de33d003f46cfb80c0d7a009644"

URI_aarch64_python3-grpcio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-grpcio-1.48.4-44.el10_0.aarch64.rpm;name=aarch64_python3-grpcio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-grpcio}"
SRC_URI[aarch64_python3-grpcio.sha256sum] = "4cdd75e78e19b21a50f115a175dbe086c0b831a71905b9a30003f464aa0e4cc1"

URI_aarch64_python3-grpcio+protobuf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-grpcio+protobuf-1.48.4-44.el10_0.aarch64.rpm;name=aarch64_python3-grpcio+protobuf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-grpcio+protobuf}"
SRC_URI[aarch64_python3-grpcio+protobuf.sha256sum] = "8ef473565d23304a1d44caa9dc50de9f1c5388acf05418ef3d89caba26aec649"

URI_aarch64_python3-grpcio-channelz = "${EPEL_MIRROR}/aarch64/Packages/p/python3-grpcio-channelz-1.48.4-44.el10_0.noarch.rpm;name=aarch64_python3-grpcio-channelz;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-grpcio-channelz}"
SRC_URI[aarch64_python3-grpcio-channelz.sha256sum] = "0fe2309c578aec4888122ce861ae2894684ea7a906b6568fec21800892705a34"

URI_aarch64_python3-grpcio-health-checking = "${EPEL_MIRROR}/aarch64/Packages/p/python3-grpcio-health-checking-1.48.4-44.el10_0.noarch.rpm;name=aarch64_python3-grpcio-health-checking;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-grpcio-health-checking}"
SRC_URI[aarch64_python3-grpcio-health-checking.sha256sum] = "aea2b728614240fc8c8280f944098ac693cba1f39dacd2a877544eacd694b71f"

URI_aarch64_python3-grpcio-reflection = "${EPEL_MIRROR}/aarch64/Packages/p/python3-grpcio-reflection-1.48.4-44.el10_0.noarch.rpm;name=aarch64_python3-grpcio-reflection;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-grpcio-reflection}"
SRC_URI[aarch64_python3-grpcio-reflection.sha256sum] = "ce2c803143a9598f1f9e55697aa15cdd59f7c7bb9a16d9db48a0d3cdedfa9e49"

URI_aarch64_python3-grpcio-status = "${EPEL_MIRROR}/aarch64/Packages/p/python3-grpcio-status-1.48.4-44.el10_0.noarch.rpm;name=aarch64_python3-grpcio-status;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-grpcio-status}"
SRC_URI[aarch64_python3-grpcio-status.sha256sum] = "ea8cc436befe1cf0a97949f90dbb1f7eb2fc8c3dfe2864ba25adcdfa5f3fed46"

URI_aarch64_python3-grpcio-testing = "${EPEL_MIRROR}/aarch64/Packages/p/python3-grpcio-testing-1.48.4-44.el10_0.noarch.rpm;name=aarch64_python3-grpcio-testing;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-grpcio-testing}"
SRC_URI[aarch64_python3-grpcio-testing.sha256sum] = "3d9ad6adbef8b85655be4a8d7cf87a7f7934701a8d58744ca4e53c482fd065bb"

URI_aarch64_python3-grpcio-tools = "${EPEL_MIRROR}/aarch64/Packages/p/python3-grpcio-tools-1.48.4-44.el10_0.aarch64.rpm;name=aarch64_python3-grpcio-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-grpcio-tools}"
SRC_URI[aarch64_python3-grpcio-tools.sha256sum] = "1cf175a2ff44e01009afb52ce82f64e7b79f93f17aed398051552765681f62c4"

RDEPENDS:grpc = " \
 abseil-cpp \
 c-ares \
 glibc \
 grpc-data \
 libgcc \
 libstdc++ \
 openssl-libs \
 re2 \
 zlib-ng-compat \
 "
RDEPENDS:grpc-cli = " \
 abseil-cpp \
 glibc \
 grpc \
 grpc-cpp \
 libgcc \
 libstdc++ \
 protobuf \
 "
RDEPENDS:grpc-cpp = " \
 abseil-cpp \
 glibc \
 grpc \
 libgcc \
 libstdc++ \
 protobuf \
 protobuf-compiler \
 "
RDEPENDS:grpc-data = " \
 ca-certificates \
 "
RDEPENDS:grpc-devel = " \
 abseil-cpp-devel \
 c-ares-devel \
 cmake-filesystem \
 gmock-devel \
 grpc \
 grpc-cpp \
 grpc-devel \
 grpc-plugins \
 kernel-headers \
 openssl-devel \
 pkgconf-pkg-config \
 protobuf-devel \
 re2-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:grpc-doc = " \
 "
RDEPENDS:grpc-plugins = " \
 glibc \
 grpc \
 grpc-cpp \
 libgcc \
 libstdc++ \
 protobuf \
 protobuf-compiler \
 "
RDEPENDS:python3-grpcio = " \
 abseil-cpp \
 c-ares \
 glibc \
 grpc-data \
 libstdc++ \
 openssl-libs \
 python3 \
 python3-six \
 re2 \
 zlib-ng-compat \
 "
RDEPENDS:python3-grpcio+protobuf = " \
 python3 \
 python3-grpcio \
 python3-grpcio-tools \
 "
RDEPENDS:python3-grpcio-channelz = " \
 python3 \
 python3-grpcio \
 python3-protobuf \
 "
RDEPENDS:python3-grpcio-health-checking = " \
 python3 \
 python3-grpcio \
 python3-protobuf \
 "
RDEPENDS:python3-grpcio-reflection = " \
 python3 \
 python3-grpcio \
 python3-protobuf \
 "
RDEPENDS:python3-grpcio-status = " \
 python3 \
 python3-googleapis-common-protos \
 python3-grpcio \
 python3-protobuf \
 "
RDEPENDS:python3-grpcio-testing = " \
 python3 \
 python3-grpcio \
 python3-protobuf \
 "
RDEPENDS:python3-grpcio-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 protobuf-compiler \
 python3 \
 python3-grpcio \
 python3-protobuf \
 python3-setuptools \
 "
