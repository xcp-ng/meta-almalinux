# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yyjson"
PV = "0.12.0"
PR = "1.el10_1"
PACKAGES = " \
 yyjson \
 yyjson-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yyjson-0.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "906e4438e65aa17749e45c7ae86a0b05ab97bdbde3aadfa47a8aa90599bfab5d"

URI_x86_64_v2_yyjson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yyjson-0.12.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yyjson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yyjson}"
SRC_URI[x86_64_v2_yyjson.sha256sum] = "dae73b4174b6d5ee77b660ccf8764140cc99f1fc66e1b5eb4c96ace811d3ac49"

URI_x86_64_v2_yyjson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yyjson-devel-0.12.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yyjson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yyjson-devel}"
SRC_URI[x86_64_v2_yyjson-devel.sha256sum] = "b93890bb05de45d135ac87d6c34d692d122da343ffa74cdbaf64a319200de169"

URI_aarch64_yyjson = "${EPEL_MIRROR}/aarch64/Packages/y/yyjson-0.12.0-1.el10_1.aarch64.rpm;name=aarch64_yyjson;unpack=0"
SRC_URI:append = " ${URI_aarch64_yyjson}"
SRC_URI[aarch64_yyjson.sha256sum] = "51fb3abd98004d16130daa81077b998c297bbfffb898e79ddd8c56bf1fd93219"

URI_aarch64_yyjson-devel = "${EPEL_MIRROR}/aarch64/Packages/y/yyjson-devel-0.12.0-1.el10_1.aarch64.rpm;name=aarch64_yyjson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yyjson-devel}"
SRC_URI[aarch64_yyjson-devel.sha256sum] = "9f18f82eab78dc9a29cdbff0257c66a57a486a39523659284c4158b52840cd38"

RDEPENDS:yyjson = " \
 glibc \
 "
RDEPENDS:yyjson-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 yyjson \
 "
