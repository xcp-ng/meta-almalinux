# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dolphin"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 dolphin \
 dolphin-devel \
 dolphin-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dolphin-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2bb800c01bb34a0a7c8aafd7fae955bf1232a5c54dc23d5fc2cb2137ca41537"

URI_x86_64_v2_dolphin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dolphin}"
SRC_URI[x86_64_v2_dolphin.sha256sum] = "4d260c44a2630f1743239a20dc228e3fdb798e25f13f9ca6c89a91d7bb0d26e1"

URI_x86_64_v2_dolphin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dolphin-devel}"
SRC_URI[x86_64_v2_dolphin-devel.sha256sum] = "5f3829948d3109c1675b70da897f4b040b9cbab1941c79774550f2dc256b4048"

URI_x86_64_v2_dolphin-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dolphin-libs}"
SRC_URI[x86_64_v2_dolphin-libs.sha256sum] = "d75f2d9b366de67158302af578b3b8a2a190ef69f0b87a789cb5ab39a774bc03"

URI_aarch64_dolphin = "${EPEL_MIRROR}/aarch64/Packages/d/dolphin-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_dolphin;unpack=0"
SRC_URI:append = " ${URI_aarch64_dolphin}"
SRC_URI[aarch64_dolphin.sha256sum] = "8c3b44f0e2a40b12e4b7c923ca14f7b0c8f72605958f302bb36ec7ae5ee73443"

URI_aarch64_dolphin-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dolphin-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_dolphin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dolphin-devel}"
SRC_URI[aarch64_dolphin-devel.sha256sum] = "317d6c4a27840756ef46123fddc9a68c1592ebd153626c7aad7c35ced6083f67"

URI_aarch64_dolphin-libs = "${EPEL_MIRROR}/aarch64/Packages/d/dolphin-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_dolphin-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_dolphin-libs}"
SRC_URI[aarch64_dolphin-libs.sha256sum] = "975a44d33be7a6e7b516a17d5aba650331b65ef846fa51432745ef7df65a37ab"

RDEPENDS:dolphin = " \
 PackageKit-Qt6 \
 baloo-widgets \
 dolphin-libs \
 glibc \
 kf6-baloo-libs \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kparts \
 kf6-kservice \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 libstdc++ \
 phonon-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:dolphin-devel = " \
 cmake-filesystem \
 dolphin-libs \
 kf6-kio-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:dolphin-libs = " \
 baloo-widgets \
 glibc \
 kf6-baloo-libs \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
