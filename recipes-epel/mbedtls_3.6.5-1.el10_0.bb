# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mbedtls"
PV = "3.6.5"
PR = "1.el10_0"
PACKAGES = " \
 mbedtls \
 mbedtls-devel \
 mbedtls-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mbedtls-3.6.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02467711b1c0939598e13ddabb09bf60fb7741c94b00167a6d78e1888acb3402"

URI_x86_64_v2_mbedtls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbedtls-3.6.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbedtls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbedtls}"
SRC_URI[x86_64_v2_mbedtls.sha256sum] = "a94046927e0041061235a43b139becef8f65081fec4d460feae1c6e7b2aa089e"

URI_x86_64_v2_mbedtls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbedtls-devel-3.6.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbedtls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbedtls-devel}"
SRC_URI[x86_64_v2_mbedtls-devel.sha256sum] = "d806f83750b41638abb025f44cec65407c74fc3611856bbe6f66e3f456f93fec"

URI_x86_64_v2_mbedtls-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbedtls-doc-3.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mbedtls-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbedtls-doc}"
SRC_URI[x86_64_v2_mbedtls-doc.sha256sum] = "74680a178470b5092ade76d115d8f6c615a1497650f772507a5793e20c0fa690"

URI_aarch64_mbedtls = "${EPEL_MIRROR}/aarch64/Packages/m/mbedtls-3.6.5-1.el10_0.aarch64.rpm;name=aarch64_mbedtls;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbedtls}"
SRC_URI[aarch64_mbedtls.sha256sum] = "d483642c7d18fd73218b4686a52515f650daa6e84d67cca9d6724fb2a0343e2f"

URI_aarch64_mbedtls-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mbedtls-devel-3.6.5-1.el10_0.aarch64.rpm;name=aarch64_mbedtls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbedtls-devel}"
SRC_URI[aarch64_mbedtls-devel.sha256sum] = "8fe07eb9189a8f867bbc2d7e6b094fcbf8099062604666d5543e51c7f601a5da"

URI_aarch64_mbedtls-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mbedtls-doc-3.6.5-1.el10_0.noarch.rpm;name=aarch64_mbedtls-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbedtls-doc}"
SRC_URI[aarch64_mbedtls-doc.sha256sum] = "17ca46c3ffb0cff1bc4c016aa6b2825fb342ec66ba5fbbd9f81f1e16a6625cd3"

RDEPENDS:mbedtls = " \
 glibc \
 "
RDEPENDS:mbedtls-devel = " \
 cmake-filesystem \
 glibc \
 mbedtls \
 mbedtls-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:mbedtls-doc = " \
 "
