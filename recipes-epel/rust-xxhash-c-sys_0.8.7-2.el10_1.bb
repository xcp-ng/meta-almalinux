# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xxhash-c-sys"
PV = "0.8.7"
PR = "2.el10_1"
PACKAGES = " \
 rust-xxhash-c-sys+default-devel \
 rust-xxhash-c-sys+no_std-devel \
 rust-xxhash-c-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-xxhash-c-sys-0.8.7-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a9ff730f6dd8dbef2a5eaa19837ab7560d6991d64a40307b0b5367d3827fadf"

URI_x86_64_v2_rust-xxhash-c-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-c-sys+default-devel-0.8.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-c-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-c-sys+default-devel}"
SRC_URI[x86_64_v2_rust-xxhash-c-sys+default-devel.sha256sum] = "c0630de4076ea2b2f89baa471f16b3c7e07b02012e32c721d9aca5a4a92a208c"

URI_x86_64_v2_rust-xxhash-c-sys+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-c-sys+no_std-devel-0.8.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-c-sys+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-c-sys+no_std-devel}"
SRC_URI[x86_64_v2_rust-xxhash-c-sys+no_std-devel.sha256sum] = "32e2df74d86e00133d8a85cdf764167af1f2bd7a2944917fcd2c20f5daa64bf7"

URI_x86_64_v2_rust-xxhash-c-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-c-sys-devel-0.8.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-c-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-c-sys-devel}"
SRC_URI[x86_64_v2_rust-xxhash-c-sys-devel.sha256sum] = "bfd4b1251e3d70af35485b6e75bb68dc39361803f733ce00bbca8c232e48babf"

URI_aarch64_rust-xxhash-c-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-c-sys+default-devel-0.8.7-2.el10_1.noarch.rpm;name=aarch64_rust-xxhash-c-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-c-sys+default-devel}"
SRC_URI[aarch64_rust-xxhash-c-sys+default-devel.sha256sum] = "40671b75890e35367418aa4300fefcaf9d7ff4e7c6f6393e74affe817f912073"

URI_aarch64_rust-xxhash-c-sys+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-c-sys+no_std-devel-0.8.7-2.el10_1.noarch.rpm;name=aarch64_rust-xxhash-c-sys+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-c-sys+no_std-devel}"
SRC_URI[aarch64_rust-xxhash-c-sys+no_std-devel.sha256sum] = "8bb4a976fb45f50003daeebf6967175ad98b1a8e3d21cf127be192c01cdfdccc"

URI_aarch64_rust-xxhash-c-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-c-sys-devel-0.8.7-2.el10_1.noarch.rpm;name=aarch64_rust-xxhash-c-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-c-sys-devel}"
SRC_URI[aarch64_rust-xxhash-c-sys-devel.sha256sum] = "8542ffedea042fde8f896345dec2f76029bda48c5fa780188ee7d3da9340d4a7"

RDEPENDS:rust-xxhash-c-sys+default-devel = " \
 cargo \
 rust-xxhash-c-sys-devel \
 "
RDEPENDS:rust-xxhash-c-sys+no_std-devel = " \
 cargo \
 rust-xxhash-c-sys-devel \
 "
RDEPENDS:rust-xxhash-c-sys-devel = " \
 cargo \
 rust-libc-devel \
 rust-pkg-config+default-devel \
 xxhash-devel \
 "
