# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-either"
PV = "1.16.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-either+default-devel \
 rust-either+serde-devel \
 rust-either+std-devel \
 rust-either+use_std-devel \
 rust-either-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-either-1.16.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd22514d246ed4c3106333ad61953495105d72732b3a9748617ad60026f0a987"

URI_x86_64_v2_rust-either+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+default-devel-1.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+default-devel}"
SRC_URI[x86_64_v2_rust-either+default-devel.sha256sum] = "7bc822a080c348a298571ab6bcd8983a1cc86d6c7e6306ca7a0c445e379dc272"

URI_x86_64_v2_rust-either+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+serde-devel-1.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+serde-devel}"
SRC_URI[x86_64_v2_rust-either+serde-devel.sha256sum] = "16652b9b4a48bc3c40cb51f9f62ca998e5e8f5d979ed0d41e90ccb5099d21e04"

URI_x86_64_v2_rust-either+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+std-devel-1.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+std-devel}"
SRC_URI[x86_64_v2_rust-either+std-devel.sha256sum] = "4ca99abc4fe030dfc2c1eb277560c761e810a912c035d9626f198faf33832fad"

URI_x86_64_v2_rust-either+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+use_std-devel-1.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+use_std-devel}"
SRC_URI[x86_64_v2_rust-either+use_std-devel.sha256sum] = "651d935f358c9e0f2077d5f097d644c1cd9b978e9ab966523cec5de950916fc9"

URI_x86_64_v2_rust-either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either-devel-1.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either-devel}"
SRC_URI[x86_64_v2_rust-either-devel.sha256sum] = "32d7d08657b57c83fa82d6fd42059021c972fa1c3fd165f5d3105584a60ae803"

URI_aarch64_rust-either+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+default-devel-1.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-either+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+default-devel}"
SRC_URI[aarch64_rust-either+default-devel.sha256sum] = "ff886362cf8c8b9b9931f2a3b950aafde3b37a45dface7044f389a3083f5e7da"

URI_aarch64_rust-either+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+serde-devel-1.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-either+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+serde-devel}"
SRC_URI[aarch64_rust-either+serde-devel.sha256sum] = "ac3b5c0b0ca4553da2fb03d624d786b2d8625b3f685d75c24705e710b4ec1791"

URI_aarch64_rust-either+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+std-devel-1.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-either+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+std-devel}"
SRC_URI[aarch64_rust-either+std-devel.sha256sum] = "78e3d3608960a128c86be3caa354ccdfe6337cbf1989d8745912a2062cdc92be"

URI_aarch64_rust-either+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+use_std-devel-1.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-either+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+use_std-devel}"
SRC_URI[aarch64_rust-either+use_std-devel.sha256sum] = "3c675a31c12c18cd0498112754b88736b4eb1d9d25f5545de3cb8b2cf734388c"

URI_aarch64_rust-either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either-devel-1.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either-devel}"
SRC_URI[aarch64_rust-either-devel.sha256sum] = "e102828e869b56c70910464fefd7723d8fffaacc785c50f1c6a8b205af586a80"

RDEPENDS:rust-either+default-devel = " \
 cargo \
 rust-either+std-devel \
 rust-either-devel \
 "
RDEPENDS:rust-either+serde-devel = " \
 cargo \
 rust-either-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-either+std-devel = " \
 cargo \
 rust-either-devel \
 "
RDEPENDS:rust-either+use_std-devel = " \
 cargo \
 rust-either+std-devel \
 rust-either-devel \
 "
RDEPENDS:rust-either-devel = " \
 cargo \
 rust \
 "
