# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-pl"
PV = "0.20060726"
PR = "33.el10"
PACKAGES = " \
 hyphen-pl \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-pl-0.20060726-33.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a2bcdd6436e3ba996db87b62da5fd7986c75024728f69b574e9b403f40ab3285"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-pl-0.20060726-33.el10.noarch.rpm;name=x86_64_v2_hyphen-pl;unpack=0"
SRC_URI[x86_64_v2_hyphen-pl.sha256sum] = "1dbe3de7653fc8656b6f0eb777a8f2f0fd0f00151dec3681e10cdad7aeb7fa05"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-pl-0.20060726-33.el10.noarch.rpm;name=aarch64_hyphen-pl;unpack=0"
SRC_URI[aarch64_hyphen-pl.sha256sum] = "1dbe3de7653fc8656b6f0eb777a8f2f0fd0f00151dec3681e10cdad7aeb7fa05"

RDEPENDS:hyphen-pl = " \
 hyphen \
 "
