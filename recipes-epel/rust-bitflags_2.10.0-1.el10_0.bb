# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitflags"
PV = "2.10.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-bitflags+arbitrary-devel \
 rust-bitflags+bytemuck-devel \
 rust-bitflags+default-devel \
 rust-bitflags+example_generated-devel \
 rust-bitflags+serde-devel \
 rust-bitflags+serde_core-devel \
 rust-bitflags+std-devel \
 rust-bitflags-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bitflags-2.10.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f33212205a3cd5e11ab3287a04c00c1b31cbe8ea3beaf4dfd6ffd13efbe9c36"

URI_x86_64_v2_rust-bitflags+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+arbitrary-devel-2.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-bitflags+arbitrary-devel.sha256sum] = "26381045a4ac1bb8ca1911e7eb2207a70e147ad9626f775816821fd308c98d0e"

URI_x86_64_v2_rust-bitflags+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+bytemuck-devel-2.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-bitflags+bytemuck-devel.sha256sum] = "c6378a34d9e7530dfa84e38691e9f5d58bfc03ace9aff07e1b2fa25278e24245"

URI_x86_64_v2_rust-bitflags+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+default-devel-2.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+default-devel}"
SRC_URI[x86_64_v2_rust-bitflags+default-devel.sha256sum] = "d64d02613a4ef940abe916679bee862f7dba3d203f952ab15b82630a585374e3"

URI_x86_64_v2_rust-bitflags+example_generated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+example_generated-devel-2.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+example_generated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+example_generated-devel}"
SRC_URI[x86_64_v2_rust-bitflags+example_generated-devel.sha256sum] = "41322ecb06157baf63d4a3491815bfea594e6f0f7b31e9bb27d878c671e07db0"

URI_x86_64_v2_rust-bitflags+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+serde-devel-2.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+serde-devel}"
SRC_URI[x86_64_v2_rust-bitflags+serde-devel.sha256sum] = "2d32d920a10d39ee24a6655804c0654024b0235f0aa2fb3fa98360ca3f8cad1b"

URI_x86_64_v2_rust-bitflags+serde_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+serde_core-devel-2.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+serde_core-devel}"
SRC_URI[x86_64_v2_rust-bitflags+serde_core-devel.sha256sum] = "bb303c1c898f4aa98e36970dc270e6e022bf5cfb4eafd18e3d7b189a45d3f36a"

URI_x86_64_v2_rust-bitflags+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+std-devel-2.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+std-devel}"
SRC_URI[x86_64_v2_rust-bitflags+std-devel.sha256sum] = "0e35f748acfd7444110e0d2065174c62cdb6f503124390fa638744efe7a84952"

URI_x86_64_v2_rust-bitflags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags-devel-2.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags-devel}"
SRC_URI[x86_64_v2_rust-bitflags-devel.sha256sum] = "824e3fa518ad6ea6fcea5c217f2a4c01897babb81d4961cdec09573e05f97749"

URI_aarch64_rust-bitflags+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+arbitrary-devel-2.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-bitflags+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+arbitrary-devel}"
SRC_URI[aarch64_rust-bitflags+arbitrary-devel.sha256sum] = "544c6b7aeb97153e04946c03fa5c7280d4c13282ca8c2a49842015ce5f4f81d8"

URI_aarch64_rust-bitflags+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+bytemuck-devel-2.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-bitflags+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+bytemuck-devel}"
SRC_URI[aarch64_rust-bitflags+bytemuck-devel.sha256sum] = "01885716b72c380f3fa526b669ae63bb2a4e6210874c23a06bf79b98a0b876a1"

URI_aarch64_rust-bitflags+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+default-devel-2.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-bitflags+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+default-devel}"
SRC_URI[aarch64_rust-bitflags+default-devel.sha256sum] = "db229274a6905d4c52261acd683dbc8dd493a6b9182078b301caa5e22bff5b69"

URI_aarch64_rust-bitflags+example_generated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+example_generated-devel-2.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-bitflags+example_generated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+example_generated-devel}"
SRC_URI[aarch64_rust-bitflags+example_generated-devel.sha256sum] = "30dabd5385e8a4d99fc454b0c7cb34f160e1cb3c729d51afa0262f2f97f52cf6"

URI_aarch64_rust-bitflags+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+serde-devel-2.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-bitflags+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+serde-devel}"
SRC_URI[aarch64_rust-bitflags+serde-devel.sha256sum] = "4b909bf32b0e73705b45138cbad7981966acdb754ca75d040fec9f12d3069b04"

URI_aarch64_rust-bitflags+serde_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+serde_core-devel-2.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-bitflags+serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+serde_core-devel}"
SRC_URI[aarch64_rust-bitflags+serde_core-devel.sha256sum] = "ae9e36230a7980e2159fd02981c72d4a05de24a0b2bd6dc3ffdc80478fbfe196"

URI_aarch64_rust-bitflags+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+std-devel-2.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-bitflags+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+std-devel}"
SRC_URI[aarch64_rust-bitflags+std-devel.sha256sum] = "401cafbaf602881045fe16918397e65635970cb2a69953d4d2ccaad28c7b4cf2"

URI_aarch64_rust-bitflags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags-devel-2.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-bitflags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags-devel}"
SRC_URI[aarch64_rust-bitflags-devel.sha256sum] = "98fdafc69faae43274e512e02e0891b10a0f49cb6932b985da5c3d9fdb8da7bc"

RDEPENDS:rust-bitflags+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+bytemuck-devel = " \
 cargo \
 rust-bitflags-devel \
 rust-bytemuck+default-devel \
 "
RDEPENDS:rust-bitflags+default-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+example_generated-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+serde-devel = " \
 cargo \
 rust-bitflags+serde_core-devel \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+serde_core-devel = " \
 cargo \
 rust-bitflags-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bitflags+std-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags-devel = " \
 cargo \
 rust \
 "
