# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ca-certificates"
PV = "2025.2.80_v9.0.305"
PR = "102.el10_0"
PACKAGES = " \
 ca-certificates \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ca-certificates-2025.2.80_v9.0.305-102.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "713335f5511fbfd6f2adc09a384692fcf5db8320e63830b5161e377eb925c71e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ca-certificates-2025.2.80_v9.0.305-102.el10_0.noarch.rpm;name=x86_64_v2_ca-certificates;unpack=0"
SRC_URI[x86_64_v2_ca-certificates.sha256sum] = "fb19ca670a213eb70690c70824b3791057abb9773124c5f9f1bb93f7181bc623"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ca-certificates-2025.2.80_v9.0.305-102.el10_0.noarch.rpm;name=aarch64_ca-certificates;unpack=0"
SRC_URI[aarch64_ca-certificates.sha256sum] = "fb19ca670a213eb70690c70824b3791057abb9773124c5f9f1bb93f7181bc623"

RDEPENDS:ca-certificates = " \
 bash \
 findutils \
 grep \
 libffi \
 p11-kit-trust \
 sed \
 virtual/coreutils \
 "
