# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-webpki-roots0.26"
PV = "0.26.11"
PR = "1.el10_1"
PACKAGES = " \
 rust-webpki-roots0.26+default-devel \
 rust-webpki-roots0.26-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-webpki-roots0.26-0.26.11-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc4bf07ab51b9a4ec6ed815d4002d68fba94976df4e993d6a5aaf95258c98af6"

URI_x86_64_v2_rust-webpki-roots0.26+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webpki-roots0.26+default-devel-0.26.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webpki-roots0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webpki-roots0.26+default-devel}"
SRC_URI[x86_64_v2_rust-webpki-roots0.26+default-devel.sha256sum] = "15b20f1df0840e9fb789a3b3f8fd9d80ee6e6f8661757d8037434ae5baacef4d"

URI_x86_64_v2_rust-webpki-roots0.26-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webpki-roots0.26-devel-0.26.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webpki-roots0.26-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webpki-roots0.26-devel}"
SRC_URI[x86_64_v2_rust-webpki-roots0.26-devel.sha256sum] = "d7362c412e5e3f1d6764c7e3a3ffce1df1e044f2de59bc35eeedb2381c4f9514"

URI_aarch64_rust-webpki-roots0.26+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webpki-roots0.26+default-devel-0.26.11-1.el10_1.noarch.rpm;name=aarch64_rust-webpki-roots0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webpki-roots0.26+default-devel}"
SRC_URI[aarch64_rust-webpki-roots0.26+default-devel.sha256sum] = "38ad31d738331ed78d6698d49c5fc3ca748ae2575fa8f1d83b321fa9e196f645"

URI_aarch64_rust-webpki-roots0.26-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webpki-roots0.26-devel-0.26.11-1.el10_1.noarch.rpm;name=aarch64_rust-webpki-roots0.26-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webpki-roots0.26-devel}"
SRC_URI[aarch64_rust-webpki-roots0.26-devel.sha256sum] = "c4f10cf62ddfa19d910cfe37720efc5a0f3d612e3aaa05f4c5195fe7cfb932ed"

RDEPENDS:rust-webpki-roots0.26+default-devel = " \
 cargo \
 rust-webpki-roots0.26-devel \
 "
RDEPENDS:rust-webpki-roots0.26-devel = " \
 cargo \
 rust-webpki-roots+default-devel \
 "
