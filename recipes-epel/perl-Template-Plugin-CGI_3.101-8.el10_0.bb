# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Template-Plugin-CGI"
PV = "3.101"
PR = "8.el10_0"
PACKAGES = " \
 perl-Template-Plugin-CGI \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Template-Plugin-CGI-3.101-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f62f8ba4437715ff517512288b90ce7a86b9699b90f80b3e12344827ee7da02"

URI_x86_64_v2_perl-Template-Plugin-CGI = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Template-Plugin-CGI-3.101-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Template-Plugin-CGI;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Template-Plugin-CGI}"
SRC_URI[x86_64_v2_perl-Template-Plugin-CGI.sha256sum] = "2080cfc743bac2d0c83e7676b9b6b96a668316ccd373ab92b72a03c17ad5ce1f"

URI_aarch64_perl-Template-Plugin-CGI = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Template-Plugin-CGI-3.101-8.el10_0.noarch.rpm;name=aarch64_perl-Template-Plugin-CGI;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Template-Plugin-CGI}"
SRC_URI[aarch64_perl-Template-Plugin-CGI.sha256sum] = "cb7963294baa0b25f680ed4bf9530fbe85cecf1b3278939244e4c0cbbd241cdd"

RDEPENDS:perl-Template-Plugin-CGI = " \
 perl-CGI \
 perl-Template-Toolkit \
 perl-base \
 perl-libs \
 "
