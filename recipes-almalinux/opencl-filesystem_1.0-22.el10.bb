# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opencl-filesystem"
PV = "1.0"
PR = "22.el10"
PACKAGES = " \
 opencl-filesystem \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/opencl-filesystem-1.0-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2af43a028b78df27f44f99f9783ff37ca4782a41f56ed4eccf5ecbcfd6830d3"

URI_x86_64_v2_opencl-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/opencl-filesystem-1.0-22.el10.noarch.rpm;name=x86_64_v2_opencl-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencl-filesystem}"
SRC_URI[x86_64_v2_opencl-filesystem.sha256sum] = "0aa533eb07ff469344000db9ddff7da77595cb945482b6f823377020c4179814"

URI_aarch64_opencl-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/opencl-filesystem-1.0-22.el10.noarch.rpm;name=aarch64_opencl-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencl-filesystem}"
SRC_URI[aarch64_opencl-filesystem.sha256sum] = "0aa533eb07ff469344000db9ddff7da77595cb945482b6f823377020c4179814"

RDEPENDS:opencl-filesystem = " \
 "
