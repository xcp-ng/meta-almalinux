# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crc32fast"
PV = "1.5.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-crc32fast+default-devel \
 rust-crc32fast+nightly-devel \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crc32fast-1.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82fdd15e1d849c5600a413249f4a72b49c3e61c6cc0edb6eb940858480fe1681"

URI_x86_64_v2_rust-crc32fast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast+default-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc32fast+default-devel}"
SRC_URI[x86_64_v2_rust-crc32fast+default-devel.sha256sum] = "c0c9560cfba5da4739410c684b21ca78a2ae3df919632123d4ac97cee9644f68"

URI_x86_64_v2_rust-crc32fast+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast+nightly-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc32fast+nightly-devel}"
SRC_URI[x86_64_v2_rust-crc32fast+nightly-devel.sha256sum] = "e2f4e810c53c59e8bbf1b37c671f33ec08037372a9ba83db6b53f76d885a0dc4"

URI_x86_64_v2_rust-crc32fast+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast+std-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc32fast+std-devel}"
SRC_URI[x86_64_v2_rust-crc32fast+std-devel.sha256sum] = "6ab3b733189a1a7fc1beb89b49cfa03f127e182be5406bc0cc4207a01eff163b"

URI_x86_64_v2_rust-crc32fast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc32fast-devel}"
SRC_URI[x86_64_v2_rust-crc32fast-devel.sha256sum] = "4e60d86f83046f28d55675d7461382bff04f0a7b2ed0c58d8bedd128fc789b7e"

URI_aarch64_rust-crc32fast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast+default-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-crc32fast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc32fast+default-devel}"
SRC_URI[aarch64_rust-crc32fast+default-devel.sha256sum] = "11247b9e887ae47d1fc3a49c3caa235523ba49b3189e13259a798900a1bbddb1"

URI_aarch64_rust-crc32fast+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast+nightly-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-crc32fast+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc32fast+nightly-devel}"
SRC_URI[aarch64_rust-crc32fast+nightly-devel.sha256sum] = "763635acaf54bedf1eae1c77e6bd230f116767e38cc5b31239dee9bb33b15f45"

URI_aarch64_rust-crc32fast+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast+std-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-crc32fast+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc32fast+std-devel}"
SRC_URI[aarch64_rust-crc32fast+std-devel.sha256sum] = "ad1287bf462b2b19af70ff66fd059357e3d7f413d5885ac1bfc0ac7ccff48bd4"

URI_aarch64_rust-crc32fast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-crc32fast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc32fast-devel}"
SRC_URI[aarch64_rust-crc32fast-devel.sha256sum] = "5997cee6ddfa78508dd1244bb0377c17daebbe1e5a0c040e81894d0418888066"

RDEPENDS:rust-crc32fast+default-devel = " \
 cargo \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 "
RDEPENDS:rust-crc32fast+nightly-devel = " \
 cargo \
 rust-crc32fast-devel \
 "
RDEPENDS:rust-crc32fast+std-devel = " \
 cargo \
 rust-crc32fast-devel \
 "
RDEPENDS:rust-crc32fast-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "
