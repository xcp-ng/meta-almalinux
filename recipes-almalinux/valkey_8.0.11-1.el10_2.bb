# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "valkey"
PV = "8.0.11"
PR = "1.el10_2"
PACKAGES = " \
 valkey \
 valkey-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/valkey-8.0.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "74b57ffadf480b219150b280dda81fffaea3a2e567b990293bf5ab78359967d3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valkey-8.0.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_valkey;unpack=0"
SRC_URI[x86_64_v2_valkey.sha256sum] = "56337cd8913d1c8dddaaaa9ad221babcf9c3ac2b7b1e252890b1c335e5ba5086"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valkey-devel-8.0.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_valkey-devel;unpack=0"
SRC_URI[x86_64_v2_valkey-devel.sha256sum] = "1cb8aa92bf970e17e6dae5c12af6d7eb09f2a2d736a476cfbf686cfe065d376a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valkey-8.0.11-1.el10_2.aarch64.rpm;name=aarch64_valkey;unpack=0"
SRC_URI[aarch64_valkey.sha256sum] = "a27198fd7ba85b1bcfe365155f1682141d2dcda7304da62ea4f7e61a274a8ccf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valkey-devel-8.0.11-1.el10_2.aarch64.rpm;name=aarch64_valkey-devel;unpack=0"
SRC_URI[aarch64_valkey-devel.sha256sum] = "fc7cf85013436b84f400a2b7ed5397f9969e7f19168afcf24931e81605547650"

RDEPENDS:valkey = " \
 bash \
 glibc \
 logrotate \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:valkey-devel = " \
 "
