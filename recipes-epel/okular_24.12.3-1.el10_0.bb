# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "okular"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 okular \
 okular-devel \
 okular-libs \
 okular-mobile \
 okular-part \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/okular-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4281fb4394a0da02770ab359ff00baab5cc151ab2723c9ea184c96d36ed0647"

URI_x86_64_v2_okular = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular}"
SRC_URI[x86_64_v2_okular.sha256sum] = "3d459c1173d236431e51633b02e050431e3b5fcb6f5d2b4cb631fa7e408eb788"

URI_x86_64_v2_okular-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-devel}"
SRC_URI[x86_64_v2_okular-devel.sha256sum] = "3f8122355840afb2e19d70f136a7d095a6904cb20b6d15e4b049c9d21bedc3eb"

URI_x86_64_v2_okular-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-libs}"
SRC_URI[x86_64_v2_okular-libs.sha256sum] = "9a2f6a933a4bb7284fbf9076bb0242a1146364a8fa6461a14e748fbd4b84c32b"

URI_x86_64_v2_okular-mobile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-mobile-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-mobile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-mobile}"
SRC_URI[x86_64_v2_okular-mobile.sha256sum] = "ccda5e9408d640e5be08663ff920350fbee4061e8cac6dd42c667106b835abe8"

URI_x86_64_v2_okular-part = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-part-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-part;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-part}"
SRC_URI[x86_64_v2_okular-part.sha256sum] = "22f527d848cca933ede9a823e364b23e23244e62153ee6cc4876ad9e879bb659"

URI_aarch64_okular = "${EPEL_MIRROR}/aarch64/Packages/o/okular-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_okular;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular}"
SRC_URI[aarch64_okular.sha256sum] = "941f59624047d642b7f828975360f1b9336bd8d4a47355e4bc438917d29e7e99"

URI_aarch64_okular-devel = "${EPEL_MIRROR}/aarch64/Packages/o/okular-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_okular-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-devel}"
SRC_URI[aarch64_okular-devel.sha256sum] = "4bd0b41204cca6d5b38eb153739ad614b03649faad4f545efde2eaf53bc7c560"

URI_aarch64_okular-libs = "${EPEL_MIRROR}/aarch64/Packages/o/okular-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_okular-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-libs}"
SRC_URI[aarch64_okular-libs.sha256sum] = "85c5add74032e3e0f4392916013aad139be51625d648660ec665a30eb9c981f9"

URI_aarch64_okular-mobile = "${EPEL_MIRROR}/aarch64/Packages/o/okular-mobile-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_okular-mobile;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-mobile}"
SRC_URI[aarch64_okular-mobile.sha256sum] = "05da0e2adb4f8c3a716883669930dbee2bbdefd909904a869181857cb268a528"

URI_aarch64_okular-part = "${EPEL_MIRROR}/aarch64/Packages/o/okular-part-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_okular-part;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-part}"
SRC_URI[aarch64_okular-part.sha256sum] = "c2b6639a2755665b2798e6fbc90f3aba72cb4724dbf2315f0d5ee60d89681cff"

RDEPENDS:okular = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-purpose \
 libstdc++ \
 okular-part \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:okular-devel = " \
 cmake-filesystem \
 okular-libs \
 "
RDEPENDS:okular-libs = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-threadweaver \
 libstdc++ \
 phonon-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 zlib-ng-compat \
 "
RDEPENDS:okular-mobile = " \
 glibc \
 kf6-kbookmarks \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 okular-libs \
 okular-part \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:okular-part = " \
 freetype \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kparts \
 kf6-kpty \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 libkexiv2-qt6 \
 libmarkdown \
 libspectre \
 libstdc++ \
 libtiff \
 okular-libs \
 phonon-qt6 \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 "
