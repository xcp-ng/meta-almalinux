# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liblockfile"
PV = "1.17"
PR = "11.el10_1"
PACKAGES = " \
 liblockfile \
 liblockfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/liblockfile-1.17-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90d917f87438693ac9096064ebfa579c8b0aef55089c3d75ae6e06f50e8bbcdf"

URI_x86_64_v2_liblockfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblockfile-1.17-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblockfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblockfile}"
SRC_URI[x86_64_v2_liblockfile.sha256sum] = "805b5e366fdc76edf34508127b90318f655cbfb02b61ab0ba18ae1674d95e60f"

URI_x86_64_v2_liblockfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblockfile-devel-1.17-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblockfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblockfile-devel}"
SRC_URI[x86_64_v2_liblockfile-devel.sha256sum] = "bdf410f900533c3377f34e9fdacbb084e50b0c290cf54ab64753e4e5eb05971c"

URI_aarch64_liblockfile = "${EPEL_MIRROR}/aarch64/Packages/l/liblockfile-1.17-11.el10_1.aarch64.rpm;name=aarch64_liblockfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblockfile}"
SRC_URI[aarch64_liblockfile.sha256sum] = "61ed4535e8a30828cd97ab82b19816cb9a9ef0c846d21d4460d764403b2ec99a"

URI_aarch64_liblockfile-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liblockfile-devel-1.17-11.el10_1.aarch64.rpm;name=aarch64_liblockfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblockfile-devel}"
SRC_URI[aarch64_liblockfile-devel.sha256sum] = "69dc4a7e06cc2c954b190bd8853ed9bb79ab529b87757a5aef5e4905755ad34d"

RDEPENDS:liblockfile = " \
 glibc \
 "
RDEPENDS:liblockfile-devel = " \
 liblockfile \
 "
