# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet8.0"
PV = "8.0.130"
PR = "1.el10_2"
PACKAGES = " \
 aspnetcore-runtime-8.0 \
 aspnetcore-runtime-dbg-8.0 \
 aspnetcore-targeting-pack-8.0 \
 dotnet-apphost-pack-8.0 \
 dotnet-hostfxr-8.0 \
 dotnet-runtime-8.0 \
 dotnet-runtime-dbg-8.0 \
 dotnet-sdk-8.0 \
 dotnet-sdk-8.0-source-built-artifacts \
 dotnet-sdk-dbg-8.0 \
 dotnet-targeting-pack-8.0 \
 dotnet-templates-8.0 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet8.0-8.0.130-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e703345ef340acaa9697ebc159032b11f64f170c1c006620028865ba574e0425"

URI_x86_64_v2_aspnetcore-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-8.0-8.0.30-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-8.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-8.0.sha256sum] = "ad0d49d7948d14242a15077f2e45f0070a16d711c8c9eaa44c58b4d1e1695ce6"

URI_x86_64_v2_aspnetcore-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-8.0-8.0.30-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-dbg-8.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-8.0.sha256sum] = "84d1514499666812232c6abcfbda962b94a18af220b7de520b56152523d83d9c"

URI_x86_64_v2_aspnetcore-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-8.0-8.0.30-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-targeting-pack-8.0}"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-8.0.sha256sum] = "36aadd435481447bcf3b0974bf32cb29b2c53f724a97154f493f9a303ae758f3"

URI_x86_64_v2_dotnet-apphost-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-8.0-8.0.30-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-apphost-pack-8.0}"
SRC_URI[x86_64_v2_dotnet-apphost-pack-8.0.sha256sum] = "f6b8de9d880ee309e8b05a3e35069d73f812afbe1f68b5f7a232ba085524daf6"

URI_x86_64_v2_dotnet-hostfxr-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-8.0-8.0.30-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-hostfxr-8.0}"
SRC_URI[x86_64_v2_dotnet-hostfxr-8.0.sha256sum] = "17588a3afb801d317e74dcaa85052b234c02f064e4806dc73f2bdace1cf2c807"

URI_x86_64_v2_dotnet-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-8.0-8.0.30-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-8.0}"
SRC_URI[x86_64_v2_dotnet-runtime-8.0.sha256sum] = "a31dde77266f6304a9fbb196fd93545d32f1fa1a181b40ce684efa1478e0dbcd"

URI_x86_64_v2_dotnet-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-8.0-8.0.30-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-dbg-8.0}"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-8.0.sha256sum] = "3ff56f493395049ad9c242fa9b71a35d4bdc2be253fcb27776d956552412a94d"

URI_x86_64_v2_dotnet-sdk-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-8.0-8.0.130-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-8.0}"
SRC_URI[x86_64_v2_dotnet-sdk-8.0.sha256sum] = "0f8e497573a998001cfe44c090afabbd1caa92cb42ae258859c52ef3dd674591"

URI_x86_64_v2_dotnet-sdk-8.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-8.0-source-built-artifacts-8.0.130-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-8.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-8.0-source-built-artifacts}"
SRC_URI[x86_64_v2_dotnet-sdk-8.0-source-built-artifacts.sha256sum] = "078d5d23c859b79e2753dcafc348375e1c095cc594bd23d5849fc60d1724d1e2"

URI_x86_64_v2_dotnet-sdk-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-8.0-8.0.130-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-dbg-8.0}"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-8.0.sha256sum] = "28e7419355536c4f567d1756b2a2e0a3f1ff720475422326cefb675f3f377b7d"

URI_x86_64_v2_dotnet-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-8.0-8.0.30-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-targeting-pack-8.0}"
SRC_URI[x86_64_v2_dotnet-targeting-pack-8.0.sha256sum] = "f860100e992132646be3a15176ef3bef03002466b05fc4d168c0be8d3c7d0517"

URI_x86_64_v2_dotnet-templates-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-8.0-8.0.130-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-templates-8.0}"
SRC_URI[x86_64_v2_dotnet-templates-8.0.sha256sum] = "9bc87f9d7bfa854266aef1b605817f722a34bd57858f2de2f25b05101e1c7207"

URI_aarch64_aspnetcore-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-8.0-8.0.30-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-8.0}"
SRC_URI[aarch64_aspnetcore-runtime-8.0.sha256sum] = "14b623505e033ccb669ed385fdd4912dd6e45f6c3bb940282c873987e4066cb4"

URI_aarch64_aspnetcore-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-8.0-8.0.30-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-dbg-8.0}"
SRC_URI[aarch64_aspnetcore-runtime-dbg-8.0.sha256sum] = "d2ea8e7c18a9487c4f6415f3f22f148c3f7a4948f38a33aeffaae9d293107307"

URI_aarch64_aspnetcore-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-8.0-8.0.30-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-targeting-pack-8.0}"
SRC_URI[aarch64_aspnetcore-targeting-pack-8.0.sha256sum] = "22bde6a81567c395af82533403cc97a8337d1e7027f575bd7d92a12e6c7abce3"

URI_aarch64_dotnet-apphost-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-8.0-8.0.30-1.el10_2.aarch64.rpm;name=aarch64_dotnet-apphost-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-apphost-pack-8.0}"
SRC_URI[aarch64_dotnet-apphost-pack-8.0.sha256sum] = "6a46a9c71baeb02e689a48727dee36320b012758960814199ce5315354939c3c"

URI_aarch64_dotnet-hostfxr-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-8.0-8.0.30-1.el10_2.aarch64.rpm;name=aarch64_dotnet-hostfxr-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-hostfxr-8.0}"
SRC_URI[aarch64_dotnet-hostfxr-8.0.sha256sum] = "1f68c537fbf8463fd5929db6e2c584e36c3e0c71c5bc8e2a138d18b145c9eb25"

URI_aarch64_dotnet-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-8.0-8.0.30-1.el10_2.aarch64.rpm;name=aarch64_dotnet-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-8.0}"
SRC_URI[aarch64_dotnet-runtime-8.0.sha256sum] = "d4e12881d2de7c6556efea3d95b65768cf1bba3876aaf9f8535ca33b73995653"

URI_aarch64_dotnet-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-8.0-8.0.30-1.el10_2.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-dbg-8.0}"
SRC_URI[aarch64_dotnet-runtime-dbg-8.0.sha256sum] = "5e0856bb64c59a4c6f32a058beabcffe68b334c1fdfcf3650008b8893035c18b"

URI_aarch64_dotnet-sdk-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-8.0-8.0.130-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-8.0}"
SRC_URI[aarch64_dotnet-sdk-8.0.sha256sum] = "4b0be8bba8ffc2f5ee1787b545242a1d36741faf20ef226f2ffadcd063ba9769"

URI_aarch64_dotnet-sdk-8.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-8.0-source-built-artifacts-8.0.130-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-8.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-8.0-source-built-artifacts}"
SRC_URI[aarch64_dotnet-sdk-8.0-source-built-artifacts.sha256sum] = "e3c69923df79f94f6a4823a88d55239fc016b6f1c7afc11697d6006e47f3138f"

URI_aarch64_dotnet-sdk-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-8.0-8.0.130-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-dbg-8.0}"
SRC_URI[aarch64_dotnet-sdk-dbg-8.0.sha256sum] = "31ec42ee57d1f77c3f03d0d300c3cc001e70f0e09652451c58111598d7bacc56"

URI_aarch64_dotnet-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-8.0-8.0.30-1.el10_2.aarch64.rpm;name=aarch64_dotnet-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-targeting-pack-8.0}"
SRC_URI[aarch64_dotnet-targeting-pack-8.0.sha256sum] = "3561cd94cf056712c5efc5583a1e77e120c3ab90aee1609b22e7db47e75bccd4"

URI_aarch64_dotnet-templates-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-8.0-8.0.130-1.el10_2.aarch64.rpm;name=aarch64_dotnet-templates-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-templates-8.0}"
SRC_URI[aarch64_dotnet-templates-8.0.sha256sum] = "5913dd41b2c1e6fb53ae96181f20a2c0adec7893378504ba93f7ad3243d86cf1"

RDEPENDS:aspnetcore-runtime-8.0 = " \
 dotnet-runtime-8.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-8.0 = " \
 aspnetcore-runtime-8.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-8.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-8.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-hostfxr-8.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-8.0 = " \
 dotnet-hostfxr-8.0 \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-8.0 = " \
 dotnet-runtime-8.0 \
 "
RDEPENDS:dotnet-sdk-8.0 = " \
 aspnetcore-runtime-8.0 \
 aspnetcore-targeting-pack-8.0 \
 dotnet-apphost-pack-8.0 \
 dotnet-runtime-8.0 \
 dotnet-targeting-pack-8.0 \
 dotnet-templates-8.0 \
 glibc \
 libgcc \
 libstdc++ \
 netstandard-targeting-pack-2.1 \
 "
RDEPENDS:dotnet-sdk-8.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-dbg-8.0 = " \
 dotnet-sdk-8.0 \
 "
RDEPENDS:dotnet-targeting-pack-8.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-8.0 = " \
 dotnet-host \
 "
