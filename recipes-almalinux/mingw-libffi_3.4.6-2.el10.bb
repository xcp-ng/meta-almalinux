# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-libffi"
PV = "3.4.6"
PR = "2.el10"
PACKAGES:x86_64_v2 = " \
 mingw32-libffi \
 mingw64-libffi \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-libffi-3.4.6-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6cea077b9c272ba0bb78315b0c4e2e1d5c7f13f1025be92e567033d18ec45e36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-libffi-3.4.6-2.el10.noarch.rpm;name=x86_64_v2_mingw32-libffi;unpack=0"
SRC_URI[x86_64_v2_mingw32-libffi.sha256sum] = "fc75aaa064f5aefb398a2eb19e1efd1c8b004f470a54e5669ca165cd3dbfa65b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-libffi-3.4.6-2.el10.noarch.rpm;name=x86_64_v2_mingw64-libffi;unpack=0"
SRC_URI[x86_64_v2_mingw64-libffi.sha256sum] = "fc7b7cc5f8acc4a68d23eb18c4eb2b242953cf0beec47f15d9413dfa03e79845"

RDEPENDS:mingw32-libffi = " \
 mingw32-crt \
 mingw32-filesystem \
 "
RDEPENDS:mingw64-libffi = " \
 mingw64-crt \
 mingw64-filesystem \
 "
