# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crc"
PV = "3.3.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-crc+default-devel \
 rust-crc-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crc-3.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "74b7dde4837f636fbfa97efe91bf244c861b58b436841cc7eb8470d2ca710a7e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc+default-devel-3.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crc+default-devel.sha256sum] = "81b36671e2ccb9b4cc92e7b8e52f0dba51d3ed4381212f98e2c21984105c0882"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-devel-3.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crc-devel.sha256sum] = "1f5f3008408a16b9d53b637a3647b7fd2a335d059cf5897e81509947c0f61e77"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crc+default-devel-3.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-crc+default-devel;unpack=0"
SRC_URI[aarch64_rust-crc+default-devel.sha256sum] = "8264291161622cf5b41305d40555ce3fde0e05fd93e9f8747cb891737f41af3c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-devel-3.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-crc-devel;unpack=0"
SRC_URI[aarch64_rust-crc-devel.sha256sum] = "d48063daf60e5b2b953c4fb9dae8c55a9abaf79113afc493171b40b2c64e9f93"

RDEPENDS:rust-crc+default-devel = " \
 cargo \
 rust-crc-devel \
 "
RDEPENDS:rust-crc-devel = " \
 cargo \
 rust \
 rust-crc-catalog+default-devel \
 "
