# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdump-anaconda-addon"
PV = "006"
PR = "19.20220714git7ca2d3e.el10"
PACKAGES = " \
 kdump-anaconda-addon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/kdump-anaconda-addon-006-19.20220714git7ca2d3e.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42c121670a259d0c6364a33e39aa2abb8a064b4ce82ea63f7946f06f92a71ff8"

URI_x86_64_v2_kdump-anaconda-addon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kdump-anaconda-addon-006-19.20220714git7ca2d3e.el10.noarch.rpm;name=x86_64_v2_kdump-anaconda-addon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdump-anaconda-addon}"
SRC_URI[x86_64_v2_kdump-anaconda-addon.sha256sum] = "7588701186f6b54a05f06b1db365c1c71e2032c5b1e0db2f18d7a09a1bf9c9b6"

URI_aarch64_kdump-anaconda-addon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kdump-anaconda-addon-006-19.20220714git7ca2d3e.el10.noarch.rpm;name=aarch64_kdump-anaconda-addon;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdump-anaconda-addon}"
SRC_URI[aarch64_kdump-anaconda-addon.sha256sum] = "7588701186f6b54a05f06b1db365c1c71e2032c5b1e0db2f18d7a09a1bf9c9b6"

RDEPENDS:kdump-anaconda-addon = " \
 anaconda \
 hicolor-icon-theme \
 "
