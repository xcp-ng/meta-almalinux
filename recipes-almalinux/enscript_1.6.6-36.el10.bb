# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "enscript"
PV = "1.6.6"
PR = "36.el10"
PACKAGES = " \
 enscript \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/enscript-1.6.6-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06bda76369c2ecc7d6635ef18239a85a8a904254ab691767f1369703f40cff0d"

URI_x86_64_v2_enscript = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/enscript-1.6.6-36.el10.x86_64_v2.rpm;name=x86_64_v2_enscript;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_enscript}"
SRC_URI[x86_64_v2_enscript.sha256sum] = "cb2b14931c85410058a64f0da3fd14ce8687b3e288f5b26c8813b4f941d9bfbb"

URI_aarch64_enscript = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/enscript-1.6.6-36.el10.aarch64.rpm;name=aarch64_enscript;unpack=0"
SRC_URI:append = " ${URI_aarch64_enscript}"
SRC_URI[aarch64_enscript.sha256sum] = "ee1a230808f7c31c78e4e676fc5ec92c8529361e4e65d9ff1cef9a48ca87dbc4"

RDEPENDS:enscript = " \
 bash \
 glibc \
 perl-interpreter \
 "
