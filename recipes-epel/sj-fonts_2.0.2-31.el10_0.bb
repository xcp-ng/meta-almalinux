# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sj-fonts"
PV = "2.0.2"
PR = "31.el10_0"
PACKAGES = " \
 sj-delphine-fonts \
 sj-fonts-common \
 sj-stevehand-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sj-fonts-2.0.2-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b578b327cee48a5059c26fab52b94829208c4d14def5231ebf382b9edc72005d"

URI_x86_64_v2_sj-delphine-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sj-delphine-fonts-2.0.2-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_sj-delphine-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sj-delphine-fonts}"
SRC_URI[x86_64_v2_sj-delphine-fonts.sha256sum] = "31335ffd716c997c9b7f3e7b49b72715cc8973535db9ae2a9a9c83814577d78f"

URI_x86_64_v2_sj-fonts-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sj-fonts-common-2.0.2-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_sj-fonts-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sj-fonts-common}"
SRC_URI[x86_64_v2_sj-fonts-common.sha256sum] = "8d5949198ac6fceb7e952b5053d544826f03ce5e8d0c95eb4f1faf3a19106592"

URI_x86_64_v2_sj-stevehand-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sj-stevehand-fonts-2.0.2-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_sj-stevehand-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sj-stevehand-fonts}"
SRC_URI[x86_64_v2_sj-stevehand-fonts.sha256sum] = "ff47b22cb2b2cf0890c51f2fed857ccdc7826067738d6b191a0099b82e08b8e4"

URI_aarch64_sj-delphine-fonts = "${EPEL_MIRROR}/aarch64/Packages/s/sj-delphine-fonts-2.0.2-31.el10_0.noarch.rpm;name=aarch64_sj-delphine-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_sj-delphine-fonts}"
SRC_URI[aarch64_sj-delphine-fonts.sha256sum] = "acec2f4d640ede0114c43df438177aeda128675e1aa31e50c4ce5bb798fb3aee"

URI_aarch64_sj-fonts-common = "${EPEL_MIRROR}/aarch64/Packages/s/sj-fonts-common-2.0.2-31.el10_0.noarch.rpm;name=aarch64_sj-fonts-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_sj-fonts-common}"
SRC_URI[aarch64_sj-fonts-common.sha256sum] = "e3612beba7d3ac2246fddc0a8f95bf51ec3c399c47a416e3504af0eeed1f252b"

URI_aarch64_sj-stevehand-fonts = "${EPEL_MIRROR}/aarch64/Packages/s/sj-stevehand-fonts-2.0.2-31.el10_0.noarch.rpm;name=aarch64_sj-stevehand-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_sj-stevehand-fonts}"
SRC_URI[aarch64_sj-stevehand-fonts.sha256sum] = "e5f42c4129001cccb776c9f7cd606db4b0e1305b32c4d563c2e1737b2ac01972"

RDEPENDS:sj-delphine-fonts = " \
 sj-fonts-common \
 "
RDEPENDS:sj-fonts-common = " \
 fonts-filesystem \
 "
RDEPENDS:sj-stevehand-fonts = " \
 sj-fonts-common \
 "
