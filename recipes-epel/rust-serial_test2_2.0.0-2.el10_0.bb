# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serial_test2"
PV = "2.0.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-serial_test2+async-devel \
 rust-serial_test2+default-devel \
 rust-serial_test2+file_locks-devel \
 rust-serial_test2+fslock-devel \
 rust-serial_test2+futures-devel \
 rust-serial_test2+log-devel \
 rust-serial_test2+logging-devel \
 rust-serial_test2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serial_test2-2.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cea17ebc18851892df5d047f3fad046c2e181ce364478e4b3c6d96427ee21d8a"

URI_x86_64_v2_rust-serial_test2+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test2+async-devel-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test2+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test2+async-devel}"
SRC_URI[x86_64_v2_rust-serial_test2+async-devel.sha256sum] = "b44b36cbca2154e07ea0ab2135b300a8d5bf440631ff8629b4969feca72769ca"

URI_x86_64_v2_rust-serial_test2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test2+default-devel-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test2+default-devel}"
SRC_URI[x86_64_v2_rust-serial_test2+default-devel.sha256sum] = "e5f408e78f1c351df24701c94bf556e155ff7e1fff34a988798a4ec95c484d29"

URI_x86_64_v2_rust-serial_test2+file_locks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test2+file_locks-devel-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test2+file_locks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test2+file_locks-devel}"
SRC_URI[x86_64_v2_rust-serial_test2+file_locks-devel.sha256sum] = "06759bfdf4073338a07629944656b509265cddee734a9f5ed4516f75c20d63a6"

URI_x86_64_v2_rust-serial_test2+fslock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test2+fslock-devel-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test2+fslock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test2+fslock-devel}"
SRC_URI[x86_64_v2_rust-serial_test2+fslock-devel.sha256sum] = "3a5f298d1d1f86e338eb53c5c9842eb84dfd7969b2edc2a1b46d5bae2330f8ab"

URI_x86_64_v2_rust-serial_test2+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test2+futures-devel-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test2+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test2+futures-devel}"
SRC_URI[x86_64_v2_rust-serial_test2+futures-devel.sha256sum] = "4760e15092d9a81e68748ccfbba957e2ccba6be295691705a67c55fd54926304"

URI_x86_64_v2_rust-serial_test2+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test2+log-devel-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test2+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test2+log-devel}"
SRC_URI[x86_64_v2_rust-serial_test2+log-devel.sha256sum] = "d2ec85d6d964932463f4bb8fdc2a5010c947f26ccaadb32929974ff4afac02fa"

URI_x86_64_v2_rust-serial_test2+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test2+logging-devel-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test2+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test2+logging-devel}"
SRC_URI[x86_64_v2_rust-serial_test2+logging-devel.sha256sum] = "b3883eb40d4eb83bf312fa37ea9f55ccc0ba2e73b7534d0d3805d1a119009a5c"

URI_x86_64_v2_rust-serial_test2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test2-devel-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test2-devel}"
SRC_URI[x86_64_v2_rust-serial_test2-devel.sha256sum] = "98670c366ffa247ebc0b0c6e962639c1d44917728278784cab0aa93b6866bff0"

URI_aarch64_rust-serial_test2+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test2+async-devel-2.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-serial_test2+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test2+async-devel}"
SRC_URI[aarch64_rust-serial_test2+async-devel.sha256sum] = "eeaf7ee0afbff9a6bc64234537b10d4e78ff227403b1736da148aace6e912cc5"

URI_aarch64_rust-serial_test2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test2+default-devel-2.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-serial_test2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test2+default-devel}"
SRC_URI[aarch64_rust-serial_test2+default-devel.sha256sum] = "bd32df19a4af53fd6ea0ed856b71c2dc938964c84ac9d6883838828cdb9053f1"

URI_aarch64_rust-serial_test2+file_locks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test2+file_locks-devel-2.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-serial_test2+file_locks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test2+file_locks-devel}"
SRC_URI[aarch64_rust-serial_test2+file_locks-devel.sha256sum] = "ead3f630a920d913d0987a61729637b77abd3ceaf9d5df06380416e0f975054e"

URI_aarch64_rust-serial_test2+fslock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test2+fslock-devel-2.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-serial_test2+fslock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test2+fslock-devel}"
SRC_URI[aarch64_rust-serial_test2+fslock-devel.sha256sum] = "4cc1e9c02396a76e76931a9c938e3fb15087e76e3f53e4b76642e2a07a1258f0"

URI_aarch64_rust-serial_test2+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test2+futures-devel-2.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-serial_test2+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test2+futures-devel}"
SRC_URI[aarch64_rust-serial_test2+futures-devel.sha256sum] = "829dfc2baaf7636c5d95d98b1200f4eb851e6d8b4b144e96d8ee7e4c7c84f270"

URI_aarch64_rust-serial_test2+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test2+log-devel-2.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-serial_test2+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test2+log-devel}"
SRC_URI[aarch64_rust-serial_test2+log-devel.sha256sum] = "9549adcb1bc86e6f5431f26fb8ffd177a2008599d47c0f006e543064ff8bdeb2"

URI_aarch64_rust-serial_test2+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test2+logging-devel-2.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-serial_test2+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test2+logging-devel}"
SRC_URI[aarch64_rust-serial_test2+logging-devel.sha256sum] = "34f9111b51535a77105dfadc6f9ab183e710cb361a813fbbc25c35dfc52813d8"

URI_aarch64_rust-serial_test2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test2-devel-2.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-serial_test2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test2-devel}"
SRC_URI[aarch64_rust-serial_test2-devel.sha256sum] = "038251f3c2f5386e1c76e340c94c934fc7f53f2fc4c7ed874c7290140dd30c7c"

RDEPENDS:rust-serial_test2+async-devel = " \
 cargo \
 rust-serial_test2+futures-devel \
 rust-serial_test2-devel \
 rust-serial_test_derive2+async-devel \
 "
RDEPENDS:rust-serial_test2+default-devel = " \
 cargo \
 rust-serial_test2+async-devel \
 rust-serial_test2+logging-devel \
 rust-serial_test2-devel \
 "
RDEPENDS:rust-serial_test2+file_locks-devel = " \
 cargo \
 rust-serial_test2+fslock-devel \
 rust-serial_test2-devel \
 "
RDEPENDS:rust-serial_test2+fslock-devel = " \
 cargo \
 rust-fslock+default-devel \
 rust-serial_test2-devel \
 "
RDEPENDS:rust-serial_test2+futures-devel = " \
 cargo \
 rust-futures+executor-devel \
 rust-futures-devel \
 rust-serial_test2-devel \
 "
RDEPENDS:rust-serial_test2+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-serial_test2-devel \
 "
RDEPENDS:rust-serial_test2+logging-devel = " \
 cargo \
 rust-serial_test2+log-devel \
 rust-serial_test2-devel \
 "
RDEPENDS:rust-serial_test2-devel = " \
 cargo \
 rust-dashmap5+default-devel \
 rust-lazy_static+default-devel \
 rust-parking_lot+default-devel \
 rust-serial_test_derive2+default-devel \
 "
