# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "debhelper"
PV = "13.11.6"
PR = "4.el10_0"
PACKAGES = " \
 debhelper \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/debhelper-13.11.6-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8c9e1fc64727eb801e97d7bf86411faa48921b6614447291f15480b57d180c4d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debhelper-13.11.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_debhelper;unpack=0"
SRC_URI[x86_64_v2_debhelper.sha256sum] = "961bee50e454ae644289defb32823f97df5562f50fb18a415d573e875039541a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/debhelper-13.11.6-4.el10_0.noarch.rpm;name=aarch64_debhelper;unpack=0"
SRC_URI[aarch64_debhelper.sha256sum] = "60adf9aa31610cb03703707260faf32cf42d47a756b345991283ab606a50f049"

RDEPENDS:debhelper = " \
 binutils \
 dh-autoreconf \
 dpkg \
 dpkg-dev \
 dpkg-perl \
 gzip \
 perl-Carp \
 perl-Digest-SHA \
 perl-Errno \
 perl-Exporter \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-stat \
 perl-Getopt-Long \
 perl-JSON-PP \
 perl-PathTools \
 perl-Time-Piece \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-parent \
 po-debconf \
 "
