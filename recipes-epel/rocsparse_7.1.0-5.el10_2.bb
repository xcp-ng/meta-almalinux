# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocsparse"
PV = "7.1.0"
PR = "5.el10_2"
PACKAGES:x86_64_v2 = " \
 rocsparse \
 rocsparse-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocsparse-7.1.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd15454a09d4cefe5b99e015f4c9155d7050ef736133fd39b5f154778bd39df1"

URI_x86_64_v2_rocsparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocsparse-7.1.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocsparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocsparse}"
SRC_URI[x86_64_v2_rocsparse.sha256sum] = "b992e5da251d785a592b5f0276a04be88323b8e14a5b9f65d110b58caddc99c9"

URI_x86_64_v2_rocsparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocsparse-devel-7.1.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocsparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocsparse-devel}"
SRC_URI[x86_64_v2_rocsparse-devel.sha256sum] = "7a492375e19f70356eab3009b71891b8165e53bd43b471404740c4aa2504b28c"

RDEPENDS:rocsparse = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 "
RDEPENDS:rocsparse-devel = " \
 cmake-filesystem \
 rocsparse \
 "
