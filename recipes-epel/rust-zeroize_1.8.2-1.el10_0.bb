# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zeroize"
PV = "1.8.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-zeroize+aarch64-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize+default-devel \
 rust-zeroize+derive-devel \
 rust-zeroize+serde-devel \
 rust-zeroize+simd-devel \
 rust-zeroize+std-devel \
 rust-zeroize+zeroize_derive-devel \
 rust-zeroize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zeroize-1.8.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "849c6a0ceb3b2ce0be0ce2d276068954d9d030273eccf5a7459b51cf4906875a"

URI_x86_64_v2_rust-zeroize+aarch64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+aarch64-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+aarch64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+aarch64-devel}"
SRC_URI[x86_64_v2_rust-zeroize+aarch64-devel.sha256sum] = "12b4caf3fb8a031ded8714a679654d5b1fd579cf4798b3a99ea5721610b1f137"

URI_x86_64_v2_rust-zeroize+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+alloc-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+alloc-devel}"
SRC_URI[x86_64_v2_rust-zeroize+alloc-devel.sha256sum] = "8fa31735b4cbc20d70a584bfffc36fdc018e383efd520fad8cd3020547aab04f"

URI_x86_64_v2_rust-zeroize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+default-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+default-devel}"
SRC_URI[x86_64_v2_rust-zeroize+default-devel.sha256sum] = "e60a539248e7fb86b531cf20ef8860083845605f9606268421523eff34d39a0f"

URI_x86_64_v2_rust-zeroize+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+derive-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+derive-devel}"
SRC_URI[x86_64_v2_rust-zeroize+derive-devel.sha256sum] = "c9d98243b377a86a0c81aa1211cbd48fae90435fbd314598e50d46201427b327"

URI_x86_64_v2_rust-zeroize+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+serde-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+serde-devel}"
SRC_URI[x86_64_v2_rust-zeroize+serde-devel.sha256sum] = "a3fe02d32b9ae9205d559974bb4b959a6b4382870e98b88d2a0f93182b908c15"

URI_x86_64_v2_rust-zeroize+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+simd-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+simd-devel}"
SRC_URI[x86_64_v2_rust-zeroize+simd-devel.sha256sum] = "a064f1d8c2a1691f27864d608aa659e0d41a1980715a7b54d033ca6ac6949a73"

URI_x86_64_v2_rust-zeroize+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+std-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+std-devel}"
SRC_URI[x86_64_v2_rust-zeroize+std-devel.sha256sum] = "1916042d938761757458abc77c862d17d8cbd327ec7e073e60d56bf08471ae43"

URI_x86_64_v2_rust-zeroize+zeroize_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+zeroize_derive-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+zeroize_derive-devel}"
SRC_URI[x86_64_v2_rust-zeroize+zeroize_derive-devel.sha256sum] = "87f980cdd5d3c527d75db7574f3250d7412da8c8e823750647cd5c709942dd3d"

URI_x86_64_v2_rust-zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize-devel}"
SRC_URI[x86_64_v2_rust-zeroize-devel.sha256sum] = "b0901a8cd8211e43212cf000c46bee774031f00c656e3668e9b232bd31eec5a3"

URI_aarch64_rust-zeroize+aarch64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+aarch64-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-zeroize+aarch64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+aarch64-devel}"
SRC_URI[aarch64_rust-zeroize+aarch64-devel.sha256sum] = "9a85e2da21dcfc28927bbc1226429c27fd589285f6f6eefb2822477c3d11b7c9"

URI_aarch64_rust-zeroize+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+alloc-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-zeroize+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+alloc-devel}"
SRC_URI[aarch64_rust-zeroize+alloc-devel.sha256sum] = "43460878f915eb95ba06da04dfc993c65ff623a5e744ffe449279bb815839a5e"

URI_aarch64_rust-zeroize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+default-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-zeroize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+default-devel}"
SRC_URI[aarch64_rust-zeroize+default-devel.sha256sum] = "d16f3118cd48b38fd16212d7b450dccbf40912396b7c471bb48be3a186b392c1"

URI_aarch64_rust-zeroize+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+derive-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-zeroize+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+derive-devel}"
SRC_URI[aarch64_rust-zeroize+derive-devel.sha256sum] = "6806a88fdd40baafc57d3c8c1a6d4ba33affdacd1f7167875a95638d876a1b64"

URI_aarch64_rust-zeroize+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+serde-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-zeroize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+serde-devel}"
SRC_URI[aarch64_rust-zeroize+serde-devel.sha256sum] = "01e2b51aeb3111e6988c4795e7041f1828c7b514e7d0e3bd17c56f05a14e297b"

URI_aarch64_rust-zeroize+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+simd-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-zeroize+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+simd-devel}"
SRC_URI[aarch64_rust-zeroize+simd-devel.sha256sum] = "96f7464ab25177d9872ea61c63b2410fec5f489a68408b29960d5296eeeb82e9"

URI_aarch64_rust-zeroize+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+std-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-zeroize+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+std-devel}"
SRC_URI[aarch64_rust-zeroize+std-devel.sha256sum] = "2f2f36563ac688434a6cb50c9c08c9c5054e8b7c9f2ad32937a42581280b4afe"

URI_aarch64_rust-zeroize+zeroize_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+zeroize_derive-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-zeroize+zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+zeroize_derive-devel}"
SRC_URI[aarch64_rust-zeroize+zeroize_derive-devel.sha256sum] = "f13a345ec0ae262e11b9d6d829530846bca219f4192e7ccc1d9d2de1374f5003"

URI_aarch64_rust-zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize-devel}"
SRC_URI[aarch64_rust-zeroize-devel.sha256sum] = "2250efd62b7b514c2f52c9b44bcaa3d3c636a6e86144c341e1e6e0318a4c5c74"

RDEPENDS:rust-zeroize+aarch64-devel = " \
 cargo \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+alloc-devel = " \
 cargo \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+default-devel = " \
 cargo \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+derive-devel = " \
 cargo \
 rust-zeroize+zeroize_derive-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+simd-devel = " \
 cargo \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+std-devel = " \
 cargo \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+zeroize_derive-devel = " \
 cargo \
 rust-zeroize-devel \
 rust-zeroize_derive+default-devel \
 "
RDEPENDS:rust-zeroize-devel = " \
 cargo \
 rust \
 "
