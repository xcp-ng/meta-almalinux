# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwin"
PV = "6.6.4"
PR = "2.el10_2"
PACKAGES = " \
 kwin \
 kwin-common \
 kwin-devel \
 kwin-doc \
 kwin-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwin-6.6.4-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a94b813a96d67a50f23bb3e50e9f8dac9b5883a26081e135ceb25fee10e2d27"

URI_x86_64_v2_kwin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-6.6.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin}"
SRC_URI[x86_64_v2_kwin.sha256sum] = "18b8d4752c95dbf0ffa46dd48f139b5e97eb8f6a8dcd61b4d4c4819be3ff3463"
RPROVIDES:kwin:x86_64_v2 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_x86_64_v2_kwin-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-common-6.6.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin-common}"
SRC_URI[x86_64_v2_kwin-common.sha256sum] = "60e793531db4035427a974faad613d1c279c4efbc3d3517d6ed4b66e1c1ec8ad"

URI_x86_64_v2_kwin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-devel-6.6.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin-devel}"
SRC_URI[x86_64_v2_kwin-devel.sha256sum] = "866f04ece8c3daa53fcb197e88dc2aa65325c6a2494ff76cdb3be8f6058b1626"

URI_x86_64_v2_kwin-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-doc-6.6.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kwin-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin-doc}"
SRC_URI[x86_64_v2_kwin-doc.sha256sum] = "8990a1cef30f7020c923df39219bb88bdbb11e169a18673071991e38f4f62cae"

URI_x86_64_v2_kwin-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-libs-6.6.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin-libs}"
SRC_URI[x86_64_v2_kwin-libs.sha256sum] = "9394bb68d4b9904f0c9e9d90e5779009f9d1d2b36cf776962118213d0bc22110"

URI_aarch64_kwin = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-6.6.4-2.el10_2.aarch64.rpm;name=aarch64_kwin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin}"
SRC_URI[aarch64_kwin.sha256sum] = "881587f67ba0c27b52bb700a0a21d863786f865f6a8735905c93a8725b6bd14a"
RPROVIDES:kwin:aarch64 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_aarch64_kwin-common = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-common-6.6.4-2.el10_2.aarch64.rpm;name=aarch64_kwin-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin-common}"
SRC_URI[aarch64_kwin-common.sha256sum] = "17e24f07c6ac6fdaedbfe4f828665ba21ee4e127ef84598fbcbc31a80c57d07f"

URI_aarch64_kwin-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-devel-6.6.4-2.el10_2.aarch64.rpm;name=aarch64_kwin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin-devel}"
SRC_URI[aarch64_kwin-devel.sha256sum] = "443354cad0d5eb5b1ba0bc179164646a007ed4f2e37a2104ca2af4c3bbf87c57"

URI_aarch64_kwin-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-doc-6.6.4-2.el10_2.noarch.rpm;name=aarch64_kwin-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin-doc}"
SRC_URI[aarch64_kwin-doc.sha256sum] = "56bbe3b2be59eb5c73a987979bdd21cb67baa27b2d7698a09688bdecd02bc4a7"

URI_aarch64_kwin-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-libs-6.6.4-2.el10_2.aarch64.rpm;name=aarch64_kwin-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin-libs}"
SRC_URI[aarch64_kwin-libs.sha256sum] = "5b3cfaecd70de8612a5a49b34a48825a66f14549be3e36f8c5d93531aab0461d"

RDEPENDS:kwin = " \
 aurorae \
 glibc \
 iio-sensor-proxy \
 kdecoration \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kirigami \
 kf6-knotifications \
 kf6-ksvg \
 kf6-kwindowsystem \
 kglobalacceld \
 kscreenlocker \
 kwin-common \
 kwin-libs \
 libcanberra \
 libepoxy \
 libplasma \
 libstdc++ \
 libxcb \
 qaccessibilityclient-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 systemd-libs \
 xorg-x11-server-Xwayland \
 "
RDEPENDS:kwin-common = " \
 glibc \
 kdecoration \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-ksvg \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 knighttime \
 kwayland \
 kwin-libs \
 libeis \
 libepoxy \
 libevdev \
 libstdc++ \
 pipewire-libs \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools \
 systemd-libs \
 "
RDEPENDS:kwin-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kservice-devel \
 kf6-kwindowsystem-devel \
 kwin-common \
 kwin-libs \
 "
RDEPENDS:kwin-doc = " \
 kwin \
 "
RDEPENDS:kwin-libs = " \
 glibc \
 kdecoration \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kglobalacceld \
 kscreenlocker \
 kwayland \
 lcms2 \
 libdisplay-info \
 libdrm \
 libepoxy \
 libinput \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 libxcb \
 libxcvt \
 libxkbcommon \
 mesa-libgbm \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 systemd-libs \
 xcb-util-keysyms \
 xcb-util-wm \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

PROVIDES:append:aarch64 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"
