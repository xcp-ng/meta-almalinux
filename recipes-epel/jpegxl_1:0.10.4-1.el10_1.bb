# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jpegxl"
PE = "1"
PV = "0.10.4"
PR = "1.el10_1"
PACKAGES = " \
 jpegxl-doc \
 jxl-pixbuf-loader \
 libjxl \
 libjxl-devel \
 libjxl-devtools \
 libjxl-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jpegxl-0.10.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb69a8bcf78e997a92f437c66b6be9629bb320baf278434eda06a54c3b38eb89"

URI_x86_64_v2_jpegxl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jpegxl-doc-0.10.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_jpegxl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jpegxl-doc}"
SRC_URI[x86_64_v2_jpegxl-doc.sha256sum] = "2a97560a8651b43ec421a74d96fd942f87ba10572152ade63b7503fe760afd96"

URI_x86_64_v2_jxl-pixbuf-loader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jxl-pixbuf-loader-0.10.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jxl-pixbuf-loader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jxl-pixbuf-loader}"
SRC_URI[x86_64_v2_jxl-pixbuf-loader.sha256sum] = "f331640d7d233102fc35417e589af0b2bec732a578df5a00adf489b09fcced1c"

URI_x86_64_v2_libjxl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjxl-0.10.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjxl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjxl}"
SRC_URI[x86_64_v2_libjxl.sha256sum] = "ea07b9446ccdd42e3f47850db4078ab5b4d3843be376c45100d4f233fbca58c7"

URI_x86_64_v2_libjxl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjxl-devel-0.10.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjxl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjxl-devel}"
SRC_URI[x86_64_v2_libjxl-devel.sha256sum] = "c125527b75caf4f2e0e7870fef6d845a1144e23e07e06be5cb2ca8e5b60af099"

URI_x86_64_v2_libjxl-devtools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjxl-devtools-0.10.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjxl-devtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjxl-devtools}"
SRC_URI[x86_64_v2_libjxl-devtools.sha256sum] = "962638db4869d144c8e700f1e0ac4d54ac73850f28b561c0f060242dc951c9d5"

URI_x86_64_v2_libjxl-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjxl-utils-0.10.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjxl-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjxl-utils}"
SRC_URI[x86_64_v2_libjxl-utils.sha256sum] = "5bbb6a9c05c58bc33b29f5458d8b78812f7fcf6d0e0e227b1a44cd163b5a37c6"

URI_aarch64_jpegxl-doc = "${EPEL_MIRROR}/aarch64/Packages/j/jpegxl-doc-0.10.4-1.el10_1.noarch.rpm;name=aarch64_jpegxl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jpegxl-doc}"
SRC_URI[aarch64_jpegxl-doc.sha256sum] = "1b98fe79c88dc51c148355a00d82214b31a48013e83888da03e0e267f6bf2b3f"

URI_aarch64_jxl-pixbuf-loader = "${EPEL_MIRROR}/aarch64/Packages/j/jxl-pixbuf-loader-0.10.4-1.el10_1.aarch64.rpm;name=aarch64_jxl-pixbuf-loader;unpack=0"
SRC_URI:append = " ${URI_aarch64_jxl-pixbuf-loader}"
SRC_URI[aarch64_jxl-pixbuf-loader.sha256sum] = "0e5f3a3e17a772a7d0732e856132078f3f15ccd6c2f0feb4bfa85a22429d5c0c"

URI_aarch64_libjxl = "${EPEL_MIRROR}/aarch64/Packages/l/libjxl-0.10.4-1.el10_1.aarch64.rpm;name=aarch64_libjxl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjxl}"
SRC_URI[aarch64_libjxl.sha256sum] = "982876ce55a88bb83a2c60872501862b12c83450d0901ab7ea890dc292263965"

URI_aarch64_libjxl-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libjxl-devel-0.10.4-1.el10_1.aarch64.rpm;name=aarch64_libjxl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjxl-devel}"
SRC_URI[aarch64_libjxl-devel.sha256sum] = "14c5a0983ccf98e82d55a11ee86b09afbfd4e4eaabe75b5da916cf3b4ee5b258"

URI_aarch64_libjxl-devtools = "${EPEL_MIRROR}/aarch64/Packages/l/libjxl-devtools-0.10.4-1.el10_1.aarch64.rpm;name=aarch64_libjxl-devtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjxl-devtools}"
SRC_URI[aarch64_libjxl-devtools.sha256sum] = "95c39a88ba3a3ee80b05c80cc0ca733726245f17c86dbdc0da29dbcd533d6c4d"

URI_aarch64_libjxl-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libjxl-utils-0.10.4-1.el10_1.aarch64.rpm;name=aarch64_libjxl-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjxl-utils}"
SRC_URI[aarch64_libjxl-utils.sha256sum] = "aa98e80482bcc4fca45708aa56a56a642d62da83f2fa5892b9085d50b2522ee9"

RDEPENDS:jpegxl-doc = " \
 "
RDEPENDS:jxl-pixbuf-loader = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libjxl \
 "
RDEPENDS:libjxl = " \
 giflib \
 glibc \
 highway \
 libbrotli \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 openexr-libs \
 shared-mime-info \
 "
RDEPENDS:libjxl-devel = " \
 brotli-devel \
 highway-devel \
 libjxl \
 libjxl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libjxl-devtools = " \
 giflib \
 glibc \
 highway \
 libbrotli \
 libgcc \
 libjpeg-turbo \
 libjxl \
 libpng \
 libstdc++ \
 openexr-libs \
 "
RDEPENDS:libjxl-utils = " \
 giflib \
 glibc \
 highway \
 libbrotli \
 libgcc \
 libjpeg-turbo \
 libjxl \
 libpng \
 libstdc++ \
 openexr-libs \
 "
