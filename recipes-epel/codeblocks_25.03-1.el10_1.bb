# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "codeblocks"
PV = "25.03"
PR = "1.el10_1"
PACKAGES = " \
 codeblocks \
 codeblocks-contrib \
 codeblocks-contrib-devel \
 codeblocks-contrib-libs \
 codeblocks-devel \
 codeblocks-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/codeblocks-25.03-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f3e1fcd7b9bdd01c2a0846aef104c903af831e79209e9d91142e22b8717f740"

URI_x86_64_v2_codeblocks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codeblocks-25.03-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_codeblocks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codeblocks}"
SRC_URI[x86_64_v2_codeblocks.sha256sum] = "dcc5a5a53c98f367cd8a43a17e61ca6106c395bff1d7b1367441a28c405ba934"

URI_x86_64_v2_codeblocks-contrib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codeblocks-contrib-25.03-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_codeblocks-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codeblocks-contrib}"
SRC_URI[x86_64_v2_codeblocks-contrib.sha256sum] = "92236bb16ebaf7ed511554ba22c75a5c152431ad0b953e60c0684c100b70099d"

URI_x86_64_v2_codeblocks-contrib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codeblocks-contrib-devel-25.03-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_codeblocks-contrib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codeblocks-contrib-devel}"
SRC_URI[x86_64_v2_codeblocks-contrib-devel.sha256sum] = "d5feed1f6b46c0da736e3304992e41b79631a61ed093bf2ec0340c249232940f"

URI_x86_64_v2_codeblocks-contrib-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codeblocks-contrib-libs-25.03-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_codeblocks-contrib-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codeblocks-contrib-libs}"
SRC_URI[x86_64_v2_codeblocks-contrib-libs.sha256sum] = "189b73f97bfe4f67af2fff8289e12b31a73a5126657377ebde7f59f21e3d1672"

URI_x86_64_v2_codeblocks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codeblocks-devel-25.03-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_codeblocks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codeblocks-devel}"
SRC_URI[x86_64_v2_codeblocks-devel.sha256sum] = "a3961efeddd44fd268b182c64f40b4102c28cf78745efbdb826faa582c60c5f3"

URI_x86_64_v2_codeblocks-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codeblocks-libs-25.03-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_codeblocks-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codeblocks-libs}"
SRC_URI[x86_64_v2_codeblocks-libs.sha256sum] = "d663eecce83f799c284f2bdd7516a9f236957a189746f931de4cc98c84f615d3"

URI_aarch64_codeblocks = "${EPEL_MIRROR}/aarch64/Packages/c/codeblocks-25.03-1.el10_1.aarch64.rpm;name=aarch64_codeblocks;unpack=0"
SRC_URI:append = " ${URI_aarch64_codeblocks}"
SRC_URI[aarch64_codeblocks.sha256sum] = "d17bf26649be6e2e209d068ec864228cc20c7c2387199309d3b95ea65b3e78f9"

URI_aarch64_codeblocks-contrib = "${EPEL_MIRROR}/aarch64/Packages/c/codeblocks-contrib-25.03-1.el10_1.aarch64.rpm;name=aarch64_codeblocks-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_codeblocks-contrib}"
SRC_URI[aarch64_codeblocks-contrib.sha256sum] = "a9b608eca2c5b0e10f6b995ba3fe33600911604eb4fbcab84311c09b9dfa2b16"

URI_aarch64_codeblocks-contrib-devel = "${EPEL_MIRROR}/aarch64/Packages/c/codeblocks-contrib-devel-25.03-1.el10_1.aarch64.rpm;name=aarch64_codeblocks-contrib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_codeblocks-contrib-devel}"
SRC_URI[aarch64_codeblocks-contrib-devel.sha256sum] = "1aa647f6941bf108dabd5f711d3250bb31e0d0b0ffc32a209d3fd81fd0188e73"

URI_aarch64_codeblocks-contrib-libs = "${EPEL_MIRROR}/aarch64/Packages/c/codeblocks-contrib-libs-25.03-1.el10_1.aarch64.rpm;name=aarch64_codeblocks-contrib-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_codeblocks-contrib-libs}"
SRC_URI[aarch64_codeblocks-contrib-libs.sha256sum] = "70f61f4e4effdea386dae8922eeb9a38b48cde7f4503c4515baeb66ce339f4f3"

URI_aarch64_codeblocks-devel = "${EPEL_MIRROR}/aarch64/Packages/c/codeblocks-devel-25.03-1.el10_1.aarch64.rpm;name=aarch64_codeblocks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_codeblocks-devel}"
SRC_URI[aarch64_codeblocks-devel.sha256sum] = "d61b2109baa9c1c2e100a83b44e7e4c31bb5b852bc8efb6c2de2ea62f67c2591"

URI_aarch64_codeblocks-libs = "${EPEL_MIRROR}/aarch64/Packages/c/codeblocks-libs-25.03-1.el10_1.aarch64.rpm;name=aarch64_codeblocks-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_codeblocks-libs}"
SRC_URI[aarch64_codeblocks-libs.sha256sum] = "a1e5e6f6da9613c35eba7cd2da38758347ae1ed9f7d2e7723463eb1dfc68f370"

RDEPENDS:codeblocks = " \
 astyle \
 atk \
 cairo \
 cairo-gobject \
 codeblocks-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libgcc \
 libstdc++ \
 pango \
 shared-mime-info \
 tinyxml \
 wxBase \
 wxGTK \
 xterm \
 "
RDEPENDS:codeblocks-contrib = " \
 atk \
 boost-system \
 bzip2-libs \
 cairo \
 cairo-gobject \
 codeblocks \
 codeblocks-contrib-libs \
 codeblocks-libs \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 hunspell \
 libX11 \
 libgcc \
 libstdc++ \
 pango \
 tinyxml \
 wxBase \
 wxGTK \
 zlib-ng-compat \
 "
RDEPENDS:codeblocks-contrib-devel = " \
 codeblocks-contrib-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:codeblocks-contrib-libs = " \
 cairo \
 cairo-gobject \
 codeblocks-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libgcc \
 libstdc++ \
 pango \
 tinyxml \
 wxBase \
 wxGTK \
 "
RDEPENDS:codeblocks-devel = " \
 codeblocks-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:codeblocks-libs = " \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libgcc \
 libstdc++ \
 pango \
 tinyxml \
 wxBase \
 wxGTK \
 "
