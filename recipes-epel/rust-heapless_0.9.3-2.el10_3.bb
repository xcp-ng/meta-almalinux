# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-heapless"
PV = "0.9.3"
PR = "2.el10_3"
PACKAGES = " \
 rust-heapless+alloc-devel \
 rust-heapless+bytes-devel \
 rust-heapless+default-devel \
 rust-heapless+mpmc_large-devel \
 rust-heapless+portable-atomic-critical-section-devel \
 rust-heapless+portable-atomic-devel \
 rust-heapless+portable-atomic-unsafe-assume-single-core-devel \
 rust-heapless+serde-devel \
 rust-heapless+zeroize-devel \
 rust-heapless-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-heapless-0.9.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "baa15dd61d1f5619308668b2411a98cf547ae8f080ef25d25c8bf0da15360708"

URI_x86_64_v2_rust-heapless+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+alloc-devel-0.9.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+alloc-devel}"
SRC_URI[x86_64_v2_rust-heapless+alloc-devel.sha256sum] = "b7089c826d12301d0b434a2c474bf0e804ea8f68edaf369fe0ebf924faed34c2"

URI_x86_64_v2_rust-heapless+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+bytes-devel-0.9.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+bytes-devel}"
SRC_URI[x86_64_v2_rust-heapless+bytes-devel.sha256sum] = "9b1f4b32402fec9f6e9b9bdbf78fdd398e8830bd5efb5667b3f67d39f2d7f8b7"

URI_x86_64_v2_rust-heapless+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+default-devel-0.9.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+default-devel}"
SRC_URI[x86_64_v2_rust-heapless+default-devel.sha256sum] = "33bf8b27c289526400575e90cb4896027babcc9167ccd6e457472ae5d173d0ed"
RPROVIDES:rust-heapless+default-devel:x86_64_v2 = "virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~"

URI_x86_64_v2_rust-heapless+mpmc_large-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+mpmc_large-devel-0.9.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+mpmc_large-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+mpmc_large-devel}"
SRC_URI[x86_64_v2_rust-heapless+mpmc_large-devel.sha256sum] = "e5d6eb3728b12b627fd3f5fc5e30c233d0dabe5283ee3667c0f2a956fc0e950a"

URI_x86_64_v2_rust-heapless+portable-atomic-critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+portable-atomic-critical-section-devel-0.9.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+portable-atomic-critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+portable-atomic-critical-section-devel}"
SRC_URI[x86_64_v2_rust-heapless+portable-atomic-critical-section-devel.sha256sum] = "3915b65a55e8bc76a19feb7490c27b613db9caa1493c83f15bcb7464116d8955"

URI_x86_64_v2_rust-heapless+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+portable-atomic-devel-0.9.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-heapless+portable-atomic-devel.sha256sum] = "384804d540df27d0184f60ac7f9c98758d6970583c8c791262f394815d2d385f"

URI_x86_64_v2_rust-heapless+portable-atomic-unsafe-assume-single-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+portable-atomic-unsafe-assume-single-core-devel-0.9.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+portable-atomic-unsafe-assume-single-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+portable-atomic-unsafe-assume-single-core-devel}"
SRC_URI[x86_64_v2_rust-heapless+portable-atomic-unsafe-assume-single-core-devel.sha256sum] = "988349b0cc6eb33dcfaa63247d0b76c348dc6cf6be2c8f209ba718b64b19e3d6"

URI_x86_64_v2_rust-heapless+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+serde-devel-0.9.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+serde-devel}"
SRC_URI[x86_64_v2_rust-heapless+serde-devel.sha256sum] = "41e568b9de0f500238c673a6db9fee90911390c0832c98c680d6c58e95aedb9a"

URI_x86_64_v2_rust-heapless+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+zeroize-devel-0.9.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+zeroize-devel}"
SRC_URI[x86_64_v2_rust-heapless+zeroize-devel.sha256sum] = "0bf174ffaa30b19cb29ff451400660fc8e31ee34344fc2214a8f089ce6f38640"

URI_x86_64_v2_rust-heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless-devel-0.9.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless-devel}"
SRC_URI[x86_64_v2_rust-heapless-devel.sha256sum] = "4a2c7cff250a6bf946aa673cddcc07302c9d893161845ed711429a99d364556e"

URI_aarch64_rust-heapless+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+alloc-devel-0.9.3-2.el10_3.noarch.rpm;name=aarch64_rust-heapless+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+alloc-devel}"
SRC_URI[aarch64_rust-heapless+alloc-devel.sha256sum] = "e60fa0f8ebe2e4e435e447e7c37ba450c3d266e60830344e03ad8afbb7042e40"

URI_aarch64_rust-heapless+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+bytes-devel-0.9.3-2.el10_3.noarch.rpm;name=aarch64_rust-heapless+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+bytes-devel}"
SRC_URI[aarch64_rust-heapless+bytes-devel.sha256sum] = "6fe21726dfad5bf2cda19c3cab27b3cbff9269eb080bf910a114eea2fd014a59"

URI_aarch64_rust-heapless+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+default-devel-0.9.3-2.el10_3.noarch.rpm;name=aarch64_rust-heapless+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+default-devel}"
SRC_URI[aarch64_rust-heapless+default-devel.sha256sum] = "be9772c1a600dedd44d3d4dfee6afcd11507749855f744dc600b771f4bde63f5"
RPROVIDES:rust-heapless+default-devel:aarch64 = "virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~"

URI_aarch64_rust-heapless+mpmc_large-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+mpmc_large-devel-0.9.3-2.el10_3.noarch.rpm;name=aarch64_rust-heapless+mpmc_large-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+mpmc_large-devel}"
SRC_URI[aarch64_rust-heapless+mpmc_large-devel.sha256sum] = "102e00d8e848d160779e8c69e34a84578a6ce89c9c4157d8fb3520305d538835"

URI_aarch64_rust-heapless+portable-atomic-critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+portable-atomic-critical-section-devel-0.9.3-2.el10_3.noarch.rpm;name=aarch64_rust-heapless+portable-atomic-critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+portable-atomic-critical-section-devel}"
SRC_URI[aarch64_rust-heapless+portable-atomic-critical-section-devel.sha256sum] = "3cfc5958d1d56d9f535ca33ad253ce898ab79eb6e4d1cf5be635ce3cf4472ac7"

URI_aarch64_rust-heapless+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+portable-atomic-devel-0.9.3-2.el10_3.noarch.rpm;name=aarch64_rust-heapless+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+portable-atomic-devel}"
SRC_URI[aarch64_rust-heapless+portable-atomic-devel.sha256sum] = "ea8def237eb155015c662338a3baf584409ef411492fb3273642297ee60aa499"

URI_aarch64_rust-heapless+portable-atomic-unsafe-assume-single-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+portable-atomic-unsafe-assume-single-core-devel-0.9.3-2.el10_3.noarch.rpm;name=aarch64_rust-heapless+portable-atomic-unsafe-assume-single-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+portable-atomic-unsafe-assume-single-core-devel}"
SRC_URI[aarch64_rust-heapless+portable-atomic-unsafe-assume-single-core-devel.sha256sum] = "e6b4c2c7c75a1d02dcad204fa4f5b61f5efaed124e80c1bf1919f6b507f94fe6"

URI_aarch64_rust-heapless+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+serde-devel-0.9.3-2.el10_3.noarch.rpm;name=aarch64_rust-heapless+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+serde-devel}"
SRC_URI[aarch64_rust-heapless+serde-devel.sha256sum] = "72d80a2e9af6c7ff6e4eac6f1a10dcfd565f7661ae0b7a6eb9806a4de4cac7db"

URI_aarch64_rust-heapless+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+zeroize-devel-0.9.3-2.el10_3.noarch.rpm;name=aarch64_rust-heapless+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+zeroize-devel}"
SRC_URI[aarch64_rust-heapless+zeroize-devel.sha256sum] = "b36b9b8014b45b0671de8ff4396fc977783378b5897ebf9b1616e6ec47dc6637"

URI_aarch64_rust-heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless-devel-0.9.3-2.el10_3.noarch.rpm;name=aarch64_rust-heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless-devel}"
SRC_URI[aarch64_rust-heapless-devel.sha256sum] = "b757f44fb8c64e5d485391bfee15a3eb8072595b5823254d051ab2cdfdc07bd9"

RDEPENDS:rust-heapless+alloc-devel = " \
 cargo \
 rust-heapless-devel \
 "
RDEPENDS:rust-heapless+bytes-devel = " \
 cargo \
 rust-bytes-devel \
 rust-heapless-devel \
 "
RDEPENDS:rust-heapless+default-devel = " \
 cargo \
 rust-heapless-devel \
 "
RDEPENDS:rust-heapless+mpmc_large-devel = " \
 cargo \
 rust-heapless-devel \
 "
RDEPENDS:rust-heapless+portable-atomic-critical-section-devel = " \
 cargo \
 rust-heapless+portable-atomic-devel \
 rust-heapless-devel \
 rust-portable-atomic+critical-section-devel \
 rust-portable-atomic+default-devel \
 "
RDEPENDS:rust-heapless+portable-atomic-devel = " \
 cargo \
 rust-heapless-devel \
 rust-portable-atomic+default-devel \
 "
RDEPENDS:rust-heapless+portable-atomic-unsafe-assume-single-core-devel = " \
 cargo \
 rust-heapless+portable-atomic-devel \
 rust-heapless-devel \
 rust-portable-atomic+default-devel \
 rust-portable-atomic+unsafe-assume-single-core-devel \
 "
RDEPENDS:rust-heapless+serde-devel = " \
 cargo \
 rust-heapless-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-heapless+zeroize-devel = " \
 cargo \
 rust-heapless-devel \
 rust-zeroize+derive-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-heapless-devel = " \
 cargo \
 rust \
 rust-hash32+default-devel \
 rust-stable_deref_trait-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~"
