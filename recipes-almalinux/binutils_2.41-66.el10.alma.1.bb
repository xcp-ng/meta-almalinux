# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "binutils"
PV = "2.41"
PR = "66.el10.alma.1"
PACKAGES = " \
 binutils \
 binutils-devel \
 binutils-gold \
 binutils-gprofng \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/binutils-2.41-66.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "29c9145e7db10ac6bff8e4d3d26abb156124eb4fb21a3fcceeb124ca0cf655d3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/binutils-2.41-66.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils;unpack=0"
SRC_URI[x86_64_v2_binutils.sha256sum] = "8ea1c72660f7fd743bfd90eb79c30c3a4785a418627e0d9f5db142be2157ef96"
RPROVIDES:binutils:append:x86_64_v2 = " virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_ virtual/libgprofng.so.0___64bit_ virtual/libsframe.so.1___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/binutils-devel-2.41-66.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils-devel;unpack=0"
SRC_URI[x86_64_v2_binutils-devel.sha256sum] = "ab133156b2cdd1a83fc80844f7a9bffdff02dfd904e869b25845210bc6b46ba5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/binutils-gold-2.41-66.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils-gold;unpack=0"
SRC_URI[x86_64_v2_binutils-gold.sha256sum] = "5d600f95b725f822699df9de920e2588175e485ab0d19c881048e4756a1d8890"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/binutils-gprofng-2.41-66.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils-gprofng;unpack=0"
SRC_URI[x86_64_v2_binutils-gprofng.sha256sum] = "bcbcc69ac5e92dbe0c75f6e9c13ba5747fb9aed44a5652cda401ca09dc0c91fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/binutils-2.41-66.el10.alma.1.aarch64.rpm;name=aarch64_binutils;unpack=0"
SRC_URI[aarch64_binutils.sha256sum] = "ca5bd2d5f8623a70c9f8d7b52034a3403cae07e51e505b1441136ad7c493f457"
RPROVIDES:binutils:append:aarch64 = " virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_ virtual/libgprofng.so.0___64bit_ virtual/libsframe.so.1___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/binutils-devel-2.41-66.el10.alma.1.aarch64.rpm;name=aarch64_binutils-devel;unpack=0"
SRC_URI[aarch64_binutils-devel.sha256sum] = "94dc73d531d66416504aaab1a4672f957b37e8c95324b51fcf142f3e78fcb6d5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/binutils-gold-2.41-66.el10.alma.1.aarch64.rpm;name=aarch64_binutils-gold;unpack=0"
SRC_URI[aarch64_binutils-gold.sha256sum] = "837606fa275b01fe184102da86848ec2ffb986f38e3cc9763332debdcd3c13fc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/binutils-gprofng-2.41-66.el10.alma.1.aarch64.rpm;name=aarch64_binutils-gprofng;unpack=0"
SRC_URI[aarch64_binutils-gprofng.sha256sum] = "6d4f4b37dccc9f551f0aa46b6b07afe46bafab33b172018bb0f0ae567da37061"

RDEPENDS:binutils = " \
 alternatives \
 bash \
 binutils-gold \
 elfutils-debuginfod-client \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:binutils-devel = " \
 binutils \
 virtual/coreutils \
 zlib-ng-compat-devel \
 "
RDEPENDS:binutils-gold = " \
 bash \
 binutils \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:binutils-gprofng = " \
 binutils \
 glibc \
 libgcc \
 libstdc++ \
 perl-interpreter \
 virtual/libgprofng.so.0___64bit_ \
 "
