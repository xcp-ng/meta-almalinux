# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rfc2047-decoder"
PV = "1.0.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-rfc2047-decoder+default-devel \
 rust-rfc2047-decoder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rfc2047-decoder-1.0.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25a7c66210e63c7aa90b560a8bb83d97809e2cd8781ae533a11329c3f8b56f06"

URI_x86_64_v2_rust-rfc2047-decoder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rfc2047-decoder+default-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rfc2047-decoder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rfc2047-decoder+default-devel}"
SRC_URI[x86_64_v2_rust-rfc2047-decoder+default-devel.sha256sum] = "b99f86d2dd1ab87f9798c19b22604602b17953c8c41d3b5b96ea620695e5b999"

URI_x86_64_v2_rust-rfc2047-decoder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rfc2047-decoder-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rfc2047-decoder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rfc2047-decoder-devel}"
SRC_URI[x86_64_v2_rust-rfc2047-decoder-devel.sha256sum] = "91675bfee048dd96ce06a53a948c01a4449232fe3f38166c1d7d8c9b79213fdb"

URI_aarch64_rust-rfc2047-decoder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rfc2047-decoder+default-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-rfc2047-decoder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rfc2047-decoder+default-devel}"
SRC_URI[aarch64_rust-rfc2047-decoder+default-devel.sha256sum] = "c462c6246d58045b7991524482ba36c3dca65790eb9ed104716c60e3599fee90"

URI_aarch64_rust-rfc2047-decoder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rfc2047-decoder-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-rfc2047-decoder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rfc2047-decoder-devel}"
SRC_URI[aarch64_rust-rfc2047-decoder-devel.sha256sum] = "073f356a4bfa8c8847c49f6f48cc0f757c86c64ce074c61438a649c069980c75"

RDEPENDS:rust-rfc2047-decoder+default-devel = " \
 cargo \
 rust-rfc2047-decoder-devel \
 "
RDEPENDS:rust-rfc2047-decoder-devel = " \
 cargo \
 rust-base64_0.22+default-devel \
 rust-charset+default-devel \
 rust-chumsky+default-devel \
 rust-memchr+default-devel \
 rust-quoted_printable+default-devel \
 rust-thiserror+default-devel \
 "
