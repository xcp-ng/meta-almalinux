# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-repoze-who-plugins-sa"
PV = "1.0.1"
PR = "45.20160106gite1a36c5.el10_0"
PACKAGES = " \
 python3-repoze-who-plugins-sa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-repoze-who-plugins-sa-1.0.1-45.20160106gite1a36c5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "704d8189677272368f3de9fff5165fc73294ad6fcac60f2219a5229d32da1f4a"

URI_x86_64_v2_python3-repoze-who-plugins-sa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-repoze-who-plugins-sa-1.0.1-45.20160106gite1a36c5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-repoze-who-plugins-sa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-repoze-who-plugins-sa}"
SRC_URI[x86_64_v2_python3-repoze-who-plugins-sa.sha256sum] = "a9efdd4bc95906caaa3ff9a12bc71f3b567d1a2cc716702d84c21ac7e0d36eae"

URI_aarch64_python3-repoze-who-plugins-sa = "${EPEL_MIRROR}/aarch64/Packages/p/python3-repoze-who-plugins-sa-1.0.1-45.20160106gite1a36c5.el10_0.noarch.rpm;name=aarch64_python3-repoze-who-plugins-sa;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-repoze-who-plugins-sa}"
SRC_URI[aarch64_python3-repoze-who-plugins-sa.sha256sum] = "1b3a70dd4559aac7d742be8e64b9b9c81740ec0f63d0e73a2a86f0f51156e66f"

RDEPENDS:python3-repoze-who-plugins-sa = " \
 python3 \
 python3-repoze-who \
 python3-sqlalchemy \
 "
