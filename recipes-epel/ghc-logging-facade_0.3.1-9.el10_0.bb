# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-logging-facade"
PV = "0.3.1"
PR = "9.el10_0"
PACKAGES = " \
 ghc-logging-facade \
 ghc-logging-facade-devel \
 ghc-logging-facade-doc \
 ghc-logging-facade-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-logging-facade-0.3.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58ad4e3da6266b478e42c92089926c9ed35c1b2b7de10e51fab8c50dea8e8a95"

URI_x86_64_v2_ghc-logging-facade = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-logging-facade-0.3.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-logging-facade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-logging-facade}"
SRC_URI[x86_64_v2_ghc-logging-facade.sha256sum] = "ac1d5f0c600374e711ac1ab95412664a49800bb419762d1b9293be2b1fb4d3ae"

URI_x86_64_v2_ghc-logging-facade-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-logging-facade-devel-0.3.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-logging-facade-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-logging-facade-devel}"
SRC_URI[x86_64_v2_ghc-logging-facade-devel.sha256sum] = "9244e3b18354baf85f046e7f696a7655845cc24088c906600f848553b5acd8c4"

URI_x86_64_v2_ghc-logging-facade-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-logging-facade-doc-0.3.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-logging-facade-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-logging-facade-doc}"
SRC_URI[x86_64_v2_ghc-logging-facade-doc.sha256sum] = "b9f199ae29045f94d8c859bca81502c35f7d97a86b684b18e3db5c308de3754a"

URI_x86_64_v2_ghc-logging-facade-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-logging-facade-prof-0.3.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-logging-facade-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-logging-facade-prof}"
SRC_URI[x86_64_v2_ghc-logging-facade-prof.sha256sum] = "de389a0ceef089f6bfedce1cd8fe89d24fdb729542d7ec77da071dc33b6349c2"

URI_aarch64_ghc-logging-facade = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-logging-facade-0.3.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-logging-facade;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-logging-facade}"
SRC_URI[aarch64_ghc-logging-facade.sha256sum] = "0717a605d65ba016f4a54a25637f6d03f98eccfead74c78a04763c267f7659cb"

URI_aarch64_ghc-logging-facade-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-logging-facade-devel-0.3.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-logging-facade-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-logging-facade-devel}"
SRC_URI[aarch64_ghc-logging-facade-devel.sha256sum] = "324ea99e58c30565ee35e34555ba9b60aeb7c4ab220523fcfb1758787cbe13f5"

URI_aarch64_ghc-logging-facade-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-logging-facade-doc-0.3.1-9.el10_0.noarch.rpm;name=aarch64_ghc-logging-facade-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-logging-facade-doc}"
SRC_URI[aarch64_ghc-logging-facade-doc.sha256sum] = "0d3591b1427a90ca129ae58736c60ae46b8380df4d3725192825558cfdad4e04"

URI_aarch64_ghc-logging-facade-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-logging-facade-prof-0.3.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-logging-facade-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-logging-facade-prof}"
SRC_URI[aarch64_ghc-logging-facade-prof.sha256sum] = "667da2ba9dda269fc406284ffae5c6591c617cedb6478adf01c556e01b7ce9fe"

RDEPENDS:ghc-logging-facade = " \
 ghc-base \
 ghc-call-stack \
 ghc-ghc-bignum \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-logging-facade-devel = " \
 ghc-base-devel \
 ghc-call-stack-devel \
 ghc-compiler \
 ghc-logging-facade \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-logging-facade-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-logging-facade-prof = " \
 ghc-base-prof \
 ghc-call-stack-prof \
 ghc-logging-facade-devel \
 ghc-transformers-prof \
 "
