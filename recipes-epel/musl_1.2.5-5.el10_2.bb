# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "musl"
PV = "1.2.5"
PR = "5.el10_2"
PACKAGES = " \
 musl-clang \
 musl-devel \
 musl-filesystem \
 musl-gcc \
 musl-libc \
 musl-libc-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/musl-1.2.5-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19aa85f5e3f9831a1b1ddeac4cf7add415ad190abbe83da45033b9b4031196ed"

URI_x86_64_v2_musl-clang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-clang-1.2.5-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-clang}"
SRC_URI[x86_64_v2_musl-clang.sha256sum] = "11adf598d516dac3a785223c4ad76bf150c66cb442953bd28e3a398ca4a1370f"

URI_x86_64_v2_musl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-devel-1.2.5-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-devel}"
SRC_URI[x86_64_v2_musl-devel.sha256sum] = "9b984c05ff8745355ba48375c63c1b6e943da623d51d863845d715d97093e862"

URI_x86_64_v2_musl-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-filesystem-1.2.5-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-filesystem}"
SRC_URI[x86_64_v2_musl-filesystem.sha256sum] = "72bf309f8736ff837346ba472ea3740da59bd7158c1134b90c88b410c21d390a"

URI_x86_64_v2_musl-gcc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-gcc-1.2.5-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-gcc}"
SRC_URI[x86_64_v2_musl-gcc.sha256sum] = "5b9161f07b24ef4278de46af07a577dd2322734d53dc766a859e230c1b7160ab"

URI_x86_64_v2_musl-libc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-libc-1.2.5-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-libc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-libc}"
SRC_URI[x86_64_v2_musl-libc.sha256sum] = "abd124e8035b0fbb74f55aa7613c4628296b461cedcef584be324dda358bd803"

URI_x86_64_v2_musl-libc-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-libc-static-1.2.5-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-libc-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-libc-static}"
SRC_URI[x86_64_v2_musl-libc-static.sha256sum] = "0cf6357a76d67469d85f40d9bb6eea08b0123d51a50211b8f2196f17e32d7c16"

URI_aarch64_musl-clang = "${EPEL_MIRROR}/aarch64/Packages/m/musl-clang-1.2.5-5.el10_2.aarch64.rpm;name=aarch64_musl-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-clang}"
SRC_URI[aarch64_musl-clang.sha256sum] = "d7e01df0abea642387b7bce9308874b05482d11a21516dd7a1f877b0e66113ff"

URI_aarch64_musl-devel = "${EPEL_MIRROR}/aarch64/Packages/m/musl-devel-1.2.5-5.el10_2.aarch64.rpm;name=aarch64_musl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-devel}"
SRC_URI[aarch64_musl-devel.sha256sum] = "8e79aa3bff31db172c7b4af93da03087857fbf7c247f70ab67b250a97e4b9db2"

URI_aarch64_musl-filesystem = "${EPEL_MIRROR}/aarch64/Packages/m/musl-filesystem-1.2.5-5.el10_2.aarch64.rpm;name=aarch64_musl-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-filesystem}"
SRC_URI[aarch64_musl-filesystem.sha256sum] = "f81749f29a88d5b0c3c590de5ec5564b505e91bb5d72306965bc8d1be5dfbf99"

URI_aarch64_musl-gcc = "${EPEL_MIRROR}/aarch64/Packages/m/musl-gcc-1.2.5-5.el10_2.aarch64.rpm;name=aarch64_musl-gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-gcc}"
SRC_URI[aarch64_musl-gcc.sha256sum] = "934b0461d60dc1983224b2d9ea6ab8619f861bdc63e329cd5222cfd72c327eae"

URI_aarch64_musl-libc = "${EPEL_MIRROR}/aarch64/Packages/m/musl-libc-1.2.5-5.el10_2.aarch64.rpm;name=aarch64_musl-libc;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-libc}"
SRC_URI[aarch64_musl-libc.sha256sum] = "27522b3be6f64ee8151ac928d2db5f570813037711a7ec48a5a2d0ea2123adca"

URI_aarch64_musl-libc-static = "${EPEL_MIRROR}/aarch64/Packages/m/musl-libc-static-1.2.5-5.el10_2.aarch64.rpm;name=aarch64_musl-libc-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-libc-static}"
SRC_URI[aarch64_musl-libc-static.sha256sum] = "b294048df83c884c186c05414893cf65babdf74e2146ea21bc4798b3b2a44f6c"

RDEPENDS:musl-clang = " \
 bash \
 clang \
 musl-devel \
 "
RDEPENDS:musl-devel = " \
 musl-libc \
 "
RDEPENDS:musl-filesystem = " \
 "
RDEPENDS:musl-gcc = " \
 bash \
 gcc \
 musl-devel \
 "
RDEPENDS:musl-libc = " \
 musl-filesystem \
 "
RDEPENDS:musl-libc-static = " \
 musl-devel \
 "
