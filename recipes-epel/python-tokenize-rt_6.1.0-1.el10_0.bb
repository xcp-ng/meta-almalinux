# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tokenize-rt"
PV = "6.1.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-tokenize-rt \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-tokenize-rt-6.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "355830dcc60d85925163864a38eb373e043324a7d9cba954c2c7bfdd2c2dca55"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tokenize-rt-6.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tokenize-rt;unpack=0"
SRC_URI[x86_64_v2_python3-tokenize-rt.sha256sum] = "545162096c56a85a7c2bbb3eeff88511767d918082f2f7c77d7a4820b046c8e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-tokenize-rt-6.1.0-1.el10_0.noarch.rpm;name=aarch64_python3-tokenize-rt;unpack=0"
SRC_URI[aarch64_python3-tokenize-rt.sha256sum] = "856c87cd2e40e19e8216a015dcb93a1f9d7d8a8ddfd15782a997856b323dcb08"

RDEPENDS:python3-tokenize-rt = " \
 python3 \
 "
