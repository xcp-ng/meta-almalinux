# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mbedtls"
PV = "3.6.7"
PR = "1.el10_2"
PACKAGES = " \
 mbedtls \
 mbedtls-devel \
 mbedtls-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mbedtls-3.6.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd125981baa64326f718bae92e27bc4cb91994f2ba5feb463fe86a4350441f78"

URI_x86_64_v2_mbedtls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbedtls-3.6.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbedtls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbedtls}"
SRC_URI[x86_64_v2_mbedtls.sha256sum] = "b1872771fe09e03e50291d26e0bb9e7ef6b6ec923eaa38cb6e0f58302b109195"

URI_x86_64_v2_mbedtls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbedtls-devel-3.6.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbedtls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbedtls-devel}"
SRC_URI[x86_64_v2_mbedtls-devel.sha256sum] = "5d957e7a9f74605b2245d02b4f304a84e32f45d7285b5cba17f9a851c9f66521"

URI_x86_64_v2_mbedtls-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbedtls-doc-3.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mbedtls-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbedtls-doc}"
SRC_URI[x86_64_v2_mbedtls-doc.sha256sum] = "3391d409b4739659aede5acb8e2365cca3ac95787ed16b733914ad345395d346"

URI_aarch64_mbedtls = "${EPEL_MIRROR}/aarch64/Packages/m/mbedtls-3.6.7-1.el10_2.aarch64.rpm;name=aarch64_mbedtls;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbedtls}"
SRC_URI[aarch64_mbedtls.sha256sum] = "2e718ee4dfb5e3e67632c54c1abc7504eb59380a2a25e780306e73fe5293775f"

URI_aarch64_mbedtls-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mbedtls-devel-3.6.7-1.el10_2.aarch64.rpm;name=aarch64_mbedtls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbedtls-devel}"
SRC_URI[aarch64_mbedtls-devel.sha256sum] = "20c224b4e29d6d5217ed69eddce50cac5644301f443fe8ef605ec605ceb62154"

URI_aarch64_mbedtls-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mbedtls-doc-3.6.7-1.el10_2.noarch.rpm;name=aarch64_mbedtls-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbedtls-doc}"
SRC_URI[aarch64_mbedtls-doc.sha256sum] = "5bf7f6aabac9067c0dc0eac6bff88f9f15e5548d6c86e7a05f1ea1dfe5d3341e"

RDEPENDS:mbedtls = " \
 glibc \
 "
RDEPENDS:mbedtls-devel = " \
 cmake-filesystem \
 glibc \
 mbedtls \
 mbedtls-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:mbedtls-doc = " \
 "
