# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "global"
PV = "6.6.14"
PR = "1.el10_2"
PACKAGES = " \
 global \
 global-ctags \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/global-6.6.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71e56ea1639a3e91878309f8e43d2ae38fcced68c67e44ec670bd52d3e8e2e93"

URI_x86_64_v2_global = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/global-6.6.14-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_global;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_global}"
SRC_URI[x86_64_v2_global.sha256sum] = "24dfc5af111a82f6950be302a6659fb81e12bab03ee827109465fd8fb3d2f457"

URI_x86_64_v2_global-ctags = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/global-ctags-6.6.14-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_global-ctags;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_global-ctags}"
SRC_URI[x86_64_v2_global-ctags.sha256sum] = "263642d526e3673d8cea2984da4c7e18de15d806592b3ec6ad04f57f33ef3f60"

URI_aarch64_global = "${EPEL_MIRROR}/aarch64/Packages/g/global-6.6.14-1.el10_2.aarch64.rpm;name=aarch64_global;unpack=0"
SRC_URI:append = " ${URI_aarch64_global}"
SRC_URI[aarch64_global.sha256sum] = "0910747274d07bdd74f1fad9bb108b0050d884a9abca9eadcb13646db89b4a83"

URI_aarch64_global-ctags = "${EPEL_MIRROR}/aarch64/Packages/g/global-ctags-6.6.14-1.el10_2.aarch64.rpm;name=aarch64_global-ctags;unpack=0"
SRC_URI:append = " ${URI_aarch64_global-ctags}"
SRC_URI[aarch64_global-ctags.sha256sum] = "0ec42cb5ff9dbef509c9c93f7ca6a4dc96e933fcfffab11a55f59101d98017cb"

RDEPENDS:global = " \
 bash \
 emacs-filesystem \
 glibc \
 libtool-ltdl \
 ncurses-libs \
 perl-interpreter \
 python3 \
 "
RDEPENDS:global-ctags = " \
 glibc \
 global \
 python3-pygments \
 "
