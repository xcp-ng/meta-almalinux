# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hddfancontrol"
PV = "2.1.2"
PR = "2.el10_2"
PACKAGES = " \
 hddfancontrol \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hddfancontrol-2.1.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d33a8ece94487698d5f4fdb0a7d3f52be8209bd456fa6b613913b55f0f2d246"

URI_x86_64_v2_hddfancontrol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hddfancontrol-2.1.2-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hddfancontrol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hddfancontrol}"
SRC_URI[x86_64_v2_hddfancontrol.sha256sum] = "b61d9c1405b5be9d118dc29ebbfed17aa4b783b52d40bc7d50e04b1381e7c6c3"

URI_aarch64_hddfancontrol = "${EPEL_MIRROR}/aarch64/Packages/h/hddfancontrol-2.1.2-2.el10_2.aarch64.rpm;name=aarch64_hddfancontrol;unpack=0"
SRC_URI:append = " ${URI_aarch64_hddfancontrol}"
SRC_URI[aarch64_hddfancontrol.sha256sum] = "8e0977f0491c144fcada302582a22105f118e2f8265a18912aade524a1c165eb"

RDEPENDS:hddfancontrol = " \
 bash \
 glibc \
 hdparm \
 libgcc \
 smartmontools \
 "
