# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iscsi-initiator-utils"
PV = "6.2.1.9"
PR = "22.gita65a472.el10"
PACKAGES = " \
 iscsi-initiator-utils \
 iscsi-initiator-utils-iscsiuio \
 python3-iscsi-initiator-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iscsi-initiator-utils-6.2.1.9-22.gita65a472.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0d212adc9cdafd156cb5328c28c62a1336376a07442626c64e92a1ee1b4bbf1"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - iscsi-initiator-utils: (fedora-release-common >= 38-0.23 if fedora-release-common)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - iscsi-initiator-utils: (fedora-release-common >= 38-0.23 if fedora-release-common)

URI_x86_64_v2_iscsi-initiator-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iscsi-initiator-utils-6.2.1.9-22.gita65a472.el10.x86_64_v2.rpm;name=x86_64_v2_iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iscsi-initiator-utils}"
SRC_URI[x86_64_v2_iscsi-initiator-utils.sha256sum] = "a45ccfa717bc2b0dce2677227ba3208751d35bdb54e30c84f8d7cc1adb6b4682"

URI_x86_64_v2_iscsi-initiator-utils-iscsiuio = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iscsi-initiator-utils-iscsiuio-6.2.1.9-22.gita65a472.el10.x86_64_v2.rpm;name=x86_64_v2_iscsi-initiator-utils-iscsiuio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iscsi-initiator-utils-iscsiuio}"
SRC_URI[x86_64_v2_iscsi-initiator-utils-iscsiuio.sha256sum] = "68db0c69df1481f0ea52bd01ca5011f0b41b4e880963e7d3a9a8160e3b09c13e"

URI_x86_64_v2_python3-iscsi-initiator-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-iscsi-initiator-utils-6.2.1.9-22.gita65a472.el10.x86_64_v2.rpm;name=x86_64_v2_python3-iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-iscsi-initiator-utils}"
SRC_URI[x86_64_v2_python3-iscsi-initiator-utils.sha256sum] = "e7a6cdfd31c8c14443c02cc6be3a75ab7f884b5b361d28635816950cc49f6ef1"

URI_aarch64_iscsi-initiator-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iscsi-initiator-utils-6.2.1.9-22.gita65a472.el10.aarch64.rpm;name=aarch64_iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_iscsi-initiator-utils}"
SRC_URI[aarch64_iscsi-initiator-utils.sha256sum] = "26037f6bb3e0f6370f5feb50fb557ca5b0b25c6cc7a5eed2136b8e850b1a810d"

URI_aarch64_iscsi-initiator-utils-iscsiuio = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iscsi-initiator-utils-iscsiuio-6.2.1.9-22.gita65a472.el10.aarch64.rpm;name=aarch64_iscsi-initiator-utils-iscsiuio;unpack=0"
SRC_URI:append = " ${URI_aarch64_iscsi-initiator-utils-iscsiuio}"
SRC_URI[aarch64_iscsi-initiator-utils-iscsiuio.sha256sum] = "3a89f30a18e78c46dcc77c1c1f4ef602094cd27fcf981c2258e544b1a2389a93"

URI_aarch64_python3-iscsi-initiator-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-iscsi-initiator-utils-6.2.1.9-22.gita65a472.el10.aarch64.rpm;name=aarch64_python3-iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-iscsi-initiator-utils}"
SRC_URI[aarch64_python3-iscsi-initiator-utils.sha256sum] = "b54aad7bf9544a6124abbafbdc7e325b506f030acb74fadb05d7185b277cee5e"

RDEPENDS:iscsi-initiator-utils = " \
 bash \
 glibc \
 iscsi-initiator-utils-iscsiuio \
 isns-utils-libs \
 kmod-libs \
 libmount \
 openssl-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:iscsi-initiator-utils-iscsiuio = " \
 bash \
 glibc \
 iscsi-initiator-utils \
 libgcc \
 systemd-libs \
 "
RDEPENDS:python3-iscsi-initiator-utils = " \
 glibc \
 iscsi-initiator-utils \
 python3 \
 "
