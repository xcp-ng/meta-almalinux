# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-notify2"
PV = "0.3.1"
PR = "25.el10_1"
PACKAGES = " \
 python-notify2-doc \
 python3-notify2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-notify2-0.3.1-25.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b25c8914f8992cda870430a74df8c61c7322452ee18d7aa503a0682f9d4e535"

URI_x86_64_v2_python-notify2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-notify2-doc-0.3.1-25.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-notify2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-notify2-doc}"
SRC_URI[x86_64_v2_python-notify2-doc.sha256sum] = "908958a61ab487a8b68789ee005f13f5fc0c44d9fe021815939994ef3f2d9db3"

URI_x86_64_v2_python3-notify2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-notify2-0.3.1-25.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-notify2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-notify2}"
SRC_URI[x86_64_v2_python3-notify2.sha256sum] = "0f4305dfd34b7248e36afdf95614b665fc8802e6f353413d3928fa2693ed8f7a"

URI_aarch64_python-notify2-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-notify2-doc-0.3.1-25.el10_1.noarch.rpm;name=aarch64_python-notify2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-notify2-doc}"
SRC_URI[aarch64_python-notify2-doc.sha256sum] = "5e9c61cf154ad5db147d1052ca86899fa9284af9ffe59ef6ed9faa8217b627d7"

URI_aarch64_python3-notify2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-notify2-0.3.1-25.el10_1.noarch.rpm;name=aarch64_python3-notify2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-notify2}"
SRC_URI[aarch64_python3-notify2.sha256sum] = "b21b29bdccadbe7fb4cb08a1af9db0c2f4678d5e9320c2035a5d329a609ee6a4"

RDEPENDS:python-notify2-doc = " \
 "
RDEPENDS:python3-notify2 = " \
 python3 \
 python3-dbus \
 "
