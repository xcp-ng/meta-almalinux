# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mailcommon"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 mailcommon \
 mailcommon-devel \
 mailcommon-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mailcommon-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e33aecc56c73045afb78974c96b88f62a3b972861a1a87dce7917f6ffdab1d6"

URI_x86_64_v2_mailcommon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailcommon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailcommon}"
SRC_URI[x86_64_v2_mailcommon.sha256sum] = "b063233813c4ee855ea9a5731bcf66f603570a0b6484486570cee28737929a68"

URI_x86_64_v2_mailcommon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailcommon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailcommon-devel}"
SRC_URI[x86_64_v2_mailcommon-devel.sha256sum] = "cfb4503a96427968379e579524e90364533c77b4e5ee632a8d6f26eb3ebe9386"

URI_x86_64_v2_mailcommon-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mailcommon-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailcommon-doc}"
SRC_URI[x86_64_v2_mailcommon-doc.sha256sum] = "86345cf8df286791bbd1327339e233b7e613d7df96daea1da0d81c313844c73d"

URI_aarch64_mailcommon = "${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_mailcommon;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailcommon}"
SRC_URI[aarch64_mailcommon.sha256sum] = "a162fe0121ab7ebb968b34f0b90799ea9a7fc567d89be8333fc5150430cae449"

URI_aarch64_mailcommon-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_mailcommon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailcommon-devel}"
SRC_URI[aarch64_mailcommon-devel.sha256sum] = "f4d6732e880a2d09bd978ddd3ec731e5fe77e6567aca7e5d5c987d8fa4185239"

URI_aarch64_mailcommon-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_mailcommon-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailcommon-doc}"
SRC_URI[aarch64_mailcommon-doc.sha256sum] = "fa2d5be24b564845bff4494eefc48b389e852b411389a1a59c9f1b1d8b095630"

RDEPENDS:mailcommon = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 glibc \
 gpgmepp \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kmailtransport \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libkleo \
 libstdc++ \
 mailimporter \
 messagelib \
 phonon-qt6 \
 pimcommon \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:mailcommon-devel = " \
 akonadi-mime-devel \
 akonadi-server-devel \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 mailcommon \
 messagelib-devel \
 pimcommon-devel \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:mailcommon-doc = " \
 "
