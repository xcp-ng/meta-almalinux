# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmamba"
PV = "2.4.0"
PR = "2.el10_2"
PACKAGES = " \
 libmamba \
 libmamba-devel \
 mamba \
 python3-libmambapy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmamba-2.4.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cca373225ddb2b6a5fde050501facd3b1f01e7a02a5e421314cbc6de394f661"

URI_x86_64_v2_libmamba = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmamba-2.4.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmamba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmamba}"
SRC_URI[x86_64_v2_libmamba.sha256sum] = "9d9f19b02a52d93234636079642c6efff75dad857c6d4e42e5b0e7d66a9e7833"

URI_x86_64_v2_libmamba-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmamba-devel-2.4.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmamba-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmamba-devel}"
SRC_URI[x86_64_v2_libmamba-devel.sha256sum] = "aa09baa5dab44142fe1aa75c5e8fd80e2b7beeb697edd0feef7132387f7f5d07"

URI_x86_64_v2_mamba = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mamba-2.4.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mamba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mamba}"
SRC_URI[x86_64_v2_mamba.sha256sum] = "2beaa241847b0bf40078e40eff67a9104fce9fe91f8c0936fa8d16da2a745877"

URI_x86_64_v2_python3-libmambapy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libmambapy-2.4.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-libmambapy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libmambapy}"
SRC_URI[x86_64_v2_python3-libmambapy.sha256sum] = "4efe98e3a70db61fe4f30116707745ca9f0dfa464debad206c4a7d6e228ac4ed"

URI_aarch64_libmamba = "${EPEL_MIRROR}/aarch64/Packages/l/libmamba-2.4.0-2.el10_2.aarch64.rpm;name=aarch64_libmamba;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmamba}"
SRC_URI[aarch64_libmamba.sha256sum] = "04f5475d07f1e5caec6227e6c75b909951ab5110b9d913c6475e688576b91eaa"

URI_aarch64_libmamba-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmamba-devel-2.4.0-2.el10_2.aarch64.rpm;name=aarch64_libmamba-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmamba-devel}"
SRC_URI[aarch64_libmamba-devel.sha256sum] = "36274b0fe80488f924bc6dd129596c6a1068bc7d996bfb8f7707c83c08c062c2"

URI_aarch64_mamba = "${EPEL_MIRROR}/aarch64/Packages/m/mamba-2.4.0-2.el10_2.aarch64.rpm;name=aarch64_mamba;unpack=0"
SRC_URI:append = " ${URI_aarch64_mamba}"
SRC_URI[aarch64_mamba.sha256sum] = "3dbf3a90014dd02a2958a98c7be236bdfa602a7d9da2595c86de42d0594e1fa8"

URI_aarch64_python3-libmambapy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libmambapy-2.4.0-2.el10_2.aarch64.rpm;name=aarch64_python3-libmambapy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libmambapy}"
SRC_URI[aarch64_python3-libmambapy.sha256sum] = "5a106404895cd9356589c0e4685044f090b098a24439646a137c5ca61a9b11e0"

RDEPENDS:libmamba = " \
 bzip2-libs \
 fmt \
 glibc \
 libarchive \
 libgcc \
 libsolv \
 libstdc++ \
 libzstd \
 openssl-libs \
 reproc \
 simdjson \
 virtual/libcurl.so.4___64bit_ \
 yaml-cpp \
 "
RDEPENDS:libmamba-devel = " \
 cmake-filesystem \
 expected-devel \
 fmt-devel \
 json-devel \
 libmamba \
 libsolv-devel \
 pkgconf-pkg-config \
 reproc-devel \
 spdlog-devel \
 yaml-cpp-devel \
 "
RDEPENDS:mamba = " \
 fmt \
 glibc \
 libgcc \
 libmamba \
 libstdc++ \
 reproc \
 yaml-cpp \
 "
RDEPENDS:python3-libmambapy = " \
 fmt \
 glibc \
 libgcc \
 libmamba \
 libstdc++ \
 python3 \
 "
