# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpkg"
PV = "1.69"
PR = "5.el10_2"
PACKAGES = " \
 python3-rpkg \
 rpkg-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rpkg-1.69-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e576a6e3aa4bbf5f78032861c733e61cf509decab3c9d3eea10dd845deed866"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3-rpkg: python3-GitPython
# - python3-rpkg: python3.12dist(gitpython)

URI_x86_64_v2_python3-rpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpkg-1.69-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpkg}"
SRC_URI[x86_64_v2_python3-rpkg.sha256sum] = "cada5f945fe117dd47038e793ae43740b3d2f59cbce4bfac7abb600893f8a197"

URI_x86_64_v2_rpkg-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpkg-common-1.69-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rpkg-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpkg-common}"
SRC_URI[x86_64_v2_rpkg-common.sha256sum] = "ab5dede0368afff7faa50e6de6004dae8344209b47805f57d6ee0fb5c7d6b966"

URI_aarch64_python3-rpkg = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpkg-1.69-5.el10_2.noarch.rpm;name=aarch64_python3-rpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpkg}"
SRC_URI[aarch64_python3-rpkg.sha256sum] = "9eaf7d300692c065437d65bbb0efb0c67852029ec49ed6c3cb877154ca82aa1d"

URI_aarch64_rpkg-common = "${EPEL_MIRROR}/aarch64/Packages/r/rpkg-common-1.69-5.el10_2.noarch.rpm;name=aarch64_rpkg-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpkg-common}"
SRC_URI[aarch64_rpkg-common.sha256sum] = "7cc90fb2111556429726479c9f6dcd29214f2fd494553afcdba6c3cff38dc892"

RDEPENDS:python3-rpkg:x86_64_v2 = " \
 libmodulemd \
 mock \
 python3 \
 python3-argcomplete \
 python3-cccolutils \
 python3-gobject-base \
 python3-koji \
 python3-pycurl \
 python3-pyyaml \
 python3-requests \
 python3-requests-gssapi \
 python3-rpm \
 python3-six \
 redhat-rpm-config \
 rpkg-common \
 rpm-build \
 rpmdevtools \
 rpmlint \
"
RDEPENDS:python3-rpkg:aarch64 = " \
 libmodulemd \
 mock \
 python3 \
 python3-GitPython \
 python3-argcomplete \
 python3-cccolutils \
 python3-gobject-base \
 python3-koji \
 python3-pycurl \
 python3-pyyaml \
 python3-requests \
 python3-requests-gssapi \
 python3-rpm \
 python3-six \
 redhat-rpm-config \
 rpkg-common \
 rpm-build \
 rpmdevtools \
 rpmlint \
"
RDEPENDS:rpkg-common = " \
 "
