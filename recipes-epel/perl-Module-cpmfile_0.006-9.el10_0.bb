# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-cpmfile"
PV = "0.006"
PR = "9.el10_0"
PACKAGES = " \
 perl-Module-cpmfile \
 perl-Module-cpmfile-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-cpmfile-0.006-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb8ed904e08a70da38a49502499516ad91479cc95152f024f8caee7b27082418"

URI_x86_64_v2_perl-Module-cpmfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-cpmfile-0.006-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-cpmfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-cpmfile}"
SRC_URI[x86_64_v2_perl-Module-cpmfile.sha256sum] = "1318fdfc002ed49a13498e933e58222dbf873a784be71930aa9b024d0f6306f9"

URI_x86_64_v2_perl-Module-cpmfile-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-cpmfile-tests-0.006-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-cpmfile-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-cpmfile-tests}"
SRC_URI[x86_64_v2_perl-Module-cpmfile-tests.sha256sum] = "49564477e5d05de511baee5e33ab7b8359615c2f835d6ce1bbb35772ef5e5c3b"

URI_aarch64_perl-Module-cpmfile = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-cpmfile-0.006-9.el10_0.noarch.rpm;name=aarch64_perl-Module-cpmfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-cpmfile}"
SRC_URI[aarch64_perl-Module-cpmfile.sha256sum] = "6efa66fe4c31e9ed36c1a71ba4bf54c756f4e3afd400a14fa3ac9feafd6acc1e"

URI_aarch64_perl-Module-cpmfile-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-cpmfile-tests-0.006-9.el10_0.noarch.rpm;name=aarch64_perl-Module-cpmfile-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-cpmfile-tests}"
SRC_URI[aarch64_perl-Module-cpmfile-tests.sha256sum] = "82a754dd43a626bd7a4e73c4586d1f7b3de6b9e9db5e6b35ea7ebca931b3ac6b"

RDEPENDS:perl-Module-cpmfile = " \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-YAML-PP \
 perl-libs \
 "
RDEPENDS:perl-Module-cpmfile-tests = " \
 bash \
 perl-Data-Dumper \
 perl-Module-CPANfile \
 perl-Module-cpmfile \
 perl-Test-Harness \
 perl-Test2-Suite \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
