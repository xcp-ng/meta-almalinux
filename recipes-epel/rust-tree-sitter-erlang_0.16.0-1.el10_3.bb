# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-erlang"
PV = "0.16.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-erlang+default-devel \
 rust-tree-sitter-erlang-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-erlang-0.16.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef11faf743e893a5454cede86be83faacade7036bde1973d562ab2e21b245d91"

URI_x86_64_v2_rust-tree-sitter-erlang+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-erlang+default-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-erlang+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-erlang+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-erlang+default-devel.sha256sum] = "f241af752603d54d0fa9fb779366855dae9bbdfd6e94caa7188135622fe5bb2e"

URI_x86_64_v2_rust-tree-sitter-erlang-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-erlang-devel-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-erlang-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-erlang-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-erlang-devel.sha256sum] = "f51484af11dadd877d713092a3f63702907d6c9cd86ce4d578fb5c0603c032f7"

URI_aarch64_rust-tree-sitter-erlang+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-erlang+default-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-erlang+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-erlang+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-erlang+default-devel.sha256sum] = "1813fc82b77da6ca6acd5c1e40a1fbc38ce449ef9084e5d6dc95340f4ac369a9"

URI_aarch64_rust-tree-sitter-erlang-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-erlang-devel-0.16.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-erlang-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-erlang-devel}"
SRC_URI[aarch64_rust-tree-sitter-erlang-devel.sha256sum] = "9eb97fcc0d652934d91871fdd1815aa0c8b52e1319a8b5ab47c89677e33faf9d"

RDEPENDS:rust-tree-sitter-erlang+default-devel = " \
 cargo \
 rust-tree-sitter-erlang-devel \
 "
RDEPENDS:rust-tree-sitter-erlang-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
