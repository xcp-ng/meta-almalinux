# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dtoa-short"
PV = "0.3.5"
PR = "5.el10_3"
PACKAGES = " \
 rust-dtoa-short+default-devel \
 rust-dtoa-short-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dtoa-short-0.3.5-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f13677e312862a128997c5280b72c4ec700361d77f8f91b33c2a5684faa42ccc"

URI_x86_64_v2_rust-dtoa-short+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dtoa-short+default-devel-0.3.5-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dtoa-short+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dtoa-short+default-devel}"
SRC_URI[x86_64_v2_rust-dtoa-short+default-devel.sha256sum] = "ae108af4c0549521d160d5cd6add4221ce4d3636d9c4c1e6534b505062d2e2b2"

URI_x86_64_v2_rust-dtoa-short-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dtoa-short-devel-0.3.5-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dtoa-short-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dtoa-short-devel}"
SRC_URI[x86_64_v2_rust-dtoa-short-devel.sha256sum] = "fdca37573d3b6bef5543c23528b5aae4d936fee2798052d1039875f93fe71b58"

URI_aarch64_rust-dtoa-short+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dtoa-short+default-devel-0.3.5-5.el10_3.noarch.rpm;name=aarch64_rust-dtoa-short+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dtoa-short+default-devel}"
SRC_URI[aarch64_rust-dtoa-short+default-devel.sha256sum] = "8e310a556feabcf3761e94a748d3e7a6f0c51d7cd25b581ec2ee08ee91285e89"

URI_aarch64_rust-dtoa-short-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dtoa-short-devel-0.3.5-5.el10_3.noarch.rpm;name=aarch64_rust-dtoa-short-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dtoa-short-devel}"
SRC_URI[aarch64_rust-dtoa-short-devel.sha256sum] = "3c46b625633c5621c8e58ad000881a2065bdc6a8cd9b37929fe36ceda3b4a7e0"

RDEPENDS:rust-dtoa-short+default-devel = " \
 cargo \
 rust-dtoa-short-devel \
 "
RDEPENDS:rust-dtoa-short-devel = " \
 cargo \
 rust-dtoa+default-devel \
 "
