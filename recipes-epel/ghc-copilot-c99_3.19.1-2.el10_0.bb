# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-copilot-c99"
PV = "3.19.1"
PR = "2.el10_0"
PACKAGES = " \
 ghc-copilot-c99 \
 ghc-copilot-c99-devel \
 ghc-copilot-c99-doc \
 ghc-copilot-c99-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-copilot-c99-3.19.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20f197aede9dc5266a6e7a6045c85eef75bfa94d72b9ad91360e368118953d6f"

URI_x86_64_v2_ghc-copilot-c99 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-c99-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-c99;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-c99}"
SRC_URI[x86_64_v2_ghc-copilot-c99.sha256sum] = "1af4088724705dc21a37af42a13708f329be3580036479221b8aebc2bf4193b3"

URI_x86_64_v2_ghc-copilot-c99-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-c99-devel-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-c99-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-c99-devel}"
SRC_URI[x86_64_v2_ghc-copilot-c99-devel.sha256sum] = "7d2f90aeb178b01648183edab5fd06cc54eb4de1dbee6ab15e7ccc1cece2b673"

URI_x86_64_v2_ghc-copilot-c99-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-c99-doc-3.19.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-copilot-c99-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-c99-doc}"
SRC_URI[x86_64_v2_ghc-copilot-c99-doc.sha256sum] = "3028c76bb90ad23354246a390a6af00457e190368141033b4ac2742cde15b0ef"

URI_x86_64_v2_ghc-copilot-c99-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-c99-prof-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-c99-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-c99-prof}"
SRC_URI[x86_64_v2_ghc-copilot-c99-prof.sha256sum] = "d5f9b2d7bd525c48db0da489b21f03ac6e32c60ca9b163b46f0cf67add3a1d0a"

URI_aarch64_ghc-copilot-c99 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-c99-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-c99;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-c99}"
SRC_URI[aarch64_ghc-copilot-c99.sha256sum] = "e098dd0147fcb21f051a44f0ffafff0c380acc35194bec1c9c273f1946dfb993"

URI_aarch64_ghc-copilot-c99-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-c99-devel-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-c99-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-c99-devel}"
SRC_URI[aarch64_ghc-copilot-c99-devel.sha256sum] = "dd521bb300bca72f1de1151dec26dad6da373055d0c226811ad9bc327435e020"

URI_aarch64_ghc-copilot-c99-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-c99-doc-3.19.1-2.el10_0.noarch.rpm;name=aarch64_ghc-copilot-c99-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-c99-doc}"
SRC_URI[aarch64_ghc-copilot-c99-doc.sha256sum] = "7c395f9d2e3d2ce5d2215319d0607dcfc8f70b70440730ec729ec9c9b578ccb0"

URI_aarch64_ghc-copilot-c99-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-c99-prof-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-c99-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-c99-prof}"
SRC_URI[aarch64_ghc-copilot-c99-prof.sha256sum] = "094cff06e2ce281257f4e4a6a6bfe339ecda028dfab1af3deb0de2341b44171a"

RDEPENDS:ghc-copilot-c99 = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-copilot-core \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-ieee754 \
 ghc-language-c99 \
 ghc-language-c99-simple \
 ghc-language-c99-util \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-copilot-c99-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-copilot-c99 \
 ghc-copilot-core-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-language-c99-devel \
 ghc-language-c99-simple-devel \
 ghc-mtl-devel \
 ghc-pretty-devel \
 "
RDEPENDS:ghc-copilot-c99-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-copilot-c99-prof = " \
 ghc-base-prof \
 ghc-copilot-c99-devel \
 ghc-copilot-core-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-language-c99-prof \
 ghc-language-c99-simple-prof \
 ghc-mtl-prof \
 ghc-pretty-prof \
 "
