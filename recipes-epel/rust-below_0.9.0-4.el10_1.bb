# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below"
PV = "0.9.0"
PR = "4.el10_1"
PACKAGES = " \
 below \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-below-0.9.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "09350094def3f479f51a1a3ed5ce2ac7354fa3434f91a44a0601522500209406"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/below-0.9.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_below;unpack=0"
SRC_URI[x86_64_v2_below.sha256sum] = "b86ac862eeb13cce22e5b682dfb270df9fc587853ab1be18c8ca2a3bad7131fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/below-0.9.0-4.el10_1.aarch64.rpm;name=aarch64_below;unpack=0"
SRC_URI[aarch64_below.sha256sum] = "7b75b9253032634d504f91ef455688a1abde6f2ef3c4b6287eb3bafb83a77854"

RDEPENDS:below = " \
 bash \
 elfutils-libelf \
 glibc \
 libgcc \
 libzstd \
 zlib-ng-compat \
 "
