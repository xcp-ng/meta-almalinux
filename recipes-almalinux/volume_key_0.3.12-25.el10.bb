# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "volume_key"
PV = "0.3.12"
PR = "25.el10"
PACKAGES = " \
 python3-volume_key \
 volume_key \
 volume_key-devel \
 volume_key-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/volume_key-0.3.12-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b6f9a1daeda279df7ed57d659c36a9bd0ea95f101de53d82b0b4ab720ff6074"

URI_x86_64_v2_python3-volume_key = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-volume_key-0.3.12-25.el10.x86_64_v2.rpm;name=x86_64_v2_python3-volume_key;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-volume_key}"
SRC_URI[x86_64_v2_python3-volume_key.sha256sum] = "86dc503aa39c457a1a41782892c01a90a4841935f323886e294e61f437e096d3"

URI_x86_64_v2_volume_key = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/volume_key-0.3.12-25.el10.x86_64_v2.rpm;name=x86_64_v2_volume_key;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volume_key}"
SRC_URI[x86_64_v2_volume_key.sha256sum] = "5598551bd1ee8fd164d69d5179323950f86fcd8b902821efe7374f5060c88a55"

URI_x86_64_v2_volume_key-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/volume_key-devel-0.3.12-25.el10.x86_64_v2.rpm;name=x86_64_v2_volume_key-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volume_key-devel}"
SRC_URI[x86_64_v2_volume_key-devel.sha256sum] = "ce2f625a58d0460059221b83f47364fe91c3d2a5c38ae7b1117b2810cadd6d8a"

URI_x86_64_v2_volume_key-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/volume_key-libs-0.3.12-25.el10.x86_64_v2.rpm;name=x86_64_v2_volume_key-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volume_key-libs}"
SRC_URI[x86_64_v2_volume_key-libs.sha256sum] = "791107350b811d6d1296b6ad56e38d052318532825a7222afc1335712f9642f9"

URI_aarch64_python3-volume_key = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-volume_key-0.3.12-25.el10.aarch64.rpm;name=aarch64_python3-volume_key;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-volume_key}"
SRC_URI[aarch64_python3-volume_key.sha256sum] = "2e89e767915d62ac25d496ce12180b9984aa63c9cfe804bf1d0f0974f7f7dd87"

URI_aarch64_volume_key = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/volume_key-0.3.12-25.el10.aarch64.rpm;name=aarch64_volume_key;unpack=0"
SRC_URI:append = " ${URI_aarch64_volume_key}"
SRC_URI[aarch64_volume_key.sha256sum] = "5b7ff184dcc8237b870469bd1533595bbaa42be2472c97472dd5fdc908bd78d6"

URI_aarch64_volume_key-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/volume_key-devel-0.3.12-25.el10.aarch64.rpm;name=aarch64_volume_key-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_volume_key-devel}"
SRC_URI[aarch64_volume_key-devel.sha256sum] = "88b32b8917fa533acbe700b84e2147383da669a41e51c0e55670abe3159135de"

URI_aarch64_volume_key-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/volume_key-libs-0.3.12-25.el10.aarch64.rpm;name=aarch64_volume_key-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_volume_key-libs}"
SRC_URI[aarch64_volume_key-libs.sha256sum] = "6396fe109572b55d62c45be4443d11f73993041e5eaa86b35e54597721fc1fa2"

RDEPENDS:python3-volume_key = " \
 cryptsetup-libs \
 glib2 \
 glibc \
 libblkid \
 nspr \
 nss \
 nss-util \
 python3 \
 volume_key-libs \
 "
RDEPENDS:volume_key = " \
 glib2 \
 glibc \
 nspr \
 nss \
 volume_key-libs \
 "
RDEPENDS:volume_key-devel = " \
 volume_key-libs \
 "
RDEPENDS:volume_key-libs = " \
 cryptsetup-libs \
 glib2 \
 glibc \
 libblkid \
 nspr \
 nss \
 nss-util \
 sequoia-sq \
 "
