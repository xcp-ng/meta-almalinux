# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-tempfile"
PV = "23.0.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-tempfile+default-devel \
 rust-gix-tempfile+document-features-devel \
 rust-gix-tempfile+hp-hashmap-devel \
 rust-gix-tempfile+signals-devel \
 rust-gix-tempfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-tempfile-23.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10596bafb3945e12c7f36ec428476fc0d1caac4c974d08c4d6291de0aaef8cf6"

URI_x86_64_v2_rust-gix-tempfile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+default-devel-23.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+default-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+default-devel.sha256sum] = "6091b3ad043ae4ae85694790c1b91d88ac83461abc3e35579be81c185cb9051f"

URI_x86_64_v2_rust-gix-tempfile+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+document-features-devel-23.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+document-features-devel.sha256sum] = "e2e433d2956bf87165806c6f9f3a469e6968449de05314df886a481b2a07c01e"

URI_x86_64_v2_rust-gix-tempfile+hp-hashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+hp-hashmap-devel-23.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+hp-hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+hp-hashmap-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+hp-hashmap-devel.sha256sum] = "f2f486d7f3eab630c02d9ea5bc796a379d5989a4ac7c22e58481aceb0c9f61ee"

URI_x86_64_v2_rust-gix-tempfile+signals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+signals-devel-23.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+signals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+signals-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+signals-devel.sha256sum] = "566284279048947210b83f4d1218cd83abdc71ba04c43b6e545fc4350486a0a7"

URI_x86_64_v2_rust-gix-tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile-devel-23.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile-devel.sha256sum] = "4be5a5fbccb7a6d9c9944b45cfc3a1f6509e15e2c25a11abb57f5226139a21f4"

URI_aarch64_rust-gix-tempfile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+default-devel-23.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+default-devel}"
SRC_URI[aarch64_rust-gix-tempfile+default-devel.sha256sum] = "237b5a1066504ed2c409aeffb3290926f9bbcc99401816f6ee1db32a5633c2be"

URI_aarch64_rust-gix-tempfile+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+document-features-devel-23.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-tempfile+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+document-features-devel}"
SRC_URI[aarch64_rust-gix-tempfile+document-features-devel.sha256sum] = "2f8f77c6c7bb3f1f5f52b3c7251d7d3740d2b88283390111ccbbc86cd681cdc8"

URI_aarch64_rust-gix-tempfile+hp-hashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+hp-hashmap-devel-23.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-tempfile+hp-hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+hp-hashmap-devel}"
SRC_URI[aarch64_rust-gix-tempfile+hp-hashmap-devel.sha256sum] = "d457a89b9dd823243bc3aca05cb993494755bf7fe7bee8351dd3a9270ef28904"

URI_aarch64_rust-gix-tempfile+signals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+signals-devel-23.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-tempfile+signals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+signals-devel}"
SRC_URI[aarch64_rust-gix-tempfile+signals-devel.sha256sum] = "326f13bb91d90c2aac949acce39f00e6c89a7eb58438e45b3dc5a3da9cb3d9ee"

URI_aarch64_rust-gix-tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile-devel-23.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile-devel}"
SRC_URI[aarch64_rust-gix-tempfile-devel.sha256sum] = "1d246844aba3d467e3a2c7007cd5cb4ad8d1f23637acb0cd5e27b9539c6ad227"

RDEPENDS:rust-gix-tempfile+default-devel = " \
 cargo \
 rust-gix-tempfile+hp-hashmap-devel \
 rust-gix-tempfile-devel \
 "
RDEPENDS:rust-gix-tempfile+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-tempfile-devel \
 "
RDEPENDS:rust-gix-tempfile+hp-hashmap-devel = " \
 cargo \
 rust-dashmap+default-devel \
 rust-gix-tempfile-devel \
 "
RDEPENDS:rust-gix-tempfile+signals-devel = " \
 cargo \
 rust-gix-tempfile-devel \
 rust-signal-hook-devel \
 rust-signal-hook-registry+default-devel \
 "
RDEPENDS:rust-gix-tempfile-devel = " \
 cargo \
 rust \
 rust-gix-fs+default-devel \
 rust-libc-devel \
 rust-parking_lot+default-devel \
 rust-tempfile+default-devel \
 "
