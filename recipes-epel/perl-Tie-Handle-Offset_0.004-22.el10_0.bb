# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Tie-Handle-Offset"
PV = "0.004"
PR = "22.el10_0"
PACKAGES = " \
 perl-Tie-Handle-Offset \
 perl-Tie-Handle-Offset-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Tie-Handle-Offset-0.004-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a80aa64a687b22cf8ec34597340cdeb6dd1137f376b34b15f0dbb841bd2e9549"

URI_x86_64_v2_perl-Tie-Handle-Offset = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tie-Handle-Offset-0.004-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tie-Handle-Offset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-Handle-Offset}"
SRC_URI[x86_64_v2_perl-Tie-Handle-Offset.sha256sum] = "fe352d1e6808076b95e21dad7ebf7f1b2f72e6e6653c87e62754f1d89d273b52"

URI_x86_64_v2_perl-Tie-Handle-Offset-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tie-Handle-Offset-tests-0.004-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tie-Handle-Offset-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-Handle-Offset-tests}"
SRC_URI[x86_64_v2_perl-Tie-Handle-Offset-tests.sha256sum] = "932dd9fcc305bd84c5882f4c4c870bb75ecec2181c9a03ef0ef4743b7900a159"

URI_aarch64_perl-Tie-Handle-Offset = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tie-Handle-Offset-0.004-22.el10_0.noarch.rpm;name=aarch64_perl-Tie-Handle-Offset;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-Handle-Offset}"
SRC_URI[aarch64_perl-Tie-Handle-Offset.sha256sum] = "032cfdbb46b0c39a923a381b5124ecadf3994574252f875c9452e5f7fbbaf84c"

URI_aarch64_perl-Tie-Handle-Offset-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tie-Handle-Offset-tests-0.004-22.el10_0.noarch.rpm;name=aarch64_perl-Tie-Handle-Offset-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-Handle-Offset-tests}"
SRC_URI[aarch64_perl-Tie-Handle-Offset-tests.sha256sum] = "383be35bc2c7e59c67e7044cb62f308c8c59696ea6cc932ab40d15e4407d5146"

RDEPENDS:perl-Tie-Handle-Offset = " \
 perl-Tie \
 perl-Tie-Handle-Offset \
 perl-libs \
 "
RDEPENDS:perl-Tie-Handle-Offset-tests = " \
 bash \
 perl-ExtUtils-MakeMaker \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Tie-Handle-Offset \
 perl-interpreter \
 perl-libs \
 "
