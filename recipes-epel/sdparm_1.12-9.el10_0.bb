# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sdparm"
PV = "1.12"
PR = "9.el10_0"
PACKAGES = " \
 sdparm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sdparm-1.12-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae2eb71bf993d0a1edb20e3625a6ff9f3af4d4c6833f02abcd1b2fb9380c54f4"

URI_x86_64_v2_sdparm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sdparm-1.12-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sdparm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sdparm}"
SRC_URI[x86_64_v2_sdparm.sha256sum] = "74a59614aabaa3e913579b3eefbe9fac2a46a232cd434f0d3043c4c04fcb149e"

URI_aarch64_sdparm = "${EPEL_MIRROR}/aarch64/Packages/s/sdparm-1.12-9.el10_0.aarch64.rpm;name=aarch64_sdparm;unpack=0"
SRC_URI:append = " ${URI_aarch64_sdparm}"
SRC_URI[aarch64_sdparm.sha256sum] = "15be2af7a29a6f99bd76118cec0b501a2c3b5a161d9921a133ffc35cff971958"

RDEPENDS:sdparm = " \
 bash \
 glibc \
 "
