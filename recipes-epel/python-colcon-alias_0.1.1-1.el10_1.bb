# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-alias"
PV = "0.1.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-alias \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-alias-0.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca995fc182b7ec05fcd152b69c74b15b60a964666e864be5ad496da1cc4f9ed2"

URI_x86_64_v2_python3-colcon-alias = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-alias-0.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-alias;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-alias}"
SRC_URI[x86_64_v2_python3-colcon-alias.sha256sum] = "22a623ec20f6c7a159377f15d608fee77d6e63ca534eb22480f88c47dcb91a13"

URI_aarch64_python3-colcon-alias = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-alias-0.1.1-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-alias;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-alias}"
SRC_URI[aarch64_python3-colcon-alias.sha256sum] = "933801496e264c12fc28508c08a37d87f4deb39d9e7a28f3c2796823e5f4d111"

RDEPENDS:python3-colcon-alias = " \
 python3 \
 python3-colcon-core \
 python3-filelock \
 python3-pyyaml \
 "
