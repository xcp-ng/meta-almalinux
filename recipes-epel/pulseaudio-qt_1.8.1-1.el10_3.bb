# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pulseaudio-qt"
PV = "1.8.1"
PR = "1.el10_3"
PACKAGES = " \
 pulseaudio-qt-qt6 \
 pulseaudio-qt-qt6-devel \
 pulseaudio-qt-qt6-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pulseaudio-qt-1.8.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3867d3634ae6f4ef8d67d7a3d11abe73b11a46556b9cf74314564b38c81809d7"

URI_x86_64_v2_pulseaudio-qt-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulseaudio-qt-qt6-1.8.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-qt-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-qt-qt6}"
SRC_URI[x86_64_v2_pulseaudio-qt-qt6.sha256sum] = "d970b536b50c3bfaf316abf2ff7d0ec6228b6c60a4c935f84be1196e4d2b642d"

URI_x86_64_v2_pulseaudio-qt-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulseaudio-qt-qt6-devel-1.8.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-qt-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-qt-qt6-devel}"
SRC_URI[x86_64_v2_pulseaudio-qt-qt6-devel.sha256sum] = "4ab2f3dadc9e41eed10502e540f1fa58166544a46a53aa8380f11b062c23d91f"

URI_x86_64_v2_pulseaudio-qt-qt6-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulseaudio-qt-qt6-doc-1.8.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-qt-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-qt-qt6-doc}"
SRC_URI[x86_64_v2_pulseaudio-qt-qt6-doc.sha256sum] = "9df8fa6e0969469196996007f18e0a1c9666ae985c8a69b1095663a27feefdab"

URI_aarch64_pulseaudio-qt-qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/pulseaudio-qt-qt6-1.8.1-1.el10_3.aarch64.rpm;name=aarch64_pulseaudio-qt-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-qt-qt6}"
SRC_URI[aarch64_pulseaudio-qt-qt6.sha256sum] = "5be4317821c454336c37771c130331d9cd758e972780e5f4ac0ad9317615d032"

URI_aarch64_pulseaudio-qt-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pulseaudio-qt-qt6-devel-1.8.1-1.el10_3.aarch64.rpm;name=aarch64_pulseaudio-qt-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-qt-qt6-devel}"
SRC_URI[aarch64_pulseaudio-qt-qt6-devel.sha256sum] = "e9330cc5df92e2a31ed00def335912a33d6fc13cc9cb376eba1d6de633c67851"

URI_aarch64_pulseaudio-qt-qt6-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pulseaudio-qt-qt6-doc-1.8.1-1.el10_3.aarch64.rpm;name=aarch64_pulseaudio-qt-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-qt-qt6-doc}"
SRC_URI[aarch64_pulseaudio-qt-qt6-doc.sha256sum] = "4e30c22d5fa251bd627d458f1ccfdd70f64dd24f5e50d0e133c01b915703f193"

RDEPENDS:pulseaudio-qt-qt6 = " \
 glibc \
 libstdc++ \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pulseaudio-qt-qt6-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pulseaudio-qt-qt6 \
 qt6-qtbase-devel \
 "
RDEPENDS:pulseaudio-qt-qt6-doc = " \
 "
