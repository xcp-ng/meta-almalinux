# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-log"
PV = "0.4.29"
PR = "1.el10_1"
PACKAGES = " \
 rust-log+default-devel \
 rust-log+kv-devel \
 rust-log+max_level_debug-devel \
 rust-log+max_level_error-devel \
 rust-log+max_level_info-devel \
 rust-log+max_level_off-devel \
 rust-log+max_level_trace-devel \
 rust-log+max_level_warn-devel \
 rust-log+release_max_level_debug-devel \
 rust-log+release_max_level_error-devel \
 rust-log+release_max_level_info-devel \
 rust-log+release_max_level_off-devel \
 rust-log+release_max_level_trace-devel \
 rust-log+release_max_level_warn-devel \
 rust-log+serde-devel \
 rust-log+serde_core-devel \
 rust-log+std-devel \
 rust-log-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-log-0.4.29-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a8d490ffbcc0683bab6603fed024c953ea2d4ac43e0888e7c5fb9d13504e115"

URI_x86_64_v2_rust-log+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+default-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+default-devel}"
SRC_URI[x86_64_v2_rust-log+default-devel.sha256sum] = "047dd9cbc958d9d83507f4f04144d045f84f1cf82fda250b7574153016dcddfe"

URI_x86_64_v2_rust-log+kv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+kv-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+kv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+kv-devel}"
SRC_URI[x86_64_v2_rust-log+kv-devel.sha256sum] = "d35b579e74eb2a44db48e0b278033f65f049d49882185877abcfc0ffa3ba8a49"

URI_x86_64_v2_rust-log+max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_debug-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_debug-devel.sha256sum] = "53e1243ece3f6c35b03d476c19d1fa5d64541001f7bfa4ccb4f750e94baf6092"

URI_x86_64_v2_rust-log+max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_error-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_error-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_error-devel.sha256sum] = "d0bc9b6224f49318f888f7a47958ff2398e6bc1df515edc50828837b69ca88df"

URI_x86_64_v2_rust-log+max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_info-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_info-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_info-devel.sha256sum] = "def78e327d44b6f5cb6e9b34e6f8ae254246ab97ab05e4827885e6a7943ab1df"

URI_x86_64_v2_rust-log+max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_off-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_off-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_off-devel.sha256sum] = "1fc3846abeb278f6e342bf2fab6e86cb763904735ec08fb600b4023a5069bdd4"

URI_x86_64_v2_rust-log+max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_trace-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_trace-devel.sha256sum] = "328756cca5a8ece3771642d2f684e14ddb27edd25db283d24d0b42e499a6fd71"

URI_x86_64_v2_rust-log+max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_warn-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_warn-devel.sha256sum] = "83cb786d7a63540f2e43026d8eec219acd5c66d9400e57b8567f8d92275356de"

URI_x86_64_v2_rust-log+release_max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_debug-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_debug-devel.sha256sum] = "953e5a4b20e82abe14391ff491d4a6ab6789c039d038e563499eb0ca86f19bae"

URI_x86_64_v2_rust-log+release_max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_error-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_error-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_error-devel.sha256sum] = "e2807fabc5bca49374b4ce09f18bf445f11c1f76889b85e9f6c1cf6393dee2e6"

URI_x86_64_v2_rust-log+release_max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_info-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_info-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_info-devel.sha256sum] = "e0a00b2e0f7b3cce7a4ffe86e4c8af658e7314f3dcc5a593c0a8d76404276397"

URI_x86_64_v2_rust-log+release_max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_off-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_off-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_off-devel.sha256sum] = "41bf0bbf6d6f5a975f13aef9417b81b6a875c148c93e9b494c916a142091cfe4"

URI_x86_64_v2_rust-log+release_max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_trace-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_trace-devel.sha256sum] = "19b7fe1f18f5ece3c27dcd35202aa2100e4deeb93e91e1e5525ab2617b4834c8"

URI_x86_64_v2_rust-log+release_max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_warn-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_warn-devel.sha256sum] = "03e1363a8fcd09ab22e498c6fb39b2f7fe48551a529818e2df22e54942b6d1ab"

URI_x86_64_v2_rust-log+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+serde-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+serde-devel}"
SRC_URI[x86_64_v2_rust-log+serde-devel.sha256sum] = "0058f8e2e1d9d6fd2f664c9dc01f78a2429eaaa0dc4d07b664b991295a262267"

URI_x86_64_v2_rust-log+serde_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+serde_core-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+serde_core-devel}"
SRC_URI[x86_64_v2_rust-log+serde_core-devel.sha256sum] = "d8fcc8183f4873375f89645d77edb02cec7423022e97144f62db13b5aff7d858"

URI_x86_64_v2_rust-log+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+std-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+std-devel}"
SRC_URI[x86_64_v2_rust-log+std-devel.sha256sum] = "393282a7cb6289d75c86ea61dc808055824a8013b06a7d1dfbc8b56f1dc6a37e"

URI_x86_64_v2_rust-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log-devel-0.4.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log-devel}"
SRC_URI[x86_64_v2_rust-log-devel.sha256sum] = "dd819c62e95f057e993431f4455aec446c07c237d87821fe22fe4e17bf075c4e"

URI_aarch64_rust-log+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+default-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+default-devel}"
SRC_URI[aarch64_rust-log+default-devel.sha256sum] = "256df94f88483370a1d9b16a39255ee533ddefde26c643d13b54e14bd009ea92"

URI_aarch64_rust-log+kv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+kv-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+kv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+kv-devel}"
SRC_URI[aarch64_rust-log+kv-devel.sha256sum] = "82aa3ddc0154a6ed87459b05d67ab6ba52fbeba7154941edf9cf11f673e71ec8"

URI_aarch64_rust-log+max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_debug-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_debug-devel}"
SRC_URI[aarch64_rust-log+max_level_debug-devel.sha256sum] = "84fea74ab8cab9f8f1682785f51772dc555d3f53f904a57f8c61212bcd5b4a6e"

URI_aarch64_rust-log+max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_error-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_error-devel}"
SRC_URI[aarch64_rust-log+max_level_error-devel.sha256sum] = "20e2d40ccd64c7f80e56f554d539cb5f9ea7f7185908891cd1163ab0bd33839e"

URI_aarch64_rust-log+max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_info-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_info-devel}"
SRC_URI[aarch64_rust-log+max_level_info-devel.sha256sum] = "d1a44b9f1bfa039f536733a1952c6bfd74726f98410522dd1f7fbb4de535d292"

URI_aarch64_rust-log+max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_off-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_off-devel}"
SRC_URI[aarch64_rust-log+max_level_off-devel.sha256sum] = "bb7d5442007c6d2a6c8ec493721b3d705f7d0939fccf282f2530ff2cba8e0014"

URI_aarch64_rust-log+max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_trace-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_trace-devel}"
SRC_URI[aarch64_rust-log+max_level_trace-devel.sha256sum] = "42fbe1cd1f3883c21be1140146afb52ac30d1bf2461979932054f62a2009917f"

URI_aarch64_rust-log+max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_warn-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_warn-devel}"
SRC_URI[aarch64_rust-log+max_level_warn-devel.sha256sum] = "12855854cd110018128c83e4dcbbfd419bcb208955faf49bc500efe319909c6d"

URI_aarch64_rust-log+release_max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_debug-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_debug-devel}"
SRC_URI[aarch64_rust-log+release_max_level_debug-devel.sha256sum] = "70b569deb97059815b8add485b78412c83d6897495105f5b50453a0794f6d9f3"

URI_aarch64_rust-log+release_max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_error-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_error-devel}"
SRC_URI[aarch64_rust-log+release_max_level_error-devel.sha256sum] = "51c8e6562bada958a839cd359801b11e98c1222d114e347dc376d566ceecdc3c"

URI_aarch64_rust-log+release_max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_info-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_info-devel}"
SRC_URI[aarch64_rust-log+release_max_level_info-devel.sha256sum] = "6dd412bca6488bf26a318fc823e6f0c0454ac4d2d0949f5e2622433da8edd708"

URI_aarch64_rust-log+release_max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_off-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_off-devel}"
SRC_URI[aarch64_rust-log+release_max_level_off-devel.sha256sum] = "b155d6e84025cfba53acfaaceb736b428d34a9f53749c320ccc7782e25c95a7e"

URI_aarch64_rust-log+release_max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_trace-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_trace-devel}"
SRC_URI[aarch64_rust-log+release_max_level_trace-devel.sha256sum] = "a50c0c7acf4cd7b5d7f58824deaf701c274bc48706a5b9fd7f9bfc55d9f2f1fe"

URI_aarch64_rust-log+release_max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_warn-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_warn-devel}"
SRC_URI[aarch64_rust-log+release_max_level_warn-devel.sha256sum] = "dbc3b3125f97da23da1ce372b9c8bc2ae3e86a869b78351407fdc28044a93c78"

URI_aarch64_rust-log+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+serde-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+serde-devel}"
SRC_URI[aarch64_rust-log+serde-devel.sha256sum] = "8d06262dcf067e5fe2036064556db335ee872b7154e34256db64680001c7b697"

URI_aarch64_rust-log+serde_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+serde_core-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+serde_core-devel}"
SRC_URI[aarch64_rust-log+serde_core-devel.sha256sum] = "36aea72056ffedcab3678fcbc0f1c9cd07421297f7d3ef9178e5cb83c5feaf5c"

URI_aarch64_rust-log+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+std-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+std-devel}"
SRC_URI[aarch64_rust-log+std-devel.sha256sum] = "ae8d95634f46dc02a8eec19f03d679b3dca31f3487ae8a4d744c8e88c66b2537"

URI_aarch64_rust-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log-devel-0.4.29-1.el10_1.noarch.rpm;name=aarch64_rust-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log-devel}"
SRC_URI[aarch64_rust-log-devel.sha256sum] = "d12f89ca9d169dca4ad7e6d2925259930b76c1f79ca80fcad437a453963cb8a4"

RDEPENDS:rust-log+default-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+kv-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_debug-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_error-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_info-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_off-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_trace-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_warn-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_debug-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_error-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_info-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_off-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_trace-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_warn-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+serde-devel = " \
 cargo \
 rust-log+serde_core-devel \
 rust-log-devel \
 "
RDEPENDS:rust-log+serde_core-devel = " \
 cargo \
 rust-log-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-log+std-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log-devel = " \
 cargo \
 rust \
 "
