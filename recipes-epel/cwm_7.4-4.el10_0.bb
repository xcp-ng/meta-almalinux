# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cwm"
PV = "7.4"
PR = "4.el10_0"
PACKAGES = " \
 cwm \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cwm-7.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "418df3ea487fa763366c01a261782531fc864b010537ebd18da8be9ce4d02251"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cwm-7.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cwm;unpack=0"
SRC_URI[x86_64_v2_cwm.sha256sum] = "467d03e175b5036dcfb7e869eb8c6a363e207edf6cdd5b81022e407478686a41"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cwm-7.4-4.el10_0.aarch64.rpm;name=aarch64_cwm;unpack=0"
SRC_URI[aarch64_cwm.sha256sum] = "c8e080f1cb354f90a7976595c2664e224b834c5bf251dde4a0a2bd6971df6605"

RDEPENDS:cwm = " \
 glibc \
 libX11 \
 libXft \
 libXrandr \
 "
