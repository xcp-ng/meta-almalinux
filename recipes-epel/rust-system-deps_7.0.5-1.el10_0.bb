# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-system-deps"
PV = "7.0.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-system-deps+default-devel \
 rust-system-deps-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-system-deps-7.0.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20532c78d6c745f87510d9bb0fab303911b92f49584f1d57d55f6990a381cc89"

URI_x86_64_v2_rust-system-deps+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-system-deps+default-devel-7.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-system-deps+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-system-deps+default-devel}"
SRC_URI[x86_64_v2_rust-system-deps+default-devel.sha256sum] = "573a0d64acd4c2ecbe437b45f51721b75182cceed3b1e3a74f8876075772b91f"

URI_x86_64_v2_rust-system-deps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-system-deps-devel-7.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-system-deps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-system-deps-devel}"
SRC_URI[x86_64_v2_rust-system-deps-devel.sha256sum] = "8dc2ef65190b7d6243c14029a299a756ac07832c00c9cb7075be9b56ef24bd25"

URI_aarch64_rust-system-deps+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-system-deps+default-devel-7.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-system-deps+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-system-deps+default-devel}"
SRC_URI[aarch64_rust-system-deps+default-devel.sha256sum] = "ccf2aa298f2406b1f70ec7ff43f8b7b7c89db5b98d78a6ce9d321f8900fe8e43"

URI_aarch64_rust-system-deps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-system-deps-devel-7.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-system-deps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-system-deps-devel}"
SRC_URI[aarch64_rust-system-deps-devel.sha256sum] = "e965cbacbe1c520242acc2b92f57690a0e6a67b8b3323fcf6943693ad52668af"

RDEPENDS:rust-system-deps+default-devel = " \
 cargo \
 rust-system-deps-devel \
 "
RDEPENDS:rust-system-deps-devel = " \
 cargo \
 rust \
 rust-cfg-expr+default-devel \
 rust-cfg-expr+targets-devel \
 rust-heck+default-devel \
 rust-pkg-config+default-devel \
 rust-toml+parse-devel \
 rust-toml-devel \
 rust-version-compare+default-devel \
 "
