# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ptr_meta_derive"
PV = "0.3.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-ptr_meta_derive+default-devel \
 rust-ptr_meta_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ptr_meta_derive-0.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5bc5338b9c89e3eed123221cfc33c8ed56e8f9640642f86c4f0ba035afc639b"

URI_x86_64_v2_rust-ptr_meta_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta_derive+default-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta_derive+default-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta_derive+default-devel.sha256sum] = "e4b21cd0ccdf290dabcc0c2939a1ed6ba2f68ed881ef205755f7764379a30b9f"

URI_x86_64_v2_rust-ptr_meta_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta_derive-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta_derive-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta_derive-devel.sha256sum] = "b19d0038e0a0f181e7ffb7fde8e441a4f5b69cc5f95e5b9acf87de09894b7c43"

URI_aarch64_rust-ptr_meta_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta_derive+default-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-ptr_meta_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta_derive+default-devel}"
SRC_URI[aarch64_rust-ptr_meta_derive+default-devel.sha256sum] = "6985dc18817e8ad0777125441386233d7d1836ee0ba5c42a381fdfa48abb8005"

URI_aarch64_rust-ptr_meta_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta_derive-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta_derive-devel}"
SRC_URI[aarch64_rust-ptr_meta_derive-devel.sha256sum] = "7177325fd40c6ff0856884a0cf74862051ec4df032d62251256df54f1032aba2"

RDEPENDS:rust-ptr_meta_derive+default-devel = " \
 cargo \
 rust-ptr_meta_derive-devel \
 "
RDEPENDS:rust-ptr_meta_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
