# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-perlfaq"
PV = "5.20240218"
PR = "511.el10"
PACKAGES = " \
 perl-perlfaq \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-perlfaq-5.20240218-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a33dee75e1c54b8da86b88b0fed3aac4b28d97cd681442ff1e94042a852d59c4"

URI_x86_64_v2_perl-perlfaq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-perlfaq-5.20240218-511.el10.noarch.rpm;name=x86_64_v2_perl-perlfaq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-perlfaq}"
SRC_URI[x86_64_v2_perl-perlfaq.sha256sum] = "6faef71d77d814ed09b4ff2478987a6c79d2da894214e7ddb190f82917844482"

URI_aarch64_perl-perlfaq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-perlfaq-5.20240218-511.el10.noarch.rpm;name=aarch64_perl-perlfaq;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-perlfaq}"
SRC_URI[aarch64_perl-perlfaq.sha256sum] = "6faef71d77d814ed09b4ff2478987a6c79d2da894214e7ddb190f82917844482"

RDEPENDS:perl-perlfaq = " \
 perl-libs \
 "
