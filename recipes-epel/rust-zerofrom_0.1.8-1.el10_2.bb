# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerofrom"
PV = "0.1.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-zerofrom+alloc-devel \
 rust-zerofrom+default-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerofrom-0.1.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5130bace1c299c58d81e06191312428df1f53cf5a72902e4e020ed11d452957e"

URI_x86_64_v2_rust-zerofrom+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom+alloc-devel-0.1.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerofrom+alloc-devel.sha256sum] = "bdaad08004ccda42f92e441b31b8f3b222aa2fad01dce12f55b2609584481d91"

URI_x86_64_v2_rust-zerofrom+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom+default-devel-0.1.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom+default-devel}"
SRC_URI[x86_64_v2_rust-zerofrom+default-devel.sha256sum] = "4ff2801af128324dfb64d678f1b42876f1b6a64907ac674fd0fd6d358fa321c7"

URI_x86_64_v2_rust-zerofrom+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom+derive-devel-0.1.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom+derive-devel}"
SRC_URI[x86_64_v2_rust-zerofrom+derive-devel.sha256sum] = "1b5c846f189f1f09d0f378e36b1bdffa3dc6b712a5e2d46e6bfeb5c35ea1b968"

URI_x86_64_v2_rust-zerofrom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom-devel-0.1.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom-devel}"
SRC_URI[x86_64_v2_rust-zerofrom-devel.sha256sum] = "4ab9f50501f5ea0f868ef2343606908746da5a09f64a8f568e4362972217d26a"

URI_aarch64_rust-zerofrom+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom+alloc-devel-0.1.8-1.el10_2.noarch.rpm;name=aarch64_rust-zerofrom+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom+alloc-devel}"
SRC_URI[aarch64_rust-zerofrom+alloc-devel.sha256sum] = "a5560ce9cefea8dcd9c6a7743e8f3916e9730a0e7cb6f168e11fb5dd01e48804"

URI_aarch64_rust-zerofrom+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom+default-devel-0.1.8-1.el10_2.noarch.rpm;name=aarch64_rust-zerofrom+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom+default-devel}"
SRC_URI[aarch64_rust-zerofrom+default-devel.sha256sum] = "f22ae27748294102cbf2671767b25c58ec33741e4a369745ddc5f7c857efedea"

URI_aarch64_rust-zerofrom+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom+derive-devel-0.1.8-1.el10_2.noarch.rpm;name=aarch64_rust-zerofrom+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom+derive-devel}"
SRC_URI[aarch64_rust-zerofrom+derive-devel.sha256sum] = "afacbad35fa66c516ce38aa69766dff0621e777e53e323aac74c54607bce2c3e"

URI_aarch64_rust-zerofrom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom-devel-0.1.8-1.el10_2.noarch.rpm;name=aarch64_rust-zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom-devel}"
SRC_URI[aarch64_rust-zerofrom-devel.sha256sum] = "7991edbbf0c3aa2eb96dd8300985e670b3f9f3f9460aa3bf60dab549940e99cd"

RDEPENDS:rust-zerofrom+alloc-devel = " \
 cargo \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-zerofrom+default-devel = " \
 cargo \
 rust-zerofrom+alloc-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-zerofrom+derive-devel = " \
 cargo \
 rust-zerofrom-derive-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-zerofrom-devel = " \
 cargo \
 rust \
 "
