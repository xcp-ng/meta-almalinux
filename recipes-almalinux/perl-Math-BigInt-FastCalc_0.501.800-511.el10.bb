# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Math-BigInt-FastCalc"
PV = "0.501.800"
PR = "511.el10"
PACKAGES = " \
 perl-Math-BigInt-FastCalc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Math-BigInt-FastCalc-0.501.800-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5816eb567de226e54bba08e0abd3d1d6e1353530cc1182d85b8aa8ac75037b5b"

URI_x86_64_v2_perl-Math-BigInt-FastCalc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Math-BigInt-FastCalc-0.501.800-511.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Math-BigInt-FastCalc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Math-BigInt-FastCalc}"
SRC_URI[x86_64_v2_perl-Math-BigInt-FastCalc.sha256sum] = "68b9cde3de4e49221e256bd7beb9742ccf26902f01ea59e4d6245d4ab721cfed"

URI_aarch64_perl-Math-BigInt-FastCalc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Math-BigInt-FastCalc-0.501.800-511.el10.aarch64.rpm;name=aarch64_perl-Math-BigInt-FastCalc;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Math-BigInt-FastCalc}"
SRC_URI[aarch64_perl-Math-BigInt-FastCalc.sha256sum] = "b88a4d4e349f4bcbe54354394e1d46cb2e4351b2a7d2b83a68dae7cef9ca015a"

RDEPENDS:perl-Math-BigInt-FastCalc = " \
 glibc \
 perl-Carp \
 perl-Math-BigInt \
 perl-libs \
 "
