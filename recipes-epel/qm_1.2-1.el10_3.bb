# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qm"
PV = "1.2"
PR = "1.el10_3"
PACKAGES = " \
 qm \
 qm-ctl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qm-1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e50882d9515e9660f7c1ed985ee494a1249cab09728481ba0548a8ca4ce959d"

URI_x86_64_v2_qm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qm-1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_qm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qm}"
SRC_URI[x86_64_v2_qm.sha256sum] = "0d85c14f75e802d6c8e3961039383c3bbbbddaa3579937c9b2e0dd11a6c277b3"

URI_x86_64_v2_qm-ctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qm-ctl-1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_qm-ctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qm-ctl}"
SRC_URI[x86_64_v2_qm-ctl.sha256sum] = "f4551721bce594f7d22ab358288e321a260d189cc68caa68fc3e907808d99e33"

URI_aarch64_qm = "${EPEL_MIRROR}/aarch64/Packages/q/qm-1.2-1.el10_3.noarch.rpm;name=aarch64_qm;unpack=0"
SRC_URI:append = " ${URI_aarch64_qm}"
SRC_URI[aarch64_qm.sha256sum] = "743f7e672552898fbca5b2ea537ff84e4e312a42cb70bff4e1e0811a0f2ec001"

URI_aarch64_qm-ctl = "${EPEL_MIRROR}/aarch64/Packages/q/qm-ctl-1.2-1.el10_3.noarch.rpm;name=aarch64_qm-ctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qm-ctl}"
SRC_URI[aarch64_qm-ctl.sha256sum] = "738a6f252c42c407100a6873ed5e7fe9f2e73faf4a15005e193848b04819b948"

RDEPENDS:qm = " \
 bash \
 containers-common \
 jq \
 libselinux-utils \
 parted \
 podman \
 policycoreutils \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.25 \
 "
RDEPENDS:qm-ctl = " \
 python3 \
 qm \
 "
