# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-asn1-rs-impl"
PV = "0.2.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-asn1-rs-impl+default-devel \
 rust-asn1-rs-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-asn1-rs-impl-0.2.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7671e58360ed12a397999970ec86d64f7f33b66e66a1081f5cbd7f424540291"

URI_x86_64_v2_rust-asn1-rs-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs-impl+default-devel-0.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs-impl+default-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs-impl+default-devel.sha256sum] = "a4e7013c044e593e7dea0564dbcd9dff58a65762f39521bb35c41f44036079d7"

URI_x86_64_v2_rust-asn1-rs-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs-impl-devel-0.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs-impl-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs-impl-devel.sha256sum] = "6e15b59a594d2482ade24c6d6fb3c436593e16b0f195dd8c607cf5980e10d07a"

URI_aarch64_rust-asn1-rs-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs-impl+default-devel-0.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs-impl+default-devel}"
SRC_URI[aarch64_rust-asn1-rs-impl+default-devel.sha256sum] = "15496427108cb625f1b8d48aa0407b7f1cea70ffd11f97ad186aa9b4a538f2ce"

URI_aarch64_rust-asn1-rs-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs-impl-devel-0.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs-impl-devel}"
SRC_URI[aarch64_rust-asn1-rs-impl-devel.sha256sum] = "83966079d11be157db480c8e4af3bdeaba3ac62f3ed6e28dbb68f480d2bdb521"

RDEPENDS:rust-asn1-rs-impl+default-devel = " \
 cargo \
 rust-asn1-rs-impl-devel \
 "
RDEPENDS:rust-asn1-rs-impl-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
