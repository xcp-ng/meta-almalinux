# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdc1394"
PV = "2.2.7"
PR = "6.el10_0"
PACKAGES = " \
 libdc1394 \
 libdc1394-devel \
 libdc1394-docs \
 libdc1394-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdc1394-2.2.7-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9b3e945314943a3f8d96ecb65b48b19883d7742063e72f78bdb5115f5a0f6ee"

URI_x86_64_v2_libdc1394 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdc1394-2.2.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdc1394;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdc1394}"
SRC_URI[x86_64_v2_libdc1394.sha256sum] = "4a2abf226ac3c52279a9811b76122e4ad9296592d3f497f8b73a79c219223a65"

URI_x86_64_v2_libdc1394-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdc1394-devel-2.2.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdc1394-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdc1394-devel}"
SRC_URI[x86_64_v2_libdc1394-devel.sha256sum] = "274c49aeccb7b3c1c1caa773ab650fef6a70a1adced8f9ba30ccf23210acec8b"

URI_x86_64_v2_libdc1394-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdc1394-docs-2.2.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdc1394-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdc1394-docs}"
SRC_URI[x86_64_v2_libdc1394-docs.sha256sum] = "35dd2d1bea1ed1471bc2a17e51d7d2ee7c32ac91bc5deb6e40005c597cc8d215"

URI_x86_64_v2_libdc1394-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdc1394-tools-2.2.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdc1394-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdc1394-tools}"
SRC_URI[x86_64_v2_libdc1394-tools.sha256sum] = "7d927b9904550826a1f559ac50f28e3100ac3e75fcc634b35e5bbf812f9d239d"

URI_aarch64_libdc1394 = "${EPEL_MIRROR}/aarch64/Packages/l/libdc1394-2.2.7-6.el10_0.aarch64.rpm;name=aarch64_libdc1394;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdc1394}"
SRC_URI[aarch64_libdc1394.sha256sum] = "c934b7dd2b1fa2ffa3da5f486bdc0c2f9b6850f54177550587b57b0bcbf902b7"

URI_aarch64_libdc1394-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdc1394-devel-2.2.7-6.el10_0.aarch64.rpm;name=aarch64_libdc1394-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdc1394-devel}"
SRC_URI[aarch64_libdc1394-devel.sha256sum] = "3b4363464f0d2013e8c608b88394c5122e370204d95e4c2e621a4b57db15d87f"

URI_aarch64_libdc1394-docs = "${EPEL_MIRROR}/aarch64/Packages/l/libdc1394-docs-2.2.7-6.el10_0.aarch64.rpm;name=aarch64_libdc1394-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdc1394-docs}"
SRC_URI[aarch64_libdc1394-docs.sha256sum] = "3e10ffee447e1805cfd724ed36c3ad4d3f641575df651636126377f42ad05fc2"

URI_aarch64_libdc1394-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libdc1394-tools-2.2.7-6.el10_0.aarch64.rpm;name=aarch64_libdc1394-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdc1394-tools}"
SRC_URI[aarch64_libdc1394-tools.sha256sum] = "cc5b523e386cb2b8054396b3ca9ee1cef8a64afa2cdf7bef6a1586019aba44c6"

RDEPENDS:libdc1394 = " \
 glibc \
 libraw1394 \
 libusb1 \
 "
RDEPENDS:libdc1394-devel = " \
 libdc1394 \
 libraw1394-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libdc1394-docs = " \
 "
RDEPENDS:libdc1394-tools = " \
 bash \
 glibc \
 libdc1394 \
 "
