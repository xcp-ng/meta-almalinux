# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-databake-derive"
PV = "0.2.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-databake-derive+default-devel \
 rust-databake-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-databake-derive-0.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dec4715c9ebe7b3d2ac922aab79fe926bfbacf77fa1ab3a38d585bdd58a28336"

URI_x86_64_v2_rust-databake-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake-derive+default-devel-0.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake-derive+default-devel}"
SRC_URI[x86_64_v2_rust-databake-derive+default-devel.sha256sum] = "f935164f73165c70766d56a7c5cd8a1afca6f082017e2f5fd41bd12c36db8e39"

URI_x86_64_v2_rust-databake-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake-derive-devel-0.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake-derive-devel}"
SRC_URI[x86_64_v2_rust-databake-derive-devel.sha256sum] = "f64f50566d860a80b94189ed0734fdd3defc1abcd7c921b17dc6d9b20ad42a46"

URI_aarch64_rust-databake-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake-derive+default-devel-0.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-databake-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake-derive+default-devel}"
SRC_URI[aarch64_rust-databake-derive+default-devel.sha256sum] = "403d2b00870e2c30c2ac04f5f51bf217d91074f83e91db5bf744c2bd25e056c1"

URI_aarch64_rust-databake-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake-derive-devel-0.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-databake-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake-derive-devel}"
SRC_URI[aarch64_rust-databake-derive-devel.sha256sum] = "3396457245d2fb63348cc33665608e162a9949c6f6fd01f94c2f092765e72d55"

RDEPENDS:rust-databake-derive+default-devel = " \
 cargo \
 rust-databake-derive-devel \
 "
RDEPENDS:rust-databake-derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-synstructure+default-devel \
 "
