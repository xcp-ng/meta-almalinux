# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-curl"
PV = "0.4.50"
PR = "1.el10_2"
PACKAGES = " \
 rust-curl+default-devel \
 rust-curl+http2-devel \
 rust-curl+ntlm-devel \
 rust-curl+openssl-probe-devel \
 rust-curl+openssl-sys-devel \
 rust-curl+poll_7_68_0-devel \
 rust-curl+protocol-ftp-devel \
 rust-curl+spnego-devel \
 rust-curl+ssl-devel \
 rust-curl+upkeep_7_62_0-devel \
 rust-curl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-curl-0.4.50-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4a94f02cc813038c867c872ce9cc8750f1571eb04c258ad8ac7badc6f91e5ee"

URI_x86_64_v2_rust-curl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+default-devel-0.4.50-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+default-devel}"
SRC_URI[x86_64_v2_rust-curl+default-devel.sha256sum] = "db495e104f40d0fd4e4db9f2538d3ffabe0480887bc800abed7921c90ad2b1ab"

URI_x86_64_v2_rust-curl+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+http2-devel-0.4.50-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+http2-devel}"
SRC_URI[x86_64_v2_rust-curl+http2-devel.sha256sum] = "021becc049a45cecb1a8fb798723b6d5024bf70724d6a59f749e999f74327e4d"

URI_x86_64_v2_rust-curl+ntlm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+ntlm-devel-0.4.50-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+ntlm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+ntlm-devel}"
SRC_URI[x86_64_v2_rust-curl+ntlm-devel.sha256sum] = "093f81a9393b9eee82e2c98e6723886d1088a55b5a6179233061ac1e55634efc"

URI_x86_64_v2_rust-curl+openssl-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+openssl-probe-devel-0.4.50-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+openssl-probe-devel}"
SRC_URI[x86_64_v2_rust-curl+openssl-probe-devel.sha256sum] = "5d8af1e3392dfdd3cf7f8dab3e81e2d2d6fb066f7bef7b7d15ddd6c1d2765afc"

URI_x86_64_v2_rust-curl+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+openssl-sys-devel-0.4.50-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-curl+openssl-sys-devel.sha256sum] = "df497dbee951aa4fda28cf5a24f0d655aace6c82fe8f0bf369386e55c8ec77e2"

URI_x86_64_v2_rust-curl+poll_7_68_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+poll_7_68_0-devel-0.4.50-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+poll_7_68_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+poll_7_68_0-devel}"
SRC_URI[x86_64_v2_rust-curl+poll_7_68_0-devel.sha256sum] = "f20b062b7d35c032a1c685b961bfb2bf0933e7a760684ada035df65c32f175f6"

URI_x86_64_v2_rust-curl+protocol-ftp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+protocol-ftp-devel-0.4.50-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+protocol-ftp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+protocol-ftp-devel}"
SRC_URI[x86_64_v2_rust-curl+protocol-ftp-devel.sha256sum] = "946f8e965ef9c5121ea2a05743a247388c2f5a8636ec222ffa96762d35b986de"

URI_x86_64_v2_rust-curl+spnego-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+spnego-devel-0.4.50-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+spnego-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+spnego-devel}"
SRC_URI[x86_64_v2_rust-curl+spnego-devel.sha256sum] = "f7606a15efec2bf98cc9c515b7e222950699d5fe2d0ef7149158f1a89f31413a"

URI_x86_64_v2_rust-curl+ssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+ssl-devel-0.4.50-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+ssl-devel}"
SRC_URI[x86_64_v2_rust-curl+ssl-devel.sha256sum] = "6227a8969a18efd09b8f68adcd14d5a821f0078f6cc12b95c998fbac94b5489d"

URI_x86_64_v2_rust-curl+upkeep_7_62_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+upkeep_7_62_0-devel-0.4.50-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+upkeep_7_62_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+upkeep_7_62_0-devel}"
SRC_URI[x86_64_v2_rust-curl+upkeep_7_62_0-devel.sha256sum] = "2d0e12895bd3f421d45b5565ab900ee01e145f516964446e0601e8b989bd650d"

URI_x86_64_v2_rust-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-devel-0.4.50-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-devel}"
SRC_URI[x86_64_v2_rust-curl-devel.sha256sum] = "ac5662141e1b65431632d1d34690c112cd1bcb9ecc369d635a161f71eb8fb7b8"

URI_aarch64_rust-curl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+default-devel-0.4.50-1.el10_2.noarch.rpm;name=aarch64_rust-curl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+default-devel}"
SRC_URI[aarch64_rust-curl+default-devel.sha256sum] = "a501e1a0374918e7bbfafeb5d4d54928f5381fb73da63f76bdaed403f39372da"

URI_aarch64_rust-curl+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+http2-devel-0.4.50-1.el10_2.noarch.rpm;name=aarch64_rust-curl+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+http2-devel}"
SRC_URI[aarch64_rust-curl+http2-devel.sha256sum] = "cd69a6c82c163082056d423e7913691186376e51fa5c413e507b1834b96b9663"

URI_aarch64_rust-curl+ntlm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+ntlm-devel-0.4.50-1.el10_2.noarch.rpm;name=aarch64_rust-curl+ntlm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+ntlm-devel}"
SRC_URI[aarch64_rust-curl+ntlm-devel.sha256sum] = "d98548686eedcdc61a0dd8709ae9cc5d0c96cf9043d740069e926923ae8d1d1f"

URI_aarch64_rust-curl+openssl-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+openssl-probe-devel-0.4.50-1.el10_2.noarch.rpm;name=aarch64_rust-curl+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+openssl-probe-devel}"
SRC_URI[aarch64_rust-curl+openssl-probe-devel.sha256sum] = "e3278cd2e561eeb39b6772cd14463d7daabc5cfa6957c2da2e483b42425e5442"

URI_aarch64_rust-curl+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+openssl-sys-devel-0.4.50-1.el10_2.noarch.rpm;name=aarch64_rust-curl+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+openssl-sys-devel}"
SRC_URI[aarch64_rust-curl+openssl-sys-devel.sha256sum] = "f0ef7d7b1e2e1ce55e409fe3a76525a5d9328980f84e5a15337d8df65ec1d240"

URI_aarch64_rust-curl+poll_7_68_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+poll_7_68_0-devel-0.4.50-1.el10_2.noarch.rpm;name=aarch64_rust-curl+poll_7_68_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+poll_7_68_0-devel}"
SRC_URI[aarch64_rust-curl+poll_7_68_0-devel.sha256sum] = "1a5c1a4780400a2bdbce4a156f174b0fed8a0b9d80741506db607c63b30b9f32"

URI_aarch64_rust-curl+protocol-ftp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+protocol-ftp-devel-0.4.50-1.el10_2.noarch.rpm;name=aarch64_rust-curl+protocol-ftp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+protocol-ftp-devel}"
SRC_URI[aarch64_rust-curl+protocol-ftp-devel.sha256sum] = "2c25cd310dec803dd1ceead8b966b64dafa12ad882874fa724cf4b641fba1b96"

URI_aarch64_rust-curl+spnego-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+spnego-devel-0.4.50-1.el10_2.noarch.rpm;name=aarch64_rust-curl+spnego-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+spnego-devel}"
SRC_URI[aarch64_rust-curl+spnego-devel.sha256sum] = "4b312fb1cc55f7acc131217ca3ead7cbbe35347f35c3be261b6d00e1b39523bb"

URI_aarch64_rust-curl+ssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+ssl-devel-0.4.50-1.el10_2.noarch.rpm;name=aarch64_rust-curl+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+ssl-devel}"
SRC_URI[aarch64_rust-curl+ssl-devel.sha256sum] = "eb27023dafaafe4bcaa1f72c3215a3c809b10cef516dae267af30d957b3c5632"

URI_aarch64_rust-curl+upkeep_7_62_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+upkeep_7_62_0-devel-0.4.50-1.el10_2.noarch.rpm;name=aarch64_rust-curl+upkeep_7_62_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+upkeep_7_62_0-devel}"
SRC_URI[aarch64_rust-curl+upkeep_7_62_0-devel.sha256sum] = "4d4261dfd67bca2641813723bd8530dca89ee4bfa8f42a5f8fd43e3ad8358df8"

URI_aarch64_rust-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-devel-0.4.50-1.el10_2.noarch.rpm;name=aarch64_rust-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-devel}"
SRC_URI[aarch64_rust-curl-devel.sha256sum] = "ee359e421b6a076435d208d57d39be58a257703bbb444ea685c5d7585db6c669"

RDEPENDS:rust-curl+default-devel = " \
 cargo \
 rust-curl+ssl-devel \
 rust-curl-devel \
 "
RDEPENDS:rust-curl+http2-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+http2-devel \
 "
RDEPENDS:rust-curl+ntlm-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+ntlm-devel \
 "
RDEPENDS:rust-curl+openssl-probe-devel = " \
 cargo \
 rust-curl-devel \
 rust-openssl-probe+default-devel \
 "
RDEPENDS:rust-curl+openssl-sys-devel = " \
 cargo \
 rust-curl-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-curl+poll_7_68_0-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+poll_7_68_0-devel \
 "
RDEPENDS:rust-curl+protocol-ftp-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+protocol-ftp-devel \
 "
RDEPENDS:rust-curl+spnego-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+spnego-devel \
 "
RDEPENDS:rust-curl+ssl-devel = " \
 cargo \
 rust-curl+openssl-probe-devel \
 rust-curl+openssl-sys-devel \
 rust-curl-devel \
 rust-curl-sys+ssl-devel \
 "
RDEPENDS:rust-curl+upkeep_7_62_0-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+upkeep_7_62_0-devel \
 "
RDEPENDS:rust-curl-devel = " \
 cargo \
 rust-curl-sys-devel \
 rust-libc+default-devel \
 rust-socket2+default-devel \
 "
