# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libeconf"
PV = "0.6.2"
PR = "4.el10"
PACKAGES = " \
 libeconf \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libeconf-0.6.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "844e09e1c126e13c46afbefd5add05074c9f8da95ec869193c1d5ddb6ad6d18b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libeconf-0.6.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_libeconf;unpack=0"
SRC_URI[x86_64_v2_libeconf.sha256sum] = "96ae8779c56863dbc6bbec93b8ccebf101cc24fa16e516ca772eabd4d27bcf96"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libeconf-0.6.2-4.el10.aarch64.rpm;name=aarch64_libeconf;unpack=0"
SRC_URI[aarch64_libeconf.sha256sum] = "64a52f6d3897a3831cc437e506ee7533bd4baa1b6ba0409935c70e208d76f264"

RDEPENDS:libeconf = " \
 glibc \
 "
