# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-posix"
PV = "36.2.1"
PR = "9.el10_1"
PACKAGES = " \
 lua-posix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-posix-36.2.1-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b08a61a7ca1c9314511c27cf4102f8edc7bdf97116352d7211a7081ee53e6aad"

URI_x86_64_v2_lua-posix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-posix-36.2.1-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-posix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-posix}"
SRC_URI[x86_64_v2_lua-posix.sha256sum] = "07a1d93f0e8b3bef4c56c55a1c7fbe13457c9fac6b7b4902afad290b7f4da0fb"

URI_aarch64_lua-posix = "${EPEL_MIRROR}/aarch64/Packages/l/lua-posix-36.2.1-9.el10_1.aarch64.rpm;name=aarch64_lua-posix;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-posix}"
SRC_URI[aarch64_lua-posix.sha256sum] = "071715d234c407695cd1f31d7b9840f5168a6ea0544ca8608b97d6e2ea6e9fc5"

RDEPENDS:lua-posix = " \
 glibc \
 libxcrypt \
 lua-libs \
 "
