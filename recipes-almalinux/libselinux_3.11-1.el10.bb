# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libselinux"
PV = "3.11"
PR = "1.el10"
PACKAGES = " \
 libselinux \
 libselinux-devel \
 libselinux-ruby \
 libselinux-static \
 libselinux-utils \
 python3-libselinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libselinux-3.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19cccbc3b096b2589be329a91bfb404a5c8e05bc0b8ef4a74a6f538b53ffca63"

URI_x86_64_v2_libselinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libselinux-3.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux}"
SRC_URI[x86_64_v2_libselinux.sha256sum] = "80373946c27a67bbe7e64916f7fca6ef934402ace589e202872bb3c5428cbf41"

URI_x86_64_v2_libselinux-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libselinux-devel-3.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-devel}"
SRC_URI[x86_64_v2_libselinux-devel.sha256sum] = "c2d8c8852c0d919f25dfe2a736f51142e869bc92ca81834f9b175495995943c9"

URI_x86_64_v2_libselinux-ruby = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libselinux-ruby-3.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-ruby}"
SRC_URI[x86_64_v2_libselinux-ruby.sha256sum] = "9417e6f59ff514930b78caa5747eb9e875e900d5e1e868141f33b8735bdba8a8"

URI_x86_64_v2_libselinux-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libselinux-static-3.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-static}"
SRC_URI[x86_64_v2_libselinux-static.sha256sum] = "65b2a687d3b1614f0eca9f50e14cdea4bf02ad541ffa9a5866f087161c991ba0"

URI_x86_64_v2_libselinux-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libselinux-utils-3.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-utils}"
SRC_URI[x86_64_v2_libselinux-utils.sha256sum] = "d7e949920852a50eaf7d008a3fde541c1e7c6adad5e1067b3bc0a951d63c704b"

URI_x86_64_v2_python3-libselinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libselinux-3.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libselinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libselinux}"
SRC_URI[x86_64_v2_python3-libselinux.sha256sum] = "34da54f31ba2528991b48f7b54809936cdea0fa8cb0bdbb1c30e8bbf867ac9e4"

URI_aarch64_libselinux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libselinux-3.11-1.el10.aarch64.rpm;name=aarch64_libselinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux}"
SRC_URI[aarch64_libselinux.sha256sum] = "01e0b11b7f8f283356de845d4196fe8a6a536f612b2c9addec7ffc75941b1614"

URI_aarch64_libselinux-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libselinux-devel-3.11-1.el10.aarch64.rpm;name=aarch64_libselinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-devel}"
SRC_URI[aarch64_libselinux-devel.sha256sum] = "4975a9c0526ea528fbe80202884ca5f7d91b08633eabdffce1ba294e977f971a"

URI_aarch64_libselinux-ruby = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libselinux-ruby-3.11-1.el10.aarch64.rpm;name=aarch64_libselinux-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-ruby}"
SRC_URI[aarch64_libselinux-ruby.sha256sum] = "217f541e16b4bc0373b6b261e0771b125866813d215b31441cc086a3145f7b98"

URI_aarch64_libselinux-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libselinux-static-3.11-1.el10.aarch64.rpm;name=aarch64_libselinux-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-static}"
SRC_URI[aarch64_libselinux-static.sha256sum] = "334ce36fec80ca2f791ce502abd49bd95ef158e232b362018c289426967a54dc"

URI_aarch64_libselinux-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libselinux-utils-3.11-1.el10.aarch64.rpm;name=aarch64_libselinux-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-utils}"
SRC_URI[aarch64_libselinux-utils.sha256sum] = "3ed3ae000325a969c42a83ae32ed4772e8e94db540db3f406828426248018a4e"

URI_aarch64_python3-libselinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libselinux-3.11-1.el10.aarch64.rpm;name=aarch64_python3-libselinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libselinux}"
SRC_URI[aarch64_python3-libselinux.sha256sum] = "1148a89dbf80de0ede1bf3957e0f2153286ff5263f1b391f508ad1a8a6f3d5b4"

RDEPENDS:libselinux = " \
 glibc \
 libgcc \
 libsepol \
 pcre2 \
 "
RDEPENDS:libselinux-devel = " \
 libselinux \
 libsepol-devel \
 pcre2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libselinux-ruby = " \
 glibc \
 libselinux \
 ruby-libs \
 "
RDEPENDS:libselinux-static = " \
 libselinux-devel \
 "
RDEPENDS:libselinux-utils = " \
 glibc \
 libgcc \
 libselinux \
 libsepol \
 pcre2 \
 "
RDEPENDS:python3-libselinux = " \
 glibc \
 libselinux \
 python3 \
 "
