# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c2hs"
PV = "0.28.8"
PR = "7.el10_0"
PACKAGES = " \
 c2hs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/c2hs-0.28.8-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6080e10cc936285ff8ebcc65190e29c1abb02e6097e29cc3891a458e5aacdb6"

URI_x86_64_v2_c2hs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c2hs-0.28.8-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c2hs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c2hs}"
SRC_URI[x86_64_v2_c2hs.sha256sum] = "ace6047780aaf73e4aaa2584fd47976b695e71ea4a5c3cea1af0a202f867159e"

URI_aarch64_c2hs = "${EPEL_MIRROR}/aarch64/Packages/c/c2hs-0.28.8-7.el10_0.aarch64.rpm;name=aarch64_c2hs;unpack=0"
SRC_URI:append = " ${URI_aarch64_c2hs}"
SRC_URI[aarch64_c2hs.sha256sum] = "c9b28ab2ca0c24cc18f1f610cfba33a34b36d2a7f3eecf66be48efa4f9697857"

RDEPENDS:c2hs = " \
 glibc \
 gmp \
 libffi \
 "
