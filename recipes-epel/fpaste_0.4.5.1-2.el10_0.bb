# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fpaste"
PV = "0.4.5.1"
PR = "2.el10_0"
PACKAGES = " \
 fpaste \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fpaste-0.4.5.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cce0907124117851283e16143af564a4e3b2df62f91a8aa12e25d7ff505a6b39"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpaste-0.4.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fpaste;unpack=0"
SRC_URI[x86_64_v2_fpaste.sha256sum] = "4d4189fe25bea43a3ebf6f0a88e5a8be332bb84c96fb3cf58849cd2bc84f7189"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fpaste-0.4.5.1-2.el10_0.noarch.rpm;name=aarch64_fpaste;unpack=0"
SRC_URI[aarch64_fpaste.sha256sum] = "015a91b037154a18f9f8585c923f45f98c33f92893b31656f70a15ccba8c2557"

RDEPENDS:fpaste = " \
 python3 \
 "
