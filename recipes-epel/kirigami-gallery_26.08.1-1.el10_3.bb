# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kirigami-gallery"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kirigami-gallery \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kirigami-gallery-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "71c30d11ab967b9905b710a38063cd32da24666c461666744ba2c44434caa63b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kirigami-gallery-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kirigami-gallery;unpack=0"
SRC_URI[x86_64_v2_kirigami-gallery.sha256sum] = "b08ceed54da2fd43fc007e5ae5242a4bc1b42d3b60270b11d4cb4502de4c2eef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kirigami-gallery-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kirigami-gallery;unpack=0"
SRC_URI[aarch64_kirigami-gallery.sha256sum] = "d58fdcd7470c619ca740998eea3b455fe6c6a9bc1e8b8f15c526976884c46b8a"

RDEPENDS:kirigami-gallery = " \
 breeze-icon-theme \
 glibc \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
