# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmouth"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kmouth \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmouth-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "248840b23566d9868d04e9baaad208a0f048bf72d81d153b12410eb09a389dfe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmouth-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmouth;unpack=0"
SRC_URI[x86_64_v2_kmouth.sha256sum] = "d39545a6ee1955ca3ccea8c121dd9eb00e99a0147d5d7059ce0804c1d1e659a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmouth-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kmouth;unpack=0"
SRC_URI[aarch64_kmouth.sha256sum] = "3e953bcc05efac76335dace8b5915a4e1fcee968dcd1d82ff2bbc9ac4a0a9f05"

RDEPENDS:kmouth = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 "
