# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-foreign-types-macros"
PV = "0.2.3"
PR = "4.el10_0"
PACKAGES = " \
 rust-foreign-types-macros+default-devel \
 rust-foreign-types-macros+std-devel \
 rust-foreign-types-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-foreign-types-macros-0.2.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c7ac281a165a03454cd66c42ec152ae2c678ff92ce8c59b15cace5a12de8915"

URI_x86_64_v2_rust-foreign-types-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foreign-types-macros+default-devel-0.2.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foreign-types-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foreign-types-macros+default-devel}"
SRC_URI[x86_64_v2_rust-foreign-types-macros+default-devel.sha256sum] = "c71a08a63138f15ac06ee3341fcd8c261fd8396d5bef4230af211e4971219cbf"

URI_x86_64_v2_rust-foreign-types-macros+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foreign-types-macros+std-devel-0.2.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foreign-types-macros+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foreign-types-macros+std-devel}"
SRC_URI[x86_64_v2_rust-foreign-types-macros+std-devel.sha256sum] = "9984774e927d3e3252b2d24e7fc7d25691d9e8849e21601ebe214b1090e269e7"

URI_x86_64_v2_rust-foreign-types-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foreign-types-macros-devel-0.2.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foreign-types-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foreign-types-macros-devel}"
SRC_URI[x86_64_v2_rust-foreign-types-macros-devel.sha256sum] = "515e91c47dba95921a9717e516f319a91d0708a5ed8291e0bd86ededa7688f33"

URI_aarch64_rust-foreign-types-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foreign-types-macros+default-devel-0.2.3-4.el10_0.noarch.rpm;name=aarch64_rust-foreign-types-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foreign-types-macros+default-devel}"
SRC_URI[aarch64_rust-foreign-types-macros+default-devel.sha256sum] = "3a2c0d34af66345d6be62f4db44be4c69cca4dcd0c71fba1bc4ffafaafc42e60"

URI_aarch64_rust-foreign-types-macros+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foreign-types-macros+std-devel-0.2.3-4.el10_0.noarch.rpm;name=aarch64_rust-foreign-types-macros+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foreign-types-macros+std-devel}"
SRC_URI[aarch64_rust-foreign-types-macros+std-devel.sha256sum] = "79b69bb50e5e79451f1ce9ce71ad6ac17ef036e5fa01ead15c413f9158162258"

URI_aarch64_rust-foreign-types-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foreign-types-macros-devel-0.2.3-4.el10_0.noarch.rpm;name=aarch64_rust-foreign-types-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foreign-types-macros-devel}"
SRC_URI[aarch64_rust-foreign-types-macros-devel.sha256sum] = "0d415a03581962b6766c04a6f7b538f97dcd27c07547ed1f42ba412ea7c96d98"

RDEPENDS:rust-foreign-types-macros+default-devel = " \
 cargo \
 rust-foreign-types-macros-devel \
 "
RDEPENDS:rust-foreign-types-macros+std-devel = " \
 cargo \
 rust-foreign-types-macros-devel \
 "
RDEPENDS:rust-foreign-types-macros-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 "
