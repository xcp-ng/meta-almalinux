# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libewf"
PV = "20140608"
PR = "30.el10_0"
PACKAGES = " \
 ewftools \
 libewf \
 libewf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libewf-20140608-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17e5e34fb8df822a77baa8d1e468087686d06bc119f24f49a4d4d0ccd476d22e"

URI_x86_64_v2_ewftools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ewftools-20140608-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ewftools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ewftools}"
SRC_URI[x86_64_v2_ewftools.sha256sum] = "c8c43bc2d292bf04c050eecd4b783e96ae182fe37b6fdaacf7f3a9f29fb15c87"

URI_x86_64_v2_libewf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libewf-20140608-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libewf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libewf}"
SRC_URI[x86_64_v2_libewf.sha256sum] = "ef5bb466d186ad8d51285c70a03756af55394ad018b55544dd07a2c242660762"

URI_x86_64_v2_libewf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libewf-devel-20140608-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libewf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libewf-devel}"
SRC_URI[x86_64_v2_libewf-devel.sha256sum] = "e3f4610347a5d1ff65990eaf38ad0384c31e320f430368b9abc01a6ba8b22ea7"

URI_aarch64_ewftools = "${EPEL_MIRROR}/aarch64/Packages/e/ewftools-20140608-30.el10_0.aarch64.rpm;name=aarch64_ewftools;unpack=0"
SRC_URI:append = " ${URI_aarch64_ewftools}"
SRC_URI[aarch64_ewftools.sha256sum] = "1c01fab5a2abc679e0414fcceed2f2dcec47be0e0f2e62c17d8020f3542257f0"

URI_aarch64_libewf = "${EPEL_MIRROR}/aarch64/Packages/l/libewf-20140608-30.el10_0.aarch64.rpm;name=aarch64_libewf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libewf}"
SRC_URI[aarch64_libewf.sha256sum] = "1d5f762e94c71e579b3c5e00ec14be9229dd9ae07956a435a0eee16c883a5577"

URI_aarch64_libewf-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libewf-devel-20140608-30.el10_0.aarch64.rpm;name=aarch64_libewf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libewf-devel}"
SRC_URI[aarch64_libewf-devel.sha256sum] = "926a9c911b54a0ebaa0272a99d492c79eeea14623043eea1cb2c9c7e1804f894"

RDEPENDS:ewftools = " \
 fuse-libs \
 glibc \
 libewf \
 libuuid \
 openssl-libs \
 "
RDEPENDS:libewf = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:libewf-devel = " \
 libewf \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
