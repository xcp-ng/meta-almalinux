# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcpuid"
PV = "0.7.0"
PR = "2.el10"
PACKAGES = " \
 libcpuid \
 libcpuid-devel \
 python3-libcpuid \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libcpuid-0.7.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c685055c33342f74838ec16de4c2154ee244d90cd78236547ad624b09c1c3b6"

URI_x86_64_v2_libcpuid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcpuid-0.7.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libcpuid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcpuid}"
SRC_URI[x86_64_v2_libcpuid.sha256sum] = "b4b5db3c001dac4ac3a86c59a98e38c7e1b87dc4faf0c30204c9999ed6e3b55c"

URI_x86_64_v2_libcpuid-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libcpuid-devel-0.7.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libcpuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcpuid-devel}"
SRC_URI[x86_64_v2_libcpuid-devel.sha256sum] = "f51cc830b2f01c59c8d3f28b8fa9876dcdf5ab847fa70de88d853489ffdfda56"

URI_x86_64_v2_python3-libcpuid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libcpuid-0.7.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libcpuid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libcpuid}"
SRC_URI[x86_64_v2_python3-libcpuid.sha256sum] = "768a7fbb842a6fca4cd657e109de58ccb350a8a8e005f8e39dd71139a2446e39"

URI_aarch64_libcpuid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcpuid-0.7.0-2.el10.aarch64.rpm;name=aarch64_libcpuid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcpuid}"
SRC_URI[aarch64_libcpuid.sha256sum] = "418c1acc5245cacbf61d83331de661d9d852bb65498a1b66430370b90b40b919"

URI_aarch64_libcpuid-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libcpuid-devel-0.7.0-2.el10.aarch64.rpm;name=aarch64_libcpuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcpuid-devel}"
SRC_URI[aarch64_libcpuid-devel.sha256sum] = "be1e87b7369327200098724de67422a8dcf397e70605cf67c5a2db42626b45ea"

URI_aarch64_python3-libcpuid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libcpuid-0.7.0-2.el10.aarch64.rpm;name=aarch64_python3-libcpuid;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libcpuid}"
SRC_URI[aarch64_python3-libcpuid.sha256sum] = "d68e9e4b493b010698774fe8277041b4b981ecbb8ccf2daf869d0657c853629c"

RDEPENDS:libcpuid = " \
 glibc \
 "
RDEPENDS:libcpuid-devel = " \
 glibc \
 libcpuid \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libcpuid = " \
 glibc \
 libcpuid \
 python3 \
 python3-cffi \
 "
