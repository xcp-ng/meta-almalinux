# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-MakeMaker-CPANfile"
PV = "0.09"
PR = "19.el10_0"
PACKAGES = " \
 perl-ExtUtils-MakeMaker-CPANfile \
 perl-ExtUtils-MakeMaker-CPANfile-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-MakeMaker-CPANfile-0.09-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e68dfc33ddea1a355059d386c2ff7bc44adef0d346e628f6e3601f81770012a8"

URI_x86_64_v2_perl-ExtUtils-MakeMaker-CPANfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-MakeMaker-CPANfile-0.09-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-MakeMaker-CPANfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ExtUtils-MakeMaker-CPANfile}"
SRC_URI[x86_64_v2_perl-ExtUtils-MakeMaker-CPANfile.sha256sum] = "1f71c42dff31d8816d378a04a931df21a83eeb5cbaa88f3c806c73de7f5051f3"

URI_x86_64_v2_perl-ExtUtils-MakeMaker-CPANfile-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-MakeMaker-CPANfile-tests-0.09-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-MakeMaker-CPANfile-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ExtUtils-MakeMaker-CPANfile-tests}"
SRC_URI[x86_64_v2_perl-ExtUtils-MakeMaker-CPANfile-tests.sha256sum] = "4c507c23ed4b4bdf9f91b17d03eec1f3154c0aa55be9bed661749d1849cd66db"

URI_aarch64_perl-ExtUtils-MakeMaker-CPANfile = "${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-MakeMaker-CPANfile-0.09-19.el10_0.noarch.rpm;name=aarch64_perl-ExtUtils-MakeMaker-CPANfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ExtUtils-MakeMaker-CPANfile}"
SRC_URI[aarch64_perl-ExtUtils-MakeMaker-CPANfile.sha256sum] = "f4e16395f56d295d82eeba017418ae5b91489251fb94cd5e0d20ac278a403769"

URI_aarch64_perl-ExtUtils-MakeMaker-CPANfile-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-MakeMaker-CPANfile-tests-0.09-19.el10_0.noarch.rpm;name=aarch64_perl-ExtUtils-MakeMaker-CPANfile-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ExtUtils-MakeMaker-CPANfile-tests}"
SRC_URI[aarch64_perl-ExtUtils-MakeMaker-CPANfile-tests.sha256sum] = "89ef0d7726be013cb763dc2422bb356978848cf952467cb91739d9822269fc60"

RDEPENDS:perl-ExtUtils-MakeMaker-CPANfile = " \
 perl-CPAN-Meta \
 perl-ExtUtils-MakeMaker \
 perl-Module-CPANfile \
 perl-PathTools \
 perl-libs \
 perl-version \
 "
RDEPENDS:perl-ExtUtils-MakeMaker-CPANfile-tests = " \
 bash \
 perl-ExtUtils-MakeMaker-CPANfile \
 perl-File-Path \
 perl-FindBin \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 virtual/coreutils \
 "
