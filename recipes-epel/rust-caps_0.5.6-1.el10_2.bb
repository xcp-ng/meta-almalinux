# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-caps"
PV = "0.5.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-caps+default-devel \
 rust-caps+serde-devel \
 rust-caps+serde_support-devel \
 rust-caps-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-caps-0.5.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1358ec3770ca5b467cd5ec9754fe6907ee72b35826e63882b5f3058bcdc4ef1"

URI_x86_64_v2_rust-caps+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-caps+default-devel-0.5.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-caps+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-caps+default-devel}"
SRC_URI[x86_64_v2_rust-caps+default-devel.sha256sum] = "f88fe9e778326a039c30f212f55df1b77861761fdc11141aea07ded065c71acf"

URI_x86_64_v2_rust-caps+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-caps+serde-devel-0.5.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-caps+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-caps+serde-devel}"
SRC_URI[x86_64_v2_rust-caps+serde-devel.sha256sum] = "c846a0b023398a6bf5b8a285f6bcfb6bf1df4429952d5fa0704267d50f671c4c"

URI_x86_64_v2_rust-caps+serde_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-caps+serde_support-devel-0.5.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-caps+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-caps+serde_support-devel}"
SRC_URI[x86_64_v2_rust-caps+serde_support-devel.sha256sum] = "0694b91042c908ff0328dd699c50c79376f1694ec092f3d031c60d06d87fdbf6"

URI_x86_64_v2_rust-caps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-caps-devel-0.5.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-caps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-caps-devel}"
SRC_URI[x86_64_v2_rust-caps-devel.sha256sum] = "8c975df50b792085a970fc71d57bc68ec4748cffdee1157c99ba664efda3f355"

URI_aarch64_rust-caps+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-caps+default-devel-0.5.6-1.el10_2.noarch.rpm;name=aarch64_rust-caps+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-caps+default-devel}"
SRC_URI[aarch64_rust-caps+default-devel.sha256sum] = "e7d1278e637908f0ff73fe2a40000a871bb59212cf3d48a8c9c4938b61a8249d"

URI_aarch64_rust-caps+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-caps+serde-devel-0.5.6-1.el10_2.noarch.rpm;name=aarch64_rust-caps+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-caps+serde-devel}"
SRC_URI[aarch64_rust-caps+serde-devel.sha256sum] = "ce0d9086efa723040a3b1a6a6ea64656e83d233408478945c44c27122441e9a5"

URI_aarch64_rust-caps+serde_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-caps+serde_support-devel-0.5.6-1.el10_2.noarch.rpm;name=aarch64_rust-caps+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-caps+serde_support-devel}"
SRC_URI[aarch64_rust-caps+serde_support-devel.sha256sum] = "b9e997b43012c89b5b397a770caa1f545f8b7652ea8967826c294e11a357b62d"

URI_aarch64_rust-caps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-caps-devel-0.5.6-1.el10_2.noarch.rpm;name=aarch64_rust-caps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-caps-devel}"
SRC_URI[aarch64_rust-caps-devel.sha256sum] = "b00a2bcf2a5acc03f654775b18071fb739de1fec52761737a7ad2006b1edfb87"

RDEPENDS:rust-caps+default-devel = " \
 cargo \
 rust-caps-devel \
 "
RDEPENDS:rust-caps+serde-devel = " \
 cargo \
 rust-caps-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-caps+serde_support-devel = " \
 cargo \
 rust-caps+serde-devel \
 rust-caps-devel \
 "
RDEPENDS:rust-caps-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
