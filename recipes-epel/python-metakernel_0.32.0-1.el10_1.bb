# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-metakernel"
PV = "0.32.0"
PR = "1.el10_1"
PACKAGES = " \
 python-metakernel-doc \
 python3-metakernel \
 python3-metakernel-echo \
 python3-metakernel-python \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-metakernel-0.32.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "336de3a606f10f0e21a7f3b10fb4ffcb7e9063b582654a7ec444a0882f56a344"

URI_x86_64_v2_python-metakernel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-metakernel-doc-0.32.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-metakernel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-metakernel-doc}"
SRC_URI[x86_64_v2_python-metakernel-doc.sha256sum] = "389574b57e1479433a19368d08bc9433b71644b9e14ca4db8f2d4c88a9458126"

URI_x86_64_v2_python3-metakernel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-metakernel-0.32.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-metakernel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-metakernel}"
SRC_URI[x86_64_v2_python3-metakernel.sha256sum] = "85fa53db3cd048b55e499a87721fd4c3985210e614208d10551cd71295d5bfda"

URI_x86_64_v2_python3-metakernel-echo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-metakernel-echo-0.19.1-82.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-metakernel-echo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-metakernel-echo}"
SRC_URI[x86_64_v2_python3-metakernel-echo.sha256sum] = "5ad2f24414943b12ee27af6c6877abfb098c8eac3e1b6a6c2c8f1e43ccab7798"

URI_x86_64_v2_python3-metakernel-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-metakernel-python-0.19.1-82.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-metakernel-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-metakernel-python}"
SRC_URI[x86_64_v2_python3-metakernel-python.sha256sum] = "8b73eb3f08f1b52bd904fb4298b2ed0673dc2f839c392093675fdc132bdb5033"

URI_aarch64_python-metakernel-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-metakernel-doc-0.32.0-1.el10_1.noarch.rpm;name=aarch64_python-metakernel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-metakernel-doc}"
SRC_URI[aarch64_python-metakernel-doc.sha256sum] = "6cd99b7449cb183f093ff23fbd1ca9b1277de3d8e8fbf77115784d19af65b6f9"

URI_aarch64_python3-metakernel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-metakernel-0.32.0-1.el10_1.noarch.rpm;name=aarch64_python3-metakernel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-metakernel}"
SRC_URI[aarch64_python3-metakernel.sha256sum] = "cf7dfc5a9371b8dc9ee46fb1fbf7ff52d24152bfd515d09c97f3b5a9db4d6bdb"

URI_aarch64_python3-metakernel-echo = "${EPEL_MIRROR}/aarch64/Packages/p/python3-metakernel-echo-0.19.1-82.el10_1.noarch.rpm;name=aarch64_python3-metakernel-echo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-metakernel-echo}"
SRC_URI[aarch64_python3-metakernel-echo.sha256sum] = "37c8f60dfe2305faa2b757ad0d87fe4648d74030d873e1a86e7aea5c22a6a098"

URI_aarch64_python3-metakernel-python = "${EPEL_MIRROR}/aarch64/Packages/p/python3-metakernel-python-0.19.1-82.el10_1.noarch.rpm;name=aarch64_python3-metakernel-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-metakernel-python}"
SRC_URI[aarch64_python3-metakernel-python.sha256sum] = "0c36131d5967228ba483c4dae4d8d7088c890216c6854cccb1112a10ba2d5619"

RDEPENDS:python-metakernel-doc = " \
 "
RDEPENDS:python3-metakernel = " \
 python3 \
 python3-comm \
 python3-ipykernel \
 python3-jedi \
 python3-jupyter-core \
 python3-pexpect \
 "
RDEPENDS:python3-metakernel-echo = " \
 python-jupyter-filesystem \
 python3 \
 python3-metakernel \
 "
RDEPENDS:python3-metakernel-python = " \
 python-jupyter-filesystem \
 python3 \
 python3-ipython \
 python3-jedi \
 python3-metakernel \
 "
