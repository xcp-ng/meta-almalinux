# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-core"
PE = "1"
PV = "2.16.14"
PR = "1.el10"
PACKAGES = " \
 ansible-core \
 ansible-test \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ansible-core-2.16.14-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3151792d2b3a3caa910b04accf919f3677bef442dfebd72628aff96697af757b"

URI_x86_64_v2_ansible-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-core-2.16.14-1.el10.noarch.rpm;name=x86_64_v2_ansible-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-core}"
SRC_URI[x86_64_v2_ansible-core.sha256sum] = "8f966c697abbc20f3f6b03b7964d283d0664e07dc94e13b0c265e80c8a8d0072"

URI_x86_64_v2_ansible-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-test-2.16.14-1.el10.noarch.rpm;name=x86_64_v2_ansible-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-test}"
SRC_URI[x86_64_v2_ansible-test.sha256sum] = "6aa9ca9f5a216af4152c837da34ebfd5dde379385b40291ed0e0d54ed01b607e"

URI_aarch64_ansible-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-core-2.16.14-1.el10.noarch.rpm;name=aarch64_ansible-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-core}"
SRC_URI[aarch64_ansible-core.sha256sum] = "8f966c697abbc20f3f6b03b7964d283d0664e07dc94e13b0c265e80c8a8d0072"

URI_aarch64_ansible-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-test-2.16.14-1.el10.noarch.rpm;name=aarch64_ansible-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-test}"
SRC_URI[aarch64_ansible-test.sha256sum] = "6aa9ca9f5a216af4152c837da34ebfd5dde379385b40291ed0e0d54ed01b607e"

RDEPENDS:ansible-core = " \
 git-core \
 python3 \
 python3-cryptography \
 python3-jinja2 \
 python3-packaging \
 python3-pyyaml \
 python3-resolvelib \
 "
RDEPENDS:ansible-test = " \
 ansible-core \
 python3 \
 "
