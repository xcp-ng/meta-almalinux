# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skladnik"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 skladnik \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/skladnik-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89a0f5a48f0213c869ae08b131ee59827b59a05675e2416477080830153caed2"

URI_x86_64_v2_skladnik = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/skladnik-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_skladnik;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skladnik}"
SRC_URI[x86_64_v2_skladnik.sha256sum] = "8055c9bfba4e1bc6c94eacbd22c883fb77f9bdd363a8056a91298e4835add04e"

URI_aarch64_skladnik = "${EPEL_MIRROR}/aarch64/Packages/s/skladnik-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_skladnik;unpack=0"
SRC_URI:append = " ${URI_aarch64_skladnik}"
SRC_URI[aarch64_skladnik.sha256sum] = "76bff1a8703e2dd964dba2cfef0bb8b24315313aebfe0e35b2d041c685733cea"

RDEPENDS:skladnik = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
