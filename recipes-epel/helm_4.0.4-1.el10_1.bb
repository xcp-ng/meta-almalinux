# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "helm"
PV = "4.0.4"
PR = "1.el10_1"
PACKAGES = " \
 helm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/helm-4.0.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf8b05b42cf20f55d9881fffb6dd8052dafdc9e3b6f0e1515f8bef538655f6d2"

URI_x86_64_v2_helm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/helm-4.0.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_helm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_helm}"
SRC_URI[x86_64_v2_helm.sha256sum] = "5c73974187901e73e8156fa5d64e14732bfd4edd0faa6b1288577b3f7b731902"

URI_aarch64_helm = "${EPEL_MIRROR}/aarch64/Packages/h/helm-4.0.4-1.el10_1.aarch64.rpm;name=aarch64_helm;unpack=0"
SRC_URI:append = " ${URI_aarch64_helm}"
SRC_URI[aarch64_helm.sha256sum] = "4fb0e9790e91a7f0080ddd193e3a864b7d1a679babe9abf605edbbc7a9f1fea3"

RDEPENDS:helm = " \
 glibc \
 "
