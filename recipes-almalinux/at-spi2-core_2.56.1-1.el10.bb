# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "at-spi2-core"
PV = "2.56.1"
PR = "1.el10"
PACKAGES = " \
 at-spi2-atk \
 at-spi2-atk-devel \
 at-spi2-core \
 at-spi2-core-devel \
 atk \
 atk-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/at-spi2-core-2.56.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3d5c2bb07156d97823b4fa98d6b88aa2a025c42b7717f547982b57a09ff4bac"

URI_x86_64_v2_at-spi2-atk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/at-spi2-atk-2.56.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_at-spi2-atk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_at-spi2-atk}"
SRC_URI[x86_64_v2_at-spi2-atk.sha256sum] = "bd691a7c93e0d68c98b9f1c8861aac407d5d549241120fc17b2a8af7f8468b0c"

URI_x86_64_v2_at-spi2-atk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/at-spi2-atk-devel-2.56.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_at-spi2-atk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_at-spi2-atk-devel}"
SRC_URI[x86_64_v2_at-spi2-atk-devel.sha256sum] = "906aadad8772949d55f3d31b97ebd5e16425d28659e03d7470a36cbdc4f5cfc3"

URI_x86_64_v2_at-spi2-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/at-spi2-core-2.56.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_at-spi2-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_at-spi2-core}"
SRC_URI[x86_64_v2_at-spi2-core.sha256sum] = "22a4c4d0d72d31509fbcbb26ae865f8c224feebb414a40a3739fa0f215fe200b"

URI_x86_64_v2_at-spi2-core-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/at-spi2-core-devel-2.56.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_at-spi2-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_at-spi2-core-devel}"
SRC_URI[x86_64_v2_at-spi2-core-devel.sha256sum] = "fb3972ba808e57e2d5d89711477b5fe48137b0221f2ef70eb84a8dd7a07a4645"

URI_x86_64_v2_atk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/atk-2.56.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_atk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atk}"
SRC_URI[x86_64_v2_atk.sha256sum] = "1ff7faefff9453698886666d0efaa24c420d86deec12a07009e7c28450d24e6d"

URI_x86_64_v2_atk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/atk-devel-2.56.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_atk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atk-devel}"
SRC_URI[x86_64_v2_atk-devel.sha256sum] = "9ab6a8fd0ba2819d5532c88115f2d7e7b9121aacc83c018b8b9d0ed2e3e93496"

URI_aarch64_at-spi2-atk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/at-spi2-atk-2.56.1-1.el10.aarch64.rpm;name=aarch64_at-spi2-atk;unpack=0"
SRC_URI:append = " ${URI_aarch64_at-spi2-atk}"
SRC_URI[aarch64_at-spi2-atk.sha256sum] = "77da8b47b44e95d9582a10fdbf8472c76a857ac2aec16cee64782fdc40c78c71"

URI_aarch64_at-spi2-atk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/at-spi2-atk-devel-2.56.1-1.el10.aarch64.rpm;name=aarch64_at-spi2-atk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_at-spi2-atk-devel}"
SRC_URI[aarch64_at-spi2-atk-devel.sha256sum] = "49c3a02eb9c492b2c0a42fbcf02fc98bd320a324be2deada7ef2888c070609c5"

URI_aarch64_at-spi2-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/at-spi2-core-2.56.1-1.el10.aarch64.rpm;name=aarch64_at-spi2-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_at-spi2-core}"
SRC_URI[aarch64_at-spi2-core.sha256sum] = "e8e35b60f76cae00ef25edb7d2f6f055a6136389acb9efe5c49fde14f2344b18"

URI_aarch64_at-spi2-core-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/at-spi2-core-devel-2.56.1-1.el10.aarch64.rpm;name=aarch64_at-spi2-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_at-spi2-core-devel}"
SRC_URI[aarch64_at-spi2-core-devel.sha256sum] = "6b733ce2c914e9ec101d93e2a69ada95f613192b23342fad446474cd87f2290c"

URI_aarch64_atk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/atk-2.56.1-1.el10.aarch64.rpm;name=aarch64_atk;unpack=0"
SRC_URI:append = " ${URI_aarch64_atk}"
SRC_URI[aarch64_atk.sha256sum] = "39c10fc8bd4d90cd0168704f2d10830a6320c3d1b93573459ef6ea0d58bffdef"

URI_aarch64_atk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/atk-devel-2.56.1-1.el10.aarch64.rpm;name=aarch64_atk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_atk-devel}"
SRC_URI[aarch64_atk-devel.sha256sum] = "8afe8d285989466683472e8713ee2ee7a6197963ca5ddaa15dbcb72610c327d5"

RDEPENDS:at-spi2-atk = " \
 at-spi2-core \
 atk \
 dbus-libs \
 glib2 \
 glibc \
 "
RDEPENDS:at-spi2-atk-devel = " \
 at-spi2-atk \
 at-spi2-core-devel \
 atk-devel \
 dbus-devel \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:at-spi2-core = " \
 bash \
 dbus \
 dbus-libs \
 glib2 \
 glibc \
 libX11 \
 libXi \
 libXtst \
 libgcc \
 systemd-libs \
 xprop \
 "
RDEPENDS:at-spi2-core-devel = " \
 at-spi2-core \
 dbus-devel \
 glib2-devel \
 libX11-devel \
 libXi-devel \
 libXtst-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:atk = " \
 at-spi2-core \
 glib2 \
 glibc \
 "
RDEPENDS:atk-devel = " \
 atk \
 glib2-devel \
 pkgconf-pkg-config \
 "
