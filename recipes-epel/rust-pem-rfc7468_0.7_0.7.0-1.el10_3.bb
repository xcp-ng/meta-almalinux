# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pem-rfc7468_0.7"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-pem-rfc7468_0.7+alloc-devel \
 rust-pem-rfc7468_0.7+default-devel \
 rust-pem-rfc7468_0.7+std-devel \
 rust-pem-rfc7468_0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pem-rfc7468_0.7-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "476a87b2f2ce7cc67833453a2fddd3ec8e3bcd29daf589b16c12a4b90301eb92"

URI_x86_64_v2_rust-pem-rfc7468_0.7+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-rfc7468_0.7+alloc-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-rfc7468_0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-rfc7468_0.7+alloc-devel}"
SRC_URI[x86_64_v2_rust-pem-rfc7468_0.7+alloc-devel.sha256sum] = "578732f051bddfd0cf954290fd1da1b6435a7a94a9782b90634a756d4cad04f9"

URI_x86_64_v2_rust-pem-rfc7468_0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-rfc7468_0.7+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-rfc7468_0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-rfc7468_0.7+default-devel}"
SRC_URI[x86_64_v2_rust-pem-rfc7468_0.7+default-devel.sha256sum] = "1c32f8c5e9f9f028e6c13d0ad5e1c4eb6de961c0056f70d62db3c4023c97a758"

URI_x86_64_v2_rust-pem-rfc7468_0.7+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-rfc7468_0.7+std-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-rfc7468_0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-rfc7468_0.7+std-devel}"
SRC_URI[x86_64_v2_rust-pem-rfc7468_0.7+std-devel.sha256sum] = "bf1ac162997ec125b36d4be4ab7f49f6ea695bf9aa016e9327223e600c67a95c"

URI_x86_64_v2_rust-pem-rfc7468_0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-rfc7468_0.7-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-rfc7468_0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-rfc7468_0.7-devel}"
SRC_URI[x86_64_v2_rust-pem-rfc7468_0.7-devel.sha256sum] = "cfe9c68f851b6791f66aaef1a3a3361868f2cf2c94b78909083041752a1b5f03"

URI_aarch64_rust-pem-rfc7468_0.7+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-rfc7468_0.7+alloc-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-pem-rfc7468_0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-rfc7468_0.7+alloc-devel}"
SRC_URI[aarch64_rust-pem-rfc7468_0.7+alloc-devel.sha256sum] = "21e3f5c73175c05a0f6160123b2ba116d094c500e675c6b7ed1602201d2863cb"

URI_aarch64_rust-pem-rfc7468_0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-rfc7468_0.7+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-pem-rfc7468_0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-rfc7468_0.7+default-devel}"
SRC_URI[aarch64_rust-pem-rfc7468_0.7+default-devel.sha256sum] = "78d2c91ed9d68371a0f057eab9b3f4ea6d1d3ecb64340f9fba180f638ce9d8b1"

URI_aarch64_rust-pem-rfc7468_0.7+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-rfc7468_0.7+std-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-pem-rfc7468_0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-rfc7468_0.7+std-devel}"
SRC_URI[aarch64_rust-pem-rfc7468_0.7+std-devel.sha256sum] = "25792771a6f81c055cd3e6bf8ec6e919b11b05310cbbeaebc07429717cc86d5f"

URI_aarch64_rust-pem-rfc7468_0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-rfc7468_0.7-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-pem-rfc7468_0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-rfc7468_0.7-devel}"
SRC_URI[aarch64_rust-pem-rfc7468_0.7-devel.sha256sum] = "69be441e5833c45a3374a2bbd50d9e84e6c493de21f6fe3bd72925141baf646a"

RDEPENDS:rust-pem-rfc7468_0.7+alloc-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-pem-rfc7468_0.7-devel \
 "
RDEPENDS:rust-pem-rfc7468_0.7+default-devel = " \
 cargo \
 rust-pem-rfc7468_0.7-devel \
 "
RDEPENDS:rust-pem-rfc7468_0.7+std-devel = " \
 cargo \
 rust-base64ct+std-devel \
 rust-pem-rfc7468_0.7+alloc-devel \
 rust-pem-rfc7468_0.7-devel \
 "
RDEPENDS:rust-pem-rfc7468_0.7-devel = " \
 cargo \
 rust \
 rust-base64ct+default-devel \
 "
