# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-parser-combinators"
PV = "1.3.0"
PR = "9.el10_0"
PACKAGES = " \
 ghc-parser-combinators \
 ghc-parser-combinators-devel \
 ghc-parser-combinators-doc \
 ghc-parser-combinators-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-parser-combinators-1.3.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a68c62c3051150f3778ea842c75a61191cbf5bfd7ba2d567bb93773306bad357"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parser-combinators-1.3.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-parser-combinators;unpack=0"
SRC_URI[x86_64_v2_ghc-parser-combinators.sha256sum] = "a41d0a280572426c765a79c31eb471f88335c28d07de705270e93029266264b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parser-combinators-devel-1.3.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-parser-combinators-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-parser-combinators-devel.sha256sum] = "52d89a3ee2dda0e1362dd566ce6597349ab777ebac0013ee68e534b9c20d8f06"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parser-combinators-doc-1.3.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-parser-combinators-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-parser-combinators-doc.sha256sum] = "9990aa4f6acc5369eefb5d17eea6e3f551ea98c3ca5386a0dca5c45126d09853"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parser-combinators-prof-1.3.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-parser-combinators-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-parser-combinators-prof.sha256sum] = "dc4efa37f3ee7d2a055fa800af35a04b44bd2ba524810ffc7379e7fdf7be9982"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-parser-combinators-1.3.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-parser-combinators;unpack=0"
SRC_URI[aarch64_ghc-parser-combinators.sha256sum] = "9e4c52d63c70c0faffb7614a882a8550096079ddadae03496ccf34ab2e3f670d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-parser-combinators-devel-1.3.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-parser-combinators-devel;unpack=0"
SRC_URI[aarch64_ghc-parser-combinators-devel.sha256sum] = "229dd09792b7e93a7c446ca7a959c4e1d323e3b099792d3e1dd47cb874c0e2e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-parser-combinators-doc-1.3.0-9.el10_0.noarch.rpm;name=aarch64_ghc-parser-combinators-doc;unpack=0"
SRC_URI[aarch64_ghc-parser-combinators-doc.sha256sum] = "b52da1721c5d03dcdd823e20da34752cae24235350c2077d900272a4627c739b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-parser-combinators-prof-1.3.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-parser-combinators-prof;unpack=0"
SRC_URI[aarch64_ghc-parser-combinators-prof.sha256sum] = "8a0253bb2405533ac98a99342ab8adb863944c0034b3d09269e0b894012345f6"

RDEPENDS:ghc-parser-combinators = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-parser-combinators-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-parser-combinators \
 "
RDEPENDS:ghc-parser-combinators-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-parser-combinators-prof = " \
 ghc-base-prof \
 ghc-parser-combinators-devel \
 "
