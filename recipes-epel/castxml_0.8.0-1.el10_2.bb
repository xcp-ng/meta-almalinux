# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "castxml"
PV = "0.8.0"
PR = "1.el10_2"
PACKAGES = " \
 castxml \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/castxml-0.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3fa54860b7ec072438845d4bbc2d9f1d26d8f38b0b4b42d920c20a73d17e3cf3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/castxml-0.8.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_castxml;unpack=0"
SRC_URI[x86_64_v2_castxml.sha256sum] = "86824a1fd7e302f38a93f254d772cf340e754a33618428b5779b23c623995bf5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/castxml-0.8.0-1.el10_2.aarch64.rpm;name=aarch64_castxml;unpack=0"
SRC_URI[aarch64_castxml.sha256sum] = "58fc242b31b8038b12266322c9ab6fde270fafa0d0f646fbc17baaed9e46087b"

RDEPENDS:castxml = " \
 clang-libs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
