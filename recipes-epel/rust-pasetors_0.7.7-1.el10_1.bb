# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pasetors"
PV = "0.7.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-pasetors+default-devel \
 rust-pasetors+ed25519-compact-devel \
 rust-pasetors+orion-devel \
 rust-pasetors+p384-devel \
 rust-pasetors+paserk-devel \
 rust-pasetors+rand_core-devel \
 rust-pasetors+regex-devel \
 rust-pasetors+serde-devel \
 rust-pasetors+serde_json-devel \
 rust-pasetors+sha2-devel \
 rust-pasetors+std-devel \
 rust-pasetors+time-devel \
 rust-pasetors+v2-devel \
 rust-pasetors+v3-devel \
 rust-pasetors+v4-devel \
 rust-pasetors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pasetors-0.7.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3af317c6ea793335b3d84d9611a53c72db92cb67308fb6ea224114c0e52f7cb"

URI_x86_64_v2_rust-pasetors+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+default-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+default-devel}"
SRC_URI[x86_64_v2_rust-pasetors+default-devel.sha256sum] = "8b3f727e78927b8e76c76b96860dcc2c43d36e74d8e44c734343af97ac34b57c"

URI_x86_64_v2_rust-pasetors+ed25519-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+ed25519-compact-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+ed25519-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+ed25519-compact-devel}"
SRC_URI[x86_64_v2_rust-pasetors+ed25519-compact-devel.sha256sum] = "3049d1ac8076d383e9d6b82ac4bb39b1107ba539c4b7b167ecfa6b3aa0b3d038"

URI_x86_64_v2_rust-pasetors+orion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+orion-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+orion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+orion-devel}"
SRC_URI[x86_64_v2_rust-pasetors+orion-devel.sha256sum] = "2ac12eaf58ab161862871bb19da91457f2671d7ed902f5be403b71aed1c137b7"

URI_x86_64_v2_rust-pasetors+p384-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+p384-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+p384-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+p384-devel}"
SRC_URI[x86_64_v2_rust-pasetors+p384-devel.sha256sum] = "505da835f8067f03215eb38e63dbcb47c8613f4d43c033e18b10e485abaacdeb"

URI_x86_64_v2_rust-pasetors+paserk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+paserk-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+paserk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+paserk-devel}"
SRC_URI[x86_64_v2_rust-pasetors+paserk-devel.sha256sum] = "f3c919e9911240ef2dfca833bd38e4f34a73640ba915b5f0fe1583157194fe54"

URI_x86_64_v2_rust-pasetors+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+rand_core-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+rand_core-devel}"
SRC_URI[x86_64_v2_rust-pasetors+rand_core-devel.sha256sum] = "db0e28c4107d2a8038e86b14d6c8b0faabee04b7f1aadbd2cf8238da07613a63"

URI_x86_64_v2_rust-pasetors+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+regex-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+regex-devel}"
SRC_URI[x86_64_v2_rust-pasetors+regex-devel.sha256sum] = "0f7b6987345173138db7dbda25cc82ca375931e24d7786fd8ef49498a961077f"

URI_x86_64_v2_rust-pasetors+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+serde-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+serde-devel}"
SRC_URI[x86_64_v2_rust-pasetors+serde-devel.sha256sum] = "2d97d50275f7b1f00c502134bb47cd2298c7393fedc031a37a01ae61b1bbda14"

URI_x86_64_v2_rust-pasetors+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+serde_json-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+serde_json-devel}"
SRC_URI[x86_64_v2_rust-pasetors+serde_json-devel.sha256sum] = "e06be153b9c4089cf8d79f95af1639a696286d59973d4728eef979c3aa7bdb37"

URI_x86_64_v2_rust-pasetors+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+sha2-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+sha2-devel}"
SRC_URI[x86_64_v2_rust-pasetors+sha2-devel.sha256sum] = "93caf4ac15230c42b4c20c7e275d1dc1108348a533aa71df40f6b50f3609de73"

URI_x86_64_v2_rust-pasetors+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+std-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+std-devel}"
SRC_URI[x86_64_v2_rust-pasetors+std-devel.sha256sum] = "a25ae1e871de52c85e773490fad801acda151e6f7a4557deb2ec2ac8f1e40c46"

URI_x86_64_v2_rust-pasetors+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+time-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+time-devel}"
SRC_URI[x86_64_v2_rust-pasetors+time-devel.sha256sum] = "38ed55c9e76425299125c1085ca89809f0941533518a52c5788f565c346bbd37"

URI_x86_64_v2_rust-pasetors+v2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+v2-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+v2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+v2-devel}"
SRC_URI[x86_64_v2_rust-pasetors+v2-devel.sha256sum] = "90e5f2ccd8171603b44a2f57c3ffe27d36bdc51fcf240941485b714217ccd832"

URI_x86_64_v2_rust-pasetors+v3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+v3-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+v3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+v3-devel}"
SRC_URI[x86_64_v2_rust-pasetors+v3-devel.sha256sum] = "d28155b1351ab16056a8d8431e5863fb4091abff44eb655ef5b93ed465793b07"

URI_x86_64_v2_rust-pasetors+v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+v4-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+v4-devel}"
SRC_URI[x86_64_v2_rust-pasetors+v4-devel.sha256sum] = "9319a8bc34039d7f7fc0806ca808eb24aa80fb73db512130b5cec9a9680298e2"

URI_x86_64_v2_rust-pasetors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors-devel-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors-devel}"
SRC_URI[x86_64_v2_rust-pasetors-devel.sha256sum] = "45945fa6ba0ddb22f09e10c5b74091b03edb6674b9af8793803f7cbcf4498d10"

URI_aarch64_rust-pasetors+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+default-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+default-devel}"
SRC_URI[aarch64_rust-pasetors+default-devel.sha256sum] = "a158d7c34e970c51a0d339bf231a8c61b6e1f50d4f3f446f7b2b2768aa1fc18e"

URI_aarch64_rust-pasetors+ed25519-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+ed25519-compact-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+ed25519-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+ed25519-compact-devel}"
SRC_URI[aarch64_rust-pasetors+ed25519-compact-devel.sha256sum] = "357997643f32203df0df65482688ec4d5d7f82245e9579660bfc20d6c7041d29"

URI_aarch64_rust-pasetors+orion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+orion-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+orion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+orion-devel}"
SRC_URI[aarch64_rust-pasetors+orion-devel.sha256sum] = "ecf617303209bb75c868a6b47a8916950c6a66975d8870ba00abbaae1cc7298c"

URI_aarch64_rust-pasetors+p384-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+p384-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+p384-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+p384-devel}"
SRC_URI[aarch64_rust-pasetors+p384-devel.sha256sum] = "e4c8f8fb502db31aef9013f91e7dddd4853b994cae29d2a1f29af712c2b9aab8"

URI_aarch64_rust-pasetors+paserk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+paserk-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+paserk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+paserk-devel}"
SRC_URI[aarch64_rust-pasetors+paserk-devel.sha256sum] = "1b92a3c552325426d4a67f46f03912016d32b908d9c17beeca02d0aa34732f70"

URI_aarch64_rust-pasetors+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+rand_core-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+rand_core-devel}"
SRC_URI[aarch64_rust-pasetors+rand_core-devel.sha256sum] = "6d192ea98a4269b4244f5afe4b8526f46b0ef2270dcfe12c49c2e5a5b77931c5"

URI_aarch64_rust-pasetors+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+regex-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+regex-devel}"
SRC_URI[aarch64_rust-pasetors+regex-devel.sha256sum] = "a5ebf8efdc984e32eb46ba7db460e44a7ed56996fab604d790d109a9cd5befa0"

URI_aarch64_rust-pasetors+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+serde-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+serde-devel}"
SRC_URI[aarch64_rust-pasetors+serde-devel.sha256sum] = "75ae0b49dc6f519acf3f4621b0e97aab74d3e4446e56189d9f5f0ffb05b559cb"

URI_aarch64_rust-pasetors+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+serde_json-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+serde_json-devel}"
SRC_URI[aarch64_rust-pasetors+serde_json-devel.sha256sum] = "a103b82580ec13c087dcb8b591e4915f8dc31fb30f6eb9cfd00718b2fce3ec0b"

URI_aarch64_rust-pasetors+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+sha2-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+sha2-devel}"
SRC_URI[aarch64_rust-pasetors+sha2-devel.sha256sum] = "c8220c3a6e496eb63894e56a97239af43c09c0b090bc42cf3c05a9baf661f47e"

URI_aarch64_rust-pasetors+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+std-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+std-devel}"
SRC_URI[aarch64_rust-pasetors+std-devel.sha256sum] = "bfbdb0152b881ee6ec861ec2783c534fac983483d37b9be1b7cf992a5c1b8dfb"

URI_aarch64_rust-pasetors+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+time-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+time-devel}"
SRC_URI[aarch64_rust-pasetors+time-devel.sha256sum] = "edca3e6ea4fb72baa42d141f6fd51b94571f5cf1949ab33b6cb43ae2862a7b31"

URI_aarch64_rust-pasetors+v2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+v2-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+v2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+v2-devel}"
SRC_URI[aarch64_rust-pasetors+v2-devel.sha256sum] = "55e15526ec9769ee7ab35d05984bab8626de1d5a2a421b9480393341d2a77b35"

URI_aarch64_rust-pasetors+v3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+v3-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+v3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+v3-devel}"
SRC_URI[aarch64_rust-pasetors+v3-devel.sha256sum] = "05c8f476b5346224fe65d12c6daefd374dd7062ae14b016b1a8cf3fba1799bb4"

URI_aarch64_rust-pasetors+v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+v4-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors+v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+v4-devel}"
SRC_URI[aarch64_rust-pasetors+v4-devel.sha256sum] = "9d07fdcf500c0414f88e0986b229b523e57ed09a1c9668d2fa842154d33f5b09"

URI_aarch64_rust-pasetors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors-devel-0.7.7-1.el10_1.noarch.rpm;name=aarch64_rust-pasetors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors-devel}"
SRC_URI[aarch64_rust-pasetors-devel.sha256sum] = "06319ff3703fbf9e173fe19fd6538fbe36a18fadd2016edb57a7f6ae67e0ee32"

RDEPENDS:rust-pasetors+default-devel = " \
 cargo \
 rust-pasetors+paserk-devel \
 rust-pasetors+std-devel \
 rust-pasetors+v4-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+ed25519-compact-devel = " \
 cargo \
 rust-ed25519-compact+random-devel \
 rust-ed25519-compact-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+orion-devel = " \
 cargo \
 rust-orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+p384-devel = " \
 cargo \
 rust-p384+default-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+paserk-devel = " \
 cargo \
 rust-pasetors+orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+rand_core-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-rand_core0.6+getrandom-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-pasetors+regex-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-regex+default-devel \
 "
RDEPENDS:rust-pasetors+serde-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-pasetors+serde_json-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-pasetors+sha2-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-pasetors+std-devel = " \
 cargo \
 rust-pasetors+regex-devel \
 rust-pasetors+serde_json-devel \
 rust-pasetors+time-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+time-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-pasetors+v2-devel = " \
 cargo \
 rust-pasetors+ed25519-compact-devel \
 rust-pasetors+orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+v3-devel = " \
 cargo \
 rust-pasetors+p384-devel \
 rust-pasetors+rand_core-devel \
 rust-pasetors+sha2-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+v4-devel = " \
 cargo \
 rust-pasetors+ed25519-compact-devel \
 rust-pasetors+orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors-devel = " \
 cargo \
 rust \
 rust-ct-codecs-devel \
 rust-getrandom+default-devel \
 rust-subtle-devel \
 rust-zeroize-devel \
 "
