# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro2-diagnostics"
PV = "0.10.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-proc-macro2-diagnostics+colors-devel \
 rust-proc-macro2-diagnostics+default-devel \
 rust-proc-macro2-diagnostics+yansi-devel \
 rust-proc-macro2-diagnostics-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro2-diagnostics-0.10.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "181e3ba09599fdc9a06dd7992f9ea0d052a373a3f52a4f22298d771de6baa2e2"

URI_x86_64_v2_rust-proc-macro2-diagnostics+colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2-diagnostics+colors-devel-0.10.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2-diagnostics+colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2-diagnostics+colors-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2-diagnostics+colors-devel.sha256sum] = "ba8ea88c1c96b7d1ac37df91d47633f202bf49aa082780ff6f1334919b970170"

URI_x86_64_v2_rust-proc-macro2-diagnostics+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2-diagnostics+default-devel-0.10.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2-diagnostics+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2-diagnostics+default-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2-diagnostics+default-devel.sha256sum] = "5474f999fbbdc27e42a8320860afb71fb31fca72222c56cb55081a0c3143f150"

URI_x86_64_v2_rust-proc-macro2-diagnostics+yansi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2-diagnostics+yansi-devel-0.10.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2-diagnostics+yansi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2-diagnostics+yansi-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2-diagnostics+yansi-devel.sha256sum] = "21c36e1077cdb4b6f3ee42a6e554e953962a94eaa417f0721ee4c05632a44bd6"

URI_x86_64_v2_rust-proc-macro2-diagnostics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2-diagnostics-devel-0.10.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2-diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2-diagnostics-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2-diagnostics-devel.sha256sum] = "7bcec77709fa605a32098f1dcd3f93ba5f1a206de4093bc59e03a02df7c48db1"

URI_aarch64_rust-proc-macro2-diagnostics+colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2-diagnostics+colors-devel-0.10.1-2.el10_0.noarch.rpm;name=aarch64_rust-proc-macro2-diagnostics+colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2-diagnostics+colors-devel}"
SRC_URI[aarch64_rust-proc-macro2-diagnostics+colors-devel.sha256sum] = "85deaeaa1c2531d3e6329b25196051b3c256f2f525629dd9ca157ee93b25ffdb"

URI_aarch64_rust-proc-macro2-diagnostics+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2-diagnostics+default-devel-0.10.1-2.el10_0.noarch.rpm;name=aarch64_rust-proc-macro2-diagnostics+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2-diagnostics+default-devel}"
SRC_URI[aarch64_rust-proc-macro2-diagnostics+default-devel.sha256sum] = "66ac5ce7c1035f0ea7834679296361342808b3698414ce08f23a0b35504d81ac"

URI_aarch64_rust-proc-macro2-diagnostics+yansi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2-diagnostics+yansi-devel-0.10.1-2.el10_0.noarch.rpm;name=aarch64_rust-proc-macro2-diagnostics+yansi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2-diagnostics+yansi-devel}"
SRC_URI[aarch64_rust-proc-macro2-diagnostics+yansi-devel.sha256sum] = "6640ebd89b73a4d07ad18261d6010912213892549e06ca59ff47451cb1046696"

URI_aarch64_rust-proc-macro2-diagnostics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2-diagnostics-devel-0.10.1-2.el10_0.noarch.rpm;name=aarch64_rust-proc-macro2-diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2-diagnostics-devel}"
SRC_URI[aarch64_rust-proc-macro2-diagnostics-devel.sha256sum] = "343f553444c6f47cbbdb59005bc0c550619d78a3b66ef855be5ab1e5dd764557"

RDEPENDS:rust-proc-macro2-diagnostics+colors-devel = " \
 cargo \
 rust-proc-macro2-diagnostics+yansi-devel \
 rust-proc-macro2-diagnostics-devel \
 "
RDEPENDS:rust-proc-macro2-diagnostics+default-devel = " \
 cargo \
 rust-proc-macro2-diagnostics+colors-devel \
 rust-proc-macro2-diagnostics-devel \
 "
RDEPENDS:rust-proc-macro2-diagnostics+yansi-devel = " \
 cargo \
 rust-proc-macro2-diagnostics-devel \
 rust-yansi+default-devel \
 "
RDEPENDS:rust-proc-macro2-diagnostics-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-version_check+default-devel \
 "
