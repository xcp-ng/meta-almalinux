# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libcst_derive"
PV = "1.9.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-libcst_derive+default-devel \
 rust-libcst_derive-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libcst_derive-1.9.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "61818ebd7e8f9e8561d8b21bcba146f359f97bdf6f2a45ad0eb8e8a35d95744d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst_derive+default-devel-1.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst_derive+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libcst_derive+default-devel.sha256sum] = "fccce694ec64593f117e3da395730911b60e02ed52667e458f5d54eb7e6e1d6d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst_derive-devel-1.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst_derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libcst_derive-devel.sha256sum] = "c7a8a21e13c06fcdd729686dab37c67a0748b2014bc94f0cd7876738c0b84e16"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst_derive+default-devel-1.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-libcst_derive+default-devel;unpack=0"
SRC_URI[aarch64_rust-libcst_derive+default-devel.sha256sum] = "ff74f1a942d26204b7061448fd5b713668789d1c31f6d256c724f558f8c250f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst_derive-devel-1.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-libcst_derive-devel;unpack=0"
SRC_URI[aarch64_rust-libcst_derive-devel.sha256sum] = "367167e52750a7e9e4d312d859ae9113d495b33bffa3d888ccb9991f7affa44d"

RDEPENDS:rust-libcst_derive+default-devel = " \
 cargo \
 rust-libcst_derive-devel \
 "
RDEPENDS:rust-libcst_derive-devel = " \
 cargo \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
