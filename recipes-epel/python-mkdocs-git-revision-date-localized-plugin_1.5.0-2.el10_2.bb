# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-git-revision-date-localized-plugin"
PV = "1.5.0"
PR = "2.el10_2"
PACKAGES = " \
 python3-mkdocs-git-revision-date-localized-plugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-git-revision-date-localized-plugin-1.5.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26739ab91e3ed34addba02b4ebe3888f9e1bdfb8ae6662d848af54c27c563d34"

URI_x86_64_v2_python3-mkdocs-git-revision-date-localized-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-git-revision-date-localized-plugin-1.5.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-git-revision-date-localized-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-git-revision-date-localized-plugin}"
SRC_URI[x86_64_v2_python3-mkdocs-git-revision-date-localized-plugin.sha256sum] = "38afb747cd28414be59411d218e824d8d447088722d24d8b6391662e45fddcf4"

URI_aarch64_python3-mkdocs-git-revision-date-localized-plugin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-git-revision-date-localized-plugin-1.5.0-2.el10_2.noarch.rpm;name=aarch64_python3-mkdocs-git-revision-date-localized-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-git-revision-date-localized-plugin}"
SRC_URI[aarch64_python3-mkdocs-git-revision-date-localized-plugin.sha256sum] = "b8ca2865b322c5bc7c4eb2a921c919887fec45af9373b341fd067c959d6985ad"

RDEPENDS:python3-mkdocs-git-revision-date-localized-plugin = " \
 mkdocs \
 python3 \
 python3-GitPython \
 python3-babel \
 "
