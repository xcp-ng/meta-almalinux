# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-bracex"
PV = "2.5"
PR = "6.el10_2"
PACKAGES = " \
 python3-bracex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-bracex-2.5-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6307e38e7d7b5a09fea3f3a2ac22ec7d0905263e37a7c0c550a2089c3a97b18a"

URI_x86_64_v2_python3-bracex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bracex-2.5-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-bracex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bracex}"
SRC_URI[x86_64_v2_python3-bracex.sha256sum] = "e90c4b1338abacc2797080b4e842786c7f0adc98f189954336cf46e7b7ead672"

URI_aarch64_python3-bracex = "${EPEL_MIRROR}/aarch64/Packages/p/python3-bracex-2.5-6.el10_2.noarch.rpm;name=aarch64_python3-bracex;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bracex}"
SRC_URI[aarch64_python3-bracex.sha256sum] = "a734aa336ba775d3766bf3bb99e4cb7e59d06bd4d840b5883a53d31b1cafa2fa"

RDEPENDS:python3-bracex = " \
 python3 \
 "
