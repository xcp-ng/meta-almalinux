# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-data-hash"
PV = "0.2.0.1"
PR = "36.el10_0"
PACKAGES = " \
 ghc-data-hash \
 ghc-data-hash-devel \
 ghc-data-hash-doc \
 ghc-data-hash-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-data-hash-0.2.0.1-36.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98f7e1f4911586ef96559da28e7b2583f618b75eb8651d985677986ad48b8a68"

URI_x86_64_v2_ghc-data-hash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-hash-0.2.0.1-36.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-hash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-hash}"
SRC_URI[x86_64_v2_ghc-data-hash.sha256sum] = "102b078ec7c1063c709dc8a498e6d1114130846c8909c59dd28f2df61a5620f6"

URI_x86_64_v2_ghc-data-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-hash-devel-0.2.0.1-36.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-hash-devel}"
SRC_URI[x86_64_v2_ghc-data-hash-devel.sha256sum] = "af33db8385af6684dc389d224e8214e3e93caf5733b047a155fcec554d303128"

URI_x86_64_v2_ghc-data-hash-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-hash-doc-0.2.0.1-36.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-data-hash-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-hash-doc}"
SRC_URI[x86_64_v2_ghc-data-hash-doc.sha256sum] = "4c981b0d6df10df90a8eda7e87b3b4476563ac1355af1de4a375a13244a9a0f9"

URI_x86_64_v2_ghc-data-hash-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-hash-prof-0.2.0.1-36.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-hash-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-hash-prof}"
SRC_URI[x86_64_v2_ghc-data-hash-prof.sha256sum] = "4f07654b60533c8b4b0546d581b6aaaef70427e82d19d430d09201cb00e9226c"

URI_aarch64_ghc-data-hash = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-hash-0.2.0.1-36.el10_0.aarch64.rpm;name=aarch64_ghc-data-hash;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-hash}"
SRC_URI[aarch64_ghc-data-hash.sha256sum] = "f1e3869364efdded3962c81f6f3b4b7c1f0e3440d9fd84c94276d00137f15793"

URI_aarch64_ghc-data-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-hash-devel-0.2.0.1-36.el10_0.aarch64.rpm;name=aarch64_ghc-data-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-hash-devel}"
SRC_URI[aarch64_ghc-data-hash-devel.sha256sum] = "86fab3bb2a990378c9415d084f28f516f3aa333e91e836636bc5b2cf7ada02a7"

URI_aarch64_ghc-data-hash-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-hash-doc-0.2.0.1-36.el10_0.noarch.rpm;name=aarch64_ghc-data-hash-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-hash-doc}"
SRC_URI[aarch64_ghc-data-hash-doc.sha256sum] = "5e8f9918173b9770a2dbd7e71a9db16cc2b903be076439c7f9b3900d5cc937d0"

URI_aarch64_ghc-data-hash-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-hash-prof-0.2.0.1-36.el10_0.aarch64.rpm;name=aarch64_ghc-data-hash-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-hash-prof}"
SRC_URI[aarch64_ghc-data-hash-prof.sha256sum] = "9f759cf5516a530a3ddabb165ad0c5a7c5060f54e4b85ddec5edffc5c13a4066"

RDEPENDS:ghc-data-hash = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-data-hash-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-data-hash \
 "
RDEPENDS:ghc-data-hash-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-data-hash-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-data-hash-devel \
 "
