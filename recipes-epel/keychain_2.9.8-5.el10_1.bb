# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keychain"
PV = "2.9.8"
PR = "5.el10_1"
PACKAGES = " \
 keychain \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keychain-2.9.8-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc9c991c902599924368ada98cf842b82fa25b0b6e0792d7b4874dd93990b334"

URI_x86_64_v2_keychain = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keychain-2.9.8-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_keychain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keychain}"
SRC_URI[x86_64_v2_keychain.sha256sum] = "e41656d9c36e63486ea357d776ec855f47ecb683d6e1b2ec494f9edcdb2b0f72"

URI_aarch64_keychain = "${EPEL_MIRROR}/aarch64/Packages/k/keychain-2.9.8-5.el10_1.noarch.rpm;name=aarch64_keychain;unpack=0"
SRC_URI:append = " ${URI_aarch64_keychain}"
SRC_URI[aarch64_keychain.sha256sum] = "bb1cf361fa1935260dcf053c0269f078f6f1d7d1a71658f36c42e532673c354b"

RDEPENDS:keychain = " \
 bash \
 findutils \
 "
