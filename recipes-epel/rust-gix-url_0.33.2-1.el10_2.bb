# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-url"
PV = "0.33.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-url+default-devel \
 rust-gix-url+document-features-devel \
 rust-gix-url+serde-devel \
 rust-gix-url-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-url-0.33.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6f27356849768d80dc2324c53adc708f1ce2a28c66d743dbdb6b496b13f59c0"

URI_x86_64_v2_rust-gix-url+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url+default-devel-0.33.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url+default-devel}"
SRC_URI[x86_64_v2_rust-gix-url+default-devel.sha256sum] = "3dddc46abf4d6fc37f40be2c9dc2ad3e5ff08b198f0de096086c1901b023422c"

URI_x86_64_v2_rust-gix-url+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url+document-features-devel-0.33.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-url+document-features-devel.sha256sum] = "73dac3cf7b19e410584cb92ab9dfebf3cf0fe743bc3fef88e1845f7e0e6647a5"

URI_x86_64_v2_rust-gix-url+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url+serde-devel-0.33.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-url+serde-devel.sha256sum] = "2b56cc654f9bf8c7bf7f187144ff874f141f79f9bcd5dc509037d3fe950c475d"

URI_x86_64_v2_rust-gix-url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url-devel-0.33.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url-devel}"
SRC_URI[x86_64_v2_rust-gix-url-devel.sha256sum] = "036b2930e2f8230655a92360eb37f8e7969aa0060f6452d4c9e53997ced0cf82"

URI_aarch64_rust-gix-url+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url+default-devel-0.33.2-1.el10_2.noarch.rpm;name=aarch64_rust-gix-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url+default-devel}"
SRC_URI[aarch64_rust-gix-url+default-devel.sha256sum] = "c9228f2e474f09dfe2d7ea3363163fc49b240c804041903ea2b0821c11c7d23f"

URI_aarch64_rust-gix-url+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url+document-features-devel-0.33.2-1.el10_2.noarch.rpm;name=aarch64_rust-gix-url+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url+document-features-devel}"
SRC_URI[aarch64_rust-gix-url+document-features-devel.sha256sum] = "4726c7332c0dd39fcf410c940d13cb83b38eac119b0270ea2b262da59934d9cb"

URI_aarch64_rust-gix-url+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url+serde-devel-0.33.2-1.el10_2.noarch.rpm;name=aarch64_rust-gix-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url+serde-devel}"
SRC_URI[aarch64_rust-gix-url+serde-devel.sha256sum] = "c1b2fa09ada9984f83dae00655bc6fc7501082d62c33928a1aad0794b0b62948"

URI_aarch64_rust-gix-url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url-devel-0.33.2-1.el10_2.noarch.rpm;name=aarch64_rust-gix-url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url-devel}"
SRC_URI[aarch64_rust-gix-url-devel.sha256sum] = "ee8499744f3fe1b127d180fab3bd91e3a182161f57b0d852ede257a8d495f97a"

RDEPENDS:rust-gix-url+default-devel = " \
 cargo \
 rust-gix-url-devel \
 "
RDEPENDS:rust-gix-url+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-url-devel \
 "
RDEPENDS:rust-gix-url+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-url-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-url-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-features+default-devel \
 rust-gix-path+default-devel \
 rust-percent-encoding+default-devel \
 rust-thiserror+default-devel \
 "
