# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cache-Memcached"
PV = "1.30"
PR = "36.el10_0"
PACKAGES = " \
 perl-Cache-Memcached \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Cache-Memcached-1.30-36.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbb4bdfdbfe6f1204e0ffcc41e4055cfc647fc40c7e9bcb318a88b8e48f39c5b"

URI_x86_64_v2_perl-Cache-Memcached = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cache-Memcached-1.30-36.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Cache-Memcached;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cache-Memcached}"
SRC_URI[x86_64_v2_perl-Cache-Memcached.sha256sum] = "b735c10fbf461029a56cc09d7affcd6db8998f8dd71048ecdba5a22740e8c023"

URI_aarch64_perl-Cache-Memcached = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cache-Memcached-1.30-36.el10_0.noarch.rpm;name=aarch64_perl-Cache-Memcached;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cache-Memcached}"
SRC_URI[aarch64_perl-Cache-Memcached.sha256sum] = "eb2d5bd183fbe89793e6bd20424a605a42291dc1b9eb30bbb31478bf73b597be"

RDEPENDS:perl-Cache-Memcached = " \
 perl-Encode \
 perl-Errno \
 perl-IO \
 perl-Socket \
 perl-Storable \
 perl-String-CRC32 \
 perl-Time-HiRes \
 perl-constant \
 perl-fields \
 perl-libs \
 perl-vars \
 "
