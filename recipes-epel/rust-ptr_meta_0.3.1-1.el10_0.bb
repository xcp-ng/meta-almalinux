# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ptr_meta"
PV = "0.3.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-ptr_meta+default-devel \
 rust-ptr_meta+derive-devel \
 rust-ptr_meta+ptr_meta_derive-devel \
 rust-ptr_meta+std-devel \
 rust-ptr_meta-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ptr_meta-0.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0df64b967d92ae32170383cf0ea9fca1a9dc3614525eced7dcbc6c6133fb5063"

URI_x86_64_v2_rust-ptr_meta+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+default-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+default-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+default-devel.sha256sum] = "19655efa87e50e2ac8df56eb34c79e417cd20d6c93a742df7c404a83ecf5057a"

URI_x86_64_v2_rust-ptr_meta+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+derive-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+derive-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+derive-devel.sha256sum] = "450957b3d1f2210a8521d1a5b738937f984e4ed18bc6c714ac2e3656ca55e37d"

URI_x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+ptr_meta_derive-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel.sha256sum] = "5f61b56eb241686a3b4fb944c1ecf7ce3dc18e817f7e0237b641ee107a374ea9"

URI_x86_64_v2_rust-ptr_meta+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+std-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+std-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+std-devel.sha256sum] = "2044b63d901edf62e8561b862f92b2d6868dc5bc324b55314e11df18155983fc"

URI_x86_64_v2_rust-ptr_meta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta-devel.sha256sum] = "bffdc17f9de3397600d558d1dba64def5fb1c8c49fe766816a919d1ae5788deb"

URI_aarch64_rust-ptr_meta+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+default-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-ptr_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+default-devel}"
SRC_URI[aarch64_rust-ptr_meta+default-devel.sha256sum] = "a1c5634b1842e808e14ed6d078339084ad857ec1e08eee978fe8ba750d7f78de"

URI_aarch64_rust-ptr_meta+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+derive-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-ptr_meta+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+derive-devel}"
SRC_URI[aarch64_rust-ptr_meta+derive-devel.sha256sum] = "febe4922ac41f167f42e9b4a4896935947dc5cd8cf03d17fede7299cd58ddb83"

URI_aarch64_rust-ptr_meta+ptr_meta_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+ptr_meta_derive-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-ptr_meta+ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+ptr_meta_derive-devel}"
SRC_URI[aarch64_rust-ptr_meta+ptr_meta_derive-devel.sha256sum] = "e2dcf81d2341790bbe820e8a4432f967cd481d59bf45b22c5767fffe9b820f88"

URI_aarch64_rust-ptr_meta+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+std-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-ptr_meta+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+std-devel}"
SRC_URI[aarch64_rust-ptr_meta+std-devel.sha256sum] = "bc5af38cbcec8146eb9eaebf635a4a83d9bb27dc6f9bf01aaa213759d0435634"

URI_aarch64_rust-ptr_meta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-ptr_meta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta-devel}"
SRC_URI[aarch64_rust-ptr_meta-devel.sha256sum] = "40c4d5d1ac30583e6d3a5effa7273a24e539f88b60be5227f2b0cca31e112be8"

RDEPENDS:rust-ptr_meta+default-devel = " \
 cargo \
 rust-ptr_meta+derive-devel \
 rust-ptr_meta+std-devel \
 rust-ptr_meta-devel \
 "
RDEPENDS:rust-ptr_meta+derive-devel = " \
 cargo \
 rust-ptr_meta+ptr_meta_derive-devel \
 rust-ptr_meta-devel \
 "
RDEPENDS:rust-ptr_meta+ptr_meta_derive-devel = " \
 cargo \
 rust-ptr_meta-devel \
 rust-ptr_meta_derive-devel \
 "
RDEPENDS:rust-ptr_meta+std-devel = " \
 cargo \
 rust-ptr_meta-devel \
 "
RDEPENDS:rust-ptr_meta-devel = " \
 cargo \
 rust \
 "
