# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libdeflate-sys"
PV = "1.26.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-libdeflate-sys+default-devel \
 rust-libdeflate-sys+dynamic-devel \
 rust-libdeflate-sys+freestanding-devel \
 rust-libdeflate-sys-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libdeflate-sys-1.26.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e1d8f0779e2560bf1fb0e7f8df25ed1dca1e5f5ea58fe8d8e486411aa1d7b37e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys+default-devel-1.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libdeflate-sys+default-devel.sha256sum] = "5b4821c89349bce33852baca8e5ff931b2d413954b53df33bd09cf2e6e061df7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys+dynamic-devel-1.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys+dynamic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libdeflate-sys+dynamic-devel.sha256sum] = "933da632435e5ba51159fdf44ed314b278c8b5f1017cf1cc0be69055031cb3b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys+freestanding-devel-1.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys+freestanding-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libdeflate-sys+freestanding-devel.sha256sum] = "a36dcadd2158fc28d5f6e2520b79771eeb50ed6de3b09abe09e9025fdaecf132"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys-devel-1.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libdeflate-sys-devel.sha256sum] = "c15d5d5c3b294cbf71a77173bd8526e23e8ffbd1330271427e226cd478be896c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys+default-devel-1.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-libdeflate-sys+default-devel;unpack=0"
SRC_URI[aarch64_rust-libdeflate-sys+default-devel.sha256sum] = "58648dfbf4b92ffd4e39ff0c5e79a096850cae9889fae4cb30c8ba8f47aa559e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys+dynamic-devel-1.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-libdeflate-sys+dynamic-devel;unpack=0"
SRC_URI[aarch64_rust-libdeflate-sys+dynamic-devel.sha256sum] = "588070010e570ceaf9fe0ea5c6de0dd7ed04d5438abce8d0a759d754a5f8ccfb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys+freestanding-devel-1.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-libdeflate-sys+freestanding-devel;unpack=0"
SRC_URI[aarch64_rust-libdeflate-sys+freestanding-devel.sha256sum] = "8c95aa6f7380a370ea51bff686688a358a3ab1ead01bc6a9b3e1a17fa7ecfb61"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys-devel-1.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-libdeflate-sys-devel;unpack=0"
SRC_URI[aarch64_rust-libdeflate-sys-devel.sha256sum] = "bcccd9cbc4888b0ea5285302bbd59e5b40bb18b628ac22d5f1c97c08c9482630"

RDEPENDS:rust-libdeflate-sys+default-devel = " \
 cargo \
 rust-libdeflate-sys-devel \
 "
RDEPENDS:rust-libdeflate-sys+dynamic-devel = " \
 cargo \
 rust-libdeflate-sys-devel \
 "
RDEPENDS:rust-libdeflate-sys+freestanding-devel = " \
 cargo \
 rust-libdeflate-sys-devel \
 "
RDEPENDS:rust-libdeflate-sys-devel = " \
 cargo \
 libdeflate-devel \
 rust-cc+default-devel \
 rust-pkg-config+default-devel \
 "
