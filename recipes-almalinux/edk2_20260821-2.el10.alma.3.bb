# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "edk2"
PV = "20260821"
PR = "2.el10.alma.3"
PACKAGES = " \
 edk2-aarch64 \
 edk2-ovmf \
 edk2-tools \
 edk2-tools-doc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/edk2-20260821-2.el10.alma.3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "008fb09bf0eb7cb10c91d32458fe956d9f8a4581cc635de650ee2bcc0e6284d0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-aarch64-20260821-2.el10.alma.3.noarch.rpm;name=x86_64_v2_edk2-aarch64;unpack=0"
SRC_URI[x86_64_v2_edk2-aarch64.sha256sum] = "77662915ed69627cb41cc5a313eed1fad6f6064da1421f2bab73ef854c67a6ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-ovmf-20260821-2.el10.alma.3.noarch.rpm;name=x86_64_v2_edk2-ovmf;unpack=0"
SRC_URI[x86_64_v2_edk2-ovmf.sha256sum] = "ae32270c20c28740a251f1fa5e467c5888d4b9baf2f4492407a1f8e160b03f9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-tools-20260821-2.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_edk2-tools;unpack=0"
SRC_URI[x86_64_v2_edk2-tools.sha256sum] = "77f757c699b9622e41978e0e18d0c1b3e1a835beb146d2260a5abb9dbfc3f905"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-tools-doc-20260821-2.el10.alma.3.noarch.rpm;name=x86_64_v2_edk2-tools-doc;unpack=0"
SRC_URI[x86_64_v2_edk2-tools-doc.sha256sum] = "0c8b8a03e0940c6f86d5c76985987aa28c6da52d6e5b0a4d78556f84bdcfd963"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-aarch64-20260821-2.el10.alma.3.noarch.rpm;name=aarch64_edk2-aarch64;unpack=0"
SRC_URI[aarch64_edk2-aarch64.sha256sum] = "77662915ed69627cb41cc5a313eed1fad6f6064da1421f2bab73ef854c67a6ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-ovmf-20260821-2.el10.alma.3.noarch.rpm;name=aarch64_edk2-ovmf;unpack=0"
SRC_URI[aarch64_edk2-ovmf.sha256sum] = "ae32270c20c28740a251f1fa5e467c5888d4b9baf2f4492407a1f8e160b03f9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-tools-20260821-2.el10.alma.3.aarch64.rpm;name=aarch64_edk2-tools;unpack=0"
SRC_URI[aarch64_edk2-tools.sha256sum] = "1f1d851dcda1c914fbceb6e68fe4d9a9e79e1bf2fdf6dda8fa66fb75c135b47e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-tools-doc-20260821-2.el10.alma.3.noarch.rpm;name=aarch64_edk2-tools-doc;unpack=0"
SRC_URI[aarch64_edk2-tools-doc.sha256sum] = "0c8b8a03e0940c6f86d5c76985987aa28c6da52d6e5b0a4d78556f84bdcfd963"

RDEPENDS:edk2-aarch64 = " \
 "
RDEPENDS:edk2-ovmf = " \
 "
RDEPENDS:edk2-tools = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:edk2-tools-doc = " \
 "
