# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Filesys-Df"
PV = "0.92"
PR = "55.el10_0"
PACKAGES = " \
 perl-Filesys-Df \
 perl-Filesys-Df-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Filesys-Df-0.92-55.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92b47c86c394d0683eeda158fd08c618f00cffa032ba0ad79ed0706beb061d70"

URI_x86_64_v2_perl-Filesys-Df = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Filesys-Df-0.92-55.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Filesys-Df;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Filesys-Df}"
SRC_URI[x86_64_v2_perl-Filesys-Df.sha256sum] = "c5a20bd692b845a6a9e5a55f57cf4a4585809acda0d41edb053789910a43e78e"

URI_x86_64_v2_perl-Filesys-Df-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Filesys-Df-tests-0.92-55.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Filesys-Df-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Filesys-Df-tests}"
SRC_URI[x86_64_v2_perl-Filesys-Df-tests.sha256sum] = "5079a62d9e8d2bc363ebc0d1251305d26ee6d4926e3cc925a9285428da175a0d"

URI_aarch64_perl-Filesys-Df = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Filesys-Df-0.92-55.el10_0.aarch64.rpm;name=aarch64_perl-Filesys-Df;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Filesys-Df}"
SRC_URI[aarch64_perl-Filesys-Df.sha256sum] = "283550d9397567b89c5a3e470344126b908e8f90f8d7e2f14d4418da378f672e"

URI_aarch64_perl-Filesys-Df-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Filesys-Df-tests-0.92-55.el10_0.noarch.rpm;name=aarch64_perl-Filesys-Df-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Filesys-Df-tests}"
SRC_URI[aarch64_perl-Filesys-Df-tests.sha256sum] = "b730ae9800c1ac4c31b21cbb174cf2ebb93aa98a910e7ecc318c8ddc5bcbbadc"

RDEPENDS:perl-Filesys-Df = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Filesys-Df-tests = " \
 bash \
 perl-Filesys-Df \
 perl-Test-Harness \
 perl-libs \
 "
