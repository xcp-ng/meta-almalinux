# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typed-builder-macro"
PV = "0.18.2"
PR = "5.el10_3"
PACKAGES = " \
 rust-typed-builder-macro+default-devel \
 rust-typed-builder-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typed-builder-macro-0.18.2-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "564b1a127326d2ea4539a4af1c174ee9e01b56aebc216c4b67bb203fd9c94fa5"

URI_x86_64_v2_rust-typed-builder-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-builder-macro+default-devel-0.18.2-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-builder-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-builder-macro+default-devel}"
SRC_URI[x86_64_v2_rust-typed-builder-macro+default-devel.sha256sum] = "56989c4538e2223bd7af102117627889a06a1e1c78742c966054fae44fae702d"

URI_x86_64_v2_rust-typed-builder-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-builder-macro-devel-0.18.2-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-builder-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-builder-macro-devel}"
SRC_URI[x86_64_v2_rust-typed-builder-macro-devel.sha256sum] = "c592a2d011c860bbb97b906ff82448bda11b09b249a16a8b13dceddd91e812d6"

URI_aarch64_rust-typed-builder-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-builder-macro+default-devel-0.18.2-5.el10_3.noarch.rpm;name=aarch64_rust-typed-builder-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-builder-macro+default-devel}"
SRC_URI[aarch64_rust-typed-builder-macro+default-devel.sha256sum] = "9c68c3979df23f7db78dc048876dddef50124f3a906ace3280be1b81f8b01661"

URI_aarch64_rust-typed-builder-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-builder-macro-devel-0.18.2-5.el10_3.noarch.rpm;name=aarch64_rust-typed-builder-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-builder-macro-devel}"
SRC_URI[aarch64_rust-typed-builder-macro-devel.sha256sum] = "d8b176c00f40bcfe66316e704511a4ebc8c5f82255f36f5f373bfe3b4aa30e3d"

RDEPENDS:rust-typed-builder-macro+default-devel = " \
 cargo \
 rust-typed-builder-macro-devel \
 "
RDEPENDS:rust-typed-builder-macro-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 "
