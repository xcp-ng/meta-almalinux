# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-stability"
PV = "0.2.1"
PR = "4.el10_1"
PACKAGES = " \
 rust-stability+default-devel \
 rust-stability-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-stability-0.2.1-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3791a356da78920fca64889571a8d5da83db7c31d56d0d26ef75db757a4f9802"

URI_x86_64_v2_rust-stability+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stability+default-devel-0.2.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stability+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stability+default-devel}"
SRC_URI[x86_64_v2_rust-stability+default-devel.sha256sum] = "f2fd9a494d9657da8ab9cdb62b25cef436d841d1c05d673476e941a7f39ef32c"

URI_x86_64_v2_rust-stability-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stability-devel-0.2.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stability-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stability-devel}"
SRC_URI[x86_64_v2_rust-stability-devel.sha256sum] = "60b4037389b06a2756982f4d174911d62ce718f4a1188c7ed419acd80de8aeea"

URI_aarch64_rust-stability+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stability+default-devel-0.2.1-4.el10_1.noarch.rpm;name=aarch64_rust-stability+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stability+default-devel}"
SRC_URI[aarch64_rust-stability+default-devel.sha256sum] = "67dc2c9373671f5c71ce1d9f1ca7eab79868ed28feddd48ffebc052aeddb7bf9"

URI_aarch64_rust-stability-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stability-devel-0.2.1-4.el10_1.noarch.rpm;name=aarch64_rust-stability-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stability-devel}"
SRC_URI[aarch64_rust-stability-devel.sha256sum] = "0a6a1110c5f97ec6750ef4966c0eeaf2c0298d0d5e0872fc29b92e5f35102da3"

RDEPENDS:rust-stability+default-devel = " \
 cargo \
 rust-stability-devel \
 "
RDEPENDS:rust-stability-devel = " \
 cargo \
 rust \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+derive-devel \
 rust-syn+full-devel \
 "
