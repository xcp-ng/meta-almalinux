# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-reportlab"
PV = "4.5.1"
PR = "1.el10_3"
PACKAGES = " \
 python3-reportlab \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-reportlab-4.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c595877c872cf2d89d30b50b3219e8308b863a722573526b92ab59d927075b14"

URI_x86_64_v2_python3-reportlab = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-reportlab-4.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-reportlab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-reportlab}"
SRC_URI[x86_64_v2_python3-reportlab.sha256sum] = "b5bd383088c4fc42cd0940eda1b5b72ad81eab98d3ff3d2d1361cdb90dd52f36"

URI_aarch64_python3-reportlab = "${EPEL_MIRROR}/aarch64/Packages/p/python3-reportlab-4.5.1-1.el10_3.noarch.rpm;name=aarch64_python3-reportlab;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-reportlab}"
SRC_URI[aarch64_python3-reportlab.sha256sum] = "35b980390372cce7ea5578eb1a5044cfabed7d4a502ae32f71522bc0dbd04ccc"

RDEPENDS:python3-reportlab = " \
 dejavu-sans-fonts \
 python3 \
 python3-charset-normalizer \
 python3-pillow \
 "
