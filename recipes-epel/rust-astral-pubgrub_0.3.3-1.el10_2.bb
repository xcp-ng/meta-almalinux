# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral-pubgrub"
PV = "0.3.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-astral-pubgrub+default-devel \
 rust-astral-pubgrub+serde-devel \
 rust-astral-pubgrub-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-astral-pubgrub-0.3.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de8326f89f9d7eebdf0a98034e01692f357bdec74fcf5e990ca89be64fbba02b"

URI_x86_64_v2_rust-astral-pubgrub+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-pubgrub+default-devel-0.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-pubgrub+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-pubgrub+default-devel}"
SRC_URI[x86_64_v2_rust-astral-pubgrub+default-devel.sha256sum] = "9c63806be1b8fc4145c6ddefca02cba99ca0a5cf0d5931cd13fb0694b056faf3"

URI_x86_64_v2_rust-astral-pubgrub+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-pubgrub+serde-devel-0.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-pubgrub+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-pubgrub+serde-devel}"
SRC_URI[x86_64_v2_rust-astral-pubgrub+serde-devel.sha256sum] = "ea6c415466ba5606f7d1c852c78b49eee10f5c559664e41fcc8e3381b3892e51"

URI_x86_64_v2_rust-astral-pubgrub-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-pubgrub-devel-0.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-pubgrub-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-pubgrub-devel}"
SRC_URI[x86_64_v2_rust-astral-pubgrub-devel.sha256sum] = "8cbcf8d61aaa97cf098c758530821860a97fddfec322cc0966415e8f2029c46d"

URI_aarch64_rust-astral-pubgrub+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-pubgrub+default-devel-0.3.3-1.el10_2.noarch.rpm;name=aarch64_rust-astral-pubgrub+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-pubgrub+default-devel}"
SRC_URI[aarch64_rust-astral-pubgrub+default-devel.sha256sum] = "99f9f6707c1244bbecd930b1f9a39bb402b6b8779a0c4d374be86db47010630c"

URI_aarch64_rust-astral-pubgrub+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-pubgrub+serde-devel-0.3.3-1.el10_2.noarch.rpm;name=aarch64_rust-astral-pubgrub+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-pubgrub+serde-devel}"
SRC_URI[aarch64_rust-astral-pubgrub+serde-devel.sha256sum] = "79906becf3e1a00367278c6c09055ca61af6034257d5d5a2ca5d6e4fa2c6093a"

URI_aarch64_rust-astral-pubgrub-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-pubgrub-devel-0.3.3-1.el10_2.noarch.rpm;name=aarch64_rust-astral-pubgrub-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-pubgrub-devel}"
SRC_URI[aarch64_rust-astral-pubgrub-devel.sha256sum] = "f22448d6c05152e7e0f9edf3684b8a52040cc95d5721a511f887715be38a562f"

RDEPENDS:rust-astral-pubgrub+default-devel = " \
 cargo \
 rust-astral-pubgrub-devel \
 "
RDEPENDS:rust-astral-pubgrub+serde-devel = " \
 cargo \
 rust-astral-pubgrub-devel \
 rust-astral-version-ranges+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-astral-pubgrub-devel = " \
 cargo \
 rust-astral-version-ranges+default-devel \
 rust-indexmap+default-devel \
 rust-log+default-devel \
 rust-priority-queue+default-devel \
 rust-rustc-hash+default-devel \
 rust-thiserror+default-devel \
 "
