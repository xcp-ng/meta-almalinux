# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "suitesparse"
PV = "7.11.0"
PR = "1.el10_0"
PACKAGES = " \
 suitesparse \
 suitesparse-devel \
 suitesparse-doc \
 suitesparse-static \
 suitesparse64 \
 suitesparse64-devel \
 suitesparse64-static \
 suitesparse64_ \
 suitesparse64_-devel \
 suitesparse64_-static \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/suitesparse-7.11.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "61b74b98867350b9f9dafa584b356bc91f361a71d128a687e1ab549215ffaebb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse-7.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse;unpack=0"
SRC_URI[x86_64_v2_suitesparse.sha256sum] = "d4b26535691f9999d8059a8d08a98f211ac6bef7e6430659395fb7d06ee9497d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse-devel-7.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse-devel;unpack=0"
SRC_URI[x86_64_v2_suitesparse-devel.sha256sum] = "73f942ec5494718d26537ac3e4f5372f30302e96b73fbff5c6896bbf389cecee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse-doc-7.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_suitesparse-doc;unpack=0"
SRC_URI[x86_64_v2_suitesparse-doc.sha256sum] = "be6dd8ecc5d5351ea291ba9929332ef5b078ca6f1e42b3478cf9dd926e7dbae8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse-static-7.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse-static;unpack=0"
SRC_URI[x86_64_v2_suitesparse-static.sha256sum] = "7bbe7fe193a207916ae42ea4c93df21b063e3866b8865d7620e83994374480e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse64-7.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse64;unpack=0"
SRC_URI[x86_64_v2_suitesparse64.sha256sum] = "b0a0212b3bbcfd88288b64a32a8636697e8a4b861fe224af8d3b9f3b0da4884a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse64-devel-7.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse64-devel;unpack=0"
SRC_URI[x86_64_v2_suitesparse64-devel.sha256sum] = "54f2e3b17530eade2def4e8b0a5e2b492bafe0869156f75f99a6a6de08839c21"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse64-static-7.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse64-static;unpack=0"
SRC_URI[x86_64_v2_suitesparse64-static.sha256sum] = "a78d7c9db9faf6adf5c9fc89057a79a797e0996316f2bb3d11de016adbc21a8e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse64_-7.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse64_;unpack=0"
SRC_URI[x86_64_v2_suitesparse64_.sha256sum] = "4658e74e5e2a1d253e03ce52c9e1902c453e4d07fdd70606cb2e1976c278f0ef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse64_-devel-7.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse64_-devel;unpack=0"
SRC_URI[x86_64_v2_suitesparse64_-devel.sha256sum] = "097f6045ef50d5945735a655aa13299e01049badc9b26a92c6bafe1c477a9820"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse64_-static-7.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse64_-static;unpack=0"
SRC_URI[x86_64_v2_suitesparse64_-static.sha256sum] = "278ee7983a2e0aac1867310d63ac605456e4c2a9a2e23ea6ecb5d8e835187bd7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/suitesparse-7.11.0-1.el10_0.aarch64.rpm;name=aarch64_suitesparse;unpack=0"
SRC_URI[aarch64_suitesparse.sha256sum] = "aeb2cfca597ff3b02822b7c587facaaa30348028edfc7cfd0c34905289bb9fc4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/suitesparse-devel-7.11.0-1.el10_0.aarch64.rpm;name=aarch64_suitesparse-devel;unpack=0"
SRC_URI[aarch64_suitesparse-devel.sha256sum] = "9c314daa71f3577a2272738cdbc13a6c4765cb61c5ae28cdb27b282f746370fe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/suitesparse-doc-7.11.0-1.el10_0.noarch.rpm;name=aarch64_suitesparse-doc;unpack=0"
SRC_URI[aarch64_suitesparse-doc.sha256sum] = "d621ea20be2fa40fb89c8d411ac6427f388108f31936631bb69148edf4c2fef1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/suitesparse-static-7.11.0-1.el10_0.aarch64.rpm;name=aarch64_suitesparse-static;unpack=0"
SRC_URI[aarch64_suitesparse-static.sha256sum] = "58e6f0a2e0281e0b9054f6852541a93aa7da7a2c18608edc9c457a277279d3e7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/suitesparse64-7.11.0-1.el10_0.aarch64.rpm;name=aarch64_suitesparse64;unpack=0"
SRC_URI[aarch64_suitesparse64.sha256sum] = "c1cf527d92752870ed756700d79bba34a8d2a0dcceb39e036cb1b42b11b8f703"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/suitesparse64-devel-7.11.0-1.el10_0.aarch64.rpm;name=aarch64_suitesparse64-devel;unpack=0"
SRC_URI[aarch64_suitesparse64-devel.sha256sum] = "60f1c59b9a3a49f750d1e6382e3fb9db25d55bb68ec9d61872b2db19d0fe72f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/suitesparse64-static-7.11.0-1.el10_0.aarch64.rpm;name=aarch64_suitesparse64-static;unpack=0"
SRC_URI[aarch64_suitesparse64-static.sha256sum] = "99fae7301e124c203385a6b843d544acf16c1950787a7a94c2307fd22a2e0d76"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/suitesparse64_-7.11.0-1.el10_0.aarch64.rpm;name=aarch64_suitesparse64_;unpack=0"
SRC_URI[aarch64_suitesparse64_.sha256sum] = "6e938472595f8f1452f540a1a71deec88d8383662911bb3178ea72ce7f26f20f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/suitesparse64_-devel-7.11.0-1.el10_0.aarch64.rpm;name=aarch64_suitesparse64_-devel;unpack=0"
SRC_URI[aarch64_suitesparse64_-devel.sha256sum] = "348c03b0aeac0ca0642c3f42ec4dec21953465b9dd18ab58e819fecf4d762538"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/suitesparse64_-static-7.11.0-1.el10_0.aarch64.rpm;name=aarch64_suitesparse64_-static;unpack=0"
SRC_URI[aarch64_suitesparse64_-static.sha256sum] = "7ec43c01db30c2b0cc315f022f68c51ec39880f0b21e3171477c36250a0a1868"

RDEPENDS:suitesparse = " \
 flexiblas-netlib \
 glibc \
 gmp \
 libgcc \
 libgomp \
 libstdc++ \
 mpfr \
 "
RDEPENDS:suitesparse-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 suitesparse \
 suitesparse-devel \
 "
RDEPENDS:suitesparse-doc = " \
 suitesparse \
 "
RDEPENDS:suitesparse-static = " \
 suitesparse-devel \
 "
RDEPENDS:suitesparse64 = " \
 glibc \
 gmp \
 libgcc \
 libgomp \
 libstdc++ \
 mpfr \
 openblas-serial \
 "
RDEPENDS:suitesparse64-devel = " \
 suitesparse-devel \
 suitesparse64 \
 "
RDEPENDS:suitesparse64-static = " \
 suitesparse-devel \
 "
RDEPENDS:suitesparse64_ = " \
 glibc \
 gmp \
 libgcc \
 libgomp \
 libstdc++ \
 mpfr \
 openblas-serial \
 "
RDEPENDS:suitesparse64_-devel = " \
 suitesparse-devel \
 suitesparse64_ \
 "
RDEPENDS:suitesparse64_-static = " \
 suitesparse-devel \
 "
