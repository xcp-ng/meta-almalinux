# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ndarray"
PV = "0.16.1"
PR = "4.el10_3"
PACKAGES = " \
 rust-ndarray+approx-devel \
 rust-ndarray+default-devel \
 rust-ndarray+matrixmultiply-threading-devel \
 rust-ndarray+portable-atomic-critical-section-devel \
 rust-ndarray+rayon-devel \
 rust-ndarray+serde-devel \
 rust-ndarray+std-devel \
 rust-ndarray+test-devel \
 rust-ndarray-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ndarray-0.16.1-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45927de718af13b81f2f4f441dae222dcee0afe93f48c5892dc2c5286f002d9a"

URI_x86_64_v2_rust-ndarray+approx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+approx-devel-0.16.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+approx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+approx-devel}"
SRC_URI[x86_64_v2_rust-ndarray+approx-devel.sha256sum] = "115e77cd8a8e50acd398b51a8d4a0bf31f5e4c25d4936ae38bff9196a0f25cb7"

URI_x86_64_v2_rust-ndarray+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+default-devel-0.16.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+default-devel}"
SRC_URI[x86_64_v2_rust-ndarray+default-devel.sha256sum] = "dc8729f3bb96af6d70658ca0ffb312b3d6834193999e607351b534c166d7f854"

URI_x86_64_v2_rust-ndarray+matrixmultiply-threading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+matrixmultiply-threading-devel-0.16.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+matrixmultiply-threading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+matrixmultiply-threading-devel}"
SRC_URI[x86_64_v2_rust-ndarray+matrixmultiply-threading-devel.sha256sum] = "8f364c6755b4efad1c62488d4883d5970bd84acd6d7a929f0bf5a252299088ec"

URI_x86_64_v2_rust-ndarray+portable-atomic-critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+portable-atomic-critical-section-devel-0.16.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+portable-atomic-critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+portable-atomic-critical-section-devel}"
SRC_URI[x86_64_v2_rust-ndarray+portable-atomic-critical-section-devel.sha256sum] = "4fa0c4db0dd14eb2afc8bd3fdfa7624e2c2aa15985c8dd31cf6477e67c9f2d07"

URI_x86_64_v2_rust-ndarray+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+rayon-devel-0.16.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+rayon-devel}"
SRC_URI[x86_64_v2_rust-ndarray+rayon-devel.sha256sum] = "f4f6dd62a7bf5e97992d79e7f1f2b6ca7702e598ea5e2628245bd3833d9b1131"

URI_x86_64_v2_rust-ndarray+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+serde-devel-0.16.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+serde-devel}"
SRC_URI[x86_64_v2_rust-ndarray+serde-devel.sha256sum] = "6c1a8d90997f147befd87591f056870ccf15966f2b631004ed27b7c9d127b4a3"

URI_x86_64_v2_rust-ndarray+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+std-devel-0.16.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+std-devel}"
SRC_URI[x86_64_v2_rust-ndarray+std-devel.sha256sum] = "4442e80c74409ff81c17741d4534b783c421ad685d5481dc017a0290757c6d37"

URI_x86_64_v2_rust-ndarray+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+test-devel-0.16.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+test-devel}"
SRC_URI[x86_64_v2_rust-ndarray+test-devel.sha256sum] = "c3e0289d104436b6fb70a514d6f194e85e155dc8242291bcdadb2d2759bc3dd5"

URI_x86_64_v2_rust-ndarray-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray-devel-0.16.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray-devel}"
SRC_URI[x86_64_v2_rust-ndarray-devel.sha256sum] = "87c5ada46e68f41cb6ca53ec68895e45f234c59a71dd9f0e6d9941cf344d82dd"

URI_aarch64_rust-ndarray+approx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+approx-devel-0.16.1-4.el10_3.noarch.rpm;name=aarch64_rust-ndarray+approx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+approx-devel}"
SRC_URI[aarch64_rust-ndarray+approx-devel.sha256sum] = "728847d1f3d719c659382d8b3655ea9a2fff71f0e715686c0d91f05ba87c937e"

URI_aarch64_rust-ndarray+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+default-devel-0.16.1-4.el10_3.noarch.rpm;name=aarch64_rust-ndarray+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+default-devel}"
SRC_URI[aarch64_rust-ndarray+default-devel.sha256sum] = "f937ab33733d5b7231f41dc1e9f78493be3d1d4fec9436c20384ab5c1e4f1767"

URI_aarch64_rust-ndarray+matrixmultiply-threading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+matrixmultiply-threading-devel-0.16.1-4.el10_3.noarch.rpm;name=aarch64_rust-ndarray+matrixmultiply-threading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+matrixmultiply-threading-devel}"
SRC_URI[aarch64_rust-ndarray+matrixmultiply-threading-devel.sha256sum] = "3b05b1ba760e3ae114f0a1173f0dc9259270baebf3a042721cb2333827b262b1"

URI_aarch64_rust-ndarray+portable-atomic-critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+portable-atomic-critical-section-devel-0.16.1-4.el10_3.noarch.rpm;name=aarch64_rust-ndarray+portable-atomic-critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+portable-atomic-critical-section-devel}"
SRC_URI[aarch64_rust-ndarray+portable-atomic-critical-section-devel.sha256sum] = "f0ccebd8192dca94c63996bc5417decc7566eb128ed9428a7ed8055506329d92"

URI_aarch64_rust-ndarray+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+rayon-devel-0.16.1-4.el10_3.noarch.rpm;name=aarch64_rust-ndarray+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+rayon-devel}"
SRC_URI[aarch64_rust-ndarray+rayon-devel.sha256sum] = "b980c81c206535e65c7fe442fcca7bf062f9408b15329388acdc9a5ab375d991"

URI_aarch64_rust-ndarray+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+serde-devel-0.16.1-4.el10_3.noarch.rpm;name=aarch64_rust-ndarray+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+serde-devel}"
SRC_URI[aarch64_rust-ndarray+serde-devel.sha256sum] = "6ad9014df622463e9cb53fa76119c9826cc158951b7119449fe2a069ce9b47ee"

URI_aarch64_rust-ndarray+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+std-devel-0.16.1-4.el10_3.noarch.rpm;name=aarch64_rust-ndarray+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+std-devel}"
SRC_URI[aarch64_rust-ndarray+std-devel.sha256sum] = "658357199a9a3b4a54085c200a776dc3356b2dec342266fa0bdfd2adc988aa04"

URI_aarch64_rust-ndarray+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+test-devel-0.16.1-4.el10_3.noarch.rpm;name=aarch64_rust-ndarray+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+test-devel}"
SRC_URI[aarch64_rust-ndarray+test-devel.sha256sum] = "7c8f776a44c22de9ccafbb984852c42992f47fb9893a47f304832c49d0630e05"

URI_aarch64_rust-ndarray-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray-devel-0.16.1-4.el10_3.noarch.rpm;name=aarch64_rust-ndarray-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray-devel}"
SRC_URI[aarch64_rust-ndarray-devel.sha256sum] = "665df9c4ba5e18b7366245e87c026687effe735706bf90cf393b6641e5d433ea"

RDEPENDS:rust-ndarray+approx-devel = " \
 cargo \
 rust-approx-devel \
 rust-ndarray-devel \
 "
RDEPENDS:rust-ndarray+default-devel = " \
 cargo \
 rust-ndarray+std-devel \
 rust-ndarray-devel \
 "
RDEPENDS:rust-ndarray+matrixmultiply-threading-devel = " \
 cargo \
 rust-matrixmultiply+threading-devel \
 rust-ndarray-devel \
 "
RDEPENDS:rust-ndarray+portable-atomic-critical-section-devel = " \
 cargo \
 rust-ndarray-devel \
 "
RDEPENDS:rust-ndarray+rayon-devel = " \
 cargo \
 rust-ndarray+std-devel \
 rust-ndarray-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-ndarray+serde-devel = " \
 cargo \
 rust-ndarray-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ndarray+std-devel = " \
 cargo \
 rust-matrixmultiply+std-devel \
 rust-ndarray-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-ndarray+test-devel = " \
 cargo \
 rust-ndarray-devel \
 "
RDEPENDS:rust-ndarray-devel = " \
 cargo \
 rust \
 rust-matrixmultiply+cgemm-devel \
 rust-matrixmultiply-devel \
 rust-num-complex-devel \
 rust-num-integer-devel \
 rust-num-traits-devel \
 rust-rawpointer+default-devel \
 "
