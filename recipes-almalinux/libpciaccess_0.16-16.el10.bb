# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpciaccess"
PV = "0.16"
PR = "16.el10"
PACKAGES = " \
 libpciaccess \
 libpciaccess-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libpciaccess-0.16-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6160fb644ddc49f6e1abef557f6f735fa02b6823190ab737816c679f921925b1"

URI_x86_64_v2_libpciaccess = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpciaccess-0.16-16.el10.x86_64_v2.rpm;name=x86_64_v2_libpciaccess;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpciaccess}"
SRC_URI[x86_64_v2_libpciaccess.sha256sum] = "33abfd879be1c2b6db9af8d90d37dc14e750d45097579fd301e72a41198a8f25"

URI_x86_64_v2_libpciaccess-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpciaccess-devel-0.16-16.el10.x86_64_v2.rpm;name=x86_64_v2_libpciaccess-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpciaccess-devel}"
SRC_URI[x86_64_v2_libpciaccess-devel.sha256sum] = "0e42db493cb108e7f9778cc916c7ed797b18cabbba03523f98568dfca4bb16bd"

URI_aarch64_libpciaccess = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpciaccess-0.16-16.el10.aarch64.rpm;name=aarch64_libpciaccess;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpciaccess}"
SRC_URI[aarch64_libpciaccess.sha256sum] = "ddfd3d8fe3812be10579ad972938661772702492fdd2559ee039e19e94505528"

URI_aarch64_libpciaccess-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpciaccess-devel-0.16-16.el10.aarch64.rpm;name=aarch64_libpciaccess-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpciaccess-devel}"
SRC_URI[aarch64_libpciaccess-devel.sha256sum] = "aa9cd5c6dd0bdb8ac77ac35bac5516074d9654fb1a3e7498af396a1792a067e8"

RDEPENDS:libpciaccess = " \
 glibc \
 hwdata \
 "
RDEPENDS:libpciaccess-devel = " \
 libpciaccess \
 pkgconf-pkg-config \
 "
