# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Business-ISMN"
PV = "1.205"
PR = "3.el10_1"
PACKAGES = " \
 perl-Business-ISMN \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Business-ISMN-1.205-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8358c107c42cd8915b0c2a86470ce9db27e8d19119a7ae328ec389eb4afb935d"

URI_x86_64_v2_perl-Business-ISMN = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Business-ISMN-1.205-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Business-ISMN;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Business-ISMN}"
SRC_URI[x86_64_v2_perl-Business-ISMN.sha256sum] = "6af1cfa2d981f8a51ab563b9fe5ada34525a1c7ccd4716bafc0ae21d573dfd76"

URI_aarch64_perl-Business-ISMN = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Business-ISMN-1.205-3.el10_1.noarch.rpm;name=aarch64_perl-Business-ISMN;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Business-ISMN}"
SRC_URI[aarch64_perl-Business-ISMN.sha256sum] = "9d6b0b3c2157b18f7e212477a27fff80ecb5cb54815a283a6a4b2bd4948c7f30"

RDEPENDS:perl-Business-ISMN = " \
 perl-Business-ISMN \
 perl-Carp \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-Tie-Cycle \
 perl-libs \
 perl-subs \
 perl-vars \
 "
