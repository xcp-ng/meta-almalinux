# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTML-Form"
PV = "6.12"
PR = "2.el10_0"
PACKAGES = " \
 perl-HTML-Form \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-HTML-Form-6.12-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7d26b6adbdb5041da12cbfee666f974e1d8c950b631b7cf2aaac95762aa01d24"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTML-Form-6.12-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTML-Form;unpack=0"
SRC_URI[x86_64_v2_perl-HTML-Form.sha256sum] = "b9285ca19f26e62ee0926db21e71139bc679bfe1162bed36399843ccd012ba2b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-HTML-Form-6.12-2.el10_0.noarch.rpm;name=aarch64_perl-HTML-Form;unpack=0"
SRC_URI[aarch64_perl-HTML-Form.sha256sum] = "391a7b29820a523f5d740615e6122eab02183d8487a207c7605e1daae68f52f0"

RDEPENDS:perl-HTML-Form = " \
 perl-Carp \
 perl-Encode \
 perl-HTML-Form \
 perl-HTML-Parser \
 perl-HTTP-Message \
 perl-URI \
 perl-libs \
 perl-parent \
 "
