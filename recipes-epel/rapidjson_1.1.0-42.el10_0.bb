# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rapidjson"
PV = "1.1.0"
PR = "42.el10_0"
PACKAGES = " \
 rapidjson-devel \
 rapidjson-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rapidjson-1.1.0-42.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31b81b6a0b4b63afe55f906ea8dd80958269005407aa2ed450ccff3ce814b8b9"

URI_x86_64_v2_rapidjson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rapidjson-devel-1.1.0-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rapidjson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rapidjson-devel}"
SRC_URI[x86_64_v2_rapidjson-devel.sha256sum] = "10e8e258b14282cc922c7a2927aba349316f5a02b7264ede24412656dedb7147"

URI_x86_64_v2_rapidjson-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rapidjson-doc-1.1.0-42.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rapidjson-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rapidjson-doc}"
SRC_URI[x86_64_v2_rapidjson-doc.sha256sum] = "fc9b0d1cacecd48ab99fadb8772adc7d43e97815708860ec32a25f8f26e7233c"

URI_aarch64_rapidjson-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rapidjson-devel-1.1.0-42.el10_0.aarch64.rpm;name=aarch64_rapidjson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rapidjson-devel}"
SRC_URI[aarch64_rapidjson-devel.sha256sum] = "f6e57fd47f90fc366293e7c53ce2816b8833777d8ea2bf7293c0ddd4c45db6cc"

URI_aarch64_rapidjson-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rapidjson-doc-1.1.0-42.el10_0.noarch.rpm;name=aarch64_rapidjson-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rapidjson-doc}"
SRC_URI[aarch64_rapidjson-doc.sha256sum] = "762af4c75cb152d91b528d02470260101b9f52c70deaf72c98697ceeadb014b7"

RDEPENDS:rapidjson-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:rapidjson-doc = " \
 "
