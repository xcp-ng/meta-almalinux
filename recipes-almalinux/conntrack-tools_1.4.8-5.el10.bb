# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "conntrack-tools"
PV = "1.4.8"
PR = "5.el10"
PACKAGES = " \
 conntrack-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/conntrack-tools-1.4.8-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d650156499e4e0a9a7a9aecb282472e02ae2e3976ef1a5e43a1caac3731aecbb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/conntrack-tools-1.4.8-5.el10.x86_64_v2.rpm;name=x86_64_v2_conntrack-tools;unpack=0"
SRC_URI[x86_64_v2_conntrack-tools.sha256sum] = "0215e2f7f1205f2345a69e959efc2dd1056feaf6e5646a52ae071854beaa1f07"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/conntrack-tools-1.4.8-5.el10.aarch64.rpm;name=aarch64_conntrack-tools;unpack=0"
SRC_URI[aarch64_conntrack-tools.sha256sum] = "4fd132638b2904086a92030b12c2e4935735941941ba13147692e817ec488cf4"

RDEPENDS:conntrack-tools = " \
 bash \
 glibc \
 libmnl \
 libnetfilter_conntrack \
 libnetfilter_cthelper \
 libnetfilter_cttimeout \
 libnetfilter_queue \
 libnfnetlink \
 systemd \
 systemd-libs \
 "
