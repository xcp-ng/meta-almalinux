# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "man-pages"
PV = "6.06"
PR = "13.el10_2"
PACKAGES = " \
 man-pages \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/man-pages-6.06-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a29ec4e7e167b8f1d358eb6eca451115f30a8535a64894b04075005e7f216195"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/man-pages-6.06-13.el10_2.noarch.rpm;name=x86_64_v2_man-pages;unpack=0"
SRC_URI[x86_64_v2_man-pages.sha256sum] = "cea91657ee2618c1e3790ffda2533d3d943f838f14cc54ab0d14b4071663d4c3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/man-pages-6.06-13.el10_2.noarch.rpm;name=aarch64_man-pages;unpack=0"
SRC_URI[aarch64_man-pages.sha256sum] = "cea91657ee2618c1e3790ffda2533d3d943f838f14cc54ab0d14b4071663d4c3"

RDEPENDS:man-pages = " \
 alternatives \
 bash \
 "
