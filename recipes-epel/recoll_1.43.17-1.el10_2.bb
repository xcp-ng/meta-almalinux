# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "recoll"
PV = "1.43.17"
PR = "1.el10_2"
PACKAGES = " \
 recoll \
 recoll-devel \
 recoll-gssp \
 recoll-helpers \
 recoll-kio \
 recoll-krunner \
 recoll-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/recoll-1.43.17-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa8af16e0da9348b5b8b8ea41090ebb93df637dbe7522c3fe91e19e597e95e02"

URI_x86_64_v2_recoll = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-1.43.17-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recoll}"
SRC_URI[x86_64_v2_recoll.sha256sum] = "366196b82422452b553af49deb837a278837b0a8589aa93976e28747a87f5181"

URI_x86_64_v2_recoll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-devel-1.43.17-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recoll-devel}"
SRC_URI[x86_64_v2_recoll-devel.sha256sum] = "c52dd34f5a1f771d63d7abf789ff9b6769c6eaf8ae7631ae0bebe7112dc369ae"

URI_x86_64_v2_recoll-gssp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-gssp-1.43.17-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-gssp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recoll-gssp}"
SRC_URI[x86_64_v2_recoll-gssp.sha256sum] = "33696ec13305fe4f110a60259f42c58a2df3e19ad04994ca50ba7b648213e43e"

URI_x86_64_v2_recoll-helpers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-helpers-1.43.17-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-helpers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recoll-helpers}"
SRC_URI[x86_64_v2_recoll-helpers.sha256sum] = "aebe9f49a464b2dedcafe6d5dd591a849c6893163698dae2dd028466914b207b"

URI_x86_64_v2_recoll-kio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-kio-1.43.17-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-kio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recoll-kio}"
SRC_URI[x86_64_v2_recoll-kio.sha256sum] = "916573a82b9dee1018e886eb22e70462832213dfd098af5a84375585cbdf3931"

URI_x86_64_v2_recoll-krunner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-krunner-1.43.17-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-krunner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recoll-krunner}"
SRC_URI[x86_64_v2_recoll-krunner.sha256sum] = "4179bbb244ddbec8ea1b553f87435b5f8d4ced65f10eb671f16df0581fd2713d"

URI_x86_64_v2_recoll-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-libs-1.43.17-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recoll-libs}"
SRC_URI[x86_64_v2_recoll-libs.sha256sum] = "695156b8078f6a0833e6a59b44def3fb2e95c3964bd2123edf85ed4a3f3e719f"

URI_aarch64_recoll = "${EPEL_MIRROR}/aarch64/Packages/r/recoll-1.43.17-1.el10_2.aarch64.rpm;name=aarch64_recoll;unpack=0"
SRC_URI:append = " ${URI_aarch64_recoll}"
SRC_URI[aarch64_recoll.sha256sum] = "6d3637d3fc5b8871f0dbb63d10006b6d46a1d1ed3989047b15d17084458b6e6a"

URI_aarch64_recoll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/recoll-devel-1.43.17-1.el10_2.aarch64.rpm;name=aarch64_recoll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_recoll-devel}"
SRC_URI[aarch64_recoll-devel.sha256sum] = "c47f5f54f3edf8a12a277e790bba8fe10939a41759dbcebcb39e1e26124d9d25"

URI_aarch64_recoll-gssp = "${EPEL_MIRROR}/aarch64/Packages/r/recoll-gssp-1.43.17-1.el10_2.aarch64.rpm;name=aarch64_recoll-gssp;unpack=0"
SRC_URI:append = " ${URI_aarch64_recoll-gssp}"
SRC_URI[aarch64_recoll-gssp.sha256sum] = "000e896d8315a3202b031ef984d994e34184f0aac30a12ddc251a8871bc25a57"

URI_aarch64_recoll-helpers = "${EPEL_MIRROR}/aarch64/Packages/r/recoll-helpers-1.43.17-1.el10_2.aarch64.rpm;name=aarch64_recoll-helpers;unpack=0"
SRC_URI:append = " ${URI_aarch64_recoll-helpers}"
SRC_URI[aarch64_recoll-helpers.sha256sum] = "ce4063a538303844b9f5286c53eb84dbfee7dfc1fed67fefaafe868f9b8b1225"

URI_aarch64_recoll-kio = "${EPEL_MIRROR}/aarch64/Packages/r/recoll-kio-1.43.17-1.el10_2.aarch64.rpm;name=aarch64_recoll-kio;unpack=0"
SRC_URI:append = " ${URI_aarch64_recoll-kio}"
SRC_URI[aarch64_recoll-kio.sha256sum] = "6a0b1a64ccafe3049a7ba586240453e569622a54f47cf75193828b8b4be61e63"

URI_aarch64_recoll-krunner = "${EPEL_MIRROR}/aarch64/Packages/r/recoll-krunner-1.43.17-1.el10_2.aarch64.rpm;name=aarch64_recoll-krunner;unpack=0"
SRC_URI:append = " ${URI_aarch64_recoll-krunner}"
SRC_URI[aarch64_recoll-krunner.sha256sum] = "44d01ccdca1aab215508286d132aa02cc7a6a31605a4a7475df2c50f605c37ac"

URI_aarch64_recoll-libs = "${EPEL_MIRROR}/aarch64/Packages/r/recoll-libs-1.43.17-1.el10_2.aarch64.rpm;name=aarch64_recoll-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_recoll-libs}"
SRC_URI[aarch64_recoll-libs.sha256sum] = "05f0cf2ba05a44cf583308360eba3bf662b9db997d5ceb6ce9d2e31fb915a034"

RDEPENDS:recoll = " \
 aspell \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 perl-interpreter \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 recoll-libs \
 xdg-utils \
 "
RDEPENDS:recoll-devel = " \
 recoll-libs \
 "
RDEPENDS:recoll-gssp = " \
 gnome-shell \
 python3 \
 python3-gobject-base \
 recoll \
 "
RDEPENDS:recoll-helpers = " \
 recoll \
 "
RDEPENDS:recoll-kio = " \
 glibc \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 recoll \
 recoll-libs \
 "
RDEPENDS:recoll-krunner = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-krunner \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 recoll \
 recoll-libs \
 "
RDEPENDS:recoll-libs = " \
 file-libs \
 glibc \
 jsoncpp \
 libX11 \
 libgcc \
 libstdc++ \
 libxml2 \
 libxslt \
 xapian-core-libs \
 zlib-ng-compat \
 "
