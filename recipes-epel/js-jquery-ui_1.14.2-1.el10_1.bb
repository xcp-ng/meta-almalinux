# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "js-jquery-ui"
PV = "1.14.2"
PR = "1.el10_1"
PACKAGES = " \
 js-jquery-ui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/js-jquery-ui-1.14.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92f1b529c6b80450183721d29e2d1f16fe6e406e4c9f3a9207a5395ecb660bef"

URI_x86_64_v2_js-jquery-ui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/js-jquery-ui-1.14.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_js-jquery-ui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_js-jquery-ui}"
SRC_URI[x86_64_v2_js-jquery-ui.sha256sum] = "af9630d38eabbd42b602c7e5051f605c779c21bd72c1ecf628ea146772155c57"

URI_aarch64_js-jquery-ui = "${EPEL_MIRROR}/aarch64/Packages/j/js-jquery-ui-1.14.2-1.el10_1.noarch.rpm;name=aarch64_js-jquery-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_js-jquery-ui}"
SRC_URI[aarch64_js-jquery-ui.sha256sum] = "c5267e0113d155e5f55ee00a2754b159c206beb91c26e707d402bd5a4cacbc5a"

RDEPENDS:js-jquery-ui = " \
 js-jquery \
 web-assets-filesystem \
 "
