# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libdeflater"
PV = "1.26.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-libdeflater+default-devel \
 rust-libdeflater+dynamic-devel \
 rust-libdeflater+freestanding-devel \
 rust-libdeflater+use_rust_alloc-devel \
 rust-libdeflater-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libdeflater-1.26.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5fcd81d8bd444fb0b746c41de9397ee7a3cf253410888d73e610eeccb03a65d6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+default-devel-1.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libdeflater+default-devel.sha256sum] = "05bace23e11270cbdcbc3298a909c07a3d9cc1106838c406523d05f7bfb82ccf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+dynamic-devel-1.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+dynamic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libdeflater+dynamic-devel.sha256sum] = "c83068a4265f48a0db0b8a69b0b5dba8c5587f1787f3b824d9ae9c6532e84970"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+freestanding-devel-1.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+freestanding-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libdeflater+freestanding-devel.sha256sum] = "f4f53b859e2f8be98b0359d3f0aa34e380296247c32352a185d5f50beb2ac2ff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+use_rust_alloc-devel-1.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+use_rust_alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libdeflater+use_rust_alloc-devel.sha256sum] = "35ee163df851995e3d7b5c1dc5508a1f6f5d18675fb06d4374d70a68f3d8d82b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater-devel-1.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libdeflater-devel.sha256sum] = "87307b26009b9b5bfb684fd31ffba072b183d2894f191af65114b9f2444e5b92"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+default-devel-1.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-libdeflater+default-devel;unpack=0"
SRC_URI[aarch64_rust-libdeflater+default-devel.sha256sum] = "65549ca5d930d767330d2940d916818151ad2239cca8c7aaeafc2a5a0216c10c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+dynamic-devel-1.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-libdeflater+dynamic-devel;unpack=0"
SRC_URI[aarch64_rust-libdeflater+dynamic-devel.sha256sum] = "38345cc643ca53f2e936c2717970dd60ff7a4d8764576c0e749db59d7a50d781"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+freestanding-devel-1.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-libdeflater+freestanding-devel;unpack=0"
SRC_URI[aarch64_rust-libdeflater+freestanding-devel.sha256sum] = "3acfba6e1fa26c7841f4afccf34ec31ff7393f0cbeaa1f97435579c85fc3ba83"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+use_rust_alloc-devel-1.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-libdeflater+use_rust_alloc-devel;unpack=0"
SRC_URI[aarch64_rust-libdeflater+use_rust_alloc-devel.sha256sum] = "5120f8fc329f92c08fcb8892d78c3af0f3a2a00414772db6c80d91e91b8de8fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater-devel-1.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-libdeflater-devel;unpack=0"
SRC_URI[aarch64_rust-libdeflater-devel.sha256sum] = "565b73262a1ca5a6dc8540d1cf698ede459266d28bd87e337735bd5a01822b55"

RDEPENDS:rust-libdeflater+default-devel = " \
 cargo \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater+dynamic-devel = " \
 cargo \
 rust-libdeflate-sys+dynamic-devel \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater+freestanding-devel = " \
 cargo \
 rust-libdeflate-sys+freestanding-devel \
 rust-libdeflater+use_rust_alloc-devel \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater+use_rust_alloc-devel = " \
 cargo \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater-devel = " \
 cargo \
 rust-libdeflate-sys+default-devel \
 "
