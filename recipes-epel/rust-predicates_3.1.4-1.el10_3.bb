# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-predicates"
PV = "3.1.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-predicates+color-devel \
 rust-predicates+default-devel \
 rust-predicates+diff-devel \
 rust-predicates+float-cmp-devel \
 rust-predicates+normalize-line-endings-devel \
 rust-predicates+regex-devel \
 rust-predicates+unstable-devel \
 rust-predicates-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-predicates-3.1.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e46a655bc6668778b1fa1fd9cf1eded45cf2fd70e823af0986b4b39429ebbb0a"

URI_x86_64_v2_rust-predicates+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+color-devel-3.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+color-devel}"
SRC_URI[x86_64_v2_rust-predicates+color-devel.sha256sum] = "94f7c758af9ae202384e78fdc34c41aecf1ea3811dc8348f9857fca17144ff27"

URI_x86_64_v2_rust-predicates+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+default-devel-3.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+default-devel}"
SRC_URI[x86_64_v2_rust-predicates+default-devel.sha256sum] = "9762f964b675f0d79ea55b1a425a6fb58bfc7e3d9d218b194c0610d72dab17b9"

URI_x86_64_v2_rust-predicates+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+diff-devel-3.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+diff-devel}"
SRC_URI[x86_64_v2_rust-predicates+diff-devel.sha256sum] = "91d6f40d22a6b78687b45a027fd3d1229b55741855595dedd05da82f1275ac47"

URI_x86_64_v2_rust-predicates+float-cmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+float-cmp-devel-3.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+float-cmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+float-cmp-devel}"
SRC_URI[x86_64_v2_rust-predicates+float-cmp-devel.sha256sum] = "d790a53cdcc4ab165b3dce6a481cc05b7236688a82c3942cb6bd935a14057782"

URI_x86_64_v2_rust-predicates+normalize-line-endings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+normalize-line-endings-devel-3.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+normalize-line-endings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+normalize-line-endings-devel}"
SRC_URI[x86_64_v2_rust-predicates+normalize-line-endings-devel.sha256sum] = "e7afe40cefa9724fd30d2471f0bffc7abe733af6de75ce34c4cb3da7c291593e"

URI_x86_64_v2_rust-predicates+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+regex-devel-3.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+regex-devel}"
SRC_URI[x86_64_v2_rust-predicates+regex-devel.sha256sum] = "b931d3978f8dc9413ba9ff16af5ba91b95c7d3e26f144c285111efe0b5b2a5ff"

URI_x86_64_v2_rust-predicates+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+unstable-devel-3.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+unstable-devel}"
SRC_URI[x86_64_v2_rust-predicates+unstable-devel.sha256sum] = "f9fbbd5c9eb07547519cb81f7c5b9d6c06cf21777ed5f842da7730c41fce11cb"

URI_x86_64_v2_rust-predicates-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-devel-3.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-devel}"
SRC_URI[x86_64_v2_rust-predicates-devel.sha256sum] = "f53e659ccca72324f42673b0e3481d3a60ab20dfef27bcb8d4fd75fc2771da0d"

URI_aarch64_rust-predicates+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+color-devel-3.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-predicates+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+color-devel}"
SRC_URI[aarch64_rust-predicates+color-devel.sha256sum] = "1ae2b494cf73a4cced4f499c59fe2246c9e8aaed153a6a3185d2e9463c1907f9"

URI_aarch64_rust-predicates+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+default-devel-3.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-predicates+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+default-devel}"
SRC_URI[aarch64_rust-predicates+default-devel.sha256sum] = "99c58d3a46e9d3ad077569db012c31dd6d230cbfd4121875330ac9c3eacfd037"

URI_aarch64_rust-predicates+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+diff-devel-3.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-predicates+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+diff-devel}"
SRC_URI[aarch64_rust-predicates+diff-devel.sha256sum] = "b5c4aae45dbb06e10f327bef62e3832facc33161b102f639667217418bcbcd75"

URI_aarch64_rust-predicates+float-cmp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+float-cmp-devel-3.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-predicates+float-cmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+float-cmp-devel}"
SRC_URI[aarch64_rust-predicates+float-cmp-devel.sha256sum] = "a5ccd4212ec9632599a368439d9befb7b25c453dc0378ddc9d1482d1836d5b33"

URI_aarch64_rust-predicates+normalize-line-endings-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+normalize-line-endings-devel-3.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-predicates+normalize-line-endings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+normalize-line-endings-devel}"
SRC_URI[aarch64_rust-predicates+normalize-line-endings-devel.sha256sum] = "7b03c01af48bd93920dc56e2705858f80bab4813e94c9d496856052ca59ff45d"

URI_aarch64_rust-predicates+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+regex-devel-3.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-predicates+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+regex-devel}"
SRC_URI[aarch64_rust-predicates+regex-devel.sha256sum] = "2d86be3e7e34fc92f6f1ecf4a14c468f198684d6cb39c33bf96f0d721832c852"

URI_aarch64_rust-predicates+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+unstable-devel-3.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-predicates+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+unstable-devel}"
SRC_URI[aarch64_rust-predicates+unstable-devel.sha256sum] = "9b8cb10c2382b429e7ef9c35f105646e74aaa688c1ca20e2df1ba83caa53ed54"

URI_aarch64_rust-predicates-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-devel-3.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-predicates-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-devel}"
SRC_URI[aarch64_rust-predicates-devel.sha256sum] = "cff046913693f1f7a44f86c654f97bad6564d9166085cd43f7c6aaec88bc9939"

RDEPENDS:rust-predicates+color-devel = " \
 cargo \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+default-devel = " \
 cargo \
 rust-predicates+color-devel \
 rust-predicates+diff-devel \
 rust-predicates+float-cmp-devel \
 rust-predicates+normalize-line-endings-devel \
 rust-predicates+regex-devel \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+diff-devel = " \
 cargo \
 rust-difflib+default-devel \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+float-cmp-devel = " \
 cargo \
 rust-float-cmp+default-devel \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+normalize-line-endings-devel = " \
 cargo \
 rust-normalize-line-endings+default-devel \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+regex-devel = " \
 cargo \
 rust-predicates-devel \
 rust-regex+default-devel \
 "
RDEPENDS:rust-predicates+unstable-devel = " \
 cargo \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-predicates-core+default-devel \
 "
