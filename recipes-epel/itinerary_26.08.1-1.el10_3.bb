# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "itinerary"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 itinerary \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/i/itinerary-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7e98eae9b05fbbb4656b93e9b136caa396865ab72f13cc52bb4208fbb876000b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/itinerary-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_itinerary;unpack=0"
SRC_URI[x86_64_v2_itinerary.sha256sum] = "d6b23ae8b8b662b07e5bd785b7fc8a48af3aad130f9a22997921e9edbf7653ab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/itinerary-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_itinerary;unpack=0"
SRC_URI[aarch64_itinerary.sha256sum] = "d6417abd122752ab9e81e3953d7bc8f80875f4ae592783262fc574c7d0057f70"

RDEPENDS:itinerary = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kunitconversion \
 kf6-kwindowsystem \
 kf6-prison \
 kf6-qqc2-desktop-style \
 khealthcertificate \
 kitinerary \
 kosmindoormap \
 kpkpass \
 kpublictransport \
 libquotient-qt6 \
 libstdc++ \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qtkeychain-qt6 \
 zlib-ng-compat \
 "
