# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-DistManifest"
PV = "1.014"
PR = "26.el10_0"
PACKAGES = " \
 perl-Test-DistManifest \
 perl-Test-DistManifest-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-DistManifest-1.014-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6dc88e9d8c8163fa4bdc707679c667a4c27d07e40368a7ebb19a18b9386eeda5"

URI_x86_64_v2_perl-Test-DistManifest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-DistManifest-1.014-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-DistManifest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-DistManifest}"
SRC_URI[x86_64_v2_perl-Test-DistManifest.sha256sum] = "be8e97253c18484829792a4a7bbfa9ec66f45f00407fdfeccbacc86b600d0c5d"

URI_x86_64_v2_perl-Test-DistManifest-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-DistManifest-tests-1.014-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-DistManifest-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-DistManifest-tests}"
SRC_URI[x86_64_v2_perl-Test-DistManifest-tests.sha256sum] = "3249186dc2a4fd30fbb8c58bf56ca8c5726d6ff1d22516d6555dc9494a4d7060"

URI_aarch64_perl-Test-DistManifest = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-DistManifest-1.014-26.el10_0.noarch.rpm;name=aarch64_perl-Test-DistManifest;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-DistManifest}"
SRC_URI[aarch64_perl-Test-DistManifest.sha256sum] = "38de26d13ffadeae8c9b0f4c4cc1e9459b5b658ee0716adec3423a839082fac3"

URI_aarch64_perl-Test-DistManifest-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-DistManifest-tests-1.014-26.el10_0.noarch.rpm;name=aarch64_perl-Test-DistManifest-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-DistManifest-tests}"
SRC_URI[aarch64_perl-Test-DistManifest-tests.sha256sum] = "59b7aec5c61a3fffd9df0d8bfda058dfce95be5e13ee60003227ae9f9dff5cb3"

RDEPENDS:perl-Test-DistManifest = " \
 perl-ExtUtils-Manifest \
 perl-File-Find \
 perl-Module-Manifest \
 perl-PathTools \
 perl-Test-Simple \
 perl-libs \
 "
RDEPENDS:perl-Test-DistManifest-tests = " \
 bash \
 perl-PathTools \
 perl-Test-DistManifest \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-if \
 perl-interpreter \
 perl-libs \
 "
