# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ed25519-compact"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-ed25519-compact+blind-keys-devel \
 rust-ed25519-compact+ct-codecs-devel \
 rust-ed25519-compact+default-devel \
 rust-ed25519-compact+disable-signatures-devel \
 rust-ed25519-compact+ed25519-devel \
 rust-ed25519-compact+getrandom-devel \
 rust-ed25519-compact+opt_size-devel \
 rust-ed25519-compact+pem-devel \
 rust-ed25519-compact+random-devel \
 rust-ed25519-compact+self-verify-devel \
 rust-ed25519-compact+std-devel \
 rust-ed25519-compact+traits-devel \
 rust-ed25519-compact+x25519-devel \
 rust-ed25519-compact-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ed25519-compact-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1855135be4efc6ab76bcd07977db34a4ad1005b1b73cb6e5eec8d5d8fd958060"

URI_x86_64_v2_rust-ed25519-compact+blind-keys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+blind-keys-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+blind-keys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+blind-keys-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+blind-keys-devel.sha256sum] = "5aec112ff8bf5f76cc25d8925a1c545792d0d8905260727216fc8580b5656d8d"

URI_x86_64_v2_rust-ed25519-compact+ct-codecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+ct-codecs-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+ct-codecs-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+ct-codecs-devel.sha256sum] = "028866b1a28944260f477039213532708f00acacb29d60b0db15559e5e103873"

URI_x86_64_v2_rust-ed25519-compact+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+default-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+default-devel.sha256sum] = "e733897500c599ca970fd5e1b2dddb97aabb3c9b281f826ae7700032bbcdbe88"

URI_x86_64_v2_rust-ed25519-compact+disable-signatures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+disable-signatures-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+disable-signatures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+disable-signatures-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+disable-signatures-devel.sha256sum] = "a60f20f8ace23f4f332e988407f1e92d3ab83f496c088d3d90338ccb5f220e6b"

URI_x86_64_v2_rust-ed25519-compact+ed25519-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+ed25519-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+ed25519-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+ed25519-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+ed25519-devel.sha256sum] = "5b32a05eb41813568be3fe3f60e055ea75d2d0ca1197264773d107bdfe322766"

URI_x86_64_v2_rust-ed25519-compact+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+getrandom-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+getrandom-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+getrandom-devel.sha256sum] = "98e4815e6223c8ea8d384b6525cb8c915039a70b327ea82d7987515689984496"

URI_x86_64_v2_rust-ed25519-compact+opt_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+opt_size-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+opt_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+opt_size-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+opt_size-devel.sha256sum] = "6e71cd020117583a4a5252952514815c685fe79c178e8436af6748b6c770683c"

URI_x86_64_v2_rust-ed25519-compact+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+pem-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+pem-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+pem-devel.sha256sum] = "84735a427545ada63e32ef6ac6ba6db1dac07ca471c806bdc5917c13daa7764d"

URI_x86_64_v2_rust-ed25519-compact+random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+random-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+random-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+random-devel.sha256sum] = "17270d26e3aa94779079076cda1834f5c723490bdc3c239b4496ef5997bfbddb"

URI_x86_64_v2_rust-ed25519-compact+self-verify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+self-verify-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+self-verify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+self-verify-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+self-verify-devel.sha256sum] = "6cf9f63db389515931c903730feffd12877ef248ec7beca11392d9b9136ae38b"

URI_x86_64_v2_rust-ed25519-compact+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+std-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+std-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+std-devel.sha256sum] = "d1bc9856b758cc0ab119f1cc36a258c3b99daa266775097c9e4b48648834fd25"

URI_x86_64_v2_rust-ed25519-compact+traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+traits-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+traits-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+traits-devel.sha256sum] = "b421e7fce5fd69bd6c7787eff311fd81b262541ca6f5f659c36189ee637095de"

URI_x86_64_v2_rust-ed25519-compact+x25519-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+x25519-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+x25519-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+x25519-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+x25519-devel.sha256sum] = "c5e5002faf2fc26d2877e3bb28f351968639e4fcec60947ae4239c5722121449"

URI_x86_64_v2_rust-ed25519-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact-devel.sha256sum] = "1418fa64dd3c6af3106ff1ae8b4a42b3f5b2ba0cdc179acce3f51d54086b970f"

URI_aarch64_rust-ed25519-compact+blind-keys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+blind-keys-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-ed25519-compact+blind-keys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+blind-keys-devel}"
SRC_URI[aarch64_rust-ed25519-compact+blind-keys-devel.sha256sum] = "03c6febd6d7e6d000ccb220f05d00ea69010a88cfce1031d48f57a6f029d48d5"

URI_aarch64_rust-ed25519-compact+ct-codecs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+ct-codecs-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-ed25519-compact+ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+ct-codecs-devel}"
SRC_URI[aarch64_rust-ed25519-compact+ct-codecs-devel.sha256sum] = "0914b83f9def5fe63f5cc34eb416642437cf0c350a7697df5486251545c14a41"

URI_aarch64_rust-ed25519-compact+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-ed25519-compact+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+default-devel}"
SRC_URI[aarch64_rust-ed25519-compact+default-devel.sha256sum] = "3036043a392f572dd138e2a1be8d8cb6b734446416a87bae675e436cde3f5a92"

URI_aarch64_rust-ed25519-compact+disable-signatures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+disable-signatures-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-ed25519-compact+disable-signatures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+disable-signatures-devel}"
SRC_URI[aarch64_rust-ed25519-compact+disable-signatures-devel.sha256sum] = "0d0621b19fa6bda1436982f56a30928e9991512e278d7455a85352dab4c9736d"

URI_aarch64_rust-ed25519-compact+ed25519-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+ed25519-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-ed25519-compact+ed25519-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+ed25519-devel}"
SRC_URI[aarch64_rust-ed25519-compact+ed25519-devel.sha256sum] = "b3c9e544e6e804f619bfab99ffad209f9fd5712ce0d76660104ac0e08a6541b1"

URI_aarch64_rust-ed25519-compact+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+getrandom-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-ed25519-compact+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+getrandom-devel}"
SRC_URI[aarch64_rust-ed25519-compact+getrandom-devel.sha256sum] = "a2433d9cfc20f794d4153a619ea09ab43938ae4ab36489d6e8eb593dd76d7565"

URI_aarch64_rust-ed25519-compact+opt_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+opt_size-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-ed25519-compact+opt_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+opt_size-devel}"
SRC_URI[aarch64_rust-ed25519-compact+opt_size-devel.sha256sum] = "adb366eb6b0e9a0118e0a8977e4524def5049d2bebbccd35c584f42381b15f39"

URI_aarch64_rust-ed25519-compact+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+pem-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-ed25519-compact+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+pem-devel}"
SRC_URI[aarch64_rust-ed25519-compact+pem-devel.sha256sum] = "fca9eecb00005c54aceb4d66867e23b1b6b45b40c920cd2a95a2a72ea641f39c"

URI_aarch64_rust-ed25519-compact+random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+random-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-ed25519-compact+random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+random-devel}"
SRC_URI[aarch64_rust-ed25519-compact+random-devel.sha256sum] = "7971e5b1278cfeec3dfa8613c9020413fa9fe1762aaf35b0d2d736dca89cf156"

URI_aarch64_rust-ed25519-compact+self-verify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+self-verify-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-ed25519-compact+self-verify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+self-verify-devel}"
SRC_URI[aarch64_rust-ed25519-compact+self-verify-devel.sha256sum] = "63c16371ad65e89958fef48eee75c42a9710b59a2182dfa0d13d6a74dc39085e"

URI_aarch64_rust-ed25519-compact+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+std-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-ed25519-compact+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+std-devel}"
SRC_URI[aarch64_rust-ed25519-compact+std-devel.sha256sum] = "f499884d2467f6316e8cf51d1487f090d7defc429f2cf7e4e59f9903b4b84121"

URI_aarch64_rust-ed25519-compact+traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+traits-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-ed25519-compact+traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+traits-devel}"
SRC_URI[aarch64_rust-ed25519-compact+traits-devel.sha256sum] = "b0bf98704a9df93e0079011ba71eb36eec6f9da365549be79f37c76199ab0d88"

URI_aarch64_rust-ed25519-compact+x25519-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+x25519-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-ed25519-compact+x25519-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+x25519-devel}"
SRC_URI[aarch64_rust-ed25519-compact+x25519-devel.sha256sum] = "a43e9b62f30aa0c58ec84994ad66d63a596e0950902c61c2d31db8c4ce0e5a55"

URI_aarch64_rust-ed25519-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-ed25519-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact-devel}"
SRC_URI[aarch64_rust-ed25519-compact-devel.sha256sum] = "5b1a961566a718bfd3dd74d81fee10b62e157ff1898a6e1aa8336043669c30fb"

RDEPENDS:rust-ed25519-compact+blind-keys-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+ct-codecs-devel = " \
 cargo \
 rust-ct-codecs+default-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+default-devel = " \
 cargo \
 rust-ed25519-compact+pem-devel \
 rust-ed25519-compact+random-devel \
 rust-ed25519-compact+std-devel \
 rust-ed25519-compact+x25519-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+disable-signatures-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+ed25519-devel = " \
 cargo \
 rust-ed25519+default-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+getrandom-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 rust-getrandom0.3+default-devel \
 "
RDEPENDS:rust-ed25519-compact+opt_size-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+pem-devel = " \
 cargo \
 rust-ed25519-compact+ct-codecs-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+random-devel = " \
 cargo \
 rust-ed25519-compact+getrandom-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+self-verify-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+std-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+traits-devel = " \
 cargo \
 rust-ed25519-compact+ed25519-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+x25519-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact-devel = " \
 cargo \
 "
