# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtmultimedia"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtmultimedia \
 qt6-qtmultimedia-devel \
 qt6-qtmultimedia-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtmultimedia-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0af1b06fc2bf9ff8106c2a08e0af0747f38eeed82c3c224d8d777ae889265b9f"

URI_x86_64_v2_qt6-qtmultimedia = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtmultimedia-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmultimedia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmultimedia}"
SRC_URI[x86_64_v2_qt6-qtmultimedia.sha256sum] = "3442581ace9371d972c4e275e450765322ca1df260ba478b128204d91781b877"

URI_x86_64_v2_qt6-qtmultimedia-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtmultimedia-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmultimedia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmultimedia-devel}"
SRC_URI[x86_64_v2_qt6-qtmultimedia-devel.sha256sum] = "a5bf66b0f10797a2929b7b31226510ac1ec8dc7f6f047001e0deae496abfba27"

URI_x86_64_v2_qt6-qtmultimedia-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtmultimedia-examples-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmultimedia-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmultimedia-examples}"
SRC_URI[x86_64_v2_qt6-qtmultimedia-examples.sha256sum] = "84961d3789cec8a3420cbabb6d975fe64c82ae4d0d2ba7c3e584bcb83c7faee6"

URI_aarch64_qt6-qtmultimedia = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtmultimedia-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtmultimedia;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmultimedia}"
SRC_URI[aarch64_qt6-qtmultimedia.sha256sum] = "5aa11528468a4e0cd3b74b6c48b8ed313b14793d341621ed69523891dc42f453"

URI_aarch64_qt6-qtmultimedia-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtmultimedia-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtmultimedia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmultimedia-devel}"
SRC_URI[aarch64_qt6-qtmultimedia-devel.sha256sum] = "953a0b6e7956e65f1d6d36997dcdcd61849f3d6bd70a721f783aa5f48c992c1a"

URI_aarch64_qt6-qtmultimedia-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtmultimedia-examples-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtmultimedia-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmultimedia-examples}"
SRC_URI[aarch64_qt6-qtmultimedia-examples.sha256sum] = "75ded1d7a0e8d23c4020d04dac62385dd874378c0aaa9ffda8a11bc82e032e91"

RDEPENDS:qt6-qtmultimedia = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 libglvnd-egl \
 libglvnd-opengl \
 libstdc++ \
 pulseaudio-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 "
RDEPENDS:qt6-qtmultimedia-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pulseaudio-libs-devel \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtmultimedia \
 qt6-qtmultimedia-devel \
 "
RDEPENDS:qt6-qtmultimedia-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
