# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libssh2"
PV = "1.11.1"
PR = "9.el10_2"
PACKAGES = " \
 libssh2 \
 libssh2-devel \
 libssh2-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libssh2-1.11.1-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7a1db40b9f693405dd56ce6a28be0e08a7012a603d2eae97bb51948b121f561"

URI_x86_64_v2_libssh2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libssh2-1.11.1-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libssh2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh2}"
SRC_URI[x86_64_v2_libssh2.sha256sum] = "57d99a1c7d2cf362bd1f503e9eb7e089b641899178013e6a1a3f187acd59bda4"

URI_x86_64_v2_libssh2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libssh2-devel-1.11.1-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libssh2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh2-devel}"
SRC_URI[x86_64_v2_libssh2-devel.sha256sum] = "34f320d4cef7fb12f936abb14b41ff2e97569c1fc3dad0a2e017cbc8d27efb6d"

URI_x86_64_v2_libssh2-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libssh2-docs-1.11.1-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libssh2-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh2-docs}"
SRC_URI[x86_64_v2_libssh2-docs.sha256sum] = "bdbb517e67373b816c781b11a2f3152251295039d61cba6ea807e87be637817e"

URI_aarch64_libssh2 = "${EPEL_MIRROR}/aarch64/Packages/l/libssh2-1.11.1-9.el10_2.aarch64.rpm;name=aarch64_libssh2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh2}"
SRC_URI[aarch64_libssh2.sha256sum] = "0bb59518f0c302432104639bb6374ff19d801805f167090675fd71ddb70012d8"

URI_aarch64_libssh2-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libssh2-devel-1.11.1-9.el10_2.aarch64.rpm;name=aarch64_libssh2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh2-devel}"
SRC_URI[aarch64_libssh2-devel.sha256sum] = "bb8833c5d57a29e435b9e2797ad75b9a359435bc8c4adf781a0018932af6e797"

URI_aarch64_libssh2-docs = "${EPEL_MIRROR}/aarch64/Packages/l/libssh2-docs-1.11.1-9.el10_2.noarch.rpm;name=aarch64_libssh2-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh2-docs}"
SRC_URI[aarch64_libssh2-docs.sha256sum] = "27f524737c128a8cd23097feeae82c0ddf70b726804842c382c30d72daed28dd"

RDEPENDS:libssh2 = " \
 glibc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libssh2-devel = " \
 libssh2 \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:libssh2-docs = " \
 libssh2 \
 "
