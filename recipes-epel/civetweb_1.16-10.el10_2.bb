# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "civetweb"
PV = "1.16"
PR = "10.el10_2"
PACKAGES = " \
 civetweb \
 civetweb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/civetweb-1.16-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7843742140ee371ce851115cba28dcfae052e40022ddb6a53e28b7ddd3b337a4"

URI_x86_64_v2_civetweb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/civetweb-1.16-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_civetweb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_civetweb}"
SRC_URI[x86_64_v2_civetweb.sha256sum] = "cc3b2ecdcf0c907bec947947b31a107fe3bc18b81707ee979b4f073e905327b8"

URI_x86_64_v2_civetweb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/civetweb-devel-1.16-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_civetweb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_civetweb-devel}"
SRC_URI[x86_64_v2_civetweb-devel.sha256sum] = "f4b1c7850749f6b7b6cb7704ffc29321638bc85c200163ad30d92d9e9e070298"

URI_aarch64_civetweb = "${EPEL_MIRROR}/aarch64/Packages/c/civetweb-1.16-10.el10_2.aarch64.rpm;name=aarch64_civetweb;unpack=0"
SRC_URI:append = " ${URI_aarch64_civetweb}"
SRC_URI[aarch64_civetweb.sha256sum] = "5f9d87aa43f19081f5c122a52a056709e809f83adb7926d6fa6bdb4fec6101c4"

URI_aarch64_civetweb-devel = "${EPEL_MIRROR}/aarch64/Packages/c/civetweb-devel-1.16-10.el10_2.aarch64.rpm;name=aarch64_civetweb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_civetweb-devel}"
SRC_URI[aarch64_civetweb-devel.sha256sum] = "b52ba22cbb49c5a1a8f243ed06c6e2a86a9734a1de766011807fc3a8f9e626d6"

RDEPENDS:civetweb = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:civetweb-devel = " \
 civetweb \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
