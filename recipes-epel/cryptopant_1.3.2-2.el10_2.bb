# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cryptopant"
PV = "1.3.2"
PR = "2.el10_2"
PACKAGES = " \
 cryptopant \
 cryptopant-devel \
 cryptopant-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cryptopant-1.3.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e56687f78e582451e20d148b65b132032e60523992d49088ac65d1e4953a63e"

URI_x86_64_v2_cryptopant = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cryptopant-1.3.2-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cryptopant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptopant}"
SRC_URI[x86_64_v2_cryptopant.sha256sum] = "c7ac3c8b6fcb1543d636be5b532b48a1ca6c0ef64317181bf2d03b83afb38307"

URI_x86_64_v2_cryptopant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cryptopant-devel-1.3.2-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cryptopant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptopant-devel}"
SRC_URI[x86_64_v2_cryptopant-devel.sha256sum] = "ca400d8b149ff41f28eb98b41c59d3ce1bd09acb0660c6078d9ae4745efc9234"

URI_x86_64_v2_cryptopant-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cryptopant-utils-1.3.2-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cryptopant-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptopant-utils}"
SRC_URI[x86_64_v2_cryptopant-utils.sha256sum] = "84be66fe85dfb5f6faba9a98d127c061f599b65f7b86806d3701b428667f905d"

URI_aarch64_cryptopant = "${EPEL_MIRROR}/aarch64/Packages/c/cryptopant-1.3.2-2.el10_2.aarch64.rpm;name=aarch64_cryptopant;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptopant}"
SRC_URI[aarch64_cryptopant.sha256sum] = "76b9ec6cbad7c55378ccd0f0e2dfc31b258b8f7336c3b4835ffae9c8dafc1b63"

URI_aarch64_cryptopant-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cryptopant-devel-1.3.2-2.el10_2.aarch64.rpm;name=aarch64_cryptopant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptopant-devel}"
SRC_URI[aarch64_cryptopant-devel.sha256sum] = "7d9e85ba84f7d5f244972e704ded7f471fdb6796bcae71d5d1b9c153bfe9e193"

URI_aarch64_cryptopant-utils = "${EPEL_MIRROR}/aarch64/Packages/c/cryptopant-utils-1.3.2-2.el10_2.aarch64.rpm;name=aarch64_cryptopant-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptopant-utils}"
SRC_URI[aarch64_cryptopant-utils.sha256sum] = "186d99d8beccb043fca181d6f432557740b7f10ce12f3fc35f27214c4976598b"

RDEPENDS:cryptopant = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:cryptopant-devel = " \
 cryptopant \
 openssl-devel \
 "
RDEPENDS:cryptopant-utils = " \
 cryptopant \
 glibc \
 "
