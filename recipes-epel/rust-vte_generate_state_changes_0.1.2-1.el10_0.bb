# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-vte_generate_state_changes"
PV = "0.1.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-vte_generate_state_changes+default-devel \
 rust-vte_generate_state_changes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-vte_generate_state_changes-0.1.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42d7c5b1920f545bdda9758143cc0ad17b03c8b94f323ca65b0fff97cd694cf0"

URI_x86_64_v2_rust-vte_generate_state_changes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte_generate_state_changes+default-devel-0.1.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte_generate_state_changes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte_generate_state_changes+default-devel}"
SRC_URI[x86_64_v2_rust-vte_generate_state_changes+default-devel.sha256sum] = "d454007f426822ba954d3e29992bb8f1aee06fdab88bd0b9e64d71032c41f89f"

URI_x86_64_v2_rust-vte_generate_state_changes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte_generate_state_changes-devel-0.1.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte_generate_state_changes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte_generate_state_changes-devel}"
SRC_URI[x86_64_v2_rust-vte_generate_state_changes-devel.sha256sum] = "74d38cac25f09c82120ef9123c71e924e691fb5616b9d57261cf82670e0d5a2a"

URI_aarch64_rust-vte_generate_state_changes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte_generate_state_changes+default-devel-0.1.2-1.el10_0.noarch.rpm;name=aarch64_rust-vte_generate_state_changes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte_generate_state_changes+default-devel}"
SRC_URI[aarch64_rust-vte_generate_state_changes+default-devel.sha256sum] = "334578e837f381aede1b9aab39f052b774f07ab9b1a587a16c3b13e2af12ea9f"

URI_aarch64_rust-vte_generate_state_changes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte_generate_state_changes-devel-0.1.2-1.el10_0.noarch.rpm;name=aarch64_rust-vte_generate_state_changes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte_generate_state_changes-devel}"
SRC_URI[aarch64_rust-vte_generate_state_changes-devel.sha256sum] = "376fd4177f1054c9223c08aa7dc2ea13cf240f41e0b37ecc3a5cf8e1600a6734"

RDEPENDS:rust-vte_generate_state_changes+default-devel = " \
 cargo \
 rust-vte_generate_state_changes-devel \
 "
RDEPENDS:rust-vte_generate_state_changes-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
