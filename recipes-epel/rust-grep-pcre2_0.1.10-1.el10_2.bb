# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-pcre2"
PV = "0.1.10"
PR = "1.el10_2"
PACKAGES = " \
 rust-grep-pcre2+default-devel \
 rust-grep-pcre2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-pcre2-0.1.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4f4bd4c8a53642355cc4ab3c45e38e4563cc5358461710c03951ba77db538e1"

URI_x86_64_v2_rust-grep-pcre2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-pcre2+default-devel-0.1.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-pcre2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-pcre2+default-devel}"
SRC_URI[x86_64_v2_rust-grep-pcre2+default-devel.sha256sum] = "3498079b23bc6451478b82456e3add09c9b3e0fefa2969a9e1bf1d4c2feda9a4"

URI_x86_64_v2_rust-grep-pcre2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-pcre2-devel-0.1.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-pcre2-devel}"
SRC_URI[x86_64_v2_rust-grep-pcre2-devel.sha256sum] = "97c05736ee832ea88d13a997d5659fc1343853705d75f48bfc3ebd45740943ca"

URI_aarch64_rust-grep-pcre2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-pcre2+default-devel-0.1.10-1.el10_2.noarch.rpm;name=aarch64_rust-grep-pcre2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-pcre2+default-devel}"
SRC_URI[aarch64_rust-grep-pcre2+default-devel.sha256sum] = "87313f13838934bcf55028364527abf8c0a74159b8618c6349cf32bc361b99c2"

URI_aarch64_rust-grep-pcre2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-pcre2-devel-0.1.10-1.el10_2.noarch.rpm;name=aarch64_rust-grep-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-pcre2-devel}"
SRC_URI[aarch64_rust-grep-pcre2-devel.sha256sum] = "169028d8c1ea880f95e8fa64383e21e532b7fc28a61da0061ce76461761f204b"

RDEPENDS:rust-grep-pcre2+default-devel = " \
 cargo \
 rust-grep-pcre2-devel \
 "
RDEPENDS:rust-grep-pcre2-devel = " \
 cargo \
 rust-grep-matcher+default-devel \
 rust-log+default-devel \
 rust-pcre2+default-devel \
 "
