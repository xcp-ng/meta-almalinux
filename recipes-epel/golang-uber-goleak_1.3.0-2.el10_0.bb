# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-uber-goleak"
PV = "1.3.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-uber-goleak-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-uber-goleak-1.3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "626e6329a66c2825ccbdb632fbab238d7a12b81f0ac178f18ef3d564b2cab43b"

URI_x86_64_v2_golang-uber-goleak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-uber-goleak-devel-1.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-uber-goleak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-uber-goleak-devel}"
SRC_URI[x86_64_v2_golang-uber-goleak-devel.sha256sum] = "9605ee1e4d4d6c89fb2eafc05edaedb235743b6586b927e165ac2ad743675a6e"

URI_aarch64_golang-uber-goleak-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-uber-goleak-devel-1.3.0-2.el10_0.noarch.rpm;name=aarch64_golang-uber-goleak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-uber-goleak-devel}"
SRC_URI[aarch64_golang-uber-goleak-devel.sha256sum] = "658b0c9f9f1dab5b70c90435053c68b1c885cfab54290cefa299075e7724360f"

RDEPENDS:golang-uber-goleak-devel = " \
 go-filesystem \
 "
