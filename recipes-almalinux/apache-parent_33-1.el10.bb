# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apache-parent"
PV = "33"
PR = "1.el10"
PACKAGES = " \
 apache-parent \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/apache-parent-33-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8449d9bd3f71dcfa872b6e6b34fa6970c1b0a7295c5334de372da1a04f073692"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-parent-33-1.el10.noarch.rpm;name=x86_64_v2_apache-parent;unpack=0"
SRC_URI[x86_64_v2_apache-parent.sha256sum] = "f92863b365f1556848ad114a7a6c229f822c5119d806e2cec4fad50f377536fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-parent-33-1.el10.noarch.rpm;name=aarch64_apache-parent;unpack=0"
SRC_URI[aarch64_apache-parent.sha256sum] = "f92863b365f1556848ad114a7a6c229f822c5119d806e2cec4fad50f377536fa"

RDEPENDS:apache-parent = " \
 apache-resource-bundles \
 javapackages-filesystem \
 maven-enforcer-plugin \
 maven-remote-resources-plugin \
 "
