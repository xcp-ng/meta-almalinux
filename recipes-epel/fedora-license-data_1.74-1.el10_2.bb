# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-license-data"
PV = "1.74"
PR = "1.el10_2"
PACKAGES = " \
 fedora-license-data \
 rpmlint-fedora-license-data \
 rpmlint-fedora-license-data-legacy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-license-data-1.74-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e17c1b7cc18ce69005c2c14003fb4ac17effea20823acb110ccbc7c581e95b72"

URI_x86_64_v2_fedora-license-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-license-data-1.74-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-license-data}"
SRC_URI[x86_64_v2_fedora-license-data.sha256sum] = "d6ffc603a20e8ea8046acb32ae1ffa6b1ff4d2b55bbaf342025be204303c2373"

URI_x86_64_v2_rpmlint-fedora-license-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmlint-fedora-license-data-1.74-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rpmlint-fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmlint-fedora-license-data}"
SRC_URI[x86_64_v2_rpmlint-fedora-license-data.sha256sum] = "0c9d4ed3f5004b35991d3d66ae44549802b0a12511a2d5bfc1d614d9d0b6f902"

URI_x86_64_v2_rpmlint-fedora-license-data-legacy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmlint-fedora-license-data-legacy-1.74-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rpmlint-fedora-license-data-legacy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmlint-fedora-license-data-legacy}"
SRC_URI[x86_64_v2_rpmlint-fedora-license-data-legacy.sha256sum] = "988fa84ce5d5d843cc9a862f11f908d6ef0902de394163d07a7c7c0c72b1aa49"

URI_aarch64_fedora-license-data = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-license-data-1.74-1.el10_2.noarch.rpm;name=aarch64_fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-license-data}"
SRC_URI[aarch64_fedora-license-data.sha256sum] = "de92d8c1748f306a5c82f4e9dd25cd97d58ff05c405f7b0d7890dafb083185d0"

URI_aarch64_rpmlint-fedora-license-data = "${EPEL_MIRROR}/aarch64/Packages/r/rpmlint-fedora-license-data-1.74-1.el10_2.noarch.rpm;name=aarch64_rpmlint-fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmlint-fedora-license-data}"
SRC_URI[aarch64_rpmlint-fedora-license-data.sha256sum] = "ebe287f640bf63df4677b0afed6ce2992a16f8bace74f8f499604ad8f4cc8619"

URI_aarch64_rpmlint-fedora-license-data-legacy = "${EPEL_MIRROR}/aarch64/Packages/r/rpmlint-fedora-license-data-legacy-1.74-1.el10_2.noarch.rpm;name=aarch64_rpmlint-fedora-license-data-legacy;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmlint-fedora-license-data-legacy}"
SRC_URI[aarch64_rpmlint-fedora-license-data-legacy.sha256sum] = "77c26a87c2964f15206c64cf3ca8c0faaebf1eb83be67ccb0feebe6d77387eec"

RDEPENDS:fedora-license-data = " \
 "
RDEPENDS:rpmlint-fedora-license-data = " \
 rpmlint \
 "
RDEPENDS:rpmlint-fedora-license-data-legacy = " \
 rpmlint \
 "
