# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fastapi"
PV = "0.115.14"
PR = "4.el10_1"
PACKAGES = " \
 python3-fastapi \
 python3-fastapi+all \
 python3-fastapi-slim \
 python3-fastapi-slim+all \
 python3-fastapi-slim+standard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fastapi-0.115.14-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1b915f0dc90e95bfc3fccccbe2a74f70fecfd09fdf6a8ffcf7a05649ab6aeab"

URI_x86_64_v2_python3-fastapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastapi-0.115.14-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fastapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastapi}"
SRC_URI[x86_64_v2_python3-fastapi.sha256sum] = "70dd1146202f4337ddcb673d33181570e87b61b72c849e2fbfaebaed4c06907d"

URI_x86_64_v2_python3-fastapi+all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastapi+all-0.115.14-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fastapi+all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastapi+all}"
SRC_URI[x86_64_v2_python3-fastapi+all.sha256sum] = "613dfab09d5782d163119deb1e72d20cdd63b576c0e0a9a2a286d5e447b26d73"

URI_x86_64_v2_python3-fastapi-slim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastapi-slim-0.115.14-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fastapi-slim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastapi-slim}"
SRC_URI[x86_64_v2_python3-fastapi-slim.sha256sum] = "bd831c850a463b4f4e7c05383baa81acb0a84b8c3fa5fd0352b2fd2fa780c4db"

URI_x86_64_v2_python3-fastapi-slim+all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastapi-slim+all-0.115.14-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fastapi-slim+all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastapi-slim+all}"
SRC_URI[x86_64_v2_python3-fastapi-slim+all.sha256sum] = "4ccd6ddd5bdf9d7c51d579875f67e4d49e6479c6607e166d22bd3ed317b70cf6"

URI_x86_64_v2_python3-fastapi-slim+standard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastapi-slim+standard-0.115.14-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fastapi-slim+standard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastapi-slim+standard}"
SRC_URI[x86_64_v2_python3-fastapi-slim+standard.sha256sum] = "ca7728413494f819b50dd90faaf77a4ff428d023003af4827cae6c5068e7bd12"

URI_aarch64_python3-fastapi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastapi-0.115.14-4.el10_1.noarch.rpm;name=aarch64_python3-fastapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastapi}"
SRC_URI[aarch64_python3-fastapi.sha256sum] = "19cf4d29cea1ed69754f0e424d6b3d429fc6720dc6bd0f6dd511fd62d54cc5b3"

URI_aarch64_python3-fastapi+all = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastapi+all-0.115.14-4.el10_1.noarch.rpm;name=aarch64_python3-fastapi+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastapi+all}"
SRC_URI[aarch64_python3-fastapi+all.sha256sum] = "e74db77b98e3c4c0481edc62a359bc19bd9bdf7ccd27885cd07600d99147d231"

URI_aarch64_python3-fastapi-slim = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastapi-slim-0.115.14-4.el10_1.noarch.rpm;name=aarch64_python3-fastapi-slim;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastapi-slim}"
SRC_URI[aarch64_python3-fastapi-slim.sha256sum] = "5773c1efa47cdf41a7a8f444f334103dca1bfaa53a4d1488b36abc0420e82c8e"

URI_aarch64_python3-fastapi-slim+all = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastapi-slim+all-0.115.14-4.el10_1.noarch.rpm;name=aarch64_python3-fastapi-slim+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastapi-slim+all}"
SRC_URI[aarch64_python3-fastapi-slim+all.sha256sum] = "d60733b4309fae946849726ccfbc155ca46237c406f900164e7c68ff45dda033"

URI_aarch64_python3-fastapi-slim+standard = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastapi-slim+standard-0.115.14-4.el10_1.noarch.rpm;name=aarch64_python3-fastapi-slim+standard;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastapi-slim+standard}"
SRC_URI[aarch64_python3-fastapi-slim+standard.sha256sum] = "642a05230d28b3589752f550f1618e9e9205c4b5b3864ffab683229119b6cdfd"

RDEPENDS:python3-fastapi = " \
 python3 \
 python3-fastapi-slim \
 python3-pydantic \
 python3-starlette \
 python3-typing-extensions \
 "
RDEPENDS:python3-fastapi+all = " \
 fastapi-cli \
 fastapi-cli+standard \
 python3 \
 python3-email-validator \
 python3-fastapi \
 python3-httpx \
 python3-itsdangerous \
 python3-jinja2 \
 python3-orjson \
 python3-pydantic-extra-types \
 python3-pydantic-settings \
 python3-python-multipart \
 python3-pyyaml \
 python3-ujson \
 python3-uvicorn \
 python3-uvicorn+standard \
 "
RDEPENDS:python3-fastapi-slim = " \
 python3 \
 python3-pydantic \
 python3-starlette \
 python3-typing-extensions \
 "
RDEPENDS:python3-fastapi-slim+all = " \
 fastapi-cli \
 fastapi-cli+standard \
 python3 \
 python3-email-validator \
 python3-fastapi-slim \
 python3-httpx \
 python3-itsdangerous \
 python3-jinja2 \
 python3-orjson \
 python3-pydantic-extra-types \
 python3-pydantic-settings \
 python3-python-multipart \
 python3-pyyaml \
 python3-ujson \
 python3-uvicorn \
 python3-uvicorn+standard \
 "
RDEPENDS:python3-fastapi-slim+standard = " \
 fastapi-cli \
 fastapi-cli+standard \
 python3 \
 python3-email-validator \
 python3-fastapi-slim \
 python3-httpx \
 python3-jinja2 \
 python3-python-multipart \
 python3-uvicorn \
 python3-uvicorn+standard \
 "
