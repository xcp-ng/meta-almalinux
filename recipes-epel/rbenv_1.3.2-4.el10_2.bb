# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rbenv"
PV = "1.3.2"
PR = "4.el10_2"
PACKAGES = " \
 rbenv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rbenv-1.3.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a8bf01cb3be72d6865825db89bf02f3afdf6464dc460f5b64e2a56258dd8f58"

URI_x86_64_v2_rbenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rbenv-1.3.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rbenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rbenv}"
SRC_URI[x86_64_v2_rbenv.sha256sum] = "666379849b1951a7269c24928c2233a898196d25ea1c05e11cd46a6e83041bfd"

URI_aarch64_rbenv = "${EPEL_MIRROR}/aarch64/Packages/r/rbenv-1.3.2-4.el10_2.noarch.rpm;name=aarch64_rbenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_rbenv}"
SRC_URI[aarch64_rbenv.sha256sum] = "5a7daa2bde4fd13fe7e0054f9009e2ddea5a09d04f6e235d19150fdedd556de5"

RDEPENDS:rbenv = " \
 bash \
 gawk \
 "
