# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-machines"
PV = "355"
PR = "1.el10"
PACKAGES = " \
 cockpit-machines \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-machines-355-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b2764c0a9f8f07e97e9498e394b46577d9da50b6455809180c13684fa7e1068c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-machines-355-1.el10.noarch.rpm;name=x86_64_v2_cockpit-machines;unpack=0"
SRC_URI[x86_64_v2_cockpit-machines.sha256sum] = "ab32dc05674a4cfa962ebcfb4c03b0692a6e5470d33431d70f5f3e6339c03a5a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-machines-355-1.el10.noarch.rpm;name=aarch64_cockpit-machines;unpack=0"
SRC_URI[aarch64_cockpit-machines.sha256sum] = "ab32dc05674a4cfa962ebcfb4c03b0692a6e5470d33431d70f5f3e6339c03a5a"

RDEPENDS:cockpit-machines = " \
 cockpit-bridge \
 libvirt-client \
 libvirt-daemon-config-network \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-storage-core \
 libvirt-dbus \
 qemu-kvm \
 virt-install \
 "
