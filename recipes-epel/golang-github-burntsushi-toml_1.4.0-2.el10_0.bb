# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-burntsushi-toml"
PV = "1.4.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-burntsushi-toml \
 golang-github-burntsushi-toml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-burntsushi-toml-1.4.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96cadba8bdc6026dc8d33d08aa962d8f65c56fc338b4e9ea10a7758f9ae1909b"

URI_x86_64_v2_golang-github-burntsushi-toml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-burntsushi-toml-1.4.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-burntsushi-toml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-burntsushi-toml}"
SRC_URI[x86_64_v2_golang-github-burntsushi-toml.sha256sum] = "1b75f71e2bb21b912378927821a2ef4d9e058abf63b42a63b509bc95a9935947"

URI_x86_64_v2_golang-github-burntsushi-toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-burntsushi-toml-devel-1.4.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-burntsushi-toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-burntsushi-toml-devel}"
SRC_URI[x86_64_v2_golang-github-burntsushi-toml-devel.sha256sum] = "b8bc5c57165b75083889c33f0ff5e70172c727ed982c385ad3a6b477a890d17d"

URI_aarch64_golang-github-burntsushi-toml = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-burntsushi-toml-1.4.0-2.el10_0.aarch64.rpm;name=aarch64_golang-github-burntsushi-toml;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-burntsushi-toml}"
SRC_URI[aarch64_golang-github-burntsushi-toml.sha256sum] = "0ae6b30c50a58b1d644d04e25de7c3249f3ffdb3599cc82cb2fa0b2dc88e9e0b"

URI_aarch64_golang-github-burntsushi-toml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-burntsushi-toml-devel-1.4.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-burntsushi-toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-burntsushi-toml-devel}"
SRC_URI[aarch64_golang-github-burntsushi-toml-devel.sha256sum] = "c7039362db25e00a607b7dc0f4ced655ceb473888fc3f45529ccd9400d87109c"

RDEPENDS:golang-github-burntsushi-toml = " \
 glibc \
 "
RDEPENDS:golang-github-burntsushi-toml-devel = " \
 go-filesystem \
 "
