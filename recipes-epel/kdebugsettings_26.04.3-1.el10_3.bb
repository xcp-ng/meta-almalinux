# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdebugsettings"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdebugsettings \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdebugsettings-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce57a6b6b43edb79ebb8a20df2df6823637ab8db3ae0fcf88a63817458542dbe"

URI_x86_64_v2_kdebugsettings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdebugsettings-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdebugsettings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdebugsettings}"
SRC_URI[x86_64_v2_kdebugsettings.sha256sum] = "be69ad258c972cac94038372d211a6e772adea15681da5963d5d8318afdf7f31"

URI_aarch64_kdebugsettings = "${EPEL_MIRROR}/aarch64/Packages/k/kdebugsettings-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdebugsettings;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdebugsettings}"
SRC_URI[aarch64_kdebugsettings.sha256sum] = "76c8f74e007ab8d8e591fb08512472e87e2d91560f6d5945769fab6921856239"

RDEPENDS:kdebugsettings = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
