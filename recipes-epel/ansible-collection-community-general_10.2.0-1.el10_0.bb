# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-community-general"
PV = "10.2.0"
PR = "1.el10_0"
PACKAGES = " \
 ansible-collection-community-general \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/ansible-collection-community-general-10.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9b99984e6bc6ef40a981b7e729903fb7d9942b2bb3f4fe4ed05f2216449e68e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-collection-community-general-10.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-collection-community-general;unpack=0"
SRC_URI[x86_64_v2_ansible-collection-community-general.sha256sum] = "851362aa46061a0262044d843d20b5805bfbfbd38b4fc16de4fbfe2086125612"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/ansible-collection-community-general-10.2.0-1.el10_0.noarch.rpm;name=aarch64_ansible-collection-community-general;unpack=0"
SRC_URI[aarch64_ansible-collection-community-general.sha256sum] = "7746e6e96f35b8d461eea24383fda8df0e6ed066508143802a0f600755cbcd97"

RDEPENDS:ansible-collection-community-general = " \
 ansible-core \
 "
