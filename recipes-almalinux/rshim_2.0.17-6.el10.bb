# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rshim"
PV = "2.0.17"
PR = "6.el10"
PACKAGES = " \
 rshim \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rshim-2.0.17-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "71df78929ef5cfc0f82fb80cf55f195b75ee949d4d8f4e6b03be60e28151a724"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rshim-2.0.17-6.el10.x86_64_v2.rpm;name=x86_64_v2_rshim;unpack=0"
SRC_URI[x86_64_v2_rshim.sha256sum] = "376375e8138e15b622d1ca9d1effe7afb49834028813b31c5a0d6d2447fd990e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rshim-2.0.17-6.el10.aarch64.rpm;name=aarch64_rshim;unpack=0"
SRC_URI[aarch64_rshim.sha256sum] = "a37a9172f052cb8a91cb2167bf1bf3384821bfffcd8e73c75337fc6ca96929e5"

RDEPENDS:rshim = " \
 bash \
 fuse-libs \
 glibc \
 libusb1 \
 pciutils-libs \
 virtual/kmod_cuse.ko_ \
 "
