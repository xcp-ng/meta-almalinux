# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtmqtt"
PV = "6.8.1"
PR = "2.el10_0"
PACKAGES = " \
 qt6-qtmqtt \
 qt6-qtmqtt-devel \
 qt6-qtmqtt-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtmqtt-6.8.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b976b39b2372b7aef9ad9b8b6e5ab47d7eb44b3bb7a3b9d8565e85cb695b30ad"

URI_x86_64_v2_qt6-qtmqtt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtmqtt-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmqtt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmqtt}"
SRC_URI[x86_64_v2_qt6-qtmqtt.sha256sum] = "66515958f1a20664f7536f2e0c5b457116e8458d5b7e18323888b4690349d249"

URI_x86_64_v2_qt6-qtmqtt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtmqtt-devel-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmqtt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmqtt-devel}"
SRC_URI[x86_64_v2_qt6-qtmqtt-devel.sha256sum] = "43b06887339a04629a1a222f23b4b56d538542ea7e12397a6e979cb33cba5ff9"

URI_x86_64_v2_qt6-qtmqtt-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtmqtt-examples-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmqtt-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmqtt-examples}"
SRC_URI[x86_64_v2_qt6-qtmqtt-examples.sha256sum] = "eff10e4e9f21d3bfa64ebbc03b68b7a77e6e58e5933b29e31a17a9bee9952bad"

URI_aarch64_qt6-qtmqtt = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtmqtt-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtmqtt;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmqtt}"
SRC_URI[aarch64_qt6-qtmqtt.sha256sum] = "1bd01002087766efde230b3b9cc84b048f7b7652ede3fc855f422869f5c5956b"

URI_aarch64_qt6-qtmqtt-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtmqtt-devel-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtmqtt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmqtt-devel}"
SRC_URI[aarch64_qt6-qtmqtt-devel.sha256sum] = "15669032c34616aa6805a02844cdd4c6211aa9ec26b327825abd9184f5e922cf"

URI_aarch64_qt6-qtmqtt-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtmqtt-examples-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtmqtt-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmqtt-examples}"
SRC_URI[aarch64_qt6-qtmqtt-examples.sha256sum] = "526684b49ab35aa8d54a72e1b86741d7c45e7f3edff3e301ba0d3bd5c3b3e72a"

RDEPENDS:qt6-qtmqtt = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtmqtt-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtmqtt \
 "
RDEPENDS:qt6-qtmqtt-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmqtt \
 "
