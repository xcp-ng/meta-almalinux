# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql16-pg_tle"
PV = "1.5.2"
PR = "1.el10_3"
PACKAGES = " \
 postgresql16-pg_tle \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/postgresql16-pg_tle-1.5.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "87a273781c39da33bfcdb86ab9f8193ad7941f99deaa714f610fc38e39051cf1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/postgresql16-pg_tle-1.5.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_postgresql16-pg_tle;unpack=0"
SRC_URI[x86_64_v2_postgresql16-pg_tle.sha256sum] = "110ee575c151ef1ffbd1b2866ce4b5536616811a4974ef19942f0c443d652659"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/postgresql16-pg_tle-1.5.2-1.el10_3.aarch64.rpm;name=aarch64_postgresql16-pg_tle;unpack=0"
SRC_URI[aarch64_postgresql16-pg_tle.sha256sum] = "2dbbfa1d645129d0ca1e358facca4861bbfe508ff949acf140a8ad380746889c"

RDEPENDS:postgresql16-pg_tle = " \
 glibc \
 postgresql-server \
 "
