# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tar"
PE = "2"
PV = "1.35"
PR = "13.el10_2"
PACKAGES = " \
 tar \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tar-1.35-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "388b1779117e9f1ca801dcd0de9ca0f3627450bb7e5a46cfefaee74a98443b6d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tar-1.35-13.el10_2.x86_64_v2.rpm;name=x86_64_v2_tar;unpack=0"
SRC_URI[x86_64_v2_tar.sha256sum] = "b66f01bdbd7e2608097d227deddf0eb67772a7a090ed27702b908be2bee073c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tar-1.35-13.el10_2.aarch64.rpm;name=aarch64_tar;unpack=0"
SRC_URI[aarch64_tar.sha256sum] = "6019ab0050f811aad3189850eac2b57b976f910751e8403f6fe255dd2c7a132f"

RDEPENDS:tar = " \
 glibc \
 libacl \
 libselinux \
 "
