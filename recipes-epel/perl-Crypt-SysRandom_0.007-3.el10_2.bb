# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-SysRandom"
PV = "0.007"
PR = "3.el10_2"
PACKAGES = " \
 perl-Crypt-SysRandom \
 perl-Crypt-SysRandom-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-SysRandom-0.007-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "89fb39efd1480d42af75f6726c3af939a90a99fd93bb6feccb5954c5461e1a07"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-SysRandom-0.007-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-SysRandom;unpack=0"
SRC_URI[x86_64_v2_perl-Crypt-SysRandom.sha256sum] = "1d93183938f3b73514a0d11caca4fa7b645545882f7b6c220e3135bf13f3c4dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-SysRandom-tests-0.007-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-SysRandom-tests;unpack=0"
SRC_URI[x86_64_v2_perl-Crypt-SysRandom-tests.sha256sum] = "b9a111e144a6d27bbfe1ec0679ed0f068ac991baf99ec6e3c568b87c9126cad9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-SysRandom-0.007-3.el10_2.noarch.rpm;name=aarch64_perl-Crypt-SysRandom;unpack=0"
SRC_URI[aarch64_perl-Crypt-SysRandom.sha256sum] = "22152f5dbbbb0563c1cb5f09a718b3edd13bf463cc6e31d4e29974982c3babd2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-SysRandom-tests-0.007-3.el10_2.noarch.rpm;name=aarch64_perl-Crypt-SysRandom-tests;unpack=0"
SRC_URI[aarch64_perl-Crypt-SysRandom-tests.sha256sum] = "ebc0de91676de78f5d8971e16f1d75cc54d2e375fc7187073adde4f4d1b9e13b"

RDEPENDS:perl-Crypt-SysRandom = " \
 perl-Carp \
 perl-Crypt-SysRandom-XS \
 perl-Errno \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Crypt-SysRandom-tests = " \
 bash \
 perl-Crypt-SysRandom \
 perl-IO \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
