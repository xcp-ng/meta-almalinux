# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zimg"
PV = "3.0.6"
PR = "2.el10_0"
PACKAGES = " \
 zimg \
 zimg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zimg-3.0.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ddf8fcac074e9d2b4cf6df9857b4e8ab0c21780fd2f44978270b4d7a696e9c7"

URI_x86_64_v2_zimg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zimg-3.0.6-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zimg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zimg}"
SRC_URI[x86_64_v2_zimg.sha256sum] = "8ec73767092a312dc908690cc28c90529039b4d3649308cc374b80e9cc8fcd37"

URI_x86_64_v2_zimg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zimg-devel-3.0.6-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zimg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zimg-devel}"
SRC_URI[x86_64_v2_zimg-devel.sha256sum] = "f28677c413f6a61ba608fe2dfdc835bb8f4f05c371823e36cb2d8727d6591e9c"

URI_aarch64_zimg = "${EPEL_MIRROR}/aarch64/Packages/z/zimg-3.0.6-2.el10_0.aarch64.rpm;name=aarch64_zimg;unpack=0"
SRC_URI:append = " ${URI_aarch64_zimg}"
SRC_URI[aarch64_zimg.sha256sum] = "e4fe4f8c3f8a5c86fb2b6845d1369a3969bd30f962cba833aa774648470ac56b"

URI_aarch64_zimg-devel = "${EPEL_MIRROR}/aarch64/Packages/z/zimg-devel-3.0.6-2.el10_0.aarch64.rpm;name=aarch64_zimg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zimg-devel}"
SRC_URI[aarch64_zimg-devel.sha256sum] = "362c2b4639e0abe2d8426a30ae2d002af7d96f78472cdaa8adf4fdb5f0d13f9c"

RDEPENDS:zimg = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:zimg-devel = " \
 glibc \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 zimg \
 "
