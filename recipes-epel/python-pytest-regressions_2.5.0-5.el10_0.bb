# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-regressions"
PV = "2.5.0"
PR = "5.el10_0"
PACKAGES = " \
 python-pytest-regressions-doc \
 python3-pytest-regressions \
 python3-pytest-regressions+dataframe \
 python3-pytest-regressions+image \
 python3-pytest-regressions+num \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-pytest-regressions-2.5.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "45088ea35e353f000dc37eaece702d54b805c1f1a420511f2086aa9d2d09c115"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pytest-regressions-doc-2.5.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-pytest-regressions-doc;unpack=0"
SRC_URI[x86_64_v2_python-pytest-regressions-doc.sha256sum] = "17ffce2ad5c1d792fe5bb0fa644897f07ff20a286976df387fe4e288b70727f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-regressions-2.5.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-regressions;unpack=0"
SRC_URI[x86_64_v2_python3-pytest-regressions.sha256sum] = "41abd7d58c73181ae5e7ff1ce405a5fa29177b8eefdc159d759682a8798c5e1c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-regressions+dataframe-2.5.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-regressions+dataframe;unpack=0"
SRC_URI[x86_64_v2_python3-pytest-regressions+dataframe.sha256sum] = "90b68d5f702829fc0e4a0b9111663b55b2481ef6ba59aaa2bc2cee5c25231ad5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-regressions+image-2.5.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-regressions+image;unpack=0"
SRC_URI[x86_64_v2_python3-pytest-regressions+image.sha256sum] = "e0b18c1bac7073975fcd0de3563dc8c08b29f0b559f3120fb9e08f028d0170ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-regressions+num-2.5.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-regressions+num;unpack=0"
SRC_URI[x86_64_v2_python3-pytest-regressions+num.sha256sum] = "5b755abd85fa8632babfc07bfa56c8b3722d3c9ea3e3bcfe123e26b094770534"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-pytest-regressions-doc-2.5.0-5.el10_0.noarch.rpm;name=aarch64_python-pytest-regressions-doc;unpack=0"
SRC_URI[aarch64_python-pytest-regressions-doc.sha256sum] = "272c3893522ea9d3742e79a3085c3030bfe73ec6f58df1ef0d64214abd7b6324"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-regressions-2.5.0-5.el10_0.noarch.rpm;name=aarch64_python3-pytest-regressions;unpack=0"
SRC_URI[aarch64_python3-pytest-regressions.sha256sum] = "248afd58d9fbaa7a995cba7023e534e310b286cd49bd606373dda3b2d05b7f61"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-regressions+dataframe-2.5.0-5.el10_0.noarch.rpm;name=aarch64_python3-pytest-regressions+dataframe;unpack=0"
SRC_URI[aarch64_python3-pytest-regressions+dataframe.sha256sum] = "a826334adfc2da6aa5cd6b82b2ff01efe892bc88dde063f09d0bb7e836626fdb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-regressions+image-2.5.0-5.el10_0.noarch.rpm;name=aarch64_python3-pytest-regressions+image;unpack=0"
SRC_URI[aarch64_python3-pytest-regressions+image.sha256sum] = "9d660e6c8b9d5f6dbfca69144bd5b38b6b22bdae260dfa4d32c937f93e1d2741"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-regressions+num-2.5.0-5.el10_0.noarch.rpm;name=aarch64_python3-pytest-regressions+num;unpack=0"
SRC_URI[aarch64_python3-pytest-regressions+num.sha256sum] = "d111c7016d37374351106047e1d4458706bbfe6781cbe409a27c0692362b25b6"

RDEPENDS:python-pytest-regressions-doc = " \
 "
RDEPENDS:python3-pytest-regressions = " \
 python3 \
 python3-pytest \
 python3-pytest-datadir \
 python3-pyyaml \
 "
RDEPENDS:python3-pytest-regressions+dataframe = " \
 python3 \
 python3-numpy \
 python3-pandas \
 python3-pytest-regressions \
 "
RDEPENDS:python3-pytest-regressions+image = " \
 python3 \
 python3-numpy \
 python3-pillow \
 python3-pytest-regressions \
 "
RDEPENDS:python3-pytest-regressions+num = " \
 python3 \
 python3-numpy \
 python3-pandas \
 python3-pytest-regressions \
 "
