# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cmakelang"
PV = "0.6.13"
PR = "1.el10_2"
PACKAGES = " \
 cmakelang \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cmakelang-0.6.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e232ae583b2a06262398d2e519b3b10f45b5fb106beb6b28906b0b23d8336497"

URI_x86_64_v2_cmakelang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cmakelang-0.6.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_cmakelang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmakelang}"
SRC_URI[x86_64_v2_cmakelang.sha256sum] = "e5d79391df961610cdbffd5941acf46060e14ed3c8567f7d10fc55a40c0848ef"

URI_aarch64_cmakelang = "${EPEL_MIRROR}/aarch64/Packages/c/cmakelang-0.6.13-1.el10_2.noarch.rpm;name=aarch64_cmakelang;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmakelang}"
SRC_URI[aarch64_cmakelang.sha256sum] = "fa66f04012e8fc32152a02fab4c1eb7f0756eec92beeeec8070f60a7307b8ad2"

RDEPENDS:cmakelang = " \
 python3 \
 python3-libs \
 python3-six \
 "
