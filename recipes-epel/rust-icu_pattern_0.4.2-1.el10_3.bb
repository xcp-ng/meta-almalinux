# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_pattern"
PV = "0.4.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_pattern+alloc-devel \
 rust-icu_pattern+databake-devel \
 rust-icu_pattern+default-devel \
 rust-icu_pattern+litemap-devel \
 rust-icu_pattern+serde-devel \
 rust-icu_pattern+yoke-devel \
 rust-icu_pattern+zerovec-devel \
 rust-icu_pattern-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_pattern-0.4.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f09520697e154667e42b90a5e7e1850842dad0d9031b50d7254e61e6a174eca5"

URI_x86_64_v2_rust-icu_pattern+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern+alloc-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern+alloc-devel.sha256sum] = "234e393f61bee92a165eb10011a6d5d27450574fda3ed6070b7d3158f467a58a"

URI_x86_64_v2_rust-icu_pattern+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern+databake-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern+databake-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern+databake-devel.sha256sum] = "7951d6a09332e6945121cc446da44efe09a54242a0487f2222d756d07328f5a3"

URI_x86_64_v2_rust-icu_pattern+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern+default-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern+default-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern+default-devel.sha256sum] = "6630ebaa3137d909bc2ee06fbecd5e24d199029a2f958f5267a0f6a741cd5743"

URI_x86_64_v2_rust-icu_pattern+litemap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern+litemap-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern+litemap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern+litemap-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern+litemap-devel.sha256sum] = "60e7c8c674389f58f125a7c55cf3142af39bd5523973168c4797edec075cbb35"

URI_x86_64_v2_rust-icu_pattern+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern+serde-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern+serde-devel.sha256sum] = "9e36ff23c04d4e0b96cc1952531bbb0bbb1fceffc0323d9aec3f3a4537120dc0"

URI_x86_64_v2_rust-icu_pattern+yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern+yoke-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern+yoke-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern+yoke-devel.sha256sum] = "291d55926a74bc1027f46e8cb426c885530fc77cf6ef340a9b5e8928281172c7"

URI_x86_64_v2_rust-icu_pattern+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern+zerovec-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern+zerovec-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern+zerovec-devel.sha256sum] = "f907465a074655ccb9c0fa07e5000afcd1eac8c902b54a89601bf5efee0938f8"

URI_x86_64_v2_rust-icu_pattern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_pattern-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_pattern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_pattern-devel}"
SRC_URI[x86_64_v2_rust-icu_pattern-devel.sha256sum] = "e17bbccefde78e613f575dbd5a613723f6c3909bb239bf349e51b92ae4e4efce"

URI_aarch64_rust-icu_pattern+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern+alloc-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-icu_pattern+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern+alloc-devel}"
SRC_URI[aarch64_rust-icu_pattern+alloc-devel.sha256sum] = "92f16aeb05627d6794de87b5fbd6591600b4600d90e98b6c83260b7258b83f06"

URI_aarch64_rust-icu_pattern+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern+databake-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-icu_pattern+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern+databake-devel}"
SRC_URI[aarch64_rust-icu_pattern+databake-devel.sha256sum] = "7554328029266053d1dea0b30b7e19c1d1c41799a30d084608acc5949f0eaec8"

URI_aarch64_rust-icu_pattern+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern+default-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-icu_pattern+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern+default-devel}"
SRC_URI[aarch64_rust-icu_pattern+default-devel.sha256sum] = "d3a8855db04f6ca21166e9306430770180d6da076a38cdf7633196fd093c315f"

URI_aarch64_rust-icu_pattern+litemap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern+litemap-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-icu_pattern+litemap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern+litemap-devel}"
SRC_URI[aarch64_rust-icu_pattern+litemap-devel.sha256sum] = "aaaede4b31e90b585d47ac71de62375d2ee6295049e9c0f090cb8a6e8af3bc91"

URI_aarch64_rust-icu_pattern+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern+serde-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-icu_pattern+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern+serde-devel}"
SRC_URI[aarch64_rust-icu_pattern+serde-devel.sha256sum] = "8e0626171256240cc227a11d8487b07bc1dcb0635065b8c40b07e075ec9c6d85"

URI_aarch64_rust-icu_pattern+yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern+yoke-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-icu_pattern+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern+yoke-devel}"
SRC_URI[aarch64_rust-icu_pattern+yoke-devel.sha256sum] = "08e333c8af4c087f6724644156f78bdac37953eda8aea9b034b373f87521a91d"

URI_aarch64_rust-icu_pattern+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern+zerovec-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-icu_pattern+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern+zerovec-devel}"
SRC_URI[aarch64_rust-icu_pattern+zerovec-devel.sha256sum] = "8531c26ec577d6924c264e033d996d50bba5330e30389d120348ea54ad8357f2"

URI_aarch64_rust-icu_pattern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_pattern-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-icu_pattern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_pattern-devel}"
SRC_URI[aarch64_rust-icu_pattern-devel.sha256sum] = "bc5a09722c021eaff86940b5a2cd900968830fe0c89679a974c18a4a6595671e"

RDEPENDS:rust-icu_pattern+alloc-devel = " \
 cargo \
 rust-icu_pattern-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-writeable+alloc-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-icu_pattern+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_pattern-devel \
 "
RDEPENDS:rust-icu_pattern+default-devel = " \
 cargo \
 rust-icu_pattern-devel \
 "
RDEPENDS:rust-icu_pattern+litemap-devel = " \
 cargo \
 rust-icu_pattern-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-icu_pattern+serde-devel = " \
 cargo \
 rust-icu_pattern+alloc-devel \
 rust-icu_pattern-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-icu_pattern+yoke-devel = " \
 cargo \
 rust-icu_pattern-devel \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 "
RDEPENDS:rust-icu_pattern+zerovec-devel = " \
 cargo \
 rust-icu_pattern+alloc-devel \
 rust-icu_pattern-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-icu_pattern-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-either-devel \
 rust-writeable+either-devel \
 rust-writeable-devel \
 "
