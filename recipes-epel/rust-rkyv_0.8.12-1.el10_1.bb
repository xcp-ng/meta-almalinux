# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rkyv"
PV = "0.8.12"
PR = "1.el10_1"
PACKAGES = " \
 rust-rkyv+aligned-devel \
 rust-rkyv+alloc-devel \
 rust-rkyv+big_endian-devel \
 rust-rkyv+bytecheck-devel \
 rust-rkyv+default-devel \
 rust-rkyv+little_endian-devel \
 rust-rkyv+pointer_width_16-devel \
 rust-rkyv+pointer_width_32-devel \
 rust-rkyv+pointer_width_64-devel \
 rust-rkyv+smallvec-1-devel \
 rust-rkyv+std-devel \
 rust-rkyv+unaligned-devel \
 rust-rkyv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rkyv-0.8.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "207a1a2553d2c4efc6a8a760118632c08bc1ccab98a02f8d5e30c206c44fa2d3"

URI_x86_64_v2_rust-rkyv+aligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+aligned-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+aligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+aligned-devel}"
SRC_URI[x86_64_v2_rust-rkyv+aligned-devel.sha256sum] = "0cfc2efac506f7417e837bd03b71ca5691d5b6c685b2a07f0934f259c8b6998d"

URI_x86_64_v2_rust-rkyv+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+alloc-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+alloc-devel}"
SRC_URI[x86_64_v2_rust-rkyv+alloc-devel.sha256sum] = "fb3ae2e988b2d7fb06ec28ebb2688505b8fc7b3c18ffd11f5941502cd9328e2c"

URI_x86_64_v2_rust-rkyv+big_endian-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+big_endian-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+big_endian-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+big_endian-devel}"
SRC_URI[x86_64_v2_rust-rkyv+big_endian-devel.sha256sum] = "728c4fcb3ea392b0ff498a9174c815b6132005b84c5a27f46e81312bdfca0526"

URI_x86_64_v2_rust-rkyv+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+bytecheck-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rkyv+bytecheck-devel.sha256sum] = "7fc5d030d5041e4ef334c0af634a899082a62f4affe0c7022e8b64a4b084e038"

URI_x86_64_v2_rust-rkyv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+default-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+default-devel}"
SRC_URI[x86_64_v2_rust-rkyv+default-devel.sha256sum] = "0521d5d9629faf0387615546f20dcfff30812ba037eb0fd625e143a7cfb7113a"

URI_x86_64_v2_rust-rkyv+little_endian-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+little_endian-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+little_endian-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+little_endian-devel}"
SRC_URI[x86_64_v2_rust-rkyv+little_endian-devel.sha256sum] = "39f4aabb7758bb04e2b554d3ad50df01cbe6d0ba2f5ac50a03ca8b4a8ca6ca12"

URI_x86_64_v2_rust-rkyv+pointer_width_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+pointer_width_16-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+pointer_width_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+pointer_width_16-devel}"
SRC_URI[x86_64_v2_rust-rkyv+pointer_width_16-devel.sha256sum] = "27cb17ad9b50707f123a071c2292ffbaeec008da61a2943530fdaa39895d7410"

URI_x86_64_v2_rust-rkyv+pointer_width_32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+pointer_width_32-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+pointer_width_32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+pointer_width_32-devel}"
SRC_URI[x86_64_v2_rust-rkyv+pointer_width_32-devel.sha256sum] = "8fc63b96b2799b9ec449852b3770369fc3e8afcb1c7c4da164011a0c08fa1f8e"

URI_x86_64_v2_rust-rkyv+pointer_width_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+pointer_width_64-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+pointer_width_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+pointer_width_64-devel}"
SRC_URI[x86_64_v2_rust-rkyv+pointer_width_64-devel.sha256sum] = "8135625051c6534b8359ce4f69700a3e38d701196a97e0e04b96bc3fca4c2205"

URI_x86_64_v2_rust-rkyv+smallvec-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+smallvec-1-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+smallvec-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+smallvec-1-devel}"
SRC_URI[x86_64_v2_rust-rkyv+smallvec-1-devel.sha256sum] = "62d61684b4ddac23bdc57253fa5ee21a9274f776182fd3cabfb838d770334cd5"

URI_x86_64_v2_rust-rkyv+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+std-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+std-devel}"
SRC_URI[x86_64_v2_rust-rkyv+std-devel.sha256sum] = "ba330ea424879c7cfca5dfc14de8292450f27281426bc5afd8606c885a317320"

URI_x86_64_v2_rust-rkyv+unaligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+unaligned-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+unaligned-devel}"
SRC_URI[x86_64_v2_rust-rkyv+unaligned-devel.sha256sum] = "6082c5046b2ea9697a728f018ab65798e576af2488045407191d2cf5e5b17478"

URI_x86_64_v2_rust-rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv-devel}"
SRC_URI[x86_64_v2_rust-rkyv-devel.sha256sum] = "b77de2c2ccb729b358207fdd749a5b641ac7056993d6b7d8677cc3ae2cb9e24a"

URI_aarch64_rust-rkyv+aligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+aligned-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv+aligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+aligned-devel}"
SRC_URI[aarch64_rust-rkyv+aligned-devel.sha256sum] = "163b8d230192072dbff70366da5ff761671c5e068ac954b70086b7ad661a7fe8"

URI_aarch64_rust-rkyv+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+alloc-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+alloc-devel}"
SRC_URI[aarch64_rust-rkyv+alloc-devel.sha256sum] = "5269b723723c429114aea741aa6dc4cac0d4e81da12af31446ecb4f7c631b939"

URI_aarch64_rust-rkyv+big_endian-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+big_endian-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv+big_endian-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+big_endian-devel}"
SRC_URI[aarch64_rust-rkyv+big_endian-devel.sha256sum] = "8d2ccdeb12381dd8013cdbad48b077d26c8e8366a087b08016d02784cd327876"

URI_aarch64_rust-rkyv+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+bytecheck-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+bytecheck-devel}"
SRC_URI[aarch64_rust-rkyv+bytecheck-devel.sha256sum] = "c1e9fb8f8ae82a4da40f0689f0fb9dcd681c0cd6c27ad7f1a6c03e6690de46ac"

URI_aarch64_rust-rkyv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+default-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+default-devel}"
SRC_URI[aarch64_rust-rkyv+default-devel.sha256sum] = "d297519dfa9ecd1bcaff0874ea123275cc7388b22ad4c4779ff98ea1c157f44c"

URI_aarch64_rust-rkyv+little_endian-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+little_endian-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv+little_endian-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+little_endian-devel}"
SRC_URI[aarch64_rust-rkyv+little_endian-devel.sha256sum] = "96fea819c3ce04e5b1621e9f0f5875dcdc649a49f2e36356c798f6bf8b42faef"

URI_aarch64_rust-rkyv+pointer_width_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+pointer_width_16-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv+pointer_width_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+pointer_width_16-devel}"
SRC_URI[aarch64_rust-rkyv+pointer_width_16-devel.sha256sum] = "64dfa7e260706a28def317668bbed0f3fe6c559a3f4fab706799d5edaea7b4c4"

URI_aarch64_rust-rkyv+pointer_width_32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+pointer_width_32-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv+pointer_width_32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+pointer_width_32-devel}"
SRC_URI[aarch64_rust-rkyv+pointer_width_32-devel.sha256sum] = "723795e34f05f586a3a90b89356e593226df53d9565f97d2b68af5430141622b"

URI_aarch64_rust-rkyv+pointer_width_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+pointer_width_64-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv+pointer_width_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+pointer_width_64-devel}"
SRC_URI[aarch64_rust-rkyv+pointer_width_64-devel.sha256sum] = "9aeae19a16ea362fb48ee149f4e9e970a2639fa6ef9796e7348750917ac6a60c"

URI_aarch64_rust-rkyv+smallvec-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+smallvec-1-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv+smallvec-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+smallvec-1-devel}"
SRC_URI[aarch64_rust-rkyv+smallvec-1-devel.sha256sum] = "bbf326fce5b952f93f55f3aec5d7a86318b4eda805913642920cd606a8cae570"

URI_aarch64_rust-rkyv+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+std-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+std-devel}"
SRC_URI[aarch64_rust-rkyv+std-devel.sha256sum] = "d555056e2a7ab87fbb3d50c5d200237666dfe1c3f25cde58be14c57a980729ca"

URI_aarch64_rust-rkyv+unaligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+unaligned-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+unaligned-devel}"
SRC_URI[aarch64_rust-rkyv+unaligned-devel.sha256sum] = "c72f39242f6a81faeadb3ede05a1bc210d61aaad9250d98ec5ed9f8c2d79f072"

URI_aarch64_rust-rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv-devel}"
SRC_URI[aarch64_rust-rkyv-devel.sha256sum] = "17d8679aaa2b59bb1620af3f052531ce2e17e56517934932363fe6403af6eb05"

RDEPENDS:rust-rkyv+aligned-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+alloc-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-rancor+alloc-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+big_endian-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+bytecheck-devel = " \
 cargo \
 rust-bytecheck+simdutf8-devel \
 rust-bytecheck-devel \
 rust-rend+bytecheck-devel \
 rust-rkyv-devel \
 rust-rkyv_derive+bytecheck-devel \
 "
RDEPENDS:rust-rkyv+default-devel = " \
 cargo \
 rust-rkyv+bytecheck-devel \
 rust-rkyv+std-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+little_endian-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+pointer_width_16-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+pointer_width_32-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+pointer_width_64-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+smallvec-1-devel = " \
 cargo \
 rust-rkyv-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-rkyv+std-devel = " \
 cargo \
 rust-ptr_meta+std-devel \
 rust-rkyv+alloc-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+unaligned-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv-devel = " \
 cargo \
 rust \
 rust-munge-devel \
 rust-ptr_meta-devel \
 rust-rancor-devel \
 rust-rend-devel \
 rust-rkyv_derive-devel \
 "
