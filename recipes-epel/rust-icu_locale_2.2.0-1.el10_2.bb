# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_locale"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale+datagen-devel \
 rust-icu_locale+default-devel \
 rust-icu_locale+serde-devel \
 rust-icu_locale-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_locale-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f37b176c61a0f953c2eb60cb90a033a52c5c82b807a6d647792b2461de7c22c"

URI_x86_64_v2_rust-icu_locale+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale+compiled_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_locale+compiled_data-devel.sha256sum] = "ac9f033a78d6f37297365e4aa660a52fb78caa515a3bad01b8d0ea08dca73973"

URI_x86_64_v2_rust-icu_locale+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale+datagen-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_locale+datagen-devel.sha256sum] = "b5d7ab5ec662e871da1d9c38201200427ff3fb0733f13ff77d546b580b290043"

URI_x86_64_v2_rust-icu_locale+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale+default-devel}"
SRC_URI[x86_64_v2_rust-icu_locale+default-devel.sha256sum] = "189418512f23c2661c8a6f648b4a0aae0133e959e60496c892be15e515a92f45"

URI_x86_64_v2_rust-icu_locale+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale+serde-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_locale+serde-devel.sha256sum] = "915610f9eb86fe5cd6974b61d117763a3289ae9df42f553ce3a6e709f5f1b554"

URI_x86_64_v2_rust-icu_locale-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale-devel}"
SRC_URI[x86_64_v2_rust-icu_locale-devel.sha256sum] = "be3c5ef88c4fb5a8d71bc6a73dff44fcf43c6fd770e799dce9763422374eeae2"

URI_aarch64_rust-icu_locale+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale+compiled_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_locale+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_locale+compiled_data-devel.sha256sum] = "318b22e60848c1e1dd1fe6496c91076d76ef660b2431e22f394acd01072851a7"

URI_aarch64_rust-icu_locale+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale+datagen-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_locale+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale+datagen-devel}"
SRC_URI[aarch64_rust-icu_locale+datagen-devel.sha256sum] = "ab46c2cb8c4d54a84c025cc71d30d21dcd034c1aad316ca421e5c67b0b00383f"

URI_aarch64_rust-icu_locale+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_locale+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale+default-devel}"
SRC_URI[aarch64_rust-icu_locale+default-devel.sha256sum] = "0d5982158c1d7af17d629f303c7636285b316e1da38510ae1387f166c3f167d6"

URI_aarch64_rust-icu_locale+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale+serde-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_locale+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale+serde-devel}"
SRC_URI[aarch64_rust-icu_locale+serde-devel.sha256sum] = "c6c7c2541e5e396e8d2260d945f99c459c1fda9365f39a214ba25314d8644d95"

URI_aarch64_rust-icu_locale-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_locale-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale-devel}"
SRC_URI[aarch64_rust-icu_locale-devel.sha256sum] = "bc339e53cc37d4beffdebcd5337e4f744e200d252700ac6c8922ebe62dff7f80"

RDEPENDS:rust-icu_locale+compiled_data-devel = " \
 cargo \
 rust-icu_locale-devel \
 rust-icu_locale_data-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_locale+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collections+databake-devel \
 rust-icu_locale+serde-devel \
 rust-icu_locale-devel \
 rust-icu_locale_core+databake-devel \
 rust-icu_provider+export-devel \
 rust-tinystr+databake-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_locale+default-devel = " \
 cargo \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale-devel \
 "
RDEPENDS:rust-icu_locale+serde-devel = " \
 cargo \
 rust-icu_collections+serde-devel \
 rust-icu_locale-devel \
 rust-icu_locale_core+serde-devel \
 rust-icu_provider+serde-devel \
 rust-potential_utf+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-tinystr+serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_locale-devel = " \
 cargo \
 rust \
 rust-icu_collections-devel \
 rust-icu_locale_core+alloc-devel \
 rust-icu_locale_core+zerovec-devel \
 rust-icu_locale_core-devel \
 rust-icu_provider+alloc-devel \
 rust-icu_provider-devel \
 rust-potential_utf+alloc-devel \
 rust-potential_utf+zerovec-devel \
 rust-potential_utf-devel \
 rust-tinystr+alloc-devel \
 rust-tinystr+zerovec-devel \
 rust-tinystr-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
