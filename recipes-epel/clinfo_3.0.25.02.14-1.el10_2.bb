# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clinfo"
PV = "3.0.25.02.14"
PR = "1.el10_2"
PACKAGES = " \
 clinfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clinfo-3.0.25.02.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6e221be0c73de60109aef2f213cd79d2f175fe8ace5d5daf47277d5190a0778"

URI_x86_64_v2_clinfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clinfo-3.0.25.02.14-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clinfo}"
SRC_URI[x86_64_v2_clinfo.sha256sum] = "6b38d98b6100f6e5be2b44f305d680807ea7ebc3abc45478364f8074f7cf9bb7"

URI_aarch64_clinfo = "${EPEL_MIRROR}/aarch64/Packages/c/clinfo-3.0.25.02.14-1.el10_2.aarch64.rpm;name=aarch64_clinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_clinfo}"
SRC_URI[aarch64_clinfo.sha256sum] = "309dc623fc5f95f65e5dd1161fce85ac3f79301849cb37e16d3a77533160995a"

RDEPENDS:clinfo = " \
 glibc \
 ocl-icd \
 "
