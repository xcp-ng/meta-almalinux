# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-progress"
PV = "1.6"
PR = "13.el10_0"
PACKAGES = " \
 python3-progress \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-progress-1.6-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfbec84faa720a107fbfa5693a11b21f71a451f2e44d02e36edf2e4358e48b51"

URI_x86_64_v2_python3-progress = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-progress-1.6-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-progress;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-progress}"
SRC_URI[x86_64_v2_python3-progress.sha256sum] = "24ffa97966261547584fb2da4a187d4f2123e76d347baf240b2216ab723c0154"

URI_aarch64_python3-progress = "${EPEL_MIRROR}/aarch64/Packages/p/python3-progress-1.6-13.el10_0.noarch.rpm;name=aarch64_python3-progress;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-progress}"
SRC_URI[aarch64_python3-progress.sha256sum] = "f4ba54dd9b77acf1c207ec983682b09c13f1284f2046d81dedf34e5096c0c305"

RDEPENDS:python3-progress = " \
 python3 \
 "
