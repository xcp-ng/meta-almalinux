# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitflags"
PV = "2.11.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-bitflags+arbitrary-devel \
 rust-bitflags+bytemuck-devel \
 rust-bitflags+default-devel \
 rust-bitflags+example_generated-devel \
 rust-bitflags+serde-devel \
 rust-bitflags+serde_core-devel \
 rust-bitflags+std-devel \
 rust-bitflags-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bitflags-2.11.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "429d6d9d41aa104ad4996e241c60ba2e87c4c1f1ae57bbe9a379c9fb9c8e91e3"

URI_x86_64_v2_rust-bitflags+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+arbitrary-devel-2.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-bitflags+arbitrary-devel.sha256sum] = "e23c8b2d349b2605febe2c8b082f7369bb6d40997b86a9570a9aaa65a62357da"

URI_x86_64_v2_rust-bitflags+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+bytemuck-devel-2.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-bitflags+bytemuck-devel.sha256sum] = "e0e5c614181f1cc443c2b2cd722a06731acf56879c7f9dba15088259d6bbaf3a"

URI_x86_64_v2_rust-bitflags+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+default-devel-2.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+default-devel}"
SRC_URI[x86_64_v2_rust-bitflags+default-devel.sha256sum] = "6fc12e8dd3ede6ee88ef54bc32ae8144706c7c0579bde6d443f18232cb03eabd"

URI_x86_64_v2_rust-bitflags+example_generated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+example_generated-devel-2.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+example_generated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+example_generated-devel}"
SRC_URI[x86_64_v2_rust-bitflags+example_generated-devel.sha256sum] = "bfa1e49fbde5f0684b8af4d00afaebf98feaae0338ef830a8ae00daef04632a8"

URI_x86_64_v2_rust-bitflags+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+serde-devel-2.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+serde-devel}"
SRC_URI[x86_64_v2_rust-bitflags+serde-devel.sha256sum] = "50222d51131122eaacb994dde8e798b0229f07bdcb4ee7584d0cf964a3196bf0"

URI_x86_64_v2_rust-bitflags+serde_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+serde_core-devel-2.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+serde_core-devel}"
SRC_URI[x86_64_v2_rust-bitflags+serde_core-devel.sha256sum] = "7c7df08ff3cd2fa545cbff11c9cb607239ec251e6bf9d61ad3e2e30bfab2630e"

URI_x86_64_v2_rust-bitflags+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+std-devel-2.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+std-devel}"
SRC_URI[x86_64_v2_rust-bitflags+std-devel.sha256sum] = "8e0e82f62dcbdf8de8dbfe13622d93ec9facff427468d601bcf0719ff00e3a78"

URI_x86_64_v2_rust-bitflags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags-devel-2.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags-devel}"
SRC_URI[x86_64_v2_rust-bitflags-devel.sha256sum] = "5c0d17eaff54899092b5d446ceb80686f29954efe11c6a17407f76efde2bdd49"

URI_aarch64_rust-bitflags+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+arbitrary-devel-2.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitflags+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+arbitrary-devel}"
SRC_URI[aarch64_rust-bitflags+arbitrary-devel.sha256sum] = "c6e2d4df780e5af0e878dd97eee92233de71ab312a2cb42d9d7b63e2062f4b83"

URI_aarch64_rust-bitflags+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+bytemuck-devel-2.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitflags+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+bytemuck-devel}"
SRC_URI[aarch64_rust-bitflags+bytemuck-devel.sha256sum] = "518392b2d85d6db7c58e42380db2ed44df9199863daea6cf7c0216dfc5425267"

URI_aarch64_rust-bitflags+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+default-devel-2.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitflags+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+default-devel}"
SRC_URI[aarch64_rust-bitflags+default-devel.sha256sum] = "3c08fa7786e6c8d643b2b58307cac8066cc7d6c2ea1772e01eb1a8ee6fb76f0c"

URI_aarch64_rust-bitflags+example_generated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+example_generated-devel-2.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitflags+example_generated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+example_generated-devel}"
SRC_URI[aarch64_rust-bitflags+example_generated-devel.sha256sum] = "fc83d26705ee478b1dd814e70d7a9d86260b65890a7b6e3bd21d9a635350ce9e"

URI_aarch64_rust-bitflags+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+serde-devel-2.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitflags+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+serde-devel}"
SRC_URI[aarch64_rust-bitflags+serde-devel.sha256sum] = "04a8e72e8388bb234a58902f7e56b27c1e8417ec0e1461de402b78a4d09c89f9"

URI_aarch64_rust-bitflags+serde_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+serde_core-devel-2.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitflags+serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+serde_core-devel}"
SRC_URI[aarch64_rust-bitflags+serde_core-devel.sha256sum] = "14a06884619cd7b3148c0080c16a17e1f9f50d55663ea4cdc4856745d00b3d3a"

URI_aarch64_rust-bitflags+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+std-devel-2.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitflags+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+std-devel}"
SRC_URI[aarch64_rust-bitflags+std-devel.sha256sum] = "23d54d2920747020d84dc45df9fe96e22da4d34cf230699aa7d1239364927edb"

URI_aarch64_rust-bitflags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags-devel-2.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitflags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags-devel}"
SRC_URI[aarch64_rust-bitflags-devel.sha256sum] = "be2669d4dbacea49f7a4df827e610fd485fda738e6cd9128177ace6cf1089b01"

RDEPENDS:rust-bitflags+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+bytemuck-devel = " \
 cargo \
 rust-bitflags-devel \
 rust-bytemuck+default-devel \
 "
RDEPENDS:rust-bitflags+default-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+example_generated-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+serde-devel = " \
 cargo \
 rust-bitflags+serde_core-devel \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+serde_core-devel = " \
 cargo \
 rust-bitflags-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bitflags+std-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags-devel = " \
 cargo \
 rust \
 "
