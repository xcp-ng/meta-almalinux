# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nghttp2"
PV = "1.68.0"
PR = "3.el10_2.2"
PACKAGES = " \
 libnghttp2 \
 libnghttp2-devel \
 nghttp2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nghttp2-1.68.0-3.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4daebf06160f65df21a1573cc1d574cee3b2400ce6a9838260a5f35fdc15939"

URI_x86_64_v2_libnghttp2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnghttp2-1.68.0-3.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_libnghttp2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnghttp2}"
SRC_URI[x86_64_v2_libnghttp2.sha256sum] = "3b75b0b35a113fcbf3e0d897cfad624ad7504f37e23f34ce461162f3eca652d3"

URI_x86_64_v2_libnghttp2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnghttp2-devel-1.68.0-3.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_libnghttp2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnghttp2-devel}"
SRC_URI[x86_64_v2_libnghttp2-devel.sha256sum] = "ffb6f60b73a88fd960bf5e43fec8113b43305b56bc249bbf5b8ce562336b2778"

URI_x86_64_v2_nghttp2 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nghttp2-1.68.0-3.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_nghttp2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nghttp2}"
SRC_URI[x86_64_v2_nghttp2.sha256sum] = "495afdb3a2a62c55f6de4256a58a58b0184f210a45ec6d6d1dec6fdc0fcfe547"

URI_aarch64_libnghttp2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnghttp2-1.68.0-3.el10_2.2.aarch64.rpm;name=aarch64_libnghttp2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnghttp2}"
SRC_URI[aarch64_libnghttp2.sha256sum] = "f2af23ee3370a9d7a591db25528744ff946dfa3abab58fe897712b5c17a167c7"

URI_aarch64_libnghttp2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnghttp2-devel-1.68.0-3.el10_2.2.aarch64.rpm;name=aarch64_libnghttp2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnghttp2-devel}"
SRC_URI[aarch64_libnghttp2-devel.sha256sum] = "77bc95780d78803ef8f5f42f580ed80944a66e879c5e8d5d13b8ff88e6d16436"

URI_aarch64_nghttp2 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nghttp2-1.68.0-3.el10_2.2.aarch64.rpm;name=aarch64_nghttp2;unpack=0"
SRC_URI:append = " ${URI_aarch64_nghttp2}"
SRC_URI[aarch64_nghttp2.sha256sum] = "8b29c32033ad944724961fffc5ea289292cfb52d55a4251abd2f68dd21658b52"

RDEPENDS:libnghttp2 = " \
 glibc \
 "
RDEPENDS:libnghttp2-devel = " \
 libnghttp2 \
 pkgconf-pkg-config \
 "
RDEPENDS:nghttp2 = " \
 bash \
 c-ares \
 glibc \
 libev \
 libgcc \
 libnghttp2 \
 libstdc++ \
 libxml2 \
 openssl-libs \
 systemd \
 zlib-ng-compat \
 "
