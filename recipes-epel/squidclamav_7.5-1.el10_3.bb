# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "squidclamav"
PV = "7.5"
PR = "1.el10_3"
PACKAGES = " \
 squidclamav \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/squidclamav-7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1b449d171897a1eff2312aee61e9fa9c18d5638b354cf0d4fa46c25689d68d8e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/squidclamav-7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_squidclamav;unpack=0"
SRC_URI[x86_64_v2_squidclamav.sha256sum] = "26689596294d6e9cafb18fa6bd95ac63e12f7573f7302cc6c8ecc1524345a36e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/squidclamav-7.5-1.el10_3.aarch64.rpm;name=aarch64_squidclamav;unpack=0"
SRC_URI[aarch64_squidclamav.sha256sum] = "423e6d4c81f2a7182dcc63591e3f6bf4513cd4f6a92c11e0226ab60825b5903b"

RDEPENDS:squidclamav = " \
 bzip2-libs \
 c-icap \
 glibc \
 httpd-filesystem \
 libarchive \
 perl-interpreter \
 squid \
 zlib-ng-compat \
 "
