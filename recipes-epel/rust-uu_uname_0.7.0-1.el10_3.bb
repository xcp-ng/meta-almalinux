# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_uname"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_uname+default-devel \
 rust-uu_uname-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_uname-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e24c7d466e1f6f4122e8800c6d3afef253e8970e5bf5abed0072e77c5f93842e"

URI_x86_64_v2_rust-uu_uname+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_uname+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_uname+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_uname+default-devel}"
SRC_URI[x86_64_v2_rust-uu_uname+default-devel.sha256sum] = "91d3104069545187943ecc738ab0fdd7293c56a0624aa609529466cdbd20e8f3"

URI_x86_64_v2_rust-uu_uname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_uname-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_uname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_uname-devel}"
SRC_URI[x86_64_v2_rust-uu_uname-devel.sha256sum] = "23cd8e66958aa8468c23f7b41f1fbc6cabad9efc11be646c35135c634a342301"

URI_aarch64_rust-uu_uname+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_uname+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_uname+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_uname+default-devel}"
SRC_URI[aarch64_rust-uu_uname+default-devel.sha256sum] = "0d33ef5e7d234c7c1c053ab46ceae7ba6cca0296a10a05b06030548de04923d5"

URI_aarch64_rust-uu_uname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_uname-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_uname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_uname-devel}"
SRC_URI[aarch64_rust-uu_uname-devel.sha256sum] = "34df002f9a1bf9158a311f268832e33f00d56807d265abea67a1e746a4117d64"

RDEPENDS:rust-uu_uname+default-devel = " \
 cargo \
 rust-uu_uname-devel \
 "
RDEPENDS:rust-uu_uname-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-platform-info+default-devel \
 rust-uucore+default-devel \
 "
