# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-mqtt"
PV = "0.12.3"
PR = "2.el10_1"
PACKAGES = " \
 aws-c-mqtt \
 aws-c-mqtt-devel \
 aws-c-mqtt-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-mqtt-0.12.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e94c5968019d3d0bbbbab73f53f5dd73039f6c708f18920ba1c3e0974f77cee2"

URI_x86_64_v2_aws-c-mqtt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-mqtt-0.12.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-mqtt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-mqtt}"
SRC_URI[x86_64_v2_aws-c-mqtt.sha256sum] = "0097f943a23e1b673a3c3501155d8c8b08be5d090402c8c72d4fd0025a8fa0c8"

URI_x86_64_v2_aws-c-mqtt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-mqtt-devel-0.12.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-mqtt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-mqtt-devel}"
SRC_URI[x86_64_v2_aws-c-mqtt-devel.sha256sum] = "3d7cb09952a048cb6ead805517ca22dea914cf6a7971a9e8c3c975f76adc08ce"

URI_x86_64_v2_aws-c-mqtt-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-mqtt-libs-0.12.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-mqtt-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-mqtt-libs}"
SRC_URI[x86_64_v2_aws-c-mqtt-libs.sha256sum] = "6aed0d39f77a53cf408b4c93fd5ece7b515634d0f6366b079853382b1d1aa327"

URI_aarch64_aws-c-mqtt = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-mqtt-0.12.3-2.el10_1.aarch64.rpm;name=aarch64_aws-c-mqtt;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-mqtt}"
SRC_URI[aarch64_aws-c-mqtt.sha256sum] = "554f3c695605d4944e7ff5702d3492d9da89cccee816d23347042a6d50309eb4"

URI_aarch64_aws-c-mqtt-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-mqtt-devel-0.12.3-2.el10_1.aarch64.rpm;name=aarch64_aws-c-mqtt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-mqtt-devel}"
SRC_URI[aarch64_aws-c-mqtt-devel.sha256sum] = "2d459fda0ad2d8c1baf1672175e34b661389567063f53e2bff699f2e7291aaca"

URI_aarch64_aws-c-mqtt-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-mqtt-libs-0.12.3-2.el10_1.aarch64.rpm;name=aarch64_aws-c-mqtt-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-mqtt-libs}"
SRC_URI[aarch64_aws-c-mqtt-libs.sha256sum] = "a5bfdcd4b37fdbdc3b48063f96f1f70f67e7f24ebfcc143d5145e06f75ae8028"

RDEPENDS:aws-c-mqtt = " \
 aws-c-common-libs \
 aws-c-io \
 aws-c-mqtt-libs \
 glibc \
 "
RDEPENDS:aws-c-mqtt-devel = " \
 aws-c-compression-devel \
 aws-c-http-devel \
 aws-c-io-devel \
 aws-c-mqtt-libs \
 cmake-filesystem \
 openssl-devel \
 "
RDEPENDS:aws-c-mqtt-libs = " \
 aws-c-common-libs \
 aws-c-http-libs \
 aws-c-io \
 glibc \
 "
