# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nmstate"
PV = "2.2.57"
PR = "1.el10_1"
PACKAGES = " \
 nmstate \
 nmstate-devel \
 nmstate-libs \
 nmstate-static \
 python3-libnmstate \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nmstate-2.2.57-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2e269905fc0cddb067f6c27dbd1618abfff1948e2a8d8a385c53d27a10043d3"

URI_x86_64_v2_nmstate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nmstate-2.2.57-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_nmstate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate}"
SRC_URI[x86_64_v2_nmstate.sha256sum] = "b6cc48a34d0804dfcdc96aac52acd350a879d98ace3b9241686b6a4d731c6fff"

URI_x86_64_v2_nmstate-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nmstate-devel-2.2.57-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_nmstate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate-devel}"
SRC_URI[x86_64_v2_nmstate-devel.sha256sum] = "fedc5b92982fd5d304a1acf6e3275a5143de0f9538a4f16f99b5ac687a8dc6ac"

URI_x86_64_v2_nmstate-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nmstate-libs-2.2.57-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_nmstate-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate-libs}"
SRC_URI[x86_64_v2_nmstate-libs.sha256sum] = "636f6705ddae5375835d547525fc9c5c0277187f13a6f21627bb81d57339b5ad"

URI_x86_64_v2_nmstate-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nmstate-static-2.2.57-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_nmstate-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate-static}"
SRC_URI[x86_64_v2_nmstate-static.sha256sum] = "421da4e173beecdd081a32af339988bc42ebeaf5b0b70bd039eb7d20dd941c17"

URI_x86_64_v2_python3-libnmstate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnmstate-2.2.57-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-libnmstate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libnmstate}"
SRC_URI[x86_64_v2_python3-libnmstate.sha256sum] = "5ef65cdbbab2396f4d5fdb2b2e9b992cbdd3c8ab6cfb1a47997b58ae0a09b52b"

URI_aarch64_nmstate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nmstate-2.2.57-1.el10_1.aarch64.rpm;name=aarch64_nmstate;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate}"
SRC_URI[aarch64_nmstate.sha256sum] = "75fef404b90af228e2574459413eb6a76560c753639ea39734d2d5d9c9a7d26f"

URI_aarch64_nmstate-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nmstate-devel-2.2.57-1.el10_1.aarch64.rpm;name=aarch64_nmstate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate-devel}"
SRC_URI[aarch64_nmstate-devel.sha256sum] = "011578acdadc1d0719c4519ab8db2f28dc043bd259ba3f202fca9c1987dc5e9b"

URI_aarch64_nmstate-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nmstate-libs-2.2.57-1.el10_1.aarch64.rpm;name=aarch64_nmstate-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate-libs}"
SRC_URI[aarch64_nmstate-libs.sha256sum] = "c6173f28f99dd58a574d9d9bc474a4c4a76446ecb1fe4210dcd72ac67d11f44f"

URI_aarch64_nmstate-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nmstate-static-2.2.57-1.el10_1.aarch64.rpm;name=aarch64_nmstate-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate-static}"
SRC_URI[aarch64_nmstate-static.sha256sum] = "43d4931253d10a5bc2ea474754b881f203364a239797f45f041dda1a7d2cec81"

URI_aarch64_python3-libnmstate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnmstate-2.2.57-1.el10_1.aarch64.rpm;name=aarch64_python3-libnmstate;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libnmstate}"
SRC_URI[aarch64_python3-libnmstate.sha256sum] = "741075945078bebc3eb282d734c1fadf44e1c55ab87fbae573aadd96548592ce"

RDEPENDS:nmstate = " \
 glibc \
 libgcc \
 nmstate-libs \
 "
RDEPENDS:nmstate-devel = " \
 nmstate-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:nmstate-libs = " \
 glibc \
 libgcc \
 "
RDEPENDS:nmstate-static = " \
 nmstate-devel \
 "
RDEPENDS:python3-libnmstate = " \
 nmstate-libs \
 python3 \
 python3-pyyaml \
 "
