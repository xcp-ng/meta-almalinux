# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gridftp-server"
PV = "13.28"
PR = "1.el10_2"
PACKAGES = " \
 globus-gridftp-server \
 globus-gridftp-server-devel \
 globus-gridftp-server-progs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gridftp-server-13.28-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c432101f995fb10a172c3db06122774fe541f875a7b3c9611f5255718c62d2c"

URI_x86_64_v2_globus-gridftp-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridftp-server-13.28-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridftp-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridftp-server}"
SRC_URI[x86_64_v2_globus-gridftp-server.sha256sum] = "0317643f2edac9beb4df2beddd2d3c8d810eb37cea6c3c1c69f2a733e2b16938"

URI_x86_64_v2_globus-gridftp-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridftp-server-devel-13.28-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridftp-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridftp-server-devel}"
SRC_URI[x86_64_v2_globus-gridftp-server-devel.sha256sum] = "5327447ab402f9cee12f7b8034cd74c5efb51e900c84ba4089560d0a605cbbc8"

URI_x86_64_v2_globus-gridftp-server-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridftp-server-progs-13.28-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridftp-server-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridftp-server-progs}"
SRC_URI[x86_64_v2_globus-gridftp-server-progs.sha256sum] = "9f930d88940a05a33bb51db5c65ce585cd7ae8fae90acdbb5b5944a6cabba325"

URI_aarch64_globus-gridftp-server = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridftp-server-13.28-1.el10_2.aarch64.rpm;name=aarch64_globus-gridftp-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridftp-server}"
SRC_URI[aarch64_globus-gridftp-server.sha256sum] = "decd2d4095138b4c42497bbac15e19b2280f4b0636243148caab332e04e56e1f"

URI_aarch64_globus-gridftp-server-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridftp-server-devel-13.28-1.el10_2.aarch64.rpm;name=aarch64_globus-gridftp-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridftp-server-devel}"
SRC_URI[aarch64_globus-gridftp-server-devel.sha256sum] = "ddfe050bfe783f9043ac4cb6e4f12881334d82ecd3ab4088692c8af79b7eb2eb"

URI_aarch64_globus-gridftp-server-progs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridftp-server-progs-13.28-1.el10_2.aarch64.rpm;name=aarch64_globus-gridftp-server-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridftp-server-progs}"
SRC_URI[aarch64_globus-gridftp-server-progs.sha256sum] = "9af9df7a454f78246b46a28d2e524d9ab07150ac02b33aab6774c4f9248cbb71"

RDEPENDS:globus-gridftp-server = " \
 glibc \
 globus-authz \
 globus-common \
 globus-ftp-control \
 globus-gfork \
 globus-gridftp-server-control \
 globus-gsi-credential \
 globus-gsi-sysconfig \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-io \
 globus-xio \
 globus-xio-gsi-driver \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:globus-gridftp-server-devel = " \
 globus-authz-devel \
 globus-common-devel \
 globus-ftp-control-devel \
 globus-gfork-devel \
 globus-gridftp-server \
 globus-gridftp-server-control-devel \
 globus-gsi-credential-devel \
 globus-gsi-sysconfig-devel \
 globus-gss-assist-devel \
 globus-gssapi-gsi-devel \
 globus-io-devel \
 globus-xio-devel \
 globus-xio-gsi-driver-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gridftp-server-progs = " \
 bash \
 glibc \
 globus-common \
 globus-gfork \
 globus-gridftp-server \
 globus-gssapi-gsi \
 globus-xio \
 libtool-ltdl \
 perl-English \
 perl-File-Path \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 systemd \
 "
