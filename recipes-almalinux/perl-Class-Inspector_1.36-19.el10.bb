# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Inspector"
PV = "1.36"
PR = "19.el10"
PACKAGES = " \
 perl-Class-Inspector \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Class-Inspector-1.36-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2277708fcd3782212a268a91c8f941806ee347d2db5cf044e3ffe88ce78e67f1"

URI_x86_64_v2_perl-Class-Inspector = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Class-Inspector-1.36-19.el10.noarch.rpm;name=x86_64_v2_perl-Class-Inspector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Inspector}"
SRC_URI[x86_64_v2_perl-Class-Inspector.sha256sum] = "d95de6a8f3ffddb37ca1916d4e17869e7fbcecf92b1b70fa78cb7fa6cdc95209"

URI_aarch64_perl-Class-Inspector = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Class-Inspector-1.36-19.el10.noarch.rpm;name=aarch64_perl-Class-Inspector;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Inspector}"
SRC_URI[aarch64_perl-Class-Inspector.sha256sum] = "d95de6a8f3ffddb37ca1916d4e17869e7fbcecf92b1b70fa78cb7fa6cdc95209"

RDEPENDS:perl-Class-Inspector = " \
 perl-Class-Inspector \
 perl-Exporter \
 perl-PathTools \
 perl-base \
 perl-libs \
 "
