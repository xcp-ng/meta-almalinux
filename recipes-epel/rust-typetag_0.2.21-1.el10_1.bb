# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typetag"
PV = "0.2.21"
PR = "1.el10_1"
PACKAGES = " \
 rust-typetag+default-devel \
 rust-typetag-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typetag-0.2.21-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92d2e1b24620a5b45e8cd4848695c14f7411441bcb0b0f3a93ce98aee4c1ecfb"

URI_x86_64_v2_rust-typetag+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag+default-devel-0.2.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typetag+default-devel}"
SRC_URI[x86_64_v2_rust-typetag+default-devel.sha256sum] = "3037a3661afaf521e69675b55efa2008bf2ec9a0995124929171d64e4665aaa6"

URI_x86_64_v2_rust-typetag-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag-devel-0.2.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typetag-devel}"
SRC_URI[x86_64_v2_rust-typetag-devel.sha256sum] = "12e2372d9a01ce0193acc3fda448343376afa313e19325d98bc30851bb053004"

URI_aarch64_rust-typetag+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag+default-devel-0.2.21-1.el10_1.noarch.rpm;name=aarch64_rust-typetag+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typetag+default-devel}"
SRC_URI[aarch64_rust-typetag+default-devel.sha256sum] = "4ffd6e574d533555d7a2f29f1feba8f5c758589b5fbd3a8aad4db689bab5d724"

URI_aarch64_rust-typetag-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag-devel-0.2.21-1.el10_1.noarch.rpm;name=aarch64_rust-typetag-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typetag-devel}"
SRC_URI[aarch64_rust-typetag-devel.sha256sum] = "0e30cb45a2bb086f3f5ac430ac2b828fe8a9ba6dcb4705197ebf97ed07726db4"

RDEPENDS:rust-typetag+default-devel = " \
 cargo \
 rust-typetag-devel \
 "
RDEPENDS:rust-typetag-devel = " \
 cargo \
 rust \
 rust-erased-serde+alloc-devel \
 rust-erased-serde-devel \
 rust-inventory+default-devel \
 rust-once_cell+alloc-devel \
 rust-once_cell-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-typetag-impl+default-devel \
 "
