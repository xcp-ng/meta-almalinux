# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strip-ansi-escapes0.1"
PV = "0.1.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-strip-ansi-escapes0.1+default-devel \
 rust-strip-ansi-escapes0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strip-ansi-escapes0.1-0.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c13ea349f4bc2630f013e11154c32ee0cd2b69db3e3126a9af5db6dfd8ee103c"

URI_x86_64_v2_rust-strip-ansi-escapes0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strip-ansi-escapes0.1+default-devel-0.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strip-ansi-escapes0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strip-ansi-escapes0.1+default-devel}"
SRC_URI[x86_64_v2_rust-strip-ansi-escapes0.1+default-devel.sha256sum] = "83a7c873ee4f6e9301a3380716a6b04db95f892b56878c1963740baf35e27415"

URI_x86_64_v2_rust-strip-ansi-escapes0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strip-ansi-escapes0.1-devel-0.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strip-ansi-escapes0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strip-ansi-escapes0.1-devel}"
SRC_URI[x86_64_v2_rust-strip-ansi-escapes0.1-devel.sha256sum] = "b183a3205e69008c623af7f3e1172f37b9586327190b9100432b438ea719c225"

URI_aarch64_rust-strip-ansi-escapes0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strip-ansi-escapes0.1+default-devel-0.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-strip-ansi-escapes0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strip-ansi-escapes0.1+default-devel}"
SRC_URI[aarch64_rust-strip-ansi-escapes0.1+default-devel.sha256sum] = "7a8b2a61b177425b585be42154e1145fc40a0b3e451cd7355778f89b8a761863"

URI_aarch64_rust-strip-ansi-escapes0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strip-ansi-escapes0.1-devel-0.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-strip-ansi-escapes0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strip-ansi-escapes0.1-devel}"
SRC_URI[aarch64_rust-strip-ansi-escapes0.1-devel.sha256sum] = "50ea979e8cfba6b8e51363874495750b79880fb9c22d9e65e7473e5945389ac9"

RDEPENDS:rust-strip-ansi-escapes0.1+default-devel = " \
 cargo \
 rust-strip-ansi-escapes0.1-devel \
 "
RDEPENDS:rust-strip-ansi-escapes0.1-devel = " \
 cargo \
 rust-vte+default-devel \
 "
