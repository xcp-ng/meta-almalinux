# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-bandwidth-test"
PV = "6.4.2"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 rocm-bandwidth-test \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-bandwidth-test-6.4.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a2c04df40353be0584fe6b3ff206773b73c8af8ce72458ea011c6fe386f18b3"

URI_x86_64_v2_rocm-bandwidth-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-bandwidth-test-6.4.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-bandwidth-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-bandwidth-test}"
SRC_URI[x86_64_v2_rocm-bandwidth-test.sha256sum] = "d30fcd60434a5cfed782debabb31d22cbfed41ccd221f217c2d339a5cc81a34d"

RDEPENDS:rocm-bandwidth-test = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-runtime \
 "
