# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hasktags"
PV = "0.73.0"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 ghc-hasktags \
 ghc-hasktags-devel \
 ghc-hasktags-doc \
 hasktags \
"
PACKAGES:aarch64 = " \
 ghc-hasktags \
 ghc-hasktags-devel \
 ghc-hasktags-doc \
 ghc-hasktags-prof \
 hasktags \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hasktags-0.73.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7820bd0d0d7b6b6ec0e7a60ea9da746274b6b9c7458f4d25b6cbe4146d1e6202"

URI_x86_64_v2_ghc-hasktags = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hasktags-0.73.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hasktags;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hasktags}"
SRC_URI[x86_64_v2_ghc-hasktags.sha256sum] = "1523cb7a4650a332e5d69a0c07cf59abd3ec49d076f43180835e7611550d0af6"

URI_x86_64_v2_ghc-hasktags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hasktags-devel-0.73.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hasktags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hasktags-devel}"
SRC_URI[x86_64_v2_ghc-hasktags-devel.sha256sum] = "5506ca690f9db1307bc6a21b01e4cf56f634116509fae43b75123c5d38667864"

URI_x86_64_v2_ghc-hasktags-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hasktags-doc-0.73.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hasktags-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hasktags-doc}"
SRC_URI[x86_64_v2_ghc-hasktags-doc.sha256sum] = "c29a15c861b46827a416febd40eca849deae64f9d4d3d7ead136fcb708280501"

URI_x86_64_v2_hasktags = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hasktags-0.73.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hasktags;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hasktags}"
SRC_URI[x86_64_v2_hasktags.sha256sum] = "192a050be79d56d62008b0177ebbc4d853dd481d7b50650cdbcd70f142554edc"

URI_aarch64_ghc-hasktags = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hasktags-0.73.0-1.el10_2.aarch64.rpm;name=aarch64_ghc-hasktags;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hasktags}"
SRC_URI[aarch64_ghc-hasktags.sha256sum] = "b4e0b9ce9da24ea15b22f33cde198d1f8c743bdf6fdab9e4dadc17b83cef06bd"

URI_aarch64_ghc-hasktags-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hasktags-devel-0.73.0-1.el10_2.aarch64.rpm;name=aarch64_ghc-hasktags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hasktags-devel}"
SRC_URI[aarch64_ghc-hasktags-devel.sha256sum] = "8d1af9d65f43bf3da2434c376676d6525ce229ad2a54a31c90d7fe2542ce7e26"

URI_aarch64_ghc-hasktags-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hasktags-doc-0.73.0-1.el10_2.noarch.rpm;name=aarch64_ghc-hasktags-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hasktags-doc}"
SRC_URI[aarch64_ghc-hasktags-doc.sha256sum] = "97aa697d768875b832178ddace71a14c4a43469d63bb16ac695830b52778371d"

URI_aarch64_ghc-hasktags-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hasktags-prof-0.73.0-1.el10_2.aarch64.rpm;name=aarch64_ghc-hasktags-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hasktags-prof}"
SRC_URI[aarch64_ghc-hasktags-prof.sha256sum] = "5a2107ea5da843282b445816e9b5d5e12769f7f3430676cf7061ee0de041f1b0"

URI_aarch64_hasktags = "${EPEL_MIRROR}/aarch64/Packages/h/hasktags-0.73.0-1.el10_2.aarch64.rpm;name=aarch64_hasktags;unpack=0"
SRC_URI:append = " ${URI_aarch64_hasktags}"
SRC_URI[aarch64_hasktags.sha256sum] = "caf4e5175487d9ca5b0fd17c1d36939d534be4faa195dbb37d11e8346a7aa448"

RDEPENDS:ghc-hasktags = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-json \
 ghc-microlens \
 ghc-microlens-ghc \
 ghc-microlens-mtl \
 ghc-microlens-platform \
 ghc-microlens-th \
 ghc-mtl \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-stm \
 ghc-syb \
 ghc-template-haskell \
 ghc-text \
 ghc-th-abstraction \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hasktags-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-hasktags \
 ghc-json-devel \
 ghc-microlens-platform-devel \
 ghc-utf8-string-devel \
 "
RDEPENDS:ghc-hasktags-doc = " \
 ghc-filesystem \
 "
RDEPENDS:hasktags = " \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc-hasktags-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-hasktags-devel \
 ghc-json-prof \
 ghc-microlens-platform-prof \
 ghc-utf8-string-prof \
 "
