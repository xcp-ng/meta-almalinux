# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chez-scheme"
PV = "10.1.0"
PR = "4.el10_1"
PACKAGES = " \
 chez-scheme \
 chez-scheme-devel \
 chez-scheme-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/chez-scheme-10.1.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "038bab55837a3121848e422e63ebc2d6c613dfd23d9e0df66473a710f6743495"

URI_x86_64_v2_chez-scheme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chez-scheme-10.1.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chez-scheme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chez-scheme}"
SRC_URI[x86_64_v2_chez-scheme.sha256sum] = "aa8d8e590ba2166da81267698a1c87b531a1bbd3e40637029f5fb7f9856219cb"

URI_x86_64_v2_chez-scheme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chez-scheme-devel-10.1.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chez-scheme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chez-scheme-devel}"
SRC_URI[x86_64_v2_chez-scheme-devel.sha256sum] = "343c409bc035004a10f78a4d035a3039cd77b74a828b1db6f985577bb0c31c63"

URI_x86_64_v2_chez-scheme-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chez-scheme-examples-10.1.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_chez-scheme-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chez-scheme-examples}"
SRC_URI[x86_64_v2_chez-scheme-examples.sha256sum] = "2fd3555942b7a40348557ed1e35095f23bb812b6f42eac1e1319f0f856fa3dc1"

URI_aarch64_chez-scheme = "${EPEL_MIRROR}/aarch64/Packages/c/chez-scheme-10.1.0-4.el10_1.aarch64.rpm;name=aarch64_chez-scheme;unpack=0"
SRC_URI:append = " ${URI_aarch64_chez-scheme}"
SRC_URI[aarch64_chez-scheme.sha256sum] = "b2e5349e95ec8a2bb9766fbb90749feaeb8d54dc56bd99d08f920d7506448222"

URI_aarch64_chez-scheme-devel = "${EPEL_MIRROR}/aarch64/Packages/c/chez-scheme-devel-10.1.0-4.el10_1.aarch64.rpm;name=aarch64_chez-scheme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_chez-scheme-devel}"
SRC_URI[aarch64_chez-scheme-devel.sha256sum] = "4f55ecfb544dbdd5b160e1693cc3e8d898a5e62356ba8daa442e810316ed2888"

URI_aarch64_chez-scheme-examples = "${EPEL_MIRROR}/aarch64/Packages/c/chez-scheme-examples-10.1.0-4.el10_1.noarch.rpm;name=aarch64_chez-scheme-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_chez-scheme-examples}"
SRC_URI[aarch64_chez-scheme-examples.sha256sum] = "42128821e009e21da75d6f30c44cd65c6550c1a0de9bbf200cb39a9bca245001"

RDEPENDS:chez-scheme = " \
 glibc \
 lz4-libs \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:chez-scheme-devel = " \
 chez-scheme \
 "
RDEPENDS:chez-scheme-examples = " \
 chez-scheme \
 "
