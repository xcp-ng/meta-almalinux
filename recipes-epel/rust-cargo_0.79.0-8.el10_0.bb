# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo"
PV = "0.79.0"
PR = "8.el10_0"
PACKAGES = " \
 rust-cargo+default-devel \
 rust-cargo+openssl-devel \
 rust-cargo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-0.79.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3c3312b4629d9ec6a7cfa183d3a0718490a5dad92e7119bd508969c82ef89e3"

URI_x86_64_v2_rust-cargo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+default-devel-0.79.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo+default-devel}"
SRC_URI[x86_64_v2_rust-cargo+default-devel.sha256sum] = "6183bf90a2acce6857f5fff532db0a953fd96d92f7e2c63701bee4b4fbff22f0"

URI_x86_64_v2_rust-cargo+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+openssl-devel-0.79.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo+openssl-devel}"
SRC_URI[x86_64_v2_rust-cargo+openssl-devel.sha256sum] = "a78c0825c9effa1dc5489b01aa8877b07a9a8d2fad1e057e9abd973060d91598"

URI_x86_64_v2_rust-cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-devel-0.79.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-devel}"
SRC_URI[x86_64_v2_rust-cargo-devel.sha256sum] = "2a040109c061faa45d78572ab5ab795a398a73544dd4eecf24e9018a054931d7"

URI_aarch64_rust-cargo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+default-devel-0.79.0-8.el10_0.noarch.rpm;name=aarch64_rust-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo+default-devel}"
SRC_URI[aarch64_rust-cargo+default-devel.sha256sum] = "6ff9e028a0603990a6620968f60ade829574f2c49c6cf795fea93716555f517c"

URI_aarch64_rust-cargo+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+openssl-devel-0.79.0-8.el10_0.noarch.rpm;name=aarch64_rust-cargo+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo+openssl-devel}"
SRC_URI[aarch64_rust-cargo+openssl-devel.sha256sum] = "cf6d09e5d6e214069d13d7c9d1aa77eb7debdb7a6c7fa9616bf0df1c95ff304d"

URI_aarch64_rust-cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-devel-0.79.0-8.el10_0.noarch.rpm;name=aarch64_rust-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-devel}"
SRC_URI[aarch64_rust-cargo-devel.sha256sum] = "f518eae76f646271f4daaf04fce61bc30dbe385aa956698f16cb059168a749b1"

RDEPENDS:rust-cargo+default-devel = " \
 cargo \
 rust-cargo-devel \
 "
RDEPENDS:rust-cargo+openssl-devel = " \
 cargo \
 rust-cargo-devel \
 rust-openssl+default-devel \
 "
RDEPENDS:rust-cargo-devel = " \
 cargo \
 rust \
 rust-annotate-snippets0.10+default-devel \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-anyhow+default-devel \
 rust-base64+default-devel \
 rust-bytesize+default-devel \
 rust-cargo-credential+default-devel \
 rust-cargo-credential-libsecret+default-devel \
 rust-cargo-platform+default-devel \
 rust-cargo-util+default-devel \
 rust-cargo-util-schemas+default-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-color-print+default-devel \
 rust-crates-io+default-devel \
 rust-curl+default-devel \
 rust-curl+http2-devel \
 rust-curl-sys+default-devel \
 rust-filetime+default-devel \
 rust-flate2+zlib-devel \
 rust-flate2-devel \
 rust-git2+default-devel \
 rust-git2-curl+default-devel \
 rust-gix+blocking-http-transport-curl-devel \
 rust-gix+progress-tree-devel \
 rust-gix+revision-devel \
 rust-gix-devel \
 rust-gix-features+default-devel \
 rust-gix-features+parallel-devel \
 rust-glob+default-devel \
 rust-hex+default-devel \
 rust-hmac+default-devel \
 rust-home+default-devel \
 rust-http-auth-devel \
 rust-humantime+default-devel \
 rust-ignore+default-devel \
 rust-im-rc+default-devel \
 rust-indexmap+default-devel \
 rust-itertools0.13+default-devel \
 rust-jobserver+default-devel \
 rust-lazycell+default-devel \
 rust-libc+default-devel \
 rust-libgit2-sys+default-devel \
 rust-memchr+default-devel \
 rust-opener+default-devel \
 rust-os_info+default-devel \
 rust-pasetors+default-devel \
 rust-pasetors+paserk-devel \
 rust-pasetors+serde-devel \
 rust-pasetors+std-devel \
 rust-pasetors+v3-devel \
 rust-pathdiff+default-devel \
 rust-rand0.8+default-devel \
 rust-regex+default-devel \
 rust-rusqlite+default-devel \
 rust-rustfix+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde-untagged+default-devel \
 rust-serde_ignored+default-devel \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-sha1+default-devel \
 rust-shell-escape+default-devel \
 rust-supports-hyperlinks+default-devel \
 rust-supports-unicode+default-devel \
 rust-tar-devel \
 rust-tempfile+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time+serde-devel \
 rust-toml+default-devel \
 rust-toml_edit+default-devel \
 rust-toml_edit+serde-devel \
 rust-tracing+default-devel \
 rust-tracing-chrome+default-devel \
 rust-tracing-subscriber+default-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-unicase+default-devel \
 rust-unicode-width0.1+default-devel \
 rust-url+default-devel \
 rust-walkdir+default-devel \
 "
