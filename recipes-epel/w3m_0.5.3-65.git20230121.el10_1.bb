# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "w3m"
PV = "0.5.3"
PR = "65.git20230121.el10_1"
PACKAGES = " \
 w3m \
 w3m-img \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/w3m-0.5.3-65.git20230121.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b46c40bd5e6d331de5addb4c3c4ad2a529c5f728a3088a71f4e57959ae3fb2e5"

URI_x86_64_v2_w3m = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/w3m-0.5.3-65.git20230121.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_w3m;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_w3m}"
SRC_URI[x86_64_v2_w3m.sha256sum] = "a47c24fac7dda495272f55b6cb96d741ccc7fdb4ac24056fa9e32acb137fdd2b"
RPROVIDES:w3m:append:x86_64_v2 = " virtual/text-www-browser"

URI_x86_64_v2_w3m-img = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/w3m-img-0.5.3-65.git20230121.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_w3m-img;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_w3m-img}"
SRC_URI[x86_64_v2_w3m-img.sha256sum] = "b04e392497eae4a21db2553b389fadb66ca1b0fdc3824cbb9ebfd09e35c2ac31"

URI_aarch64_w3m = "${EPEL_MIRROR}/aarch64/Packages/w/w3m-0.5.3-65.git20230121.el10_1.aarch64.rpm;name=aarch64_w3m;unpack=0"
SRC_URI:append = " ${URI_aarch64_w3m}"
SRC_URI[aarch64_w3m.sha256sum] = "9c46493338415009f9839bcd53271b38a17fbf04b6004f38d4b2c87262b5c126"
RPROVIDES:w3m:append:aarch64 = " virtual/text-www-browser"

URI_aarch64_w3m-img = "${EPEL_MIRROR}/aarch64/Packages/w/w3m-img-0.5.3-65.git20230121.el10_1.aarch64.rpm;name=aarch64_w3m-img;unpack=0"
SRC_URI:append = " ${URI_aarch64_w3m-img}"
SRC_URI[aarch64_w3m-img.sha256sum] = "a669a7521dcec89e703b3210421df23ea410dd090f8a97507e9a1f7e61c064ec"

RDEPENDS:w3m = " \
 bash \
 gc \
 glibc \
 gpm-libs \
 ncurses-libs \
 openssl-libs \
 perl-NKF \
 perl-interpreter \
 zlib-ng-compat \
 "
RDEPENDS:w3m-img = " \
 ImageMagick \
 gdk-pixbuf2 \
 gdk-pixbuf2-xlib \
 glib2 \
 glibc \
 libX11 \
 w3m \
 "
