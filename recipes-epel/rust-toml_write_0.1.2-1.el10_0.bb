# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_write"
PV = "0.1.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-toml_write+alloc-devel \
 rust-toml_write+default-devel \
 rust-toml_write+std-devel \
 rust-toml_write-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_write-0.1.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f5a9f91d2a86f604b6954dd5a4d182d7d8fb7957c2abe7205f28e71ae34e3d4"

URI_x86_64_v2_rust-toml_write+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_write+alloc-devel-0.1.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_write+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_write+alloc-devel}"
SRC_URI[x86_64_v2_rust-toml_write+alloc-devel.sha256sum] = "692694a55f488fb21757cd2ea2badb27664a361b59b540641af33ad612f17bc5"

URI_x86_64_v2_rust-toml_write+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_write+default-devel-0.1.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_write+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_write+default-devel}"
SRC_URI[x86_64_v2_rust-toml_write+default-devel.sha256sum] = "e9f6fdc190f0c0478ed1c3985e43c568a0e09905acb43662b7a1f1e87eb8226d"

URI_x86_64_v2_rust-toml_write+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_write+std-devel-0.1.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_write+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_write+std-devel}"
SRC_URI[x86_64_v2_rust-toml_write+std-devel.sha256sum] = "de8b51cbfd1548da1f1409229f0cec9e5c0afa7153c8c4a704a23b33da2d98b9"

URI_x86_64_v2_rust-toml_write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_write-devel-0.1.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_write-devel}"
SRC_URI[x86_64_v2_rust-toml_write-devel.sha256sum] = "793a53f4837e7d56af55eb79e008731f7ff5be07db4847fe382cc24eeaddc557"

URI_aarch64_rust-toml_write+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_write+alloc-devel-0.1.2-1.el10_0.noarch.rpm;name=aarch64_rust-toml_write+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_write+alloc-devel}"
SRC_URI[aarch64_rust-toml_write+alloc-devel.sha256sum] = "44fad51d19ed69554da47a70141f37ae4527b1b88407e01900259b5e68456edc"

URI_aarch64_rust-toml_write+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_write+default-devel-0.1.2-1.el10_0.noarch.rpm;name=aarch64_rust-toml_write+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_write+default-devel}"
SRC_URI[aarch64_rust-toml_write+default-devel.sha256sum] = "252817b5594f73c9294a1561cc2f374ca9c422347e9adcbedc7bd605ae861290"

URI_aarch64_rust-toml_write+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_write+std-devel-0.1.2-1.el10_0.noarch.rpm;name=aarch64_rust-toml_write+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_write+std-devel}"
SRC_URI[aarch64_rust-toml_write+std-devel.sha256sum] = "1e0b52493aac39a16a2fcc37d9f5fff8ade00cad5bc36c82f5dbabbff3e9981d"

URI_aarch64_rust-toml_write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_write-devel-0.1.2-1.el10_0.noarch.rpm;name=aarch64_rust-toml_write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_write-devel}"
SRC_URI[aarch64_rust-toml_write-devel.sha256sum] = "b63bc6c885fa4c759ace0245554d2e0c09e2bb17b6179cb02d2b14f305a1f086"

RDEPENDS:rust-toml_write+alloc-devel = " \
 cargo \
 rust-toml_write-devel \
 "
RDEPENDS:rust-toml_write+default-devel = " \
 cargo \
 rust-toml_write+std-devel \
 rust-toml_write-devel \
 "
RDEPENDS:rust-toml_write+std-devel = " \
 cargo \
 rust-toml_write+alloc-devel \
 rust-toml_write-devel \
 "
RDEPENDS:rust-toml_write-devel = " \
 cargo \
 rust \
 "
