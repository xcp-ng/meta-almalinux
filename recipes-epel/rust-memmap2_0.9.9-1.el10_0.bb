# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memmap2"
PV = "0.9.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-memmap2+default-devel \
 rust-memmap2+stable_deref_trait-devel \
 rust-memmap2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memmap2-0.9.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "749886006c92ff53140a249e079b1890ba1b9809d571baee7a55a0b9cdbca56e"

URI_x86_64_v2_rust-memmap2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2+default-devel-0.9.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2+default-devel}"
SRC_URI[x86_64_v2_rust-memmap2+default-devel.sha256sum] = "5e2b9751fa12abdc39667394079b945fb591f30f2e2436e8fa489b10e945dbda"

URI_x86_64_v2_rust-memmap2+stable_deref_trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2+stable_deref_trait-devel-0.9.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2+stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2+stable_deref_trait-devel}"
SRC_URI[x86_64_v2_rust-memmap2+stable_deref_trait-devel.sha256sum] = "95cc05c93b91bad88f5c8a8206fde68f3544c21a05292bea05275c147d3379f4"

URI_x86_64_v2_rust-memmap2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2-devel-0.9.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2-devel}"
SRC_URI[x86_64_v2_rust-memmap2-devel.sha256sum] = "23ddea2ccf396750bc4fcf8b0229ac0f1d5c04cdbe24ee61c3f83032fa01357a"

URI_aarch64_rust-memmap2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2+default-devel-0.9.9-1.el10_0.noarch.rpm;name=aarch64_rust-memmap2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2+default-devel}"
SRC_URI[aarch64_rust-memmap2+default-devel.sha256sum] = "42a897c73729971708a8dadd8bbc371b4ba69ce53d6453a3d0f7be51a57f54b2"

URI_aarch64_rust-memmap2+stable_deref_trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2+stable_deref_trait-devel-0.9.9-1.el10_0.noarch.rpm;name=aarch64_rust-memmap2+stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2+stable_deref_trait-devel}"
SRC_URI[aarch64_rust-memmap2+stable_deref_trait-devel.sha256sum] = "29db7df4c489241ffcfbff5af94e594787e5c1e54dab42d5db1f5d1586a5850d"

URI_aarch64_rust-memmap2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2-devel-0.9.9-1.el10_0.noarch.rpm;name=aarch64_rust-memmap2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2-devel}"
SRC_URI[aarch64_rust-memmap2-devel.sha256sum] = "a476dc544d22269d5607e908b959aaecae9999b7a91ea2c0a1926895ba9aebf9"

RDEPENDS:rust-memmap2+default-devel = " \
 cargo \
 rust-memmap2-devel \
 "
RDEPENDS:rust-memmap2+stable_deref_trait-devel = " \
 cargo \
 rust-memmap2-devel \
 rust-stable_deref_trait+default-devel \
 "
RDEPENDS:rust-memmap2-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
