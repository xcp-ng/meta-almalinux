# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sysfsutils"
PV = "2.1.1"
PR = "14.el10"
PACKAGES = " \
 libsysfs \
 libsysfs-devel \
 sysfsutils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sysfsutils-2.1.1-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "497a44a969634395fd31cf14a5812d82d84c98fd3df4ac3e867b4db03b1c8eb9"

URI_x86_64_v2_libsysfs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsysfs-2.1.1-14.el10.x86_64_v2.rpm;name=x86_64_v2_libsysfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsysfs}"
SRC_URI[x86_64_v2_libsysfs.sha256sum] = "90f6651750a89f481f297c46898e5c0c85986fd792691c8b2867abb0b4eb2756"

URI_x86_64_v2_libsysfs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsysfs-devel-2.1.1-14.el10.x86_64_v2.rpm;name=x86_64_v2_libsysfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsysfs-devel}"
SRC_URI[x86_64_v2_libsysfs-devel.sha256sum] = "e66da9a5658ea4ae80dc9e292a584c0d9e46cdb93ed2aa9feefb0eb643ce6676"

URI_x86_64_v2_sysfsutils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sysfsutils-2.1.1-14.el10.x86_64_v2.rpm;name=x86_64_v2_sysfsutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sysfsutils}"
SRC_URI[x86_64_v2_sysfsutils.sha256sum] = "9f4e23ab77c8f8e230383616b7b49cf6183de666d5872836cb58694ddfae505d"

URI_aarch64_libsysfs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsysfs-2.1.1-14.el10.aarch64.rpm;name=aarch64_libsysfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsysfs}"
SRC_URI[aarch64_libsysfs.sha256sum] = "96d3724d0caa611b796d49e3a96103f9d633fd7595ead640e366374fed693644"

URI_aarch64_libsysfs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsysfs-devel-2.1.1-14.el10.aarch64.rpm;name=aarch64_libsysfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsysfs-devel}"
SRC_URI[aarch64_libsysfs-devel.sha256sum] = "95947f822d9dccfea75978748ddef55ff119e498906d0d57a050d76a6554d53c"

URI_aarch64_sysfsutils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sysfsutils-2.1.1-14.el10.aarch64.rpm;name=aarch64_sysfsutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_sysfsutils}"
SRC_URI[aarch64_sysfsutils.sha256sum] = "429fa20066000d25eed753892a14a31ce7722bbb0bb25766ccd2049bb4ca7c8d"

RDEPENDS:libsysfs = " \
 glibc \
 "
RDEPENDS:libsysfs-devel = " \
 libsysfs \
 pkgconf-pkg-config \
 "
RDEPENDS:sysfsutils = " \
 glibc \
 libsysfs \
 "
