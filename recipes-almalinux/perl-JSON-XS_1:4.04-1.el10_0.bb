# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-JSON-XS"
PE = "1"
PV = "4.04"
PR = "1.el10_0"
PACKAGES = " \
 perl-JSON-XS \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-JSON-XS-4.04-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "567733456f5bd93faa9c53b5bc4ede573437cffd9c07bc31fea7d59171a0f22e"

URI_x86_64_v2_perl-JSON-XS = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-JSON-XS-4.04-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-JSON-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-JSON-XS}"
SRC_URI[x86_64_v2_perl-JSON-XS.sha256sum] = "a683b9fb14454a31caf736b9cb56c894c2d6d7ffd29d1a6a2f968d3779fdc729"

URI_aarch64_perl-JSON-XS = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-JSON-XS-4.04-1.el10_0.aarch64.rpm;name=aarch64_perl-JSON-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-JSON-XS}"
SRC_URI[aarch64_perl-JSON-XS.sha256sum] = "1338766ed3eac925ad250e530e255fc7f9afc568389a1dbe7fd22905fd667355"

RDEPENDS:perl-JSON-XS = " \
 glibc \
 perl-Encode \
 perl-Exporter \
 perl-Getopt-Long \
 perl-JSON-XS \
 perl-Storable \
 perl-Types-Serialiser \
 perl-common-sense \
 perl-interpreter \
 perl-libs \
 "
