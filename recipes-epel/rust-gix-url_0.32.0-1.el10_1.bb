# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-url"
PV = "0.32.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-url+default-devel \
 rust-gix-url+document-features-devel \
 rust-gix-url+serde-devel \
 rust-gix-url-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-url-0.32.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f19ffcbcba922f677142b6efdfa8389c3255e595e4de49ee69e0f7e79526f92a"

URI_x86_64_v2_rust-gix-url+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url+default-devel-0.32.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url+default-devel}"
SRC_URI[x86_64_v2_rust-gix-url+default-devel.sha256sum] = "fdb7b63cc684207e8a8e993405c218139b46cf967217431e045f0f2819cfbf54"

URI_x86_64_v2_rust-gix-url+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url+document-features-devel-0.32.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-url+document-features-devel.sha256sum] = "e7e20995bdf35064a40a5c664ec01c3fe593336fcc3faa87ba7050caf25c413a"

URI_x86_64_v2_rust-gix-url+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url+serde-devel-0.32.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-url+serde-devel.sha256sum] = "0f7092b25f924357865fca432ed33fac14c93af3eaad7d99f6c2432501619f11"

URI_x86_64_v2_rust-gix-url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url-devel-0.32.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url-devel}"
SRC_URI[x86_64_v2_rust-gix-url-devel.sha256sum] = "28f7743b1ea6c24e3d5e95c2e151b89fc26424143e8d9ad13c1d52829615fd6f"

URI_aarch64_rust-gix-url+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url+default-devel-0.32.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url+default-devel}"
SRC_URI[aarch64_rust-gix-url+default-devel.sha256sum] = "88d7a34aa46b2d646e9c87e81a57335addd08d00d47f080256a47feef51b453b"

URI_aarch64_rust-gix-url+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url+document-features-devel-0.32.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-url+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url+document-features-devel}"
SRC_URI[aarch64_rust-gix-url+document-features-devel.sha256sum] = "7af76fd630c5cfca5e9c453fd407c9478a7b889a074435c154e72d64141e532d"

URI_aarch64_rust-gix-url+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url+serde-devel-0.32.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url+serde-devel}"
SRC_URI[aarch64_rust-gix-url+serde-devel.sha256sum] = "16a37b146fb5bf3e17e960b2ebe099cdadead96eafec96f0fbc8cd37cb6a7465"

URI_aarch64_rust-gix-url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url-devel-0.32.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url-devel}"
SRC_URI[aarch64_rust-gix-url-devel.sha256sum] = "f44f852a2bb0abc8d679e6906349ab7be0aadd4cb573d51df93905d911381440"

RDEPENDS:rust-gix-url+default-devel = " \
 cargo \
 rust-gix-url-devel \
 "
RDEPENDS:rust-gix-url+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-url-devel \
 "
RDEPENDS:rust-gix-url+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-url-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-url-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-features+default-devel \
 rust-gix-path+default-devel \
 rust-percent-encoding+default-devel \
 rust-thiserror+default-devel \
 rust-url+default-devel \
 "
