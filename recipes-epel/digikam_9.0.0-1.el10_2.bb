# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "digikam"
PV = "9.0.0"
PR = "1.el10_2"
PACKAGES = " \
 digikam \
 digikam-devel \
 digikam-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/digikam-9.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "207e97853d72743b911121d724a9b89d2d5242bb1dc85186c7a50ad599de1193"

URI_x86_64_v2_digikam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/digikam-9.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_digikam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_digikam}"
SRC_URI[x86_64_v2_digikam.sha256sum] = "43434558b24b1043461cfd58d7ff1f5a8c83c1a3e7b0d20b06cceea8c5d99d3c"

URI_x86_64_v2_digikam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/digikam-devel-9.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_digikam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_digikam-devel}"
SRC_URI[x86_64_v2_digikam-devel.sha256sum] = "a1b4a3b4352dd3e35b683246467bd9ddee6162bdb8ea783f9db2ac5bdfa3335c"

URI_x86_64_v2_digikam-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/digikam-libs-9.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_digikam-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_digikam-libs}"
SRC_URI[x86_64_v2_digikam-libs.sha256sum] = "613c7bd1d92012b3428f789ed581aca1a70ea1a72f06634b4881975937b2db28"

URI_aarch64_digikam = "${EPEL_MIRROR}/aarch64/Packages/d/digikam-9.0.0-1.el10_2.aarch64.rpm;name=aarch64_digikam;unpack=0"
SRC_URI:append = " ${URI_aarch64_digikam}"
SRC_URI[aarch64_digikam.sha256sum] = "8e70906d310d7e69336864ed359b95674ef23467dba81a03bfeda1c91dd93453"

URI_aarch64_digikam-devel = "${EPEL_MIRROR}/aarch64/Packages/d/digikam-devel-9.0.0-1.el10_2.aarch64.rpm;name=aarch64_digikam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_digikam-devel}"
SRC_URI[aarch64_digikam-devel.sha256sum] = "e32debf18dcbe347dcdc906cf04b6f71647512cb7191f0d64dec20de5c580850"

URI_aarch64_digikam-libs = "${EPEL_MIRROR}/aarch64/Packages/d/digikam-libs-9.0.0-1.el10_2.aarch64.rpm;name=aarch64_digikam-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_digikam-libs}"
SRC_URI[aarch64_digikam-libs.sha256sum] = "2bd6fedd0f3886180a84052505d969fae2ffebc750ddf49fa84a883965fe72ca"

RDEPENDS:digikam = " \
 ImageMagick-c++ \
 bash \
 digikam-libs \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 perl-File-Path \
 perl-Getopt-Std \
 perl-PathTools \
 perl-interpreter \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:digikam-devel = " \
 cmake-filesystem \
 digikam-libs \
 "
RDEPENDS:digikam-libs = " \
 ImageMagick-c++ \
 ImageMagick-libs \
 exiv2-libs \
 expat \
 glib2 \
 glibc \
 jasper-libs \
 kf6-kcalendarcore \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 kf6-sonnet \
 kf6-threadweaver \
 lcms2 \
 lensfun \
 libX11 \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libgcc \
 libglvnd-opengl \
 libgomp \
 libgphoto2 \
 libheif \
 libjpeg-turbo \
 libjxl \
 libksane \
 libpng \
 libstdc++ \
 libswscale-free \
 libtiff \
 libxml2 \
 libxslt \
 opencv-core \
 opencv-dnn \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-ml \
 opencv-objdetect \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtnetworkauth \
 qt6-qtscxml \
 qt6-qtsvg \
 qt6-qtwebengine \
 zlib-ng-compat \
 "
