# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yelp-xsl"
PV = "42.1"
PR = "7.el10"
PACKAGES = " \
 yelp-xsl \
 yelp-xsl-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yelp-xsl-42.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d17098190d48f1b7364f9ee423358b8cb9b6e98c55c222a896ba2e989ed45d35"

URI_x86_64_v2_yelp-xsl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yelp-xsl-42.1-7.el10.noarch.rpm;name=x86_64_v2_yelp-xsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yelp-xsl}"
SRC_URI[x86_64_v2_yelp-xsl.sha256sum] = "60f5625a4a65e19857aedde9da36f6882290a7cada3e40931f8d5fac91553df9"

URI_x86_64_v2_yelp-xsl-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/yelp-xsl-devel-42.1-7.el10.noarch.rpm;name=x86_64_v2_yelp-xsl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yelp-xsl-devel}"
SRC_URI[x86_64_v2_yelp-xsl-devel.sha256sum] = "7da5d2759182c76feb40d17aefccb6ded2c53b2eb5757d170cb1c756e979a0d3"

URI_aarch64_yelp-xsl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yelp-xsl-42.1-7.el10.noarch.rpm;name=aarch64_yelp-xsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_yelp-xsl}"
SRC_URI[aarch64_yelp-xsl.sha256sum] = "60f5625a4a65e19857aedde9da36f6882290a7cada3e40931f8d5fac91553df9"

URI_aarch64_yelp-xsl-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/yelp-xsl-devel-42.1-7.el10.noarch.rpm;name=aarch64_yelp-xsl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yelp-xsl-devel}"
SRC_URI[aarch64_yelp-xsl-devel.sha256sum] = "7da5d2759182c76feb40d17aefccb6ded2c53b2eb5757d170cb1c756e979a0d3"

RDEPENDS:yelp-xsl = " \
 "
RDEPENDS:yelp-xsl-devel = " \
 pkgconf-pkg-config \
 yelp-xsl \
 "
