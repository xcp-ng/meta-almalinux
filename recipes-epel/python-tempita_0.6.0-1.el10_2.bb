# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tempita"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-tempita \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tempita-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5eaf0724ac5ec53fe50a9cf3f8b1a78068e2baba79d8e62f9896a318b86b2261"

URI_x86_64_v2_python3-tempita = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tempita-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tempita;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tempita}"
SRC_URI[x86_64_v2_python3-tempita.sha256sum] = "448838b120e840cd0dfc58e99948706adb3ffde0faec7569a6b81827b5e1c427"

URI_aarch64_python3-tempita = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tempita-0.6.0-1.el10_2.noarch.rpm;name=aarch64_python3-tempita;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tempita}"
SRC_URI[aarch64_python3-tempita.sha256sum] = "1985e7964d298e0dde7e9ee306b1567747c250c5c82aaf6f94b2fcb56a755569"

RDEPENDS:python3-tempita = " \
 python3 \
 "
