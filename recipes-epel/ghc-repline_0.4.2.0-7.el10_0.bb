# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-repline"
PV = "0.4.2.0"
PR = "7.el10_0"
PACKAGES = " \
 ghc-repline \
 ghc-repline-devel \
 ghc-repline-doc \
 ghc-repline-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-repline-0.4.2.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a46d7e6984e9916f0339c31ce7d08f0017cd4d7fef6ffa0e54b84c5d0b81e9ed"

URI_x86_64_v2_ghc-repline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-repline-0.4.2.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-repline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-repline}"
SRC_URI[x86_64_v2_ghc-repline.sha256sum] = "5697a67759a6643c575c644a79e41496228aeb77fecb40817ba50f9c8cbf655b"

URI_x86_64_v2_ghc-repline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-repline-devel-0.4.2.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-repline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-repline-devel}"
SRC_URI[x86_64_v2_ghc-repline-devel.sha256sum] = "d69813afa2cb2d45aaa32ad6a0af317bb96667b835f11ce9baa86d7406e116c7"

URI_x86_64_v2_ghc-repline-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-repline-doc-0.4.2.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-repline-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-repline-doc}"
SRC_URI[x86_64_v2_ghc-repline-doc.sha256sum] = "fe4ae655fc3bf498fb0c2ab480398d628517a364fad7e0b8ad0e11f83a337ce6"

URI_x86_64_v2_ghc-repline-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-repline-prof-0.4.2.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-repline-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-repline-prof}"
SRC_URI[x86_64_v2_ghc-repline-prof.sha256sum] = "bd2d3e6fe0698e660a0cca043e479583db0f1a0780c59e0cdb8446f9e88f54de"

URI_aarch64_ghc-repline = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-repline-0.4.2.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-repline;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-repline}"
SRC_URI[aarch64_ghc-repline.sha256sum] = "541a5c4e8eb1075cd7f4716c72cf2fdf07275df03f79542b91dd0fc5791ceae2"

URI_aarch64_ghc-repline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-repline-devel-0.4.2.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-repline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-repline-devel}"
SRC_URI[aarch64_ghc-repline-devel.sha256sum] = "205cf0d63afffcbe0fcf7a87f5b614cf621b3227ced4edb716709bfe36cbf86c"

URI_aarch64_ghc-repline-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-repline-doc-0.4.2.0-7.el10_0.noarch.rpm;name=aarch64_ghc-repline-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-repline-doc}"
SRC_URI[aarch64_ghc-repline-doc.sha256sum] = "8f770c62ae0be0a64db462c0d59839bd35452ae8cb58039e98e31658aad7203e"

URI_aarch64_ghc-repline-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-repline-prof-0.4.2.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-repline-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-repline-prof}"
SRC_URI[aarch64_ghc-repline-prof.sha256sum] = "89464b9998b2c2599166de3f5a14ff5de0429d1b378a5ec533fcdfb851a6f57e"

RDEPENDS:ghc-repline = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-haskeline \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-terminfo \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc-repline-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-exceptions-devel \
 ghc-haskeline-devel \
 ghc-mtl-devel \
 ghc-process-devel \
 ghc-repline \
 "
RDEPENDS:ghc-repline-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-repline-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-exceptions-prof \
 ghc-haskeline-prof \
 ghc-mtl-prof \
 ghc-process-prof \
 ghc-repline-devel \
 "
