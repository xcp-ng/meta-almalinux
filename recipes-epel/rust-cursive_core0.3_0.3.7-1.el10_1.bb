# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursive_core0.3"
PV = "0.3.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-cursive_core0.3+default-devel \
 rust-cursive_core0.3+doc-cfg-devel \
 rust-cursive_core0.3+toml-devel \
 rust-cursive_core0.3+unstable_scroll-devel \
 rust-cursive_core0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursive_core0.3-0.3.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "562f36994c170f294f72f008ebc47e3d0a1e86d9e6223be0195f266cb0e91e5e"

URI_x86_64_v2_rust-cursive_core0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core0.3+default-devel-0.3.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core0.3+default-devel}"
SRC_URI[x86_64_v2_rust-cursive_core0.3+default-devel.sha256sum] = "a3573410ab56445964dc6c5555b74f1423eb3bb07abdd1ccb10e9b45a6547799"

URI_x86_64_v2_rust-cursive_core0.3+doc-cfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core0.3+doc-cfg-devel-0.3.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core0.3+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core0.3+doc-cfg-devel}"
SRC_URI[x86_64_v2_rust-cursive_core0.3+doc-cfg-devel.sha256sum] = "41d5d18c0828136e9950eff4a87430e9e4ddd4aba22de763af382d0b36adbd08"

URI_x86_64_v2_rust-cursive_core0.3+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core0.3+toml-devel-0.3.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core0.3+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core0.3+toml-devel}"
SRC_URI[x86_64_v2_rust-cursive_core0.3+toml-devel.sha256sum] = "2eded5ea2b71e7ecf28ff173ad980306384da8b0b4a46699d70d810e3bc5abae"

URI_x86_64_v2_rust-cursive_core0.3+unstable_scroll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core0.3+unstable_scroll-devel-0.3.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core0.3+unstable_scroll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core0.3+unstable_scroll-devel}"
SRC_URI[x86_64_v2_rust-cursive_core0.3+unstable_scroll-devel.sha256sum] = "82673acac2c07b82f7111aa1dbf5870cbfd770fca498308922b4fdbc7ceb4e7a"

URI_x86_64_v2_rust-cursive_core0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core0.3-devel-0.3.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core0.3-devel}"
SRC_URI[x86_64_v2_rust-cursive_core0.3-devel.sha256sum] = "bc21e34141c51c402956c6f523a0f46f8bdaa5c7b34a0bdd98d3f06f4589bfe0"

URI_aarch64_rust-cursive_core0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core0.3+default-devel-0.3.7-1.el10_1.noarch.rpm;name=aarch64_rust-cursive_core0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core0.3+default-devel}"
SRC_URI[aarch64_rust-cursive_core0.3+default-devel.sha256sum] = "79527042dfeea019fa93e32ff3490f73e7fe7ec242714537771e36d7e6d71fea"

URI_aarch64_rust-cursive_core0.3+doc-cfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core0.3+doc-cfg-devel-0.3.7-1.el10_1.noarch.rpm;name=aarch64_rust-cursive_core0.3+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core0.3+doc-cfg-devel}"
SRC_URI[aarch64_rust-cursive_core0.3+doc-cfg-devel.sha256sum] = "96cd3a9311215e89af57abade94a8afd93ad554ac947a8ceaa1410213fea2ceb"

URI_aarch64_rust-cursive_core0.3+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core0.3+toml-devel-0.3.7-1.el10_1.noarch.rpm;name=aarch64_rust-cursive_core0.3+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core0.3+toml-devel}"
SRC_URI[aarch64_rust-cursive_core0.3+toml-devel.sha256sum] = "8521cbb6b84f33c7a26e7e880c11e2b37f9338f627b04969cc6cfe53e65c34b1"

URI_aarch64_rust-cursive_core0.3+unstable_scroll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core0.3+unstable_scroll-devel-0.3.7-1.el10_1.noarch.rpm;name=aarch64_rust-cursive_core0.3+unstable_scroll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core0.3+unstable_scroll-devel}"
SRC_URI[aarch64_rust-cursive_core0.3+unstable_scroll-devel.sha256sum] = "a7ec6954aa81d91b5aeabf9f24dec8b0b26d9983067454c8e42f491770092c97"

URI_aarch64_rust-cursive_core0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core0.3-devel-0.3.7-1.el10_1.noarch.rpm;name=aarch64_rust-cursive_core0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core0.3-devel}"
SRC_URI[aarch64_rust-cursive_core0.3-devel.sha256sum] = "04a60a06c2591aa30f19da5e7e7ab4c0fafcaf1d105525a6778aaaabadfaa237"

RDEPENDS:rust-cursive_core0.3+default-devel = " \
 cargo \
 rust-cursive_core0.3-devel \
 "
RDEPENDS:rust-cursive_core0.3+doc-cfg-devel = " \
 cargo \
 rust-cursive_core0.3-devel \
 "
RDEPENDS:rust-cursive_core0.3+toml-devel = " \
 cargo \
 rust-cursive_core0.3-devel \
 rust-toml0.5+default-devel \
 "
RDEPENDS:rust-cursive_core0.3+unstable_scroll-devel = " \
 cargo \
 rust-cursive_core0.3-devel \
 "
RDEPENDS:rust-cursive_core0.3-devel = " \
 cargo \
 rust \
 rust-ahash+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-enum-map+default-devel \
 rust-enumset+default-devel \
 rust-lazy_static+default-devel \
 rust-log+default-devel \
 rust-num-devel \
 rust-owning_ref+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width0.1+default-devel \
 rust-xi-unicode+default-devel \
 "
