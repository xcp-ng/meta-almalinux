# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "elisa-player"
PV = "24.12.3"
PR = "2.el10_0"
PACKAGES = " \
 elisa-player \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/elisa-player-24.12.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bedd63a19ab9832bf8232d3f1a0bd4d633d120fd909df422fd1271417b9e139"

URI_x86_64_v2_elisa-player = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/elisa-player-24.12.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_elisa-player;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elisa-player}"
SRC_URI[x86_64_v2_elisa-player.sha256sum] = "5f19a71476c5cc00beea62044dbd3f9dbf58f36e230732ca9642cafc7de8fcee"

URI_aarch64_elisa-player = "${EPEL_MIRROR}/aarch64/Packages/e/elisa-player-24.12.3-2.el10_0.aarch64.rpm;name=aarch64_elisa-player;unpack=0"
SRC_URI:append = " ${URI_aarch64_elisa-player}"
SRC_URI[aarch64_elisa-player.sha256sum] = "05cc6478ea402567b8d56762f2c9c5910cd1f0fb38e626356cd5813666d1f8ec"

RDEPENDS:elisa-player = " \
 dbus-common \
 glibc \
 hicolor-icon-theme \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kitemviews \
 kf6-kxmlgui \
 kf6-qqc2-desktop-style \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
