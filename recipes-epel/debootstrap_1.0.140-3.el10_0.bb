# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "debootstrap"
PV = "1.0.140"
PR = "3.el10_0"
PACKAGES = " \
 debootstrap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/debootstrap-1.0.140-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73c1a1c18f6e577dc1f0f79badb9efad6973e33e77e20c73b7b46315ec4ef254"

URI_x86_64_v2_debootstrap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debootstrap-1.0.140-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_debootstrap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debootstrap}"
SRC_URI[x86_64_v2_debootstrap.sha256sum] = "896a6f5416f70a407d287ef3c41cad2f2c866a46c0c38528b09d766421d63afa"

URI_aarch64_debootstrap = "${EPEL_MIRROR}/aarch64/Packages/d/debootstrap-1.0.140-3.el10_0.noarch.rpm;name=aarch64_debootstrap;unpack=0"
SRC_URI:append = " ${URI_aarch64_debootstrap}"
SRC_URI[aarch64_debootstrap.sha256sum] = "c119d018fe63e76327e73ed8878f6c1b647db04d8be4e6fc6bb2c53f61d038ba"

RDEPENDS:debootstrap = " \
 bash \
 dpkg \
 gzip \
 perl-interpreter \
 tar \
 wget \
 xz \
 "
